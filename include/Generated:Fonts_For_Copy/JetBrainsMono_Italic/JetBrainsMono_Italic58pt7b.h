#ifndef _JETBRAINSMONO_ITALIC58PT7B_H_
#define _JETBRAINSMONO_ITALIC58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x7F, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x01, 0xF8, 0x00, 0x3F, 0x07, 0xE7, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x03,
  0xF7, 0xE0, 0x7C, 0xFC, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F,
  0xCF, 0x81, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F,
  0x3E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x07,
  0x80, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x7C,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03,
  0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0xF8, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x7C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFC, 0xF3, 0xF8, 0x0F, 0xE3, 0xC7, 0xE0,
  0x3F, 0x0E, 0x0F, 0xC0, 0xF8, 0x38, 0x3F, 0x07, 0xC0, 0xE0, 0xFC, 0x1F,
  0x03, 0x83, 0xF0, 0x7C, 0x1E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x1F, 0x07, 0x00, 0x00, 0x7E, 0x1C, 0x00, 0x01, 0xFC, 0x70,
  0x00, 0x07, 0xFB, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0x9F, 0xC0, 0x00,
  0x1E, 0x3F, 0x80, 0x00, 0x70, 0x7E, 0x00, 0x01, 0xC1, 0xF8, 0x00, 0x07,
  0x03, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF0, 0x3E, 0x3F, 0x03, 0xC1,
  0xF8, 0xF8, 0x0E, 0x07, 0xE3, 0xF0, 0x38, 0x1F, 0x0F, 0xC0, 0xE0, 0xFC,
  0x3F, 0x87, 0x87, 0xE0, 0x7F, 0x1E, 0x3F, 0x81, 0xFF, 0x7B, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x00, 0x7F, 0xF8, 0x00, 0x3E,
  0x00, 0xFF, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0xFC, 0x00, 0x78, 0x01, 0xE0,
  0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x03, 0xC0, 0x3C, 0x0F, 0x80, 0x03,
  0xC0, 0x7C, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x1E, 0x00, 0x07, 0xC0, 0x78,
  0x3C, 0x00, 0x07, 0xC0, 0x78, 0x78, 0x00, 0x07, 0xC0, 0xF8, 0xF8, 0x00,
  0x07, 0xE1, 0xF1, 0xF0, 0x00, 0x03, 0xFF, 0xE3, 0xE0, 0x00, 0x03, 0xFF,
  0xE3, 0xC0, 0x00, 0x01, 0xFF, 0x87, 0x80, 0x00, 0x00, 0x7E, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x7F, 0x00, 0x00, 0x01, 0xE1, 0xFF, 0x80, 0x00, 0x03, 0xE7, 0xFF, 0xC0,
  0x00, 0x07, 0xC7, 0xFF, 0xE0, 0x00, 0x0F, 0x8F, 0x83, 0xE0, 0x00, 0x0F,
  0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x1F, 0x01, 0xE0, 0x00, 0x3C, 0x1E, 0x01,
  0xE0, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x00, 0xF8, 0x1E, 0x01, 0xE0, 0x01,
  0xF0, 0x1E, 0x03, 0xE0, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x03, 0xC0, 0x3E,
  0x03, 0xC0, 0x07, 0x80, 0x3E, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x07, 0xC0,
  0x1F, 0x00, 0x1F, 0xFF, 0x80, 0x3E, 0x00, 0x1F, 0xFF, 0x00, 0x3C, 0x00,
  0x0F, 0xFE, 0x00, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xEF, 0xC0, 0x1F, 0x1F, 0x8F, 0xC0, 0x3E, 0x1F, 0x07, 0xE0, 0x7E,
  0x3F, 0x03, 0xE0, 0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x3E, 0x01, 0xF9, 0xF0,
  0x3E, 0x01, 0xFB, 0xF0, 0x3E, 0x00, 0xFF, 0xE0, 0x3E, 0x00, 0xFF, 0xC0,
  0x7E, 0x00, 0x7F, 0xC0, 0x7E, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0xFF, 0xC0,
  0x7E, 0x01, 0xFF, 0xC0, 0x7F, 0x07, 0xF7, 0xE0, 0x3F, 0xFF, 0xE3, 0xE0,
  0x3F, 0xFF, 0xC3, 0xF0, 0x1F, 0xFF, 0x81, 0xF0, 0x0F, 0xFE, 0x01, 0xF8,
  0x00, 0x40, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF8, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x38, 0x03, 0xC0, 0x0C, 0x7C, 0x07, 0x80, 0xF9,
  0xFE, 0x0F, 0x0F, 0xF3, 0xFF, 0x1C, 0x7F, 0xFF, 0xFF, 0x3B, 0xFF, 0xE7,
  0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03,
  0xCF, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xE0, 0x01,
  0x80, 0x00, 0x80, 0x02, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x01,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x0F, 0x87, 0xF8, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F,
  0xF3, 0xFC, 0x3F, 0x01, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x0F,
  0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xFC,
  0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x0F,
  0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x38,
  0x1F, 0x07, 0xC3, 0xF0, 0x7C, 0x1F, 0x0F, 0xE1, 0xF0, 0xFC, 0x3F, 0x87,
  0xC3, 0xE0, 0xFE, 0x1F, 0x0F, 0x83, 0xF0, 0x7C, 0x3E, 0x07, 0xC3, 0xF0,
  0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xF8, 0x7C,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xFC, 0x1F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xF7, 0xC0, 0x03, 0xFC, 0xF8, 0x00, 0xFE, 0x1F, 0x00, 0x3F,
  0x83, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xF0, 0x1F, 0x80, 0x18, 0x03, 0xE0,
  0x06, 0x00, 0x7C, 0x00, 0x80, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF8, 0xF8,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0xFC,
  0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7C,
  0x7E, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x7E, 0x00,
  0x07, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF3, 0xFF, 0x80, 0x1F,
  0x3F, 0xFF, 0x00, 0xFB, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0,
  0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F,
  0xE0, 0x07, 0xE0, 0x3F, 0x81, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF3, 0xFC,
  0x00, 0x7E, 0xFF, 0xF0, 0x07, 0xDF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x1F,
  0xF0, 0x3F, 0xE1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xE3, 0xF0, 0x00,
  0x3E, 0x3E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xFC,
  0x7C, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x03, 0xFC,
  0x1F, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x14, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7C, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xFC,
  0xFC, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xBF, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x03,
  0xF0, 0x3E, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x3E, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x01,
  0xF8, 0x3F, 0x80, 0x1F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xF8, 0x0F,
  0xF0, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x7E, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8,
  0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0xFF,
  0x87, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xBE, 0x00, 0x3F, 0xFB,
  0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC,
  0x1F, 0xF0, 0x7F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0x08,
  0x00, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x7F, 0x1E,
  0x0F, 0x80, 0x3F, 0xF3, 0xC1, 0xF0, 0x0F, 0xFF, 0x78, 0x3E, 0x03, 0xFF,
  0xEF, 0x07, 0x80, 0x7C, 0x07, 0xE0, 0xF0, 0x1F, 0x00, 0xF8, 0x3E, 0x03,
  0xE0, 0x1F, 0x07, 0xC0, 0x78, 0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x7C, 0x1F,
  0x03, 0xE0, 0x0F, 0x83, 0xC0, 0x7C, 0x01, 0xF0, 0x78, 0x0F, 0x80, 0x3E,
  0x1F, 0x01, 0xE0, 0x07, 0x83, 0xE0, 0x3C, 0x00, 0xF0, 0x7C, 0x0F, 0x80,
  0x3E, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x3E, 0x00, 0xF8, 0x3C, 0x07,
  0xC0, 0x1F, 0x07, 0x80, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x00, 0xF8, 0x3E,
  0x03, 0xF0, 0x7F, 0x07, 0xC0, 0x3F, 0xFD, 0xE0, 0xF8, 0x07, 0xFF, 0x3C,
  0x1E, 0x00, 0x7F, 0xCF, 0x83, 0xC0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3E, 0x0F,
  0x80, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x3E,
  0x01, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xF8,
  0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0x87, 0xE0, 0x00,
  0x3E, 0x3F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7C,
  0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0xF8, 0x0F, 0x80,
  0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x3E, 0x01, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x01, 0xF0, 0x07, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8,
  0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0xFC, 0x1F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x7F, 0x81, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03,
  0xE1, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x01, 0xFE,
  0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x3E, 0x01, 0xFF, 0x01, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0xF8,
  0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x3E, 0x0F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xFC,
  0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x3F, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8, 0x7C,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x1F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xFC,
  0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xE0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x1F,
  0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x03, 0xFF, 0xF0, 0xF8, 0x1F, 0xFF,
  0x87, 0xC0, 0xFF, 0xFC, 0x7E, 0x07, 0xFF, 0xC3, 0xF0, 0x7F, 0xFE, 0x1F,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3E, 0x0F,
  0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F,
  0x00, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0x80,
  0x01, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C,
  0x07, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07,
  0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0x80, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0xF8,
  0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x0F, 0x80, 0x3F, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x0F, 0xC0,
  0x01, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0,
  0x3B, 0xC0, 0x1F, 0xF0, 0x1D, 0xE0, 0x0F, 0x78, 0x1E, 0xF0, 0x0F, 0xB8,
  0x0F, 0x7C, 0x07, 0xBC, 0x07, 0x9E, 0x07, 0xDE, 0x03, 0xCF, 0x03, 0xCF,
  0x01, 0xE7, 0x81, 0xE7, 0x80, 0xF3, 0xC1, 0xE7, 0xC0, 0x79, 0xE0, 0xF3,
  0xE0, 0x7C, 0xF8, 0xF1, 0xE0, 0x3E, 0x3C, 0x78, 0xF0, 0x1F, 0x1E, 0x78,
  0xF8, 0x0F, 0x8F, 0x3C, 0x7C, 0x07, 0xC7, 0xBE, 0x3E, 0x03, 0xC3, 0xDE,
  0x1F, 0x03, 0xE1, 0xEF, 0x0F, 0x01, 0xF0, 0x7F, 0x0F, 0x80, 0xF8, 0x3F,
  0x87, 0xC0, 0x7C, 0x1F, 0x83, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x3E, 0x07, 0xF8, 0x00, 0xF8, 0x0F, 0xF0, 0x01,
  0xF0, 0x1F, 0xE0, 0x03, 0xE0, 0x3F, 0xC0, 0x07, 0xC0, 0xFF, 0x80, 0x0F,
  0x81, 0xFF, 0x80, 0x1F, 0x03, 0xFF, 0x00, 0x7E, 0x07, 0xFE, 0x00, 0xF8,
  0x0F, 0xBC, 0x01, 0xF0, 0x1E, 0x78, 0x03, 0xE0, 0x7C, 0xF8, 0x07, 0xC0,
  0xF9, 0xF0, 0x0F, 0x81, 0xF3, 0xE0, 0x1F, 0x03, 0xE3, 0xC0, 0x7C, 0x07,
  0xC7, 0x80, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0x1F, 0x1F, 0x03, 0xE0, 0x7C,
  0x3E, 0x07, 0xC0, 0xF8, 0x3C, 0x0F, 0x81, 0xF0, 0x78, 0x3E, 0x03, 0xE0,
  0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0xF8, 0x0F, 0x83, 0xE1, 0xF0, 0x3F, 0x03,
  0xC3, 0xE0, 0x7C, 0x07, 0x87, 0xC0, 0xF8, 0x0F, 0x9F, 0x01, 0xF0, 0x1F,
  0x3E, 0x03, 0xE0, 0x3E, 0x7C, 0x07, 0xC0, 0x3C, 0xF8, 0x1F, 0x80, 0x79,
  0xF0, 0x3E, 0x00, 0xFB, 0xE0, 0x7C, 0x01, 0xF7, 0xC0, 0xF8, 0x03, 0xEF,
  0x01, 0xF0, 0x03, 0xDE, 0x03, 0xE0, 0x07, 0xBC, 0x07, 0xC0, 0x0F, 0xF8,
  0x1F, 0x00, 0x1F, 0xF0, 0x3E, 0x00, 0x3F, 0xE0, 0x7C, 0x00, 0x3F, 0x80,
  0xF8, 0x00, 0x7F, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E,
  0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x7E,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x87, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E,
  0x1F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xFC, 0x3F,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00,
  0x7F, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x07, 0xFC, 0x03, 0xE0, 0x01, 0xFE,
  0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF8,
  0x0F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x3F,
  0x80, 0x1F, 0x80, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00,
  0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x1F,
  0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xFC, 0x01, 0xFC, 0x03, 0xFC,
  0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3E,
  0x00, 0xFF, 0x80, 0x7C, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x01,
  0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x07,
  0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xFC, 0x03, 0xE0,
  0x01, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFC,
  0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x7C, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0xFE,
  0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF8, 0x3E,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80,
  0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0xFC, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00,
  0x7D, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xF1,
  0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x7C, 0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x03,
  0xF0, 0x3F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x0F,
  0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3E,
  0x01, 0xF0, 0x07, 0xCF, 0x00, 0xFC, 0x03, 0xE7, 0xC0, 0x3F, 0x00, 0xF9,
  0xF0, 0x0F, 0xC0, 0x3C, 0x7C, 0x03, 0xF0, 0x1F, 0x1F, 0x01, 0xFC, 0x07,
  0xC7, 0xC0, 0x77, 0x01, 0xF1, 0xF0, 0x1D, 0xC0, 0x78, 0x7C, 0x0F, 0x70,
  0x3E, 0x1F, 0x03, 0x9C, 0x0F, 0x87, 0xC0, 0xE7, 0x03, 0xE1, 0xF0, 0x39,
  0xC0, 0xF0, 0x7C, 0x1E, 0x70, 0x7C, 0x1F, 0x07, 0x1C, 0x1F, 0x07, 0xC1,
  0xCF, 0x07, 0x81, 0xF0, 0xF3, 0xC1, 0xE0, 0x7C, 0x38, 0xF0, 0xF8, 0x1E,
  0x0E, 0x3C, 0x3E, 0x07, 0x83, 0x8F, 0x0F, 0x01, 0xE1, 0xE3, 0xC7, 0xC0,
  0x78, 0x70, 0xF1, 0xF0, 0x1E, 0x1C, 0x38, 0x7C, 0x07, 0x8F, 0x0E, 0x1E,
  0x01, 0xE3, 0xC3, 0x8F, 0x80, 0x78, 0xE0, 0xE3, 0xE0, 0x3E, 0x38, 0x38,
  0xF0, 0x0F, 0x9E, 0x0E, 0x3C, 0x03, 0xE7, 0x03, 0x9F, 0x00, 0xF9, 0xC0,
  0xE7, 0xC0, 0x3E, 0xF0, 0x39, 0xE0, 0x0F, 0xBC, 0x0E, 0x78, 0x03, 0xEE,
  0x03, 0xBE, 0x00, 0xFB, 0x80, 0xEF, 0x00, 0x3F, 0xE0, 0x3B, 0xC0, 0x0F,
  0x70, 0x0E, 0xF0, 0x03, 0xDC, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF8,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00,
  0x03, 0xF1, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0x80,
  0x07, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xF8, 0x0F,
  0x80, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xE7, 0x80, 0x01, 0xF1,
  0xE0, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x07,
  0xC0, 0xF8, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x01, 0xE0,
  0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x03, 0xC1, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xBF, 0x00, 0x01, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x00, 0x7F, 0xE1, 0xF0, 0x0F,
  0xFF, 0x1F, 0x03, 0xFF, 0xFB, 0xF0, 0x7F, 0xFF, 0xBE, 0x07, 0xF0, 0x3F,
  0xE0, 0xFC, 0x01, 0xFE, 0x1F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0x7E, 0x1F,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF8,
  0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xF0, 0xFE, 0x00, 0xDF, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xFF, 0xBF,
  0x03, 0xFF, 0xFB, 0xE0, 0x1F, 0xFF, 0x3E, 0x00, 0xFF, 0xC3, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC3, 0xFE, 0x00, 0x7C, 0xFF, 0xF8, 0x0F, 0xDF, 0xFF,
  0xC0, 0xFB, 0xFF, 0xFC, 0x0F, 0xBC, 0x1F, 0xE0, 0xFF, 0x00, 0x7E, 0x0F,
  0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF1, 0xF8, 0x00,
  0x3F, 0x1F, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x3E, 0x3E, 0x00,
  0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x3F,
  0x0F, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0x9F, 0xFF, 0xC0, 0xF8,
  0xFF, 0xF0, 0x0F, 0x87, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE1, 0xF8,
  0x00, 0x7E, 0x1F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00,
  0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xF8, 0x1F, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xFE, 0x1F, 0x00,
  0x3F, 0xFC, 0x7C, 0x03, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0xEF, 0xC0, 0x7F,
  0x03, 0xFE, 0x03, 0xF0, 0x07, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x7E, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0,
  0x7E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x1F,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0x7C, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0xDF,
  0x01, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xFB, 0xF0, 0x0F, 0xFF, 0xEF, 0x80,
  0x1F, 0xFF, 0x3E, 0x00, 0x3F, 0xF0, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xFC, 0xF8, 0x00,
  0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE1, 0xF0, 0x0F, 0xFF, 0x1F, 0x03, 0xFF, 0xFB, 0xF0, 0x7F,
  0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0xE0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x0F,
  0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3E,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x7C, 0x7E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00,
  0x1F, 0x87, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xF0,
  0x7F, 0x00, 0xFF, 0x03, 0xFF, 0xFD, 0xF0, 0x3F, 0xFF, 0xDF, 0x01, 0xFF,
  0xFB, 0xF0, 0x0F, 0xFE, 0x3F, 0x00, 0x3F, 0x83, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC3, 0xFE, 0x00, 0x7C, 0xFF, 0xF8, 0x0F, 0xDF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xB8, 0x1F, 0xE0, 0xFF, 0x00, 0x7E, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF1, 0xF8, 0x00,
  0x3F, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x7E, 0x3E, 0x00,
  0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F,
  0x8F, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x07,
  0xE0, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0xFC,
  0x00, 0x7C, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0x80,
  0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x1F, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFE,
  0x07, 0xCF, 0xE1, 0xF8, 0x07, 0xDF, 0xE3, 0xFC, 0x07, 0xFF, 0xF7, 0xFE,
  0x07, 0xBF, 0xFF, 0xFE, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0xC0, 0xF0, 0x3E,
  0x0F, 0x80, 0xF0, 0x1E, 0x0F, 0x80, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E,
  0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x3E, 0x0F, 0x01, 0xE0, 0x3E,
  0x1F, 0x01, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0x7C,
  0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xC0, 0x7C, 0x1E, 0x03, 0xC0, 0x7C,
  0x3E, 0x03, 0xC0, 0x7C, 0x3E, 0x03, 0xC0, 0x78, 0x3E, 0x03, 0xC0, 0xF8,
  0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0x80, 0xF8, 0x3C, 0x07, 0x80, 0xF8,
  0x7C, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0x80, 0xF0, 0x7C, 0x07, 0x81, 0xF0,
  0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x01, 0xF0,
  0x78, 0x0F, 0x01, 0xF0, 0xF8, 0x0F, 0x01, 0xF0, 0x07, 0xC3, 0xFE, 0x00,
  0x7C, 0xFF, 0xF8, 0x0F, 0xDF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xB8,
  0x1F, 0xE0, 0xFF, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F,
  0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x3E,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF8, 0xFC, 0x00,
  0x1F, 0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0x87, 0xFC, 0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xF8, 0x00,
  0x1F, 0x9F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0x9F,
  0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xCF, 0x80, 0x01,
  0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xF9, 0xF0,
  0x00, 0x1F, 0x3E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x3F,
  0x1F, 0x80, 0x07, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0x80, 0x07, 0xCF, 0xFF, 0x80,
  0x3F, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xEF, 0x07, 0xF8, 0x0F,
  0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x7E,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x80,
  0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0xFC, 0x0F, 0xFC, 0x0F,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xF9, 0xFF, 0xFC, 0x03, 0xE3, 0xFF, 0xC0,
  0x0F, 0x87, 0xFE, 0x00, 0x3E, 0x03, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0xF8, 0x07, 0xFF,
  0xCF, 0xC0, 0x7F, 0xFF, 0x7E, 0x07, 0xFF, 0xFB, 0xE0, 0x7F, 0x81, 0xFF,
  0x03, 0xF0, 0x07, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7E, 0x1F,
  0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F,
  0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x1F,
  0x83, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x1B, 0xE0, 0x7F, 0x03, 0xFF, 0x03,
  0xFF, 0xFD, 0xF0, 0x0F, 0xFF, 0xEF, 0x80, 0x3F, 0xFC, 0x7C, 0x00, 0xFF,
  0xC3, 0xE0, 0x00, 0x60, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC3, 0xFE, 0x00, 0x3E, 0x7F, 0xFC, 0x01, 0xF7,
  0xFF, 0xF0, 0x1F, 0x7F, 0xFF, 0xC0, 0xFB, 0x80, 0xFE, 0x07, 0xF8, 0x03,
  0xF0, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0,
  0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x3F, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x7C,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xF0, 0x07,
  0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF1, 0xF8,
  0x00, 0x1F, 0x1F, 0x80, 0x03, 0xF1, 0xF0, 0x00, 0x3F, 0x1F, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x3F,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xF8, 0x7C, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF8,
  0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xC0,
  0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x28, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3E, 0xFC, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xF8,
  0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x03, 0xE0,
  0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x1F,
  0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x7C,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0xF9, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xF0, 0x0F, 0x80, 0x3F, 0xC0,
  0x3E, 0x01, 0xFF, 0x01, 0xF8, 0x07, 0xFC, 0x07, 0xE0, 0x1E, 0xF0, 0x1F,
  0x80, 0xFB, 0xC0, 0x7E, 0x03, 0xEF, 0x03, 0xF8, 0x0F, 0x3C, 0x0E, 0xE0,
  0x3C, 0xF0, 0x3B, 0x81, 0xF3, 0xC1, 0xEE, 0x07, 0x8F, 0x07, 0x38, 0x1E,
  0x3C, 0x1C, 0xE0, 0xF8, 0xF0, 0xF3, 0x83, 0xC3, 0xC3, 0x8E, 0x0F, 0x0F,
  0x0E, 0x38, 0x7C, 0x3C, 0x78, 0xE1, 0xE0, 0xF1, 0xC3, 0x87, 0x83, 0xC7,
  0x0E, 0x1E, 0x0F, 0x3C, 0x38, 0xF0, 0x3C, 0xE0, 0xE3, 0xC0, 0xF3, 0x83,
  0x8F, 0x03, 0xDE, 0x0E, 0x78, 0x0F, 0x70, 0x39, 0xE0, 0x3D, 0xC0, 0xE7,
  0x80, 0xF7, 0x03, 0xBC, 0x03, 0xF8, 0x0E, 0xF0, 0x0F, 0xE0, 0x3B, 0xC0,
  0x3B, 0x80, 0xFE, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01,
  0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x3F,
  0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x80,
  0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E,
  0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xE3, 0xF0,
  0x00, 0x7E, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xFC, 0x7C,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0xF8, 0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x87,
  0xE0, 0x07, 0xF0, 0x7F, 0x01, 0xFF, 0x03, 0xFF, 0xFD, 0xF0, 0x3F, 0xFF,
  0x9F, 0x01, 0xFF, 0xF3, 0xF0, 0x07, 0xFE, 0x3F, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x01,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xF8, 0xFF,
  0xE0, 0x0F, 0x8F, 0xFF, 0x80, 0x7C, 0x7F, 0xFE, 0x03, 0xE7, 0xE3, 0xF0,
  0x1F, 0x3E, 0x0F, 0xC0, 0xFB, 0xE0, 0x3F, 0x0F, 0x9F, 0x01, 0xFF, 0xFC,
  0xF8, 0x07, 0xFF, 0xC7, 0xC0, 0x1F, 0xFC, 0x3E, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x20, 0x00,
};

const GFXglyph JetBrainsMono_Italic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 14, 42, 35, 11, -42 },
  { 75, 19, 17, 35, 11, -42 },
  { 116, 34, 42, 35, 1, -42 },
  { 295, 30, 58, 35, 3, -50 },
  { 513, 40, 43, 35, -2, -43 },
  { 728, 32, 44, 35, 1, -43 },
  { 904, 8, 17, 35, 16, -42 },
  { 921, 24, 56, 35, 9, -49 },
  { 1089, 24, 56, 35, 3, -49 },
  { 1257, 31, 30, 35, 3, -35 },
  { 1374, 28, 27, 35, 4, -33 },
  { 1469, 16, 18, 35, 5, -9 },
  { 1505, 20, 4, 35, 8, -21 },
  { 1515, 11, 10, 35, 10, -9 },
  { 1529, 35, 54, 35, 1, -48 },
  { 1766, 30, 44, 35, 3, -43 },
  { 1931, 27, 42, 35, 3, -42 },
  { 2073, 30, 43, 35, 3, -43 },
  { 2235, 29, 43, 35, 3, -42 },
  { 2391, 27, 42, 35, 4, -42 },
  { 2533, 29, 43, 35, 4, -42 },
  { 2689, 28, 43, 35, 3, -42 },
  { 2840, 28, 42, 35, 7, -42 },
  { 2987, 29, 44, 35, 3, -43 },
  { 3147, 29, 43, 35, 5, -43 },
  { 3303, 14, 33, 35, 10, -32 },
  { 3361, 19, 41, 35, 6, -32 },
  { 3459, 28, 31, 35, 5, -35 },
  { 3568, 28, 18, 35, 4, -28 },
  { 3631, 28, 31, 35, 3, -35 },
  { 3740, 24, 42, 35, 8, -42 },
  { 3866, 35, 53, 35, 0, -43 },
  { 4098, 29, 42, 35, 0, -42 },
  { 4251, 30, 42, 35, 3, -42 },
  { 4409, 29, 44, 35, 4, -43 },
  { 4569, 29, 42, 35, 3, -42 },
  { 4722, 31, 42, 35, 3, -42 },
  { 4885, 32, 42, 35, 3, -42 },
  { 5053, 29, 44, 35, 4, -43 },
  { 5213, 31, 42, 35, 3, -42 },
  { 5376, 29, 42, 35, 4, -42 },
  { 5529, 32, 43, 35, 1, -42 },
  { 5701, 33, 42, 35, 3, -42 },
  { 5875, 25, 42, 35, 4, -42 },
  { 6007, 33, 42, 35, 2, -42 },
  { 6181, 31, 42, 35, 3, -42 },
  { 6344, 29, 44, 35, 4, -43 },
  { 6504, 32, 42, 35, 3, -42 },
  { 6672, 30, 53, 35, 3, -43 },
  { 6871, 31, 42, 35, 3, -42 },
  { 7034, 30, 44, 35, 3, -43 },
  { 7199, 29, 42, 35, 7, -42 },
  { 7352, 30, 43, 35, 4, -42 },
  { 7514, 29, 42, 35, 7, -42 },
  { 7667, 34, 42, 35, 4, -42 },
  { 7846, 36, 42, 35, 0, -42 },
  { 8035, 31, 42, 35, 6, -42 },
  { 8198, 31, 42, 35, 2, -42 },
  { 8361, 23, 54, 35, 8, -48 },
  { 8517, 18, 54, 35, 9, -48 },
  { 8639, 23, 54, 35, 5, -48 },
  { 8795, 26, 22, 35, 5, -42 },
  { 8867, 29, 5, 35, 0, 1 },
  { 8886, 11, 9, 35, 15, -46 },
  { 8899, 28, 33, 35, 4, -32 },
  { 9015, 28, 43, 35, 3, -42 },
  { 9166, 28, 33, 35, 4, -32 },
  { 9282, 30, 43, 35, 4, -42 },
  { 9444, 27, 33, 35, 4, -32 },
  { 9556, 40, 52, 35, -3, -42 },
  { 9816, 28, 42, 35, 4, -32 },
  { 9963, 28, 42, 35, 3, -42 },
  { 10110, 28, 45, 35, 2, -45 },
  { 10268, 30, 55, 35, 1, -45 },
  { 10475, 31, 42, 35, 3, -42 },
  { 10638, 24, 42, 35, 6, -42 },
  { 10764, 32, 32, 35, 1, -32 },
  { 10892, 28, 32, 35, 3, -32 },
  { 11004, 27, 33, 35, 4, -32 },
  { 11116, 30, 42, 35, 1, -32 },
  { 11274, 29, 42, 35, 3, -32 },
  { 11427, 29, 32, 35, 4, -32 },
  { 11543, 28, 33, 35, 3, -32 },
  { 11659, 28, 41, 35, 5, -41 },
  { 11803, 28, 33, 35, 4, -32 },
  { 11919, 28, 32, 35, 6, -32 },
  { 12031, 30, 32, 35, 5, -32 },
  { 12151, 32, 32, 35, 1, -32 },
  { 12279, 28, 42, 35, 4, -32 },
  { 12426, 28, 32, 35, 3, -32 },
  { 12538, 30, 54, 35, 5, -48 },
  { 12741, 14, 54, 35, 11, -48 },
  { 12836, 30, 54, 35, 1, -48 },
  { 13039, 29, 12, 35, 4, -26 },
};

const GFXfont JetBrainsMono_Italic58pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic58pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic58pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _JETBRAINSMONO_ITALIC58PT7B_H_
