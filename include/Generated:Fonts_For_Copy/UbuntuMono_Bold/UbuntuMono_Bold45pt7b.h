#ifndef _UBUNTUMONO_BOLD45PT7B_H_
#define _UBUNTUMONO_BOLD45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0x7C, 0xF9, 0xF3, 0xE0, 0x00, 0x00, 0x3C, 0xFF, 0xFF,
  0xFF, 0xF7, 0x80, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7,
  0xFF, 0x8F, 0xBF, 0x1F, 0x7C, 0x3E, 0x78, 0x7C, 0xF0, 0x79, 0xE0, 0xF3,
  0xC1, 0xE7, 0x83, 0x80, 0x03, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0x87, 0xC0, 0x3C, 0x3C, 0x03, 0xE1, 0xE0, 0x1F, 0x1F, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3C, 0x3C, 0x03, 0xE1, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0x0F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xE0,
  0x1F, 0x0F, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x7F, 0xFF, 0x8F, 0xC0, 0x73, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xFA, 0x00, 0x3F, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xC7, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0xF7,
  0xFC, 0x07, 0x9F, 0xF0, 0x1E, 0x7B, 0xC0, 0xF1, 0xC7, 0x07, 0x8F, 0x1E,
  0x1E, 0x3C, 0x78, 0xF0, 0xF1, 0xE7, 0xC1, 0xC7, 0x1E, 0x07, 0xBC, 0xF0,
  0x1F, 0xF3, 0xC0, 0x7F, 0xDE, 0x00, 0xFE, 0xF0, 0x01, 0xF3, 0xC0, 0x00,
  0x1E, 0x78, 0x00, 0xF3, 0xF0, 0x03, 0xDF, 0xE0, 0x1E, 0xFF, 0x80, 0xF3,
  0xCF, 0x03, 0xCF, 0x3C, 0x1E, 0x3C, 0xF0, 0xF0, 0xF3, 0xC3, 0xC3, 0xCF,
  0x1E, 0x0F, 0x3C, 0xF0, 0x3C, 0xF3, 0xC0, 0xFF, 0x9E, 0x01, 0xFE, 0xF0,
  0x03, 0xF0, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0x8F, 0x80, 0xF8, 0x7C, 0x07,
  0xC3, 0xE0, 0x3E, 0x1E, 0x01, 0xF1, 0xF0, 0x07, 0xDF, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0xF8, 0x7F, 0x87, 0xC7, 0xFE, 0x3E, 0x7D,
  0xF9, 0xE3, 0xC7, 0xEF, 0x3E, 0x1F, 0xF9, 0xF0, 0x7F, 0xCF, 0x81, 0xFC,
  0x7C, 0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x87, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xF3, 0xE0, 0x7E, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0x9E, 0x38, 0x00, 0x18, 0x00, 0x78,
  0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0x00, 0x04, 0x00, 0x20, 0x01,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01,
  0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x3F,
  0xC0, 0x7C, 0x01, 0xE0, 0x02, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x10, 0xF8, 0x47, 0x9E, 0x3C, 0xF9, 0xCF, 0xBF, 0xBF, 0xF7,
  0xFF, 0xFF, 0x3F, 0xFF, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x07, 0xDF, 0x01,
  0xFB, 0xF0, 0x7E, 0x7E, 0x07, 0xC7, 0xC0, 0x70, 0xF0, 0x02, 0x08, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x0F, 0x0F, 0xE3, 0xF8, 0xFE, 0x3F, 0xCF, 0xF3, 0xFC, 0x7E,
  0x07, 0x83, 0xE3, 0xF3, 0xF8, 0xFC, 0x3E, 0x0E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0x3C, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF,
  0x83, 0xFF, 0xF8, 0xFE, 0x3F, 0x1F, 0x03, 0xF7, 0xE0, 0x3E, 0xF8, 0x07,
  0xDF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x71, 0xFF, 0x9E, 0x3F, 0xF3, 0xE7,
  0xFE, 0x7C, 0xFF, 0xCF, 0x1F, 0xF8, 0xE3, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xBF, 0x01, 0xF3, 0xE0, 0x7E,
  0x7F, 0x1F, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xC0,
  0x07, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xFC,
  0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7C, 0xF8,
  0x06, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x07, 0xF0,
  0x03, 0xFF, 0x81, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0xF8, 0x7F,
  0x0C, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x0F, 0xFF, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x0E, 0x0F, 0xE2, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x70, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFC,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x07,
  0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83,
  0xE0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0x87, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x03,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFD, 0x80, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF,
  0xFF, 0xE3, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xE0,
  0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x83, 0xFE, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xEF, 0x01, 0xFF, 0xF8, 0xFF, 0xFF,
  0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xF8, 0xFF, 0xFC, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xF7, 0xE0, 0xFD, 0xFC,
  0x7F, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF8, 0xFC, 0x3F, 0x9F, 0x03, 0xF7, 0xE0, 0x3E, 0xFC,
  0x07, 0xDF, 0x80, 0xF9, 0xF0, 0x3F, 0x3F, 0x07, 0xC7, 0xF9, 0xF8, 0x7F,
  0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xCF, 0xF1, 0xF0,
  0x7F, 0x7C, 0x03, 0xEF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x3F, 0xFE, 0x0F, 0xDF, 0xFF, 0xF9, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF,
  0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F,
  0xFF, 0x87, 0xFF, 0xF8, 0xFC, 0x3F, 0x1F, 0x03, 0xF7, 0xE0, 0x3E, 0xF8,
  0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7E, 0xFF,
  0x3F, 0xDF, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x03,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x3F,
  0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xE0,
  0x00, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x3C, 0x0F,
  0x07, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF1, 0xFC, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x7E, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF,
  0x1F, 0xC3, 0xF0, 0x3C, 0x1E, 0x1F, 0xBF, 0xC7, 0xE1, 0xF0, 0x60, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x3F, 0xFE,
  0x1F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0x80, 0x03,
  0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x78, 0x00, 0x02, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x0F, 0x00,
  0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0xFF,
  0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x7E, 0x00,
  0x0F, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xFC, 0x3F, 0xFF,
  0x8F, 0xFF, 0xC7, 0xFF, 0xF3, 0x83, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0xFC,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0x87, 0xE3, 0xE0,
  0x3E, 0x3C, 0x01, 0xF7, 0xC0, 0x1F, 0x78, 0x01, 0xF7, 0x81, 0xFF, 0xF8,
  0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xF1, 0xFF,
  0x1F, 0x1F, 0xF1, 0xE1, 0xFF, 0x3E, 0x1F, 0xF3, 0xE1, 0xFF, 0x3E, 0x1F,
  0xF1, 0xE1, 0xFF, 0x1F, 0x1F, 0xF1, 0xF1, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF,
  0xF7, 0x8F, 0xFF, 0x78, 0x3F, 0xF7, 0xC1, 0xFC, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x60, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFB, 0xE0,
  0x03, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07,
  0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7E, 0x03, 0xE0, 0xF8, 0x1F, 0x83,
  0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE3, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8,
  0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x3F, 0xF0, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xF8, 0x3F, 0xBF, 0x03, 0xF7,
  0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3E, 0x7E, 0x0F, 0xCF,
  0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0xFF, 0xFF, 0xDF,
  0x81, 0xFB, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xCF, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFE,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFC, 0x0E, 0x3F, 0x80,
  0x23, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x02, 0x3F, 0xC0, 0xE1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x7F, 0xE0,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF9, 0xF8, 0x7F,
  0x3F, 0x07, 0xF7, 0xE0, 0x7E, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x1F, 0xBF, 0x07, 0xF7, 0xE1, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBE, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xCF,
  0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFC,
  0x0E, 0x3F, 0x80, 0x23, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F,
  0x7C, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0xC3,
  0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F,
  0xFC, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1,
  0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE2, 0x01, 0xF9, 0xE0,
  0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE1, 0xFF, 0xF0, 0x0F, 0xF0,
  0x00, 0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0xFC,
  0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0xFC, 0x0F,
  0xDF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFD, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFE,
  0x0F, 0xC7, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0xCF, 0xC0,
  0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3C, 0x03, 0xE7, 0xE0, 0x3E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E,
  0x7F, 0x07, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF8, 0xEE, 0x7B, 0x9E,
  0xF7, 0xB9, 0xEF, 0x7B, 0xDC, 0xF7, 0xBF, 0xCF, 0x79, 0xFC, 0xF7, 0x9F,
  0xCF, 0x79, 0xF8, 0xF7, 0x9F, 0x8F, 0xF8, 0xF8, 0xFF, 0x8F, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xBC,
  0x7F, 0xEF, 0x9F, 0xF9, 0xE7, 0xFE, 0x7D, 0xFF, 0x8F, 0x7F, 0xE3, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE,
  0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC3, 0xF0, 0xFE, 0x7E, 0x07, 0xE7, 0xE0, 0x3E, 0x7C,
  0x03, 0xF7, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x7E, 0x03,
  0xE7, 0xE0, 0x7E, 0x3F, 0x0F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF,
  0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF,
  0xC3, 0xFF, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC3, 0xF0, 0xFE, 0x7E, 0x07, 0xE7, 0xE0, 0x3E, 0x7C,
  0x03, 0xF7, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x7E, 0x03,
  0xE7, 0xE0, 0x7E, 0x3F, 0x0F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0xE0,
  0x3F, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x8F, 0xC3, 0xF8, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0,
  0x7C, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC3, 0xFC, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F,
  0xC7, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x8F, 0xC0, 0xF8,
  0xFC, 0x0F, 0xCF, 0xC0, 0x7C, 0xFC, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03,
  0xF0, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFC, 0x0E, 0x3F, 0x00, 0x47, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFA, 0x00, 0x3F, 0x78, 0x1F,
  0xCF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x87, 0xFF, 0xE0, 0x1F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xF7, 0xF0, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0xF8, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7D, 0xF8, 0x03, 0xE7, 0xC0, 0x3F, 0x3E, 0x01, 0xF9,
  0xF8, 0x0F, 0xCF, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0x81,
  0xF8, 0x7E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x3E, 0x03,
  0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE7, 0xC0, 0x0F, 0x3E,
  0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0xF1, 0xFF, 0x8F, 0x9F, 0xF8, 0xF9, 0xF7, 0x9F, 0x9F, 0x79, 0xFC, 0xF7,
  0x9F, 0xCF, 0x7B, 0xDC, 0xF7, 0xBD, 0xCF, 0x7B, 0x9E, 0xF7, 0xF8, 0xEF,
  0x7F, 0x8E, 0xF7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0x7E, 0x7E, 0x07,
  0xE7, 0xE0, 0x7E, 0x3E, 0x03, 0xE3, 0xC0, 0x3E, 0x7E, 0x00, 0xF8, 0xFC,
  0x07, 0xE3, 0xF0, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x3F, 0x1F,
  0x80, 0x7C, 0x7C, 0x01, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7E, 0xFC,
  0x01, 0xF3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3E, 0x1F, 0x81, 0xF8, 0x3F, 0x07,
  0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xFC, 0x07, 0xE7,
  0xE0, 0x3E, 0x1F, 0x03, 0xF0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x8F,
  0xC0, 0xFC, 0x7C, 0x03, 0xE7, 0xE0, 0x1F, 0xBE, 0x00, 0x7D, 0xF0, 0x03,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xEF, 0x80, 0x3F,
  0x7E, 0x03, 0xF1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x1F, 0x80, 0xFC,
  0xFC, 0x07, 0xEF, 0xC0, 0x1F, 0xBE, 0x00, 0xF0, 0x20, 0x02, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x20, 0x0E, 0x07, 0xC3, 0xFC, 0xFF, 0x87, 0xE0, 0x78, 0x04, 0x0F,
  0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x84, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC1, 0xFF, 0xF1, 0xFF, 0xFD,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC7, 0xFF,
  0xF0, 0x7F, 0xE0, 0x18, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x9F, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF,
  0xFB, 0xF0, 0xFE, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x81, 0xFB, 0xE0, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF,
  0xE3, 0xFF, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFC, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0x01, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xF0,
  0x08, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x3F,
  0xE0, 0x00, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x3F, 0x7C, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFD, 0xFC,
  0x3F, 0x7E, 0x07, 0xDF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xDF, 0x81, 0xF7,
  0xE0, 0x7D, 0xFC, 0x1F, 0x3F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xF0, 0x7E, 0x7E, 0x03, 0xE7, 0xE0, 0x3E,
  0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x0C, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7E, 0x06, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0x0F,
  0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7C, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xF7, 0xC0, 0x7E, 0xF8, 0x0F, 0xDF, 0x81, 0xFB, 0xF8, 0x3F,
  0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x30, 0x1F, 0xC7, 0xFF, 0xF9,
  0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x18, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0xFC, 0x1F, 0xFF, 0x8F,
  0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFD, 0xF0, 0x7E, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC1, 0x01, 0xFF,
  0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x3C,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF,
  0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x20, 0x3F, 0x78, 0x7F, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFC,
  0x7F, 0xF8, 0x0F, 0xE0, 0x18, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0xEF, 0x81, 0xF9, 0xF0,
  0x7E, 0x3E, 0x1F, 0x87, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x3F, 0x03, 0xEF,
  0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0xFC, 0x07, 0xCF,
  0xC0, 0xF8, 0xFC, 0x1F, 0x1F, 0xC3, 0xE1, 0xF8, 0x7C, 0x1F, 0x8F, 0x83,
  0xF9, 0xF0, 0x3F, 0x3E, 0x03, 0xF7, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC1,
  0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFC,
  0x1F, 0x8F, 0x8F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x0F, 0xF8, 0xF0, 0xFF, 0x8F,
  0x0F, 0xF8, 0xF8, 0xFF, 0x8F, 0x8F, 0xF8, 0xF8, 0xFF, 0x8F, 0x8F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x1F, 0xF0, 0x7F, 0xFE, 0x3F,
  0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xC1, 0xFB, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xF0, 0xFE, 0x7E, 0x07, 0xE7,
  0xE0, 0x3F, 0x7C, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x07,
  0xE3, 0xF0, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F,
  0xF0, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3E, 0x0F, 0xEF, 0x81, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xBF, 0x0F, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0x9F, 0x83, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0x0F,
  0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7C, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xF0, 0x3F,
  0x7E, 0x07, 0xEF, 0xE1, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC0, 0xFD, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xE0, 0x0B, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0xE1, 0xFF,
  0xF8, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0x80, 0xC7, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x40, 0x0F, 0xDE, 0x03, 0xF7, 0xFF,
  0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x18, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC,
  0x07, 0xFF, 0x80, 0x7F, 0xC0, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF1,
  0xFF, 0xF8, 0x3F, 0xC0, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xBF, 0x00, 0x7C,
  0xF8, 0x07, 0xE7, 0xE0, 0x3E, 0x3F, 0x01, 0xF0, 0xF8, 0x1F, 0x87, 0xE0,
  0xF8, 0x3F, 0x0F, 0xC0, 0xF8, 0x7E, 0x07, 0xE3, 0xE0, 0x1F, 0x3F, 0x00,
  0xF9, 0xF0, 0x07, 0xEF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x78, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0x78,
  0x78, 0x7D, 0xE1, 0xF1, 0xE7, 0xC7, 0xC7, 0x9F, 0x1F, 0x1E, 0x7C, 0xFC,
  0x79, 0xF3, 0xF9, 0xE3, 0xCF, 0xE7, 0x8F, 0x7F, 0x9E, 0x3D, 0xEE, 0xF0,
  0xF7, 0x3F, 0xC3, 0xDC, 0xFF, 0x0F, 0xF1, 0xFC, 0x1F, 0x87, 0xF0, 0x7E,
  0x1F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x03, 0xE0, 0xFC, 0x03,
  0xF3, 0xF0, 0x1F, 0x0F, 0xC1, 0xF8, 0x7E, 0x1F, 0x81, 0xF8, 0xF8, 0x07,
  0xEF, 0xC0, 0x1F, 0x7C, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3F,
  0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x0F, 0xC1, 0xF8, 0x3F, 0x1F, 0x81, 0xF8,
  0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0x00, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E,
  0x03, 0xF3, 0xE0, 0x3E, 0x3F, 0x03, 0xE3, 0xF0, 0x7E, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x87, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0x80, 0xFC, 0xF8,
  0x07, 0xCF, 0x80, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x04, 0x3F, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3E, 0x00, 0x1F, 0xE0, 0x0F, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC,
  0x07, 0xF8, 0x00, 0x0F, 0x80, 0x60, 0xFF, 0x07, 0xCF, 0xFC, 0x3E, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x7C, 0x7F, 0xF3, 0xE0, 0xFF, 0x06, 0x01, 0xF0,
};

const GFXglyph UbuntuMono_Bold45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 7, 29, 23, 8, -28 },
  { 27, 15, 13, 23, 4, -31 },
  { 52, 21, 28, 23, 1, -28 },
  { 126, 19, 35, 23, 2, -31 },
  { 210, 22, 30, 23, 0, -29 },
  { 293, 21, 29, 23, 1, -29 },
  { 370, 6, 13, 23, 8, -31 },
  { 380, 15, 39, 23, 4, -32 },
  { 454, 14, 39, 23, 4, -32 },
  { 523, 19, 17, 23, 2, -28 },
  { 564, 19, 21, 23, 2, -21 },
  { 614, 10, 15, 23, 6, -7 },
  { 633, 12, 5, 23, 5, -14 },
  { 641, 8, 8, 23, 7, -7 },
  { 649, 18, 38, 23, 2, -31 },
  { 735, 19, 30, 23, 2, -29 },
  { 807, 19, 28, 23, 2, -28 },
  { 874, 19, 29, 23, 2, -29 },
  { 943, 18, 30, 23, 2, -29 },
  { 1011, 20, 28, 23, 1, -28 },
  { 1081, 18, 29, 23, 2, -28 },
  { 1147, 18, 29, 23, 2, -28 },
  { 1213, 18, 28, 23, 2, -28 },
  { 1276, 19, 30, 23, 2, -29 },
  { 1348, 19, 29, 23, 2, -29 },
  { 1417, 8, 22, 23, 7, -21 },
  { 1439, 10, 29, 23, 5, -21 },
  { 1476, 19, 19, 23, 2, -21 },
  { 1522, 19, 14, 23, 2, -18 },
  { 1556, 19, 19, 23, 2, -21 },
  { 1602, 17, 30, 23, 3, -29 },
  { 1666, 20, 35, 23, 1, -29 },
  { 1754, 22, 28, 23, 0, -28 },
  { 1831, 19, 30, 23, 2, -29 },
  { 1903, 20, 30, 23, 1, -29 },
  { 1978, 19, 29, 23, 2, -28 },
  { 2047, 18, 28, 23, 3, -28 },
  { 2110, 17, 28, 23, 3, -28 },
  { 2170, 20, 30, 23, 1, -29 },
  { 2245, 18, 28, 23, 2, -28 },
  { 2308, 18, 28, 23, 2, -28 },
  { 2371, 18, 29, 23, 2, -28 },
  { 2437, 20, 28, 23, 2, -28 },
  { 2507, 18, 28, 23, 3, -28 },
  { 2570, 20, 28, 23, 1, -28 },
  { 2640, 18, 28, 23, 2, -28 },
  { 2703, 20, 30, 23, 1, -29 },
  { 2778, 19, 29, 23, 2, -29 },
  { 2847, 20, 37, 23, 1, -29 },
  { 2940, 20, 29, 23, 2, -29 },
  { 3013, 19, 30, 23, 2, -29 },
  { 3085, 20, 28, 23, 1, -28 },
  { 3155, 19, 29, 23, 2, -28 },
  { 3224, 21, 28, 23, 1, -28 },
  { 3298, 20, 28, 23, 1, -28 },
  { 3368, 22, 28, 23, 0, -28 },
  { 3445, 21, 28, 23, 1, -28 },
  { 3519, 18, 28, 23, 2, -28 },
  { 3582, 13, 38, 23, 5, -31 },
  { 3644, 18, 38, 23, 2, -31 },
  { 3730, 12, 38, 23, 5, -31 },
  { 3787, 21, 15, 23, 1, -28 },
  { 3827, 22, 5, 23, 0, 2 },
  { 3841, 10, 8, 23, 7, -31 },
  { 3851, 18, 23, 23, 2, -22 },
  { 3903, 18, 33, 23, 3, -32 },
  { 3978, 19, 23, 23, 2, -22 },
  { 4033, 18, 33, 23, 1, -32 },
  { 4108, 20, 23, 23, 1, -22 },
  { 4166, 20, 32, 23, 2, -32 },
  { 4246, 19, 30, 23, 1, -22 },
  { 4318, 17, 32, 23, 3, -32 },
  { 4386, 19, 32, 23, 2, -31 },
  { 4462, 16, 39, 23, 2, -31 },
  { 4540, 19, 32, 23, 3, -32 },
  { 4616, 19, 32, 23, 2, -31 },
  { 4692, 20, 22, 23, 1, -22 },
  { 4747, 17, 22, 23, 3, -22 },
  { 4794, 20, 23, 23, 1, -22 },
  { 4852, 18, 29, 23, 3, -22 },
  { 4918, 19, 29, 23, 1, -22 },
  { 4987, 17, 22, 23, 4, -22 },
  { 5034, 18, 23, 23, 2, -22 },
  { 5086, 19, 28, 23, 2, -27 },
  { 5153, 17, 22, 23, 3, -21 },
  { 5200, 21, 21, 23, 1, -21 },
  { 5256, 22, 21, 23, 0, -21 },
  { 5314, 21, 21, 23, 1, -21 },
  { 5370, 20, 29, 23, 1, -21 },
  { 5443, 17, 21, 23, 3, -21 },
  { 5488, 17, 38, 23, 3, -31 },
  { 5569, 6, 38, 23, 8, -31 },
  { 5598, 17, 38, 23, 3, -31 },
  { 5679, 21, 8, 23, 1, -16 },
};

const GFXfont UbuntuMono_Bold45pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold45pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold45pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _UBUNTUMONO_BOLD45PT7B_H_
