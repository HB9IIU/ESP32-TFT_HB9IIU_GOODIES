#ifndef _UBUNTUMONO_BOLD23PT7B_H_
#define _UBUNTUMONO_BOLD23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold23pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0x60, 0x0E, 0xFE, 0xE7, 0xE7, 0xE6, 0xE6,
  0xE6, 0x46, 0x0C, 0xC1, 0x98, 0x73, 0x0E, 0xEF, 0xFF, 0xFF, 0xC6, 0x61,
  0xCC, 0xFF, 0xFF, 0xFC, 0xCC, 0x19, 0x87, 0x30, 0xEE, 0x00, 0x1C, 0x07,
  0x03, 0xF9, 0xFE, 0xF0, 0xB8, 0x0E, 0x01, 0xE0, 0x7E, 0x07, 0xE0, 0x78,
  0x07, 0x01, 0xF0, 0xEF, 0xF9, 0xF8, 0x1C, 0x07, 0x00, 0x70, 0x6F, 0x1B,
  0x63, 0x64, 0xCD, 0xB0, 0xF6, 0x1D, 0x80, 0x6E, 0x0F, 0xE3, 0x6C, 0xCD,
  0x99, 0xB6, 0x3F, 0x83, 0x80, 0x1E, 0x07, 0xE0, 0xCE, 0x39, 0xC3, 0x70,
  0x7C, 0x07, 0x3B, 0xF6, 0x6F, 0xCC, 0xFB, 0x8F, 0x31, 0xE7, 0xFC, 0x7D,
  0xC0, 0xFF, 0xF6, 0xD8, 0x06, 0x0E, 0x1E, 0x3C, 0x38, 0x70, 0x60, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x06,
  0x41, 0xC1, 0xE1, 0xC1, 0xC1, 0x83, 0x87, 0x06, 0x0C, 0x18, 0x30, 0x61,
  0xC3, 0x8E, 0x38, 0xF3, 0xC2, 0x00, 0x1C, 0x03, 0x04, 0xCB, 0xFE, 0xFF,
  0x87, 0x83, 0xF1, 0xDE, 0x32, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF,
  0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x33, 0xDE, 0x71, 0x9B, 0x98,
  0xFF, 0xFF, 0xC0, 0xEF, 0xFE, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38,
  0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x60, 0x70,
  0x38, 0x1C, 0x1C, 0x00, 0x1E, 0x1F, 0xC7, 0x3B, 0x86, 0xE1, 0xB3, 0x7D,
  0xDF, 0x37, 0xC1, 0xF8, 0x6E, 0x19, 0xCE, 0x7F, 0x0F, 0x80, 0x0E, 0x07,
  0x87, 0xE3, 0xF8, 0x6E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x7F, 0xDF, 0xF0, 0x3E, 0x3F, 0xC4, 0x38, 0x0E, 0x03, 0x81, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0xC0, 0xFF, 0xFF, 0xF0, 0x3E, 0x7F,
  0x91, 0xE0, 0x70, 0x38, 0x38, 0xFC, 0x7E, 0x03, 0x81, 0xC0, 0xF0, 0x7F,
  0xF3, 0xF0, 0x07, 0x01, 0xC0, 0xF0, 0x7C, 0x3B, 0x0C, 0xC7, 0x31, 0x8C,
  0xE3, 0x3F, 0xFF, 0xFC, 0x0C, 0x03, 0x00, 0xC0, 0x7F, 0xBF, 0xDC, 0x0E,
  0x07, 0x03, 0xE1, 0xFC, 0x0F, 0x03, 0x81, 0xC0, 0xF0, 0x7F, 0xF7, 0xF0,
  0x07, 0x8F, 0xCF, 0x0E, 0x07, 0x07, 0xF3, 0xFF, 0xC7, 0xE1, 0xF0, 0xF8,
  0x6E, 0x77, 0xF0, 0xF0, 0xFF, 0xFF, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38,
  0x18, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0x3E, 0x1F, 0xE6, 0x3B,
  0x86, 0xE3, 0x9C, 0xE7, 0xF1, 0xFC, 0xE7, 0xB8, 0x7E, 0x1F, 0x8E, 0x7F,
  0x8F, 0x80, 0x3E, 0x1F, 0xC6, 0x3B, 0x8E, 0xE1, 0xB8, 0x7E, 0x19, 0xFE,
  0x3F, 0x80, 0xE0, 0x70, 0x7C, 0x7C, 0x1C, 0x00, 0xEF, 0xFE, 0x00, 0x0E,
  0xFF, 0xE0, 0x73, 0xDE, 0xE0, 0x00, 0x0E, 0x7B, 0xDE, 0x67, 0x73, 0x00,
  0x00, 0x81, 0xE1, 0xFD, 0xF8, 0xF0, 0x3C, 0x07, 0xE0, 0x7F, 0x07, 0x80,
  0x20, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x40, 0x3C, 0x0F,
  0xE0, 0x7E, 0x07, 0xC1, 0xF1, 0xFB, 0xF8, 0xF0, 0x10, 0x00, 0x7C, 0xFE,
  0x87, 0x07, 0x07, 0x1E, 0x1C, 0x38, 0x30, 0x00, 0x00, 0x38, 0x78, 0x38,
  0x0F, 0x07, 0xF8, 0xC3, 0x30, 0x76, 0x7E, 0xDF, 0xDB, 0xBF, 0x67, 0xEC,
  0xFD, 0x9D, 0xBB, 0xB3, 0xF6, 0x3E, 0xE0, 0x0E, 0x00, 0xFE, 0x0F, 0xC0,
  0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xB8, 0x37, 0x0E, 0x61, 0xCE, 0x31,
  0xCF, 0xF9, 0xFF, 0x38, 0x76, 0x0F, 0xC1, 0xC0, 0xFE, 0x3F, 0xCE, 0x3B,
  0x8E, 0xE3, 0xB8, 0xEF, 0xF3, 0xFC, 0xE3, 0xB8, 0x7E, 0x1F, 0x8F, 0xFF,
  0xBF, 0x80, 0x1F, 0x8F, 0xF7, 0x0B, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x01, 0xC2, 0x3F, 0xC7, 0xE0, 0xFC, 0x3F, 0xCE, 0x3B,
  0x8E, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3B, 0x9E, 0xFF,
  0x3F, 0x00, 0xFF, 0xBF, 0xEE, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xF3, 0xFC,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1C,
  0x0E, 0x07, 0x03, 0xFD, 0xFE, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00,
  0x1F, 0xCF, 0xE7, 0x0B, 0x80, 0xE0, 0x38, 0x0E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1D, 0xC7, 0x7F, 0xC7, 0xF0, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0xFF, 0xFF, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0C, 0xFF, 0xFF,
  0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x8F,
  0xFF, 0xFC, 0x7F, 0xBF, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE8, 0xFF, 0xF3, 0xF0, 0xE3, 0xB8, 0xEE, 0x73, 0x9C, 0xEE,
  0x3F, 0x0F, 0x83, 0xF0, 0xEE, 0x39, 0xCE, 0x7B, 0x8E, 0xE3, 0xF8, 0x70,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0F, 0xFF, 0xFC, 0xE1, 0xB8, 0xEF, 0x3B, 0xCA, 0xF7, 0xF5, 0xFD,
  0xFF, 0x77, 0xCD, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x70, 0xE1, 0xF0,
  0xFC, 0x7E, 0x3F, 0x9F, 0xCF, 0xB7, 0xDB, 0xE7, 0xF3, 0xF8, 0xFC, 0x7E,
  0x1F, 0x0C, 0x3E, 0x1F, 0xC6, 0x3B, 0x86, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1B, 0x8E, 0x7F, 0x0F, 0x80, 0xFE, 0x3F, 0xEE, 0x3F,
  0x87, 0xE1, 0xF8, 0x7E, 0x3B, 0xFE, 0xFE, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x00, 0x3E, 0x1F, 0xC6, 0x3B, 0x86, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1B, 0x8E, 0x7F, 0x0F, 0x80, 0xC0, 0x3C, 0x07, 0xC0,
  0x60, 0xFE, 0x3F, 0xCE, 0x3B, 0x8E, 0xE3, 0xB8, 0xEF, 0xF3, 0xF8, 0xE7,
  0x39, 0xCE, 0x3B, 0x8E, 0xE1, 0xF8, 0x70, 0x3F, 0x1F, 0xEE, 0x13, 0x80,
  0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x03, 0x80, 0x70, 0x1D, 0x0E, 0xFF, 0x9F,
  0x80, 0xFF, 0xFF, 0xF1, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1B, 0x8E, 0x7F, 0x8F,
  0x80, 0xE0, 0xEE, 0x1D, 0xC3, 0xB8, 0x67, 0x1C, 0x63, 0x8E, 0x71, 0xCC,
  0x19, 0x83, 0x70, 0x7C, 0x0F, 0x80, 0xF0, 0x1C, 0x00, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF3, 0x7D, 0xDF, 0x7F, 0xDF, 0xFD, 0xFF, 0x3B, 0xCE,
  0xE3, 0xB8, 0x60, 0x70, 0xEE, 0x38, 0xE7, 0x1D, 0xC1, 0xF8, 0x1E, 0x03,
  0x80, 0x78, 0x1F, 0x83, 0x70, 0xE7, 0x38, 0xE7, 0x0F, 0xE1, 0xC0, 0xE0,
  0xEE, 0x1D, 0xC7, 0x1C, 0xE3, 0x98, 0x37, 0x07, 0xC0, 0x78, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xFF, 0xFF, 0xC0, 0xE0, 0xE0,
  0xF0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x1E, 0x0F, 0xFF, 0xFC, 0xFF,
  0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0F, 0xFF, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x1C,
  0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x01, 0xC0, 0xE0,
  0x70, 0xFF, 0xFC, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0xF0, 0x0E, 0x01, 0xE0, 0x7E, 0x1C,
  0xE7, 0x1C, 0xE1, 0xC8, 0x30, 0xFF, 0xFF, 0xFC, 0x21, 0xC7, 0xC6, 0x7E,
  0x3F, 0x80, 0xE0, 0x73, 0xFB, 0xFF, 0x8F, 0xC7, 0xE3, 0xBF, 0xCF, 0xE0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xCF, 0xFB, 0x8E, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xEF, 0xF1, 0xF8, 0x1F, 0xCF, 0xE7, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x0F, 0xE1, 0xFC, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x39, 0xFD, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1D, 0xFE, 0x7F, 0x1E, 0x1F, 0xCF, 0x3B, 0x86, 0xE1, 0xFF, 0xFF,
  0xFF, 0x80, 0xF0, 0x9F, 0xE1, 0xF8, 0x0F, 0xC7, 0xF3, 0xC0, 0xE0, 0x38,
  0x3F, 0xEF, 0xF8, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x3F, 0xBF, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x7F,
  0x9F, 0xC0, 0xE0, 0x78, 0x7F, 0xF9, 0xF8, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0xF3, 0xFD, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0x18, 0x0E, 0x03, 0x80, 0x60, 0x00, 0x3F, 0x0F, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x11, 0xFC, 0x1E, 0x06, 0x0F, 0x0F,
  0x06, 0x00, 0x7F, 0x7F, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x47, 0xFE, 0x7C, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0xEE, 0x7B, 0x9C, 0xEE, 0x3F, 0x0F, 0xC3, 0xB8, 0xE7, 0x38, 0xEE, 0x3B,
  0x87, 0xFC, 0x3F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x10, 0xFC, 0x3E, 0xFF, 0xBF, 0xED,
  0xDF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0x7E,
  0x7F, 0xB8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xE0,
  0x3E, 0x1F, 0xCE, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0x9F,
  0xC3, 0xE0, 0x7E, 0x3F, 0xCE, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE3, 0xBF, 0xEF, 0xF3, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x3F, 0xBF, 0xFC,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xBF, 0xCF, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x7F, 0xFF, 0xB8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x00, 0x3F, 0xBF, 0x98, 0x0E, 0x07, 0xC1, 0xF8, 0x3E, 0x07,
  0x43, 0xFF, 0xDF, 0x80, 0x38, 0x0E, 0x03, 0x83, 0xFF, 0xFF, 0xCE, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1F, 0xC3, 0xF0, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x73, 0xBF, 0xCF, 0xE0, 0xE0,
  0xEE, 0x1D, 0xC3, 0x38, 0xE3, 0x9C, 0x77, 0x06, 0xE0, 0xF8, 0x1F, 0x01,
  0xE0, 0x38, 0x00, 0xE0, 0x7C, 0x0F, 0x99, 0xB7, 0x36, 0xE6, 0xDE, 0xDB,
  0xF3, 0xDE, 0x79, 0xC7, 0x38, 0xC7, 0x00, 0x70, 0xE7, 0x38, 0xEE, 0x0F,
  0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xFC, 0x39, 0xCE, 0x39, 0xC3, 0x80, 0x70,
  0xEE, 0x18, 0xC7, 0x1C, 0xE3, 0x9C, 0x73, 0x07, 0xE0, 0xFC, 0x0F, 0x01,
  0xE0, 0x3C, 0x03, 0x00, 0xE0, 0xF8, 0x1E, 0x00, 0xFF, 0xFF, 0x0E, 0x1E,
  0x3C, 0x38, 0x78, 0x70, 0xE0, 0xFF, 0xFF, 0x0F, 0x8F, 0xC7, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x18, 0x7C, 0x3E, 0x03, 0x01, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x7E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E,
  0x03, 0xC1, 0xE1, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x3F, 0x1F,
  0x00, 0x38, 0x6F, 0xCD, 0xFF, 0xB3, 0xE6, 0x38,
};

const GFXglyph UbuntuMono_Bold23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 14, 12, 4, -14 },
  { 8, 8, 6, 12, 2, -16 },
  { 14, 11, 14, 12, 0, -14 },
  { 34, 10, 18, 12, 1, -16 },
  { 57, 11, 14, 12, 0, -14 },
  { 77, 11, 14, 12, 0, -14 },
  { 97, 3, 7, 12, 4, -16 },
  { 100, 8, 20, 12, 2, -16 },
  { 120, 7, 20, 12, 2, -16 },
  { 138, 10, 9, 12, 1, -14 },
  { 150, 10, 10, 12, 1, -11 },
  { 163, 5, 8, 12, 3, -4 },
  { 168, 6, 3, 12, 3, -7 },
  { 171, 4, 4, 12, 4, -4 },
  { 173, 9, 20, 12, 1, -16 },
  { 196, 10, 14, 12, 1, -14 },
  { 214, 10, 14, 12, 1, -14 },
  { 232, 10, 14, 12, 1, -14 },
  { 250, 9, 14, 12, 1, -14 },
  { 266, 10, 14, 12, 1, -14 },
  { 284, 9, 14, 12, 1, -14 },
  { 300, 9, 14, 12, 1, -14 },
  { 316, 9, 14, 12, 1, -14 },
  { 332, 10, 14, 12, 1, -14 },
  { 350, 10, 14, 12, 1, -14 },
  { 368, 4, 11, 12, 4, -11 },
  { 374, 5, 15, 12, 3, -11 },
  { 384, 10, 10, 12, 1, -11 },
  { 397, 10, 6, 12, 1, -9 },
  { 405, 10, 10, 12, 1, -11 },
  { 418, 8, 14, 12, 2, -14 },
  { 432, 11, 17, 12, 0, -14 },
  { 456, 11, 14, 12, 0, -14 },
  { 476, 10, 14, 12, 1, -14 },
  { 494, 10, 14, 12, 1, -14 },
  { 512, 10, 14, 12, 1, -14 },
  { 530, 10, 14, 12, 1, -14 },
  { 548, 9, 14, 12, 1, -14 },
  { 564, 10, 14, 12, 1, -14 },
  { 582, 9, 14, 12, 1, -14 },
  { 598, 9, 14, 12, 1, -14 },
  { 614, 9, 14, 12, 1, -14 },
  { 630, 10, 14, 12, 1, -14 },
  { 648, 9, 14, 12, 2, -14 },
  { 664, 10, 14, 12, 1, -14 },
  { 682, 9, 14, 12, 1, -14 },
  { 698, 10, 14, 12, 1, -14 },
  { 716, 10, 14, 12, 1, -14 },
  { 734, 10, 18, 12, 1, -14 },
  { 757, 10, 14, 12, 1, -14 },
  { 775, 10, 14, 12, 1, -14 },
  { 793, 10, 14, 12, 1, -14 },
  { 811, 10, 14, 12, 1, -14 },
  { 829, 11, 14, 12, 0, -14 },
  { 849, 10, 14, 12, 1, -14 },
  { 867, 11, 14, 12, 0, -14 },
  { 887, 11, 14, 12, 0, -14 },
  { 907, 9, 14, 12, 1, -14 },
  { 923, 6, 20, 12, 3, -16 },
  { 938, 9, 20, 12, 1, -16 },
  { 961, 7, 20, 12, 2, -16 },
  { 979, 11, 7, 12, 0, -14 },
  { 989, 11, 2, 12, 0, 2 },
  { 992, 6, 4, 12, 3, -16 },
  { 995, 9, 11, 12, 1, -11 },
  { 1008, 10, 16, 12, 1, -16 },
  { 1028, 10, 11, 12, 1, -11 },
  { 1042, 9, 16, 12, 1, -16 },
  { 1060, 10, 11, 12, 1, -11 },
  { 1074, 10, 16, 12, 1, -16 },
  { 1094, 9, 15, 12, 1, -11 },
  { 1111, 9, 16, 12, 1, -16 },
  { 1129, 10, 16, 12, 1, -16 },
  { 1149, 8, 20, 12, 1, -16 },
  { 1169, 10, 16, 12, 1, -16 },
  { 1189, 10, 16, 12, 1, -16 },
  { 1209, 10, 11, 12, 1, -11 },
  { 1223, 9, 11, 12, 1, -11 },
  { 1236, 10, 11, 12, 1, -11 },
  { 1250, 10, 15, 12, 1, -11 },
  { 1269, 9, 15, 12, 1, -11 },
  { 1286, 9, 11, 12, 2, -11 },
  { 1299, 9, 11, 12, 1, -11 },
  { 1312, 10, 14, 12, 1, -14 },
  { 1330, 9, 11, 12, 1, -11 },
  { 1343, 11, 11, 12, 0, -11 },
  { 1359, 11, 11, 12, 0, -11 },
  { 1375, 11, 11, 12, 0, -11 },
  { 1391, 11, 15, 12, 0, -11 },
  { 1412, 8, 11, 12, 2, -11 },
  { 1423, 9, 20, 12, 1, -16 },
  { 1446, 3, 20, 12, 4, -16 },
  { 1454, 9, 20, 12, 1, -16 },
  { 1477, 11, 5, 12, 0, -8 },
};

const GFXfont UbuntuMono_Bold23pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold23pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold23pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _UBUNTUMONO_BOLD23PT7B_H_
