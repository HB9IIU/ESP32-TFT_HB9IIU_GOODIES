#ifndef _UBUNTUMONO_BOLD40PT7B_H_
#define _UBUNTUMONO_BOLD40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xE7,
  0x9E, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0x78, 0xFC, 0xFF, 0xF3, 0xFF,
  0xCF, 0xDF, 0x3F, 0x7C, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x79,
  0xE1, 0xE3, 0x87, 0x80, 0x03, 0xC7, 0x81, 0xE1, 0xE0, 0x78, 0xF8, 0x1E,
  0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF1, 0xE0, 0x7C, 0x78, 0x1E, 0x1E, 0x07, 0x8F, 0x01,
  0xE3, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF1,
  0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0xC7, 0x81, 0xE3, 0xE0, 0x78, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x07, 0xFE,
  0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x07, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0xFD, 0xE0, 0x7E, 0x7F, 0xFF, 0x9F, 0xFF, 0xC7,
  0xFF, 0xE0, 0x3F, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0xF3, 0xF0, 0x1E, 0x7F, 0x81, 0xC7, 0x38, 0x3C, 0xF3,
  0x87, 0x8F, 0x38, 0x70, 0xF3, 0x8F, 0x0F, 0x39, 0xE0, 0x73, 0x9C, 0x07,
  0xFB, 0xC0, 0x3F, 0x38, 0x01, 0xE7, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x78,
  0x01, 0xCF, 0xC0, 0x3D, 0xFE, 0x03, 0x9C, 0xE0, 0x79, 0xCE, 0x0F, 0x1C,
  0xF0, 0xE1, 0xCF, 0x1E, 0x1C, 0xF3, 0xC1, 0xCE, 0x38, 0x1F, 0xE7, 0x80,
  0xFC, 0xF0, 0x07, 0x80, 0x07, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0xFF,
  0xF0, 0x3C, 0x7C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF1, 0xF0, 0x3E, 0xF8,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7E, 0x1E, 0x3F, 0xC7, 0x9F, 0xF9, 0xE7,
  0xBF, 0x7B, 0xE7, 0xDE, 0xF0, 0xFF, 0xBC, 0x1F, 0xCF, 0x03, 0xF3, 0xC0,
  0x7C, 0xF8, 0x7F, 0x1F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xDF, 0x0F, 0xC7,
  0xC0, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0x9E, 0x79, 0xE7, 0x8E, 0x00, 0x20,
  0x07, 0x80, 0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x0F,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F,
  0x00, 0xFE, 0x03, 0xF0, 0x07, 0x00, 0x18, 0x30, 0x01, 0xC0, 0x1F, 0x00,
  0xFE, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x0F, 0xE0, 0x7E,
  0x01, 0xC0, 0x0C, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x63, 0xC6,
  0x7B, 0xDE, 0x7D, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x0F, 0xF0,
  0x1F, 0xF8, 0x3E, 0x7C, 0x3E, 0x7C, 0x1C, 0x38, 0x04, 0x30, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x1F,
  0x8F, 0xE7, 0xF3, 0xF9, 0xFC, 0x7E, 0x0E, 0x0F, 0x07, 0x8F, 0x9F, 0x8F,
  0x83, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x7E, 0x7E,
  0xFF, 0x7E, 0x7E, 0x3C, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3E,
  0x1F, 0x1F, 0x03, 0xE7, 0xC0, 0xF9, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01,
  0xEF, 0x8C, 0x7F, 0xE7, 0x9F, 0xF9, 0xE7, 0xFE, 0x79, 0xFF, 0x8C, 0x7D,
  0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x3E,
  0x1F, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x00,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0x7D, 0xE0, 0x71, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x0F, 0xE0, 0x3F, 0xF8, 0xFF, 0xFC, 0xFF, 0xFC, 0x78, 0x7E, 0x60,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0x7F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC, 0x70,
  0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0xE0, 0x7E, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF8, 0x3F, 0xE0, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1E, 0xF8, 0x0F,
  0xBE, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0xF8, 0xF8, 0x3C, 0x3E, 0x1F, 0x0F,
  0x87, 0x83, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x07,
  0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF6, 0x03, 0xF3, 0xFF,
  0xF9, 0xFF, 0xF9, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x3E, 0x01, 0xFE,
  0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xE0, 0x3F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F,
  0x7E, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xC3, 0xF7, 0xC0,
  0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1E, 0x3E, 0x1F, 0x1F, 0xDF, 0x07,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xE1, 0xF3, 0xF9, 0xF0, 0x7E, 0xF0, 0x1F,
  0x78, 0x07, 0xBC, 0x03, 0xFF, 0x03, 0xEF, 0xC3, 0xF7, 0xFF, 0xF9, 0xFF,
  0xF8, 0x7F, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7F, 0xFE, 0x7C, 0x3E, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF,
  0x0F, 0xDF, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF8,
  0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x7C, 0x00, 0x3C, 0x7E, 0x7E, 0xFF,
  0x7E, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0x7E, 0xFF,
  0x7E, 0x7E, 0x3C, 0x1E, 0x1F, 0x8F, 0xCF, 0xF3, 0xF1, 0xF8, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE1, 0xF8, 0xFC, 0xFE, 0x3F, 0x9F, 0xC7,
  0xC1, 0xE0, 0xF0, 0xF1, 0xF9, 0xF8, 0xF8, 0x70, 0x00, 0x00, 0x02, 0x00,
  0x0F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x81,
  0xFE, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x02, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x00,
  0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0x00, 0x1F, 0x00, 0xFF, 0x03, 0xFF, 0x1F, 0xFC, 0xFF, 0xF0,
  0xFF, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0x40, 0x00, 0x1F, 0xC3, 0xFF, 0xCF,
  0xFF, 0xBF, 0xFF, 0x60, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x0F, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0x78,
  0x3C, 0x3C, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x7D, 0xC1, 0xFF, 0xF0, 0xFF,
  0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0xCF, 0x8F, 0xE3, 0xC3, 0xF8, 0xF0, 0xFE,
  0x3C, 0x3F, 0x8F, 0x0F, 0xE3, 0xC3, 0xF8, 0xF0, 0xFE, 0x3E, 0x3F, 0xCF,
  0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xF7, 0x03, 0xF9, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x18, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xE0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xBE, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x79,
  0xF0, 0x0F, 0x1F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF8, 0x1F,
  0x0F, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3,
  0xE0, 0x7C, 0x7C, 0x07, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E,
  0xFC, 0x03, 0xF0, 0x7F, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF,
  0x83, 0xE7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3C, 0xF8, 0x3E, 0x7C, 0x3F,
  0x3F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFF, 0xC7, 0xFF, 0xFB, 0xE0, 0xFD, 0xF0,
  0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xF7,
  0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x00, 0xFE, 0x01,
  0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0x83, 0x8F, 0x80, 0x27, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x02, 0x3F, 0x83, 0x87, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF,
  0x1F, 0xFF, 0x8F, 0x87, 0xE7, 0xC1, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8,
  0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xBE, 0x07, 0xDF, 0x07,
  0xEF, 0x8F, 0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF,
  0x9F, 0xFF, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x9F,
  0xFF, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x01, 0xFF,
  0x81, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x81, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07,
  0x9F, 0x01, 0xE7, 0xC0, 0x79, 0xF8, 0x1E, 0x3F, 0x07, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x40, 0x3E, 0x70, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x1F,
  0xC0, 0xF8, 0x1F, 0x3E, 0x0F, 0xCF, 0x83, 0xE3, 0xE1, 0xF8, 0xF8, 0x7C,
  0x3E, 0x3F, 0x0F, 0x9F, 0x83, 0xE7, 0xC0, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xBF, 0x03, 0xE7,
  0xE0, 0xF9, 0xF8, 0x3E, 0x3F, 0x0F, 0x87, 0xE3, 0xE1, 0xF8, 0xF8, 0x3F,
  0x3E, 0x0F, 0xCF, 0x81, 0xFB, 0xE0, 0x7E, 0xF8, 0x0F, 0x80, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x0F, 0x9F,
  0x03, 0xE7, 0xC0, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0x73,
  0xF9, 0xDC, 0xEE, 0x77, 0x3B, 0x9D, 0xDE, 0xE7, 0x3F, 0x3B, 0xCF, 0xCE,
  0xF3, 0xF3, 0xFC, 0xFC, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F,
  0xF7, 0x8F, 0xF7, 0x8F, 0xF3, 0xCF, 0xF3, 0xCF, 0xF1, 0xEF, 0xF1, 0xEF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0x03, 0xF0, 0x03, 0xFF,
  0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3E, 0x1F, 0x1F, 0x03, 0xE7, 0xC0, 0xF9,
  0xE0, 0x1E, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xDE, 0x03,
  0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x3E, 0x1F, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0,
  0x3F, 0xF0, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F,
  0xFF, 0xEF, 0x83, 0xF7, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xF7, 0xFF, 0xFB, 0xFF,
  0xF9, 0xFF, 0xF0, 0xFF, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3E, 0x1F, 0x1F, 0x03,
  0xE7, 0xC0, 0xF9, 0xE0, 0x1E, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xDE, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7E, 0x1F, 0x8F, 0xFF,
  0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x78, 0x00, 0x1F, 0xE0,
  0x03, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0x38, 0xFF, 0xE0, 0x3F,
  0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF8, 0x7E, 0x3E, 0x0F, 0xCF, 0x81,
  0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x0F, 0xCF, 0x87, 0xE3, 0xFF, 0xF8,
  0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xE3, 0xE0, 0xF8, 0xFC, 0x3E,
  0x1F, 0x0F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81,
  0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0x80, 0x07, 0xF8, 0x1F, 0xFE, 0x3F, 0xFE,
  0x7F, 0xFC, 0xFC, 0x0C, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x40, 0x1F, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7F,
  0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xE0, 0xF8, 0x07, 0xDF, 0x00, 0xFB,
  0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x1F, 0x1F, 0x03, 0xE3,
  0xE0, 0x7C, 0x7C, 0x0F, 0x87, 0x81, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x81,
  0xE1, 0xF0, 0x3C, 0x3C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x0F, 0x3C, 0x01,
  0xE7, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xCF, 0xCF, 0xF3, 0xF3,
  0xFC, 0xFC, 0xF7, 0x3F, 0x39, 0xDE, 0xEE, 0x77, 0x3B, 0x9D, 0xCE, 0xE7,
  0xF1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xC0, 0xF9, 0xF0,
  0x3E, 0x7C, 0x0F, 0x80, 0x7C, 0x03, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC1,
  0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xDF, 0x00, 0xF9,
  0xF0, 0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0xC3, 0xE0, 0x7C, 0x3E,
  0x07, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xDF, 0x00, 0xFB,
  0xF0, 0x1F, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0x7C, 0x1E, 0x0F, 0x87, 0xC0,
  0xF0, 0xF8, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3E, 0x7C, 0x07,
  0xC7, 0xC1, 0xF0, 0xF8, 0x7E, 0x0F, 0x8F, 0x81, 0xFB, 0xF0, 0x1F, 0x3C,
  0x03, 0xE1, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x20, 0x1C, 0x1F, 0x1F, 0xE3, 0xF8, 0x78, 0x08, 0x1F, 0xE0,
  0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x20, 0x3E, 0x00, 0x1E, 0x00, 0x1F,
  0x0F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x0F, 0xFC,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7D, 0xF8, 0x3F, 0xFF, 0x1F,
  0xFF, 0xCF, 0xFF, 0xE7, 0xE1, 0xFB, 0xE0, 0x7D, 0xF0, 0x3F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFB, 0xE0,
  0x7D, 0xF0, 0x7E, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE7, 0xF0, 0x23, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x04, 0x7F, 0xFE, 0x1F, 0xFF,
  0x07, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x07,
  0xDF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7E, 0x3F, 0x7C, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC,
  0x1F, 0x7C, 0x1F, 0x7E, 0x1F, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07,
  0xFC, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x1F,
  0x9F, 0x03, 0xE7, 0xC0, 0x7B, 0xE0, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x30, 0xFF,
  0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7E, 0x0C, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF7,
  0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x81, 0xF7, 0xC0, 0xFB, 0xF0, 0xFD, 0xFF, 0xFE, 0x7F,
  0xFF, 0x1F, 0xFF, 0x83, 0xF7, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF3,
  0x01, 0xF9, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xF8, 0x0F, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xEF, 0xC3, 0xFF, 0xC7, 0xFF, 0xCF, 0xFF, 0xDE,
  0x0F, 0xBC, 0x1F, 0x78, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xF0, 0x07, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC2, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x70, 0x03, 0xE0, 0x1F,
  0x80, 0x7E, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFD, 0xFF,
  0xF7, 0xFF, 0xDF, 0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7D, 0x01, 0xF7,
  0x0F, 0x9F, 0xFE, 0xFF, 0xF3, 0xFF, 0xC1, 0xFC, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x3E, 0xF0, 0x7E, 0xF0, 0xFC, 0xF0, 0xF8, 0xF1,
  0xF0, 0xF3, 0xE0, 0xF7, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xF7,
  0xC0, 0xF3, 0xE0, 0xF1, 0xF0, 0xF1, 0xF8, 0xF0, 0xFC, 0xF0, 0x7C, 0xF0,
  0x7E, 0xF0, 0x3F, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC2, 0x03,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFC, 0x3F, 0x3E, 0x3F, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xF3, 0xE7, 0xFC, 0x78, 0xFF, 0x1E, 0x3F,
  0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3C, 0x3F, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x0F,
  0xDE, 0x0F, 0xBC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xF8, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7E, 0x1F, 0x9F, 0x03, 0xE7, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xE1,
  0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xC0,
  0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x7E, 0xF0, 0x3E, 0xF0, 0x3E,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3E,
  0xF0, 0x3E, 0xF8, 0x7E, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xF7, 0xE0,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF7, 0xE0,
  0xFB, 0xE0, 0x7D, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFB, 0xE0, 0x7D, 0xF8, 0x7E, 0x7F, 0xFF,
  0x3F, 0xFF, 0x8F, 0xFF, 0xC1, 0xF3, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xF8, 0x1F, 0xFE,
  0x3F, 0xFE, 0x7F, 0xFC, 0x7C, 0x0C, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0x70, 0x3F, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x1F, 0xE0, 0x01, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x81, 0xFF, 0xE0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7E,
  0x1F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xF8, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7D, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7D, 0xF0,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1E, 0x00, 0xF8, 0x01, 0xF7, 0x80, 0x1E, 0x78, 0x01, 0xE7,
  0x80, 0x1E, 0x78, 0xF1, 0xE7, 0x8F, 0x1E, 0x78, 0xF1, 0xE7, 0x9F, 0x9E,
  0x79, 0xF9, 0xE7, 0x9F, 0x9C, 0x39, 0xF9, 0xC3, 0xBF, 0xDC, 0x3B, 0x9D,
  0xC3, 0xF9, 0xFC, 0x3F, 0x9F, 0xC3, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0,
  0xF8, 0x1E, 0x07, 0x80, 0xF8, 0x07, 0xDF, 0x03, 0xE3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x1F, 0x3E, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xCF, 0x81,
  0xE3, 0xF0, 0xF8, 0x7C, 0x7C, 0x0F, 0x9F, 0x03, 0xEF, 0x80, 0x7C, 0x7C,
  0x07, 0xDF, 0x03, 0xE7, 0xC0, 0xF9, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83,
  0xC3, 0xE1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0x80, 0xFB, 0xE0,
  0x3E, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x11, 0xF8,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC3, 0xFF, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x3F, 0x80,
  0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x03, 0xFE, 0x0F,
  0xF8, 0x3F, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7F,
  0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x3F, 0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0x01,
  0x8F, 0xE0, 0xF7, 0xFE, 0x3D, 0xFF, 0xFF, 0xFF, 0xFF, 0xBC, 0x7F, 0xEF,
  0x07, 0xF0, 0xC0, 0x78,
};

const GFXglyph UbuntuMono_Bold40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 25, 20, 7, -25 },
  { 20, 14, 11, 20, 3, -27 },
  { 40, 18, 25, 20, 1, -25 },
  { 97, 18, 32, 20, 1, -28 },
  { 169, 20, 25, 20, 0, -25 },
  { 232, 18, 25, 20, 1, -25 },
  { 289, 6, 12, 20, 7, -27 },
  { 298, 13, 35, 20, 4, -28 },
  { 355, 13, 35, 20, 3, -28 },
  { 412, 16, 15, 20, 2, -25 },
  { 442, 16, 18, 20, 2, -19 },
  { 478, 9, 14, 20, 5, -7 },
  { 494, 10, 5, 20, 5, -13 },
  { 501, 8, 7, 20, 6, -7 },
  { 508, 16, 35, 20, 2, -28 },
  { 578, 18, 25, 20, 1, -25 },
  { 635, 16, 25, 20, 2, -25 },
  { 685, 16, 25, 20, 2, -25 },
  { 735, 16, 25, 20, 2, -25 },
  { 785, 18, 25, 20, 1, -25 },
  { 842, 17, 25, 20, 1, -25 },
  { 896, 16, 25, 20, 2, -25 },
  { 946, 16, 25, 20, 2, -25 },
  { 996, 17, 25, 20, 2, -25 },
  { 1050, 16, 25, 20, 2, -25 },
  { 1100, 8, 19, 20, 6, -19 },
  { 1119, 9, 26, 20, 5, -19 },
  { 1149, 17, 17, 20, 2, -19 },
  { 1186, 16, 12, 20, 2, -16 },
  { 1210, 16, 17, 20, 2, -19 },
  { 1244, 14, 25, 20, 3, -25 },
  { 1288, 18, 30, 20, 1, -25 },
  { 1356, 20, 25, 20, 0, -25 },
  { 1419, 17, 25, 20, 2, -25 },
  { 1473, 18, 25, 20, 1, -25 },
  { 1530, 17, 25, 20, 2, -25 },
  { 1584, 15, 25, 20, 3, -25 },
  { 1631, 15, 25, 20, 3, -25 },
  { 1678, 18, 25, 20, 1, -25 },
  { 1735, 16, 25, 20, 2, -25 },
  { 1785, 16, 25, 20, 2, -25 },
  { 1835, 16, 25, 20, 2, -25 },
  { 1885, 18, 25, 20, 2, -25 },
  { 1942, 15, 25, 20, 3, -25 },
  { 1989, 18, 25, 20, 1, -25 },
  { 2046, 16, 25, 20, 2, -25 },
  { 2096, 18, 25, 20, 1, -25 },
  { 2153, 17, 25, 20, 2, -25 },
  { 2207, 18, 31, 20, 1, -25 },
  { 2277, 18, 25, 20, 2, -25 },
  { 2334, 16, 25, 20, 2, -25 },
  { 2384, 18, 25, 20, 1, -25 },
  { 2441, 16, 25, 20, 2, -25 },
  { 2491, 19, 25, 20, 1, -25 },
  { 2551, 18, 25, 20, 1, -25 },
  { 2608, 20, 25, 20, 0, -25 },
  { 2671, 19, 25, 20, 1, -25 },
  { 2731, 16, 25, 20, 2, -25 },
  { 2781, 11, 35, 20, 5, -28 },
  { 2830, 16, 35, 20, 2, -28 },
  { 2900, 11, 35, 20, 4, -28 },
  { 2949, 19, 13, 20, 1, -25 },
  { 2980, 20, 4, 20, 0, 3 },
  { 2990, 9, 7, 20, 6, -28 },
  { 2998, 16, 19, 20, 2, -19 },
  { 3036, 17, 28, 20, 2, -28 },
  { 3096, 17, 19, 20, 2, -19 },
  { 3137, 16, 28, 20, 1, -28 },
  { 3193, 18, 19, 20, 1, -19 },
  { 3236, 19, 28, 20, 1, -28 },
  { 3303, 17, 26, 20, 1, -19 },
  { 3359, 15, 28, 20, 3, -28 },
  { 3412, 18, 28, 20, 1, -28 },
  { 3475, 14, 35, 20, 2, -28 },
  { 3537, 16, 28, 20, 3, -28 },
  { 3593, 18, 28, 20, 1, -28 },
  { 3656, 18, 19, 20, 1, -19 },
  { 3699, 15, 19, 20, 3, -19 },
  { 3735, 18, 19, 20, 1, -19 },
  { 3778, 16, 26, 20, 3, -19 },
  { 3830, 17, 26, 20, 1, -19 },
  { 3886, 14, 19, 20, 4, -19 },
  { 3920, 16, 19, 20, 2, -19 },
  { 3958, 18, 25, 20, 1, -25 },
  { 4015, 16, 19, 20, 2, -19 },
  { 4053, 18, 19, 20, 1, -19 },
  { 4096, 20, 19, 20, 0, -19 },
  { 4144, 18, 19, 20, 1, -19 },
  { 4187, 18, 26, 20, 1, -19 },
  { 4246, 14, 19, 20, 3, -19 },
  { 4280, 14, 35, 20, 3, -28 },
  { 4342, 5, 35, 20, 8, -28 },
  { 4364, 14, 35, 20, 3, -28 },
  { 4426, 18, 8, 20, 1, -14 },
};

const GFXfont UbuntuMono_Bold40pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold40pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold40pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _UBUNTUMONO_BOLD40PT7B_H_
