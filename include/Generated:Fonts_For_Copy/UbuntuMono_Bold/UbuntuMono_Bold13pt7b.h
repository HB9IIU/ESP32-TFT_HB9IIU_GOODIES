#ifndef _UBUNTUMONO_BOLD13PT7B_H_
#define _UBUNTUMONO_BOLD13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x4F, 0xDD, 0xDD, 0x2C, 0xBF, 0xFF, 0xFF, 0xF5, 0x94, 0x10,
  0xE7, 0xD0, 0x78, 0xF0, 0xDF, 0x70, 0x40, 0x66, 0xAA, 0x9C, 0x2C, 0xF5,
  0xF3, 0x71, 0xE5, 0x99, 0x57, 0x3F, 0xDD, 0xF5, 0x13, 0x64, 0xCC, 0xC4,
  0x63, 0x10, 0xC6, 0x33, 0x11, 0x13, 0x36, 0xC0, 0x25, 0xFE, 0xE5, 0x00,
  0x21, 0x3F, 0xF2, 0x10, 0xDD, 0x40, 0xFF, 0xF0, 0x18, 0x8C, 0x62, 0x31,
  0x88, 0xC6, 0x20, 0x39, 0xF4, 0xF5, 0xD5, 0x37, 0xCE, 0x27, 0x28, 0x42,
  0x13, 0xFF, 0xF7, 0xE6, 0x22, 0x23, 0xFF, 0xF7, 0x86, 0xE7, 0x0F, 0xFE,
  0x18, 0xE2, 0x92, 0xFF, 0xF0, 0x82, 0x7D, 0xF7, 0x1E, 0x0C, 0x37, 0xDE,
  0x33, 0xF1, 0xEF, 0xCF, 0xEE, 0xFF, 0xC4, 0x62, 0x31, 0x88, 0x79, 0xF4,
  0xDE, 0x4D, 0x37, 0xDE, 0x77, 0xE7, 0xFF, 0x8F, 0xDC, 0xF0, 0xF0, 0xF0,
  0xF6, 0x09, 0xFD, 0x8C, 0x78, 0xE1, 0xFF, 0xC1, 0xFF, 0x80, 0x86, 0x3C,
  0x73, 0xFB, 0x10, 0xF7, 0xC6, 0x66, 0x01, 0x8C, 0x39, 0x15, 0xFF, 0xB6,
  0xDF, 0xD7, 0x60, 0xF0, 0x30, 0xE2, 0x9A, 0x7D, 0xFC, 0xF1, 0xF7, 0xE7,
  0xEF, 0xC7, 0xFE, 0x3D, 0xF6, 0x70, 0xC1, 0x17, 0xCE, 0xF7, 0xE7, 0x39,
  0xCF, 0xFE, 0xFF, 0xE1, 0xEF, 0x43, 0xFF, 0xFF, 0xE1, 0xEF, 0x42, 0x10,
  0x3D, 0xF6, 0x30, 0xCD, 0x37, 0xCF, 0x9C, 0xE7, 0xFF, 0xCE, 0x73, 0xFF,
  0xD8, 0xC6, 0x33, 0xFF, 0xFF, 0xC6, 0x31, 0xCF, 0xDE, 0x9D, 0xAD, 0xCE,
  0x5A, 0x73, 0xC6, 0x31, 0x8C, 0x63, 0xFF, 0x4D, 0xB6, 0xFD, 0xD7, 0x1C,
  0x71, 0x9E, 0xF7, 0xFB, 0xDE, 0x73, 0x39, 0xFC, 0xF1, 0xC7, 0x37, 0xCE,
  0xF7, 0xE7, 0x7F, 0x42, 0x10, 0x39, 0xFC, 0xF1, 0xC7, 0x37, 0xCE, 0x1C,
  0x30, 0xF7, 0xE7, 0x3F, 0xFA, 0x53, 0x77, 0xA1, 0xE7, 0xCF, 0xFE, 0xFF,
  0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0xCF, 0x3C, 0xF3, 0xCD, 0x37, 0xDE, 0xC7,
  0x34, 0xDB, 0x68, 0xA3, 0x8C, 0xC7, 0x1C, 0x7D, 0xF5, 0xB6, 0xD3, 0x4D,
  0xA3, 0x8C, 0x39, 0xA6, 0xF3, 0xC5, 0x36, 0x8E, 0x30, 0xC3, 0x0C, 0xFF,
  0x84, 0x44, 0x23, 0xFF, 0xFF, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0x86, 0x30,
  0x86, 0x30, 0x86, 0x30, 0x86, 0xFF, 0x33, 0x33, 0x33, 0x3F, 0xF0, 0x30,
  0xE6, 0x93, 0x44, 0xFF, 0xF0, 0xCC, 0xF0, 0xFF, 0xF9, 0xFC, 0x84, 0x21,
  0xEF, 0xCE, 0x7F, 0xF0, 0x7F, 0xE1, 0x0F, 0xBC, 0x0C, 0x30, 0xDF, 0x7F,
  0x3C, 0xDF, 0x7C, 0x39, 0xFC, 0xFF, 0x40, 0xF0, 0x1C, 0xF2, 0x3F, 0xFC,
  0x82, 0x08, 0x20, 0x3D, 0xFC, 0xF3, 0x7D, 0xF0, 0x9E, 0x84, 0x21, 0xEF,
  0xCE, 0x73, 0x98, 0x30, 0xC0, 0x3C, 0xF0, 0xC3, 0x0F, 0x1C, 0x33, 0x0F,
  0xF1, 0x11, 0x9F, 0xE0, 0x84, 0x21, 0x3B, 0x72, 0xD2, 0x98, 0xF3, 0xC3,
  0x0C, 0x30, 0xC3, 0x0F, 0x1C, 0xFF, 0xFD, 0x75, 0xC7, 0x10, 0xF7, 0xE7,
  0x39, 0xCC, 0x39, 0xFC, 0xF3, 0x7C, 0xE0, 0xF7, 0xE7, 0x3F, 0xFA, 0x10,
  0x3D, 0xFC, 0xF3, 0x7D, 0xF0, 0xC3, 0xFF, 0xF1, 0x8C, 0x60, 0xF7, 0xB0,
  0x6F, 0xF8, 0x20, 0x8F, 0xFF, 0x20, 0x83, 0xCF, 0x9C, 0xE7, 0x3F, 0xBC,
  0xC5, 0x36, 0x9A, 0x38, 0xC0, 0xC7, 0x5F, 0x5D, 0x6D, 0x30, 0x4D, 0xA3,
  0x0E, 0x69, 0x30, 0x4D, 0xB6, 0x8A, 0x38, 0xC3, 0x38, 0xFF, 0x88, 0x8F,
  0xFC, 0x3B, 0xD8, 0xCE, 0x61, 0x8C, 0x63, 0xCE, 0xFF, 0xFF, 0xFC, 0xE7,
  0x08, 0x43, 0x9C, 0x84, 0x27, 0x38, 0x65, 0xFD, 0xC0,
};

const GFXglyph UbuntuMono_Bold13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 8, 7, 2, -8 },
  { 3, 4, 4, 7, 1, -9 },
  { 5, 6, 8, 7, 0, -8 },
  { 11, 6, 10, 7, 0, -9 },
  { 19, 6, 8, 7, 0, -8 },
  { 25, 6, 8, 7, 0, -8 },
  { 31, 2, 4, 7, 2, -9 },
  { 32, 4, 11, 7, 1, -9 },
  { 38, 4, 11, 7, 1, -9 },
  { 44, 5, 5, 7, 1, -8 },
  { 48, 5, 6, 7, 1, -6 },
  { 52, 3, 4, 7, 2, -2 },
  { 54, 4, 2, 7, 1, -4 },
  { 55, 2, 2, 7, 2, -2 },
  { 56, 5, 11, 7, 1, -9 },
  { 63, 6, 8, 7, 0, -8 },
  { 69, 5, 8, 7, 1, -8 },
  { 74, 5, 8, 7, 1, -8 },
  { 79, 5, 8, 7, 1, -8 },
  { 84, 6, 8, 7, 0, -8 },
  { 90, 6, 8, 7, 0, -8 },
  { 96, 5, 8, 7, 1, -8 },
  { 101, 5, 8, 7, 1, -8 },
  { 106, 6, 8, 7, 0, -8 },
  { 112, 5, 8, 7, 1, -8 },
  { 117, 2, 6, 7, 2, -6 },
  { 119, 2, 8, 7, 2, -6 },
  { 121, 5, 8, 7, 1, -9 },
  { 126, 5, 5, 7, 1, -5 },
  { 130, 5, 8, 7, 1, -9 },
  { 135, 5, 8, 7, 1, -8 },
  { 140, 6, 10, 7, 0, -8 },
  { 148, 6, 8, 7, 0, -8 },
  { 154, 5, 8, 7, 1, -8 },
  { 159, 6, 8, 7, 0, -8 },
  { 165, 5, 8, 7, 1, -8 },
  { 170, 5, 8, 7, 1, -8 },
  { 175, 5, 8, 7, 1, -8 },
  { 180, 6, 8, 7, 0, -8 },
  { 186, 5, 8, 7, 1, -8 },
  { 191, 5, 8, 7, 1, -8 },
  { 196, 5, 8, 7, 1, -8 },
  { 201, 5, 8, 7, 1, -8 },
  { 206, 5, 8, 7, 1, -8 },
  { 211, 6, 8, 7, 0, -8 },
  { 217, 5, 8, 7, 1, -8 },
  { 222, 6, 8, 7, 0, -8 },
  { 228, 5, 8, 7, 1, -8 },
  { 233, 6, 10, 7, 0, -8 },
  { 241, 5, 8, 7, 1, -8 },
  { 246, 5, 8, 7, 1, -8 },
  { 251, 6, 8, 7, 0, -8 },
  { 257, 6, 8, 7, 0, -8 },
  { 263, 6, 8, 7, 0, -8 },
  { 269, 6, 8, 7, 0, -8 },
  { 275, 6, 8, 7, 0, -8 },
  { 281, 6, 8, 7, 0, -8 },
  { 287, 5, 8, 7, 1, -8 },
  { 292, 4, 11, 7, 1, -9 },
  { 298, 5, 11, 7, 1, -9 },
  { 305, 4, 11, 7, 1, -9 },
  { 311, 6, 5, 7, 0, -8 },
  { 315, 6, 2, 7, 0, 0 },
  { 317, 3, 2, 7, 2, -9 },
  { 318, 5, 6, 7, 1, -6 },
  { 322, 5, 9, 7, 1, -9 },
  { 328, 5, 6, 7, 1, -6 },
  { 332, 6, 9, 7, 0, -9 },
  { 339, 6, 6, 7, 0, -6 },
  { 344, 6, 9, 7, 0, -9 },
  { 351, 6, 8, 7, 0, -6 },
  { 357, 5, 9, 7, 1, -9 },
  { 363, 6, 9, 7, 0, -9 },
  { 370, 4, 11, 7, 1, -9 },
  { 376, 5, 9, 7, 1, -9 },
  { 382, 6, 9, 7, 0, -9 },
  { 389, 6, 6, 7, 0, -6 },
  { 394, 5, 6, 7, 1, -6 },
  { 398, 6, 6, 7, 0, -6 },
  { 403, 5, 8, 7, 1, -6 },
  { 408, 6, 8, 7, 0, -6 },
  { 414, 5, 6, 7, 1, -6 },
  { 418, 5, 6, 7, 1, -6 },
  { 422, 6, 8, 7, 0, -8 },
  { 428, 5, 6, 7, 1, -6 },
  { 432, 6, 6, 7, 0, -6 },
  { 437, 6, 6, 7, 0, -6 },
  { 442, 6, 6, 7, 0, -6 },
  { 447, 6, 8, 7, 0, -6 },
  { 453, 5, 6, 7, 1, -6 },
  { 457, 5, 11, 7, 1, -9 },
  { 464, 2, 11, 7, 2, -9 },
  { 467, 5, 11, 7, 1, -9 },
  { 474, 6, 3, 7, 0, -5 },
};

const GFXfont UbuntuMono_Bold13pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold13pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold13pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _UBUNTUMONO_BOLD13PT7B_H_
