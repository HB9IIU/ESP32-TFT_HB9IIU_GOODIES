#ifndef _UBUNTUMONO_BOLD42PT7B_H_
#define _UBUNTUMONO_BOLD42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold42pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0x00, 0x00, 0x07, 0x3F, 0xFF, 0xFF, 0xFC,
  0xE0, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF8, 0x7F, 0x83, 0xDC, 0x1C, 0xE0, 0xE0, 0x03, 0xC3, 0xC0,
  0x78, 0xF8, 0x0F, 0x1E, 0x03, 0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x1F, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0x7C, 0x07,
  0x8F, 0x80, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0xC7, 0x80, 0xF0, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xC3, 0xC0, 0x78,
  0x78, 0x0F, 0x1F, 0x01, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x1F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x03, 0x8F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x38, 0x0F, 0xCF, 0xFF,
  0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x03, 0xDF,
  0xE0, 0x3C, 0xE7, 0x01, 0xC7, 0x3C, 0x1E, 0x79, 0xE1, 0xE3, 0xCF, 0x0E,
  0x1E, 0x78, 0xF0, 0x73, 0xCF, 0x03, 0x9C, 0x70, 0x1F, 0xE7, 0x80, 0x7E,
  0x78, 0x01, 0xE3, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x78,
  0x01, 0xEF, 0xE0, 0x1E, 0x7F, 0x80, 0xE7, 0x9C, 0x0F, 0x3C, 0xE0, 0xF1,
  0xE7, 0x87, 0x0E, 0x3C, 0x78, 0x79, 0xE7, 0x83, 0xCE, 0x38, 0x1E, 0x73,
  0xC0, 0x7F, 0xBC, 0x03, 0xF8, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xFF,
  0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xE3, 0xE0, 0x78, 0x7C, 0x0F, 0x0F,
  0x81, 0xE1, 0xF0, 0x3E, 0x7C, 0x07, 0xDF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8,
  0x00, 0xFE, 0x38, 0x3F, 0x87, 0x8F, 0xF8, 0xF3, 0xFF, 0x9E, 0x7D, 0xFB,
  0xDF, 0x1F, 0xFB, 0xC1, 0xFE, 0x78, 0x1F, 0xCF, 0x03, 0xF1, 0xF0, 0x3F,
  0x3F, 0x0F, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFE, 0x7C, 0x3F, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0xE7, 0x00, 0x00, 0x30,
  0x01, 0xC0, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0,
  0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80,
  0x1C, 0x00, 0x20, 0x20, 0x03, 0x80, 0x3F, 0x01, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x00,
  0xF0, 0x02, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x06, 0x1E, 0x33, 0xCE, 0x79, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xF0, 0x01, 0xDE, 0x03, 0xEF, 0x83, 0xF7, 0xE1, 0xF1, 0xF0, 0x78, 0xF0,
  0x08, 0x20, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0x07, 0xE3, 0xF8, 0xFE, 0x3F, 0xCF,
  0xF1, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0xF0, 0xF8, 0xFC, 0x1E, 0x06, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x38, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0x9C, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x80,
  0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xF1, 0xF8, 0x7C, 0x1F, 0x1F, 0x01, 0xF3,
  0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x71, 0xEF,
  0x9F, 0x3D, 0xF3, 0xE7, 0xFE, 0x7C, 0xFF, 0xCF, 0x9F, 0x78, 0xE3, 0xCF,
  0x00, 0x79, 0xE0, 0x0F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x8F,
  0x83, 0xE1, 0xF8, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x01,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xFE, 0x03, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x79, 0xF0, 0x10, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x81, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x07, 0xE0,
  0x1F, 0xFC, 0x1F, 0xFF, 0x1F, 0xFF, 0xC7, 0x87, 0xF1, 0x81, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x3F, 0xFC,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC7, 0x87, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x81, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0xC0, 0xFE, 0xFF,
  0xFE, 0x7F, 0xFF, 0x3F, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x01, 0xF3, 0xE0, 0x3C, 0x7C, 0x0F, 0x8F,
  0x83, 0xE1, 0xF0, 0x78, 0x3E, 0x1F, 0x07, 0xC3, 0xC0, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0xFF,
  0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xF8, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE6,
  0x03, 0xF9, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0xFE, 0x1F, 0xFF,
  0xCF, 0xFF, 0xE7, 0xFF, 0xFB, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFB, 0xE0, 0xFD, 0xF8, 0xFC,
  0x7F, 0xFE, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F,
  0xFF, 0xE7, 0xE3, 0xF3, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFE, 0x0F, 0x9F, 0x87, 0xCF, 0xE7, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x7F, 0xFC, 0x7C, 0xFF, 0x7C, 0x1F, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF,
  0x87, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x07,
  0xFF, 0xC7, 0xE3, 0xF3, 0xE0, 0xFB, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFB, 0xFF, 0xFC, 0xFF,
  0xFE, 0x7F, 0xFF, 0x0F, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0,
  0x0F, 0x00, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x9C, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x1F, 0xFF, 0xFF, 0xFF, 0xFB, 0xF3, 0x80, 0x0E, 0x0F,
  0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0x7E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0xFC, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF0, 0xF8, 0x3C, 0x3C,
  0x1E, 0x3E, 0x7E, 0x3E, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x07, 0xC0, 0x0F,
  0xE0, 0x1F, 0xF0, 0x7F, 0xF8, 0xFF, 0xF3, 0xFF, 0xC1, 0xFF, 0x80, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x40,
  0x00, 0x3C, 0x00, 0x3F, 0x80, 0x1F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0xFF,
  0xF3, 0xFF, 0xC7, 0xFF, 0x83, 0xFF, 0x01, 0xFC, 0x00, 0x78, 0x00, 0x20,
  0x00, 0x00, 0x1F, 0xE1, 0xFF, 0xF3, 0xFF, 0xF3, 0xFF, 0xE7, 0x0F, 0xE0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0,
  0x3F, 0xFC, 0x0F, 0x87, 0xC3, 0xE0, 0x3C, 0x78, 0x07, 0x9E, 0x00, 0xF3,
  0xC1, 0xFF, 0x78, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF9, 0xF9, 0xFF,
  0x3E, 0x3F, 0xE7, 0xC7, 0xFC, 0xF0, 0xFF, 0x9E, 0x1F, 0xF3, 0xC3, 0xFE,
  0x78, 0x7F, 0xCF, 0x8F, 0xF9, 0xF1, 0xFF, 0x1F, 0x3F, 0xE3, 0xFF, 0xFC,
  0x3F, 0xFF, 0x83, 0xFF, 0x78, 0x3F, 0xEF, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3F, 0x01, 0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x00,
  0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0xFB, 0xE0, 0x07,
  0xDF, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0x83, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xE0, 0x3E, 0x3F, 0x01, 0xF9,
  0xF0, 0x0F, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF7, 0xE0, 0x0F, 0xC0, 0x7F,
  0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8, 0x3F, 0x3E, 0x07,
  0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3,
  0xE0, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8,
  0x1F, 0xBE, 0x03, 0xEF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03,
  0xFF, 0x80, 0xFB, 0xE0, 0x7E, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xC0,
  0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xE1,
  0xF8, 0x1C, 0x7E, 0x00, 0x8F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x11, 0xFC, 0x0E, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F,
  0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF8, 0x7F, 0x3E, 0x07, 0xCF, 0x81,
  0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x1F, 0xBE, 0x0F, 0xCF, 0x87,
  0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0xFF,
  0xFC, 0x7F, 0xFF, 0x1F, 0xC1, 0xCF, 0xC0, 0x23, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xF7, 0xC0,
  0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x81, 0xF3, 0xF0, 0x7C, 0xFE, 0x1F,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFC, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x60, 0x3F, 0x70, 0x7E, 0xFF,
  0xFE, 0xFF, 0xFC, 0x7F, 0xF8, 0x1F, 0xE0, 0xF8, 0x0F, 0x9F, 0x03, 0xF3,
  0xE0, 0x7C, 0x7C, 0x1F, 0x8F, 0x87, 0xE1, 0xF0, 0xF8, 0x3E, 0x3F, 0x07,
  0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0x7E, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xDF, 0xC0, 0xF9, 0xFC, 0x1F,
  0x1F, 0x83, 0xE1, 0xF8, 0x7C, 0x3F, 0x8F, 0x83, 0xF1, 0xF0, 0x3F, 0x3E,
  0x07, 0xE7, 0xC0, 0x7E, 0xF8, 0x0F, 0xDF, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0,
  0xFC, 0xFE, 0x3F, 0x9F, 0xC7, 0x73, 0xF8, 0xEE, 0x7F, 0x3F, 0xCF, 0xF7,
  0xF9, 0xEE, 0xEF, 0x3D, 0xFD, 0xE7, 0xBF, 0xBD, 0xF3, 0xE7, 0xFE, 0x7C,
  0xFF, 0xCF, 0x9F, 0xF9, 0xE3, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7C, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFE, 0xF3, 0xFF, 0x79, 0xFF, 0x9E, 0xFF, 0xCF, 0x7F, 0xE3, 0xFF, 0xF1,
  0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xC0, 0x03,
  0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xF1, 0xF8, 0x7C,
  0x1F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xDF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xBE, 0x03, 0xE7, 0xC0,
  0x7C, 0xF8, 0x0F, 0x9F, 0x83, 0xF1, 0xF8, 0xFC, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF,
  0xF3, 0xFF, 0xFC, 0xF8, 0x3F, 0xBE, 0x03, 0xEF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xBF,
  0x8F, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xC0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xF1, 0xF8, 0x7C, 0x1F, 0x1F, 0x01, 0xF3,
  0xE0, 0x3E, 0x7C, 0x07, 0xDF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0xFF, 0xF0, 0x1F, 0xBE, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F,
  0x83, 0xF1, 0xF8, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01,
  0xFC, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00,
  0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x07, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0x87, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xE7,
  0xC0, 0xFC, 0xF8, 0x0F, 0x9F, 0x03, 0xF3, 0xE0, 0x7E, 0x7C, 0x0F, 0x8F,
  0x87, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0x1F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xF1, 0xF0, 0x3E, 0x3E,
  0x07, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x00, 0xFB, 0xE0, 0x1F, 0x00,
  0x07, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xC7, 0xE0, 0x67, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7D, 0x00,
  0x3E, 0xE0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x03, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0,
  0x7F, 0xF0, 0x7C, 0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0xFE, 0x01, 0xFC, 0x00,
  0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0xC0, 0x7E, 0x7C, 0x07,
  0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x0F, 0xC3, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x0F, 0x01, 0xF1, 0xF0, 0x1F,
  0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x1E, 0x00, 0xFB, 0xE0, 0x0F, 0xBE, 0x00,
  0x7B, 0xC0, 0x07, 0xBC, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x1C, 0x7F, 0xE7, 0xCF, 0xFC, 0xF9, 0xFF, 0x9F, 0x3F,
  0xF7, 0xF7, 0x9E, 0xFE, 0xF3, 0x9D, 0xDE, 0x73, 0xBB, 0xCE, 0xF3, 0xF9,
  0xDC, 0x7F, 0x3B, 0x8F, 0xE7, 0xF1, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3,
  0xF0, 0x7E, 0x7C, 0x07, 0xCF, 0x80, 0xF8, 0x7E, 0x01, 0xF1, 0xF0, 0x1F,
  0x0F, 0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xF8, 0x7C, 0x07, 0xC7, 0xC0, 0x3F,
  0x3E, 0x00, 0xFB, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xDF, 0x00, 0x3E, 0xFC, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x81,
  0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0xFC, 0x0F, 0x87, 0xC0, 0x7E, 0x7E, 0x03,
  0xF3, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x07, 0xE7,
  0xC0, 0x7C, 0x7E, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xF1, 0xF8,
  0x1F, 0x1F, 0x01, 0xF9, 0xF0, 0x0F, 0xBE, 0x00, 0xFB, 0xE0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x0F, 0xBE, 0x00, 0xF9, 0xF0, 0x1F, 0x1F, 0x03, 0xF0, 0xF8, 0x7E, 0x0F,
  0xC7, 0xC0, 0x7E, 0xFC, 0x07, 0xE7, 0x80, 0x3E, 0x18, 0x01, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x10, 0x0E,
  0x07, 0xE1, 0xFC, 0x3F, 0x83, 0xE0, 0x10, 0x1F, 0xF0, 0x1F, 0xFE, 0x0F,
  0xFF, 0x87, 0xFF, 0xE2, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x87, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xEF,
  0xFF, 0xF3, 0xFF, 0xF8, 0x7F, 0xE0, 0x38, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7D, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xE3, 0xFB,
  0xE0, 0xFD, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C,
  0x1F, 0xBE, 0x1F, 0x9F, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xC0, 0xFF, 0x80,
  0x01, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0x81, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xE0, 0x23, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80,
  0x7F, 0xC0, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x83, 0xF7, 0xC7,
  0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xFB, 0xF0, 0xFD, 0xF0, 0x3E, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0x7C, 0x0F, 0xBF, 0x07, 0xDF, 0xC3, 0xE7,
  0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xF8, 0x01, 0xF8, 0x00, 0xFF,
  0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xF0, 0xF8, 0xFC, 0x0F, 0x9F, 0x01,
  0xF3, 0xE0, 0x3E, 0xFC, 0x03, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x30, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7E,
  0x0C, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x03, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF3, 0xF0, 0xFB,
  0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xFC, 0x3F, 0x3F,
  0xFF, 0x9F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFD, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x30, 0x3F, 0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF,
  0x81, 0xFE, 0x00, 0x38, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xFF, 0xFC, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0x07, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x20, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xC0, 0x00,
  0x78, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xA0, 0x3E, 0x78,
  0x7C, 0xFF, 0xFB, 0xFF, 0xE3, 0xFF, 0x81, 0xFC, 0x00, 0x38, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x0F, 0xDF, 0x07, 0xEF, 0x87,
  0xE7, 0xC7, 0xE3, 0xE3, 0xE1, 0xF3, 0xE0, 0xFB, 0xE0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xDF, 0x83, 0xE7, 0xC1, 0xF3, 0xF0,
  0xF8, 0xFC, 0x7C, 0x3F, 0x3E, 0x0F, 0x9F, 0x07, 0xEF, 0x81, 0xFF, 0xC0,
  0xFC, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x20,
  0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xC0, 0x3F, 0x9F, 0x1F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0x1E, 0x3F, 0xE3, 0xC7, 0xFC,
  0x7C, 0x7F, 0x8F, 0x8F, 0xF1, 0xF1, 0xFE, 0x3E, 0x3F, 0xC7, 0xC7, 0xF8,
  0xF8, 0xFF, 0x1F, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1E, 0x3F,
  0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFC, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0xC3, 0xF1, 0xF8, 0xFC, 0x1F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xDF, 0x01, 0xF3, 0xE0, 0x3E, 0x7E, 0x0F, 0xC7, 0xE3, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0xE0,
  0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x87, 0xE7, 0xC1, 0xFB, 0xE0,
  0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x3F, 0x7E, 0x1F,
  0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x87, 0xDF, 0x83, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFE,
  0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF3, 0xF0, 0xFB, 0xF0, 0x7D, 0xF0,
  0x3E, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7E, 0x0F, 0xBF, 0x8F,
  0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x00, 0x03, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC7, 0xE0,
  0x63, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0xB8, 0x0F, 0x9F, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xC0, 0xFF,
  0x80, 0x01, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x08, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0,
  0x0F, 0xF0, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7E, 0x1F,
  0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFC, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x1F, 0xBE, 0x03, 0xE7, 0xC0, 0x7C, 0xFC, 0x1F, 0x8F, 0x83,
  0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0xDF,
  0x00, 0xFB, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0xF3, 0xC0,
  0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x87, 0x8F, 0x3C, 0x7C, 0x79,
  0xE3, 0xE3, 0xCF, 0x1F, 0x1E, 0x78, 0xF8, 0xF3, 0xCF, 0xE7, 0x0E, 0x7F,
  0x38, 0x7B, 0xBB, 0xC3, 0xDD, 0xFE, 0x1F, 0xEF, 0xF0, 0xFE, 0x3F, 0x87,
  0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F,
  0x80, 0xFC, 0x07, 0xEF, 0x80, 0xF8, 0xF8, 0x3E, 0x1F, 0x8F, 0xC1, 0xF9,
  0xF0, 0x1F, 0x7C, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0x7C, 0x07, 0xCF,
  0xC0, 0xF8, 0xFC, 0x3E, 0x0F, 0x8F, 0xC1, 0xF9, 0xF0, 0x1F, 0x7C, 0x01,
  0xF0, 0x7C, 0x07, 0xEF, 0x80, 0xF9, 0xF8, 0x1F, 0x3F, 0x03, 0xE3, 0xE0,
  0x7C, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xF3,
  0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x02, 0x3F, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFE,
  0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0xFF, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xFE,
  0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xF0, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x07, 0xF0,
  0x00, 0x0F, 0x01, 0x87, 0xF8, 0x3D, 0xFF, 0xC7, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xF1, 0xFF, 0xBC, 0x1F, 0xE1, 0x80, 0xF8,
};

const GFXglyph UbuntuMono_Bold42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 7, 27, 21, 7, -26 },
  { 25, 13, 12, 21, 4, -29 },
  { 45, 19, 26, 21, 1, -26 },
  { 107, 19, 33, 21, 1, -29 },
  { 186, 21, 28, 21, 0, -27 },
  { 260, 19, 27, 21, 1, -27 },
  { 325, 5, 13, 21, 8, -29 },
  { 334, 14, 37, 21, 4, -30 },
  { 399, 13, 37, 21, 4, -30 },
  { 460, 17, 16, 21, 2, -26 },
  { 494, 17, 18, 21, 2, -20 },
  { 533, 10, 15, 21, 5, -7 },
  { 552, 11, 5, 21, 5, -13 },
  { 559, 7, 8, 21, 7, -7 },
  { 566, 17, 36, 21, 2, -29 },
  { 643, 19, 28, 21, 1, -27 },
  { 710, 17, 26, 21, 2, -26 },
  { 766, 17, 27, 21, 2, -27 },
  { 824, 17, 28, 21, 2, -27 },
  { 884, 19, 26, 21, 1, -26 },
  { 946, 18, 27, 21, 1, -26 },
  { 1007, 17, 27, 21, 2, -26 },
  { 1065, 17, 26, 21, 2, -26 },
  { 1121, 17, 28, 21, 2, -27 },
  { 1181, 17, 27, 21, 2, -27 },
  { 1239, 7, 21, 21, 7, -20 },
  { 1258, 9, 28, 21, 5, -20 },
  { 1290, 17, 18, 21, 2, -20 },
  { 1329, 17, 12, 21, 2, -17 },
  { 1355, 17, 18, 21, 2, -20 },
  { 1394, 15, 28, 21, 3, -27 },
  { 1447, 19, 33, 21, 1, -27 },
  { 1526, 21, 26, 21, 0, -26 },
  { 1595, 18, 28, 21, 2, -27 },
  { 1658, 19, 28, 21, 1, -27 },
  { 1725, 18, 27, 21, 2, -26 },
  { 1786, 16, 26, 21, 3, -26 },
  { 1838, 16, 26, 21, 3, -26 },
  { 1890, 18, 28, 21, 1, -27 },
  { 1953, 17, 26, 21, 2, -26 },
  { 2009, 17, 26, 21, 2, -26 },
  { 2065, 16, 27, 21, 2, -26 },
  { 2119, 19, 26, 21, 2, -26 },
  { 2181, 16, 26, 21, 3, -26 },
  { 2233, 19, 26, 21, 1, -26 },
  { 2295, 17, 26, 21, 2, -26 },
  { 2351, 19, 28, 21, 1, -27 },
  { 2418, 18, 27, 21, 2, -27 },
  { 2479, 19, 35, 21, 1, -27 },
  { 2563, 19, 27, 21, 2, -27 },
  { 2628, 17, 28, 21, 2, -27 },
  { 2688, 19, 26, 21, 1, -26 },
  { 2750, 17, 27, 21, 2, -26 },
  { 2808, 20, 26, 21, 1, -26 },
  { 2873, 19, 26, 21, 1, -26 },
  { 2935, 21, 26, 21, 0, -26 },
  { 3004, 20, 26, 21, 1, -26 },
  { 3069, 17, 26, 21, 2, -26 },
  { 3125, 11, 36, 21, 5, -29 },
  { 3175, 17, 36, 21, 2, -29 },
  { 3252, 11, 36, 21, 5, -29 },
  { 3302, 20, 13, 21, 1, -26 },
  { 3335, 21, 4, 21, 0, 3 },
  { 3346, 10, 7, 21, 6, -29 },
  { 3355, 17, 22, 21, 2, -21 },
  { 3402, 17, 31, 21, 3, -30 },
  { 3468, 18, 22, 21, 2, -21 },
  { 3518, 17, 31, 21, 1, -30 },
  { 3584, 19, 22, 21, 1, -21 },
  { 3637, 19, 30, 21, 2, -30 },
  { 3709, 17, 29, 21, 1, -21 },
  { 3771, 16, 30, 21, 3, -30 },
  { 3831, 18, 30, 21, 2, -29 },
  { 3899, 15, 37, 21, 2, -29 },
  { 3969, 17, 30, 21, 3, -30 },
  { 4033, 18, 30, 21, 2, -29 },
  { 4101, 19, 21, 21, 1, -21 },
  { 4151, 16, 21, 21, 3, -21 },
  { 4193, 19, 22, 21, 1, -21 },
  { 4246, 17, 28, 21, 3, -21 },
  { 4306, 17, 28, 21, 1, -21 },
  { 4366, 15, 21, 21, 4, -21 },
  { 4406, 17, 22, 21, 2, -21 },
  { 4453, 18, 27, 21, 2, -26 },
  { 4514, 16, 21, 21, 2, -20 },
  { 4556, 19, 20, 21, 1, -20 },
  { 4604, 21, 20, 21, 0, -20 },
  { 4657, 19, 20, 21, 1, -20 },
  { 4705, 19, 28, 21, 1, -20 },
  { 4772, 15, 20, 21, 3, -20 },
  { 4810, 15, 36, 21, 3, -29 },
  { 4878, 5, 36, 21, 8, -29 },
  { 4901, 15, 36, 21, 3, -29 },
  { 4969, 19, 8, 21, 1, -15 },
};

const GFXfont UbuntuMono_Bold42pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold42pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold42pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _UBUNTUMONO_BOLD42PT7B_H_
