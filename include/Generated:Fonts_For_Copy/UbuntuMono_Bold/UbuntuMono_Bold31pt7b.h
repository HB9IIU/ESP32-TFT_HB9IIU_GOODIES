#ifndef _UBUNTUMONO_BOLD31PT7B_H_
#define _UBUNTUMONO_BOLD31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold31pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x00, 0x0F, 0xFF,
  0xDC, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x3B, 0x8E, 0x61,
  0x80, 0x0E, 0x38, 0x38, 0xE0, 0xE7, 0x83, 0x9C, 0x1E, 0x73, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1C, 0xE0, 0xF3, 0x83, 0x8E, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xCF, 0x07, 0x38, 0x00, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1F, 0xE3, 0xFF, 0xBF, 0xF9, 0xE0, 0x4F, 0x00,
  0x78, 0x03, 0xC0, 0x1F, 0x80, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xD8, 0x1E, 0xFF, 0xFF, 0xFF, 0x1F, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x0E, 0xFC, 0x19, 0xB8, 0x77, 0x31, 0xCE,
  0x63, 0x1C, 0xCE, 0x1B, 0xB8, 0x3F, 0x60, 0x3D, 0xC0, 0x07, 0x00, 0x0C,
  0xF0, 0x3B, 0xE0, 0xEE, 0xE1, 0x9C, 0xC7, 0x39, 0x9C, 0x73, 0x38, 0xEE,
  0xE0, 0xFF, 0x80, 0xE0, 0x0F, 0x00, 0xFF, 0x07, 0xFC, 0x1E, 0x78, 0x71,
  0xE1, 0xC7, 0x07, 0xBC, 0x0F, 0xE0, 0x3F, 0x20, 0xF8, 0xE7, 0xF3, 0xBD,
  0xEE, 0xE3, 0xFB, 0x87, 0xCE, 0x0F, 0x3C, 0x7C, 0xFF, 0xF9, 0xFE, 0xE1,
  0xF3, 0xC0, 0xFF, 0xFF, 0xFF, 0xEE, 0x60, 0x01, 0x80, 0xE0, 0x78, 0x3C,
  0x1E, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38,
  0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0,
  0x7C, 0x0F, 0xC0, 0xE0, 0x10, 0x40, 0x3C, 0x0F, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x0F, 0x07, 0xC1, 0xE1, 0xF0, 0xF8,
  0x3C, 0x04, 0x00, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0xCE, 0x27, 0xB7, 0xBF,
  0xFF, 0xFF, 0xE0, 0xF0, 0x0F, 0xC0, 0xFF, 0x0F, 0x7C, 0x39, 0xC0, 0x84,
  0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x3C,
  0x79, 0xFB, 0xF3, 0xE7, 0xC3, 0x0E, 0x79, 0xE3, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x73, 0xEF, 0xFF, 0xF9, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0x0F, 0x80, 0xFF, 0x0F, 0xFC, 0xF1, 0xE7, 0x07, 0xF8,
  0x3F, 0xC0, 0xFE, 0x67, 0xF7, 0x3F, 0xB9, 0xFC, 0xCF, 0xE0, 0x7F, 0x03,
  0xF8, 0x3D, 0xC1, 0xEF, 0x1E, 0x3F, 0xF0, 0xFF, 0x03, 0xE0, 0x03, 0x80,
  0x3C, 0x03, 0xE0, 0x7F, 0x07, 0xF8, 0x3D, 0xC1, 0x8E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x1F, 0x83, 0xFF, 0x3F, 0xFC, 0xE1, 0xE2,
  0x0F, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE,
  0x1F, 0x83, 0xFF, 0x1F, 0xFC, 0x43, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE8, 0x1F, 0x7F, 0xF7, 0xFF, 0x0F, 0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x3F,
  0x01, 0xFC, 0x07, 0xF0, 0x3B, 0xC1, 0xEF, 0x07, 0x3C, 0x38, 0xF1, 0xE3,
  0xC7, 0x0F, 0x3C, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0xE0, 0x3F, 0xE1, 0xFF, 0x80, 0xFC, 0x01,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE8, 0x1E, 0xFF, 0xF7, 0xFF, 0x1F, 0xE0,
  0x00, 0xF0, 0x3F, 0x83, 0xFC, 0x3F, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x0F,
  0xF8, 0x7F, 0xF7, 0xFF, 0xBC, 0x1F, 0xE0, 0xFF, 0x07, 0xB8, 0x3D, 0xE1,
  0xEF, 0x1F, 0x3F, 0xF0, 0xFF, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x00,
  0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xF1, 0xF7, 0x07, 0xB8, 0x3D, 0xE1, 0xEF,
  0x9E, 0x3F, 0xF0, 0xFE, 0x0F, 0xF8, 0xF3, 0xEF, 0x07, 0xF8, 0x1F, 0xC0,
  0xFF, 0x0F, 0x7F, 0xF9, 0xFF, 0x87, 0xF0, 0x0F, 0x81, 0xFF, 0x0F, 0xFC,
  0xF1, 0xE7, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0x78, 0x7B, 0xFF, 0xCF,
  0xFE, 0x3F, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0xFC, 0x3F, 0xC1, 0xF8,
  0x0F, 0x00, 0x73, 0xEF, 0xFF, 0xF9, 0xC0, 0x00, 0x01, 0xCF, 0xBF, 0xFF,
  0xE7, 0x00, 0x38, 0xF9, 0xFB, 0xF7, 0xC7, 0x00, 0x00, 0x00, 0x71, 0xF3,
  0xE7, 0xCF, 0x8F, 0x0E, 0x1C, 0xF3, 0xC6, 0x00, 0x00, 0x10, 0x03, 0xC0,
  0x7E, 0x1F, 0xF3, 0xFE, 0x7F, 0x83, 0xF0, 0x1F, 0x80, 0xFF, 0x01, 0xFF,
  0x03, 0xFE, 0x03, 0xF0, 0x07, 0x80, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x60, 0x03,
  0xC0, 0x1F, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xE0, 0x1F, 0x07,
  0xF8, 0xFF, 0xBF, 0xE0, 0xFC, 0x07, 0x80, 0x20, 0x00, 0x3F, 0x1F, 0xF9,
  0xFF, 0xB0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x0F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0xE0, 0x78, 0x00,
  0x07, 0xC0, 0x7F, 0xC3, 0x87, 0x1C, 0x0E, 0x70, 0x3B, 0x87, 0xEE, 0x7F,
  0xF9, 0xFF, 0xEF, 0x3F, 0x3C, 0xFC, 0xE3, 0xF3, 0x8F, 0xCE, 0x3F, 0x3C,
  0xFE, 0x73, 0xF9, 0xFF, 0xE3, 0xFF, 0x87, 0xE7, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7F, 0xE0, 0x3F, 0x80, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0xFE, 0x01, 0xDE, 0x03, 0xBC, 0x0F, 0x38, 0x1E, 0x70, 0x38, 0xF0,
  0xF1, 0xE1, 0xE3, 0xC3, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0x3C, 0x1E, 0x78,
  0x1E, 0xF0, 0x3F, 0xC0, 0x78, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xC3, 0xCE,
  0x0F, 0x70, 0x7B, 0x83, 0x9C, 0x3C, 0xFF, 0xC7, 0xFE, 0x3F, 0xFD, 0xC1,
  0xEE, 0x07, 0x70, 0x3F, 0x81, 0xDC, 0x1E, 0xFF, 0xF7, 0xFF, 0x3F, 0xE0,
  0x07, 0xF0, 0x7F, 0xE3, 0xFF, 0x9F, 0x06, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x1F, 0x06, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0x00, 0xFF, 0x07,
  0xFE, 0x3F, 0xF9, 0xC3, 0xCE, 0x0F, 0x70, 0x7B, 0x83, 0xDC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0x70, 0x7B, 0x83, 0xDC, 0x7C,
  0xFF, 0xC7, 0xFC, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0xCF, 0xFE, 0xF8, 0x37, 0x80, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3D, 0xE1, 0xEF, 0x8F, 0x3F, 0xF8, 0xFF, 0xC1, 0xFE, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xF9,
  0xFF, 0xCF, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xCC, 0x3E,
  0x7F, 0xE7, 0xFF, 0x0F, 0xE0, 0xF0, 0x7B, 0xC3, 0xEF, 0x0F, 0x3C, 0x7C,
  0xF1, 0xE3, 0xCF, 0x0F, 0x78, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8,
  0x3D, 0xF0, 0xF3, 0xE3, 0xC7, 0x8F, 0x0F, 0x3C, 0x3E, 0xF0, 0x7B, 0xC1,
  0xFF, 0x03, 0xC0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x79, 0xC1, 0xE7,
  0x87, 0xBE, 0x3E, 0xF8, 0xFB, 0xF3, 0xEE, 0xDF, 0xBB, 0x6E, 0xEF, 0xBB,
  0x9E, 0xEE, 0x7B, 0xB9, 0xCE, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xC0, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFF, 0x1F, 0xF8, 0xFF, 0xE7, 0xF7, 0x3F, 0x9D, 0xFC, 0xEF,
  0xE3, 0xFF, 0x1F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xFC,
  0x0E, 0x0F, 0x80, 0xFF, 0x83, 0xFF, 0x1E, 0x3E, 0x70, 0x7B, 0xC1, 0xEF,
  0x03, 0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3B,
  0xC1, 0xE7, 0x07, 0x9E, 0x3E, 0x3F, 0xF0, 0xFF, 0x80, 0xFC, 0x00, 0xFF,
  0x87, 0xFF, 0x3F, 0xFD, 0xC3, 0xEE, 0x0F, 0x70, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0xF7, 0x8F, 0xBF, 0xFD, 0xFF, 0xCF, 0xF0, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x7F, 0x83, 0xFF, 0x1E,
  0x3E, 0x70, 0x7B, 0xC1, 0xEF, 0x03, 0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3B, 0xC1, 0xEF, 0x07, 0x9E, 0x3E, 0x7F, 0xF0,
  0xFF, 0x80, 0xFC, 0x01, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x0E,
  0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xC3, 0xCE, 0x0F, 0x70, 0x7B, 0x83, 0xDC,
  0x1E, 0xE1, 0xE7, 0xFF, 0x3F, 0xF1, 0xFF, 0x0E, 0x3C, 0x71, 0xE3, 0x87,
  0x9C, 0x1E, 0xE0, 0xF7, 0x03, 0xF8, 0x1E, 0x0F, 0xE1, 0xFF, 0x9F, 0xFC,
  0xF0, 0x47, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0xFF, 0x01,
  0xFC, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xEC, 0x1F, 0x7F, 0xFF, 0xFF,
  0x8F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xEF, 0x0F, 0x7F, 0xF1, 0xFF, 0x83, 0xF0, 0xF8, 0x1E, 0xF0, 0x3D, 0xE0,
  0x7B, 0xC1, 0xE7, 0x83, 0xC7, 0x07, 0x8F, 0x0F, 0x1E, 0x1C, 0x3C, 0x78,
  0x38, 0xF0, 0x79, 0xE0, 0xF3, 0x80, 0xE7, 0x01, 0xDE, 0x03, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF9, 0xCE, 0xE7, 0xBB, 0x9E,
  0xEE, 0xFB, 0xBB, 0xEE, 0xED, 0xFB, 0xF3, 0xEF, 0x8F, 0xBE, 0x3E, 0x78,
  0x79, 0xC1, 0xE7, 0x07, 0x80, 0x78, 0x1E, 0xF8, 0x78, 0xF0, 0xE0, 0xF3,
  0xC1, 0xE7, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x7F, 0x80, 0xEF, 0x03, 0xCF, 0x07, 0x1E, 0x1E, 0x1E, 0x7C,
  0x3C, 0xF0, 0x7D, 0xE0, 0x78, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0xF1, 0xE1,
  0xE3, 0xC3, 0x83, 0x8F, 0x07, 0x9C, 0x07, 0x78, 0x0F, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x01, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x01,
  0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7F, 0x81, 0xE7, 0x83, 0x8F, 0x0F, 0x0F, 0x3C, 0x1F, 0x78, 0x1E,
  0x20, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x40, 0xE3, 0xE7, 0xE3,
  0xC1, 0x00, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x7F, 0xEF, 0xFF, 0x7F, 0xFF, 0xC3, 0xFC, 0x1F, 0xF0, 0xF7, 0xFF, 0xBF,
  0xFC, 0x7F, 0xC0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xDE, 0x1F, 0xFC, 0xFF, 0xE7, 0x8F, 0xBC, 0x3D, 0xE1, 0xEF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x1E, 0xF0, 0xF7, 0x8F, 0xBF, 0xF9, 0xFF, 0x87,
  0xF0, 0x00, 0x07, 0xF0, 0xFF, 0xCF, 0xFE, 0xF8, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xFF, 0x8F,
  0xFC, 0x1F, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x1F, 0x73, 0xFF, 0x7F, 0xF7, 0x8F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x77, 0x87, 0x7F, 0xF3, 0xFF, 0x0F, 0xE0, 0x0F,
  0xC0, 0xFF, 0x0F, 0xFC, 0xF0, 0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x3C, 0x00, 0xF8, 0x27, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0,
  0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0xC3, 0xC1, 0x1E, 0x00, 0x78, 0x0F, 0xFF,
  0xBF, 0xFE, 0xFF, 0xF8, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x0F, 0xF1, 0xFF, 0xDF, 0xFE, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xDE, 0x1E, 0xFF, 0xF3, 0xFF, 0x8F, 0xBC,
  0x01, 0xC0, 0x1E, 0x40, 0xF3, 0xFF, 0x3F, 0xF8, 0x7F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF,
  0x1E, 0xF0, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0x0E, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x41,
  0xFE, 0x0F, 0xF0, 0x1F, 0x00, 0x03, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0x80,
  0x00, 0x01, 0xFF, 0x7F, 0xDF, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xFC, 0x3F, 0xFF, 0xFF,
  0x9F, 0x80, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC3, 0xDE, 0x3C, 0xF3, 0xE7, 0x9E, 0x3D, 0xE1, 0xFE, 0x0F, 0xE0, 0x7F,
  0x83, 0xFE, 0x1E, 0xF0, 0xF3, 0xC7, 0x8F, 0x3C, 0x7D, 0xE1, 0xEF, 0x07,
  0x80, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x41, 0xFE, 0x0F, 0xF0, 0x1F, 0x00,
  0x7C, 0xF3, 0xFF, 0xEF, 0xFF, 0xB9, 0xCE, 0xE7, 0x3F, 0x9C, 0xFE, 0x73,
  0xF9, 0xCF, 0xE7, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xC0, 0x7F, 0x8F, 0xFC, 0xFF, 0xEF, 0x1E, 0xF0, 0xEF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xF0, 0x0F, 0x80, 0xFF, 0x87, 0xFF, 0x1E, 0x3E, 0xF0, 0x7B, 0xC1,
  0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xEF, 0x07, 0x9E, 0x3E, 0x7F,
  0xF0, 0xFF, 0x80, 0xF8, 0x00, 0x7F, 0x87, 0xFE, 0x3F, 0xF9, 0xE3, 0xEF,
  0x0F, 0x78, 0x7B, 0xC1, 0xDE, 0x0F, 0xF0, 0x77, 0x87, 0xBC, 0x3D, 0xE3,
  0xEF, 0xFE, 0x7F, 0xF3, 0xFE, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x00, 0x0F, 0xF1, 0xFF, 0xDF, 0xFE, 0xF0, 0xFF, 0x87, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0xF1, 0xF7, 0xFF, 0x9F,
  0xFC, 0x7D, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x1F, 0xC7, 0xFE, 0x7F,
  0xEF, 0x06, 0xF0, 0x0F, 0x80, 0x7F, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0x00,
  0xFC, 0x0F, 0xFF, 0xEF, 0xFE, 0x7F, 0x80, 0x06, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x87, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC2, 0x0F,
  0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0x7F,
  0xF7, 0xFF, 0x1F, 0xC0, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0xF3, 0xC1, 0xE3,
  0xC3, 0xC7, 0x8F, 0x0F, 0x1E, 0x0F, 0x3C, 0x1E, 0xF0, 0x1D, 0xE0, 0x3F,
  0x80, 0x7F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0xF0, 0x0F, 0xE0,
  0x1D, 0xC0, 0x3B, 0x9C, 0x77, 0x3C, 0xEE, 0x79, 0xDC, 0xF3, 0x3B, 0xEE,
  0x77, 0xDC, 0xED, 0xF8, 0xFB, 0xF1, 0xF3, 0xE3, 0xC7, 0x87, 0x8F, 0x0F,
  0x0E, 0x00, 0xF0, 0x39, 0xE1, 0xE7, 0x8F, 0x0F, 0x38, 0x1F, 0xE0, 0x3F,
  0x00, 0xF8, 0x01, 0xE0, 0x0F, 0xC0, 0x7F, 0x83, 0xDE, 0x0F, 0x3C, 0x78,
  0xFB, 0xC1, 0xEF, 0x03, 0xC0, 0xF0, 0x39, 0xC1, 0xE7, 0x87, 0x9E, 0x1E,
  0x78, 0x70, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x1E, 0xE0, 0x7F, 0x80, 0xFE,
  0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x8F, 0x03, 0xF8,
  0x0F, 0xE0, 0x3E, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x3E, 0x07, 0xC0,
  0x78, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0xFF, 0x0F, 0xF1, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0xFC, 0x0F, 0x00,
  0xFC, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x0F,
  0xE0, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0x03, 0xF0, 0x78, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0xFF, 0x0F,
  0xE0, 0xFC, 0x00, 0x3C, 0x19, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0xE3, 0xF9,
  0x83, 0xC0,
};

const GFXglyph UbuntuMono_Bold31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 5, 19, 16, 5, -19 },
  { 13, 10, 9, 16, 3, -21 },
  { 25, 14, 19, 16, 1, -19 },
  { 59, 13, 25, 16, 1, -22 },
  { 100, 15, 19, 16, 0, -19 },
  { 136, 14, 19, 16, 1, -19 },
  { 170, 4, 9, 16, 6, -21 },
  { 175, 10, 27, 16, 3, -22 },
  { 209, 10, 27, 16, 3, -22 },
  { 243, 13, 13, 16, 1, -19 },
  { 265, 13, 13, 16, 1, -15 },
  { 287, 7, 11, 16, 4, -6 },
  { 297, 9, 4, 16, 3, -10 },
  { 302, 6, 6, 16, 5, -6 },
  { 307, 13, 27, 16, 1, -22 },
  { 351, 13, 19, 16, 1, -19 },
  { 382, 13, 19, 16, 1, -19 },
  { 413, 13, 19, 16, 1, -19 },
  { 444, 13, 19, 16, 1, -19 },
  { 475, 14, 19, 16, 1, -19 },
  { 509, 13, 19, 16, 1, -19 },
  { 540, 13, 19, 16, 1, -19 },
  { 571, 12, 19, 16, 2, -19 },
  { 600, 13, 19, 16, 1, -19 },
  { 631, 13, 19, 16, 1, -19 },
  { 662, 6, 15, 16, 5, -15 },
  { 674, 7, 20, 16, 4, -15 },
  { 692, 13, 14, 16, 1, -15 },
  { 715, 13, 9, 16, 1, -13 },
  { 730, 13, 14, 16, 1, -15 },
  { 753, 11, 19, 16, 2, -19 },
  { 780, 14, 23, 16, 1, -19 },
  { 821, 15, 19, 16, 0, -19 },
  { 857, 13, 19, 16, 2, -19 },
  { 888, 14, 19, 16, 1, -19 },
  { 922, 13, 19, 16, 2, -19 },
  { 953, 12, 19, 16, 2, -19 },
  { 982, 12, 19, 16, 2, -19 },
  { 1011, 13, 19, 16, 1, -19 },
  { 1042, 13, 19, 16, 1, -19 },
  { 1073, 12, 19, 16, 2, -19 },
  { 1102, 13, 19, 16, 1, -19 },
  { 1133, 14, 19, 16, 1, -19 },
  { 1167, 12, 19, 16, 2, -19 },
  { 1196, 14, 19, 16, 1, -19 },
  { 1230, 13, 19, 16, 1, -19 },
  { 1261, 14, 19, 16, 1, -19 },
  { 1295, 13, 19, 16, 2, -19 },
  { 1326, 14, 24, 16, 1, -19 },
  { 1368, 13, 19, 16, 2, -19 },
  { 1399, 13, 19, 16, 1, -19 },
  { 1430, 14, 19, 16, 1, -19 },
  { 1464, 13, 19, 16, 1, -19 },
  { 1495, 15, 19, 16, 0, -19 },
  { 1531, 14, 19, 16, 1, -19 },
  { 1565, 15, 19, 16, 0, -19 },
  { 1601, 15, 19, 16, 0, -19 },
  { 1637, 13, 19, 16, 1, -19 },
  { 1668, 9, 27, 16, 3, -22 },
  { 1699, 12, 27, 16, 2, -22 },
  { 1740, 9, 27, 16, 3, -22 },
  { 1771, 15, 10, 16, 0, -19 },
  { 1790, 15, 3, 16, 0, 2 },
  { 1796, 7, 6, 16, 5, -21 },
  { 1802, 13, 15, 16, 1, -15 },
  { 1827, 13, 21, 16, 2, -21 },
  { 1862, 13, 15, 16, 1, -15 },
  { 1887, 12, 21, 16, 1, -21 },
  { 1919, 13, 15, 16, 1, -15 },
  { 1944, 14, 21, 16, 1, -21 },
  { 1981, 13, 20, 16, 1, -15 },
  { 2014, 12, 21, 16, 2, -21 },
  { 2046, 13, 21, 16, 1, -21 },
  { 2081, 10, 26, 16, 2, -21 },
  { 2114, 13, 21, 16, 2, -21 },
  { 2149, 13, 21, 16, 1, -21 },
  { 2184, 14, 15, 16, 1, -15 },
  { 2211, 12, 15, 16, 2, -15 },
  { 2234, 14, 15, 16, 1, -15 },
  { 2261, 13, 20, 16, 2, -15 },
  { 2294, 13, 20, 16, 1, -15 },
  { 2327, 11, 15, 16, 3, -15 },
  { 2348, 12, 15, 16, 2, -15 },
  { 2371, 14, 19, 16, 1, -19 },
  { 2405, 12, 15, 16, 2, -15 },
  { 2428, 15, 15, 16, 0, -15 },
  { 2457, 15, 15, 16, 0, -15 },
  { 2486, 14, 15, 16, 1, -15 },
  { 2513, 14, 20, 16, 1, -15 },
  { 2548, 12, 15, 16, 2, -15 },
  { 2571, 12, 27, 16, 2, -22 },
  { 2612, 4, 27, 16, 6, -22 },
  { 2626, 12, 27, 16, 2, -22 },
  { 2667, 14, 6, 16, 1, -11 },
};

const GFXfont UbuntuMono_Bold31pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold31pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold31pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _UBUNTUMONO_BOLD31PT7B_H_
