#ifndef _UBUNTUMONO_BOLD10PT7B_H_
#define _UBUNTUMONO_BOLD10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold10pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xB6, 0x80, 0x37, 0xD5, 0xF5, 0x30, 0x23, 0x90, 0xC3, 0x0F,
  0xC4, 0xCE, 0xB8, 0x75, 0xCC, 0x72, 0x9B, 0x69, 0x3C, 0xE0, 0x2B, 0x49,
  0x22, 0x20, 0x89, 0x92, 0x4A, 0x80, 0x23, 0x9C, 0xE5, 0x00, 0x21, 0x3E,
  0x42, 0x00, 0x57, 0xE0, 0xC0, 0x10, 0x8C, 0x42, 0x11, 0x88, 0x40, 0x72,
  0xAB, 0x15, 0x38, 0x23, 0x08, 0x42, 0x3C, 0x70, 0x84, 0x44, 0x3C, 0x70,
  0x9C, 0x21, 0x78, 0x11, 0x94, 0xAF, 0x88, 0x74, 0x71, 0x1F, 0x32, 0x1D,
  0xA5, 0x38, 0xF8, 0x8C, 0x42, 0x30, 0x72, 0x9C, 0xAD, 0xB8, 0x72, 0x96,
  0xE1, 0x30, 0xD8, 0x51, 0x58, 0x11, 0xD9, 0x86, 0x1C, 0x40, 0xF8, 0x3E,
  0x47, 0x0C, 0x33, 0x71, 0x00, 0xE5, 0xA1, 0x80, 0x72, 0x6F, 0x5A, 0xA9,
  0xC0, 0x22, 0x94, 0xAF, 0xEC, 0xEA, 0xEB, 0xBE, 0x7A, 0x31, 0x84, 0x3C,
  0xEA, 0xBB, 0xAE, 0xE8, 0xE8, 0x8F, 0xF3, 0xC9, 0x00, 0x72, 0x31, 0xB5,
  0xBC, 0xDE, 0xFF, 0xBD, 0xEC, 0xE9, 0x25, 0xC0, 0x71, 0x11, 0x17, 0xD7,
  0xB9, 0xCD, 0x6C, 0x88, 0x88, 0x8F, 0x56, 0xEB, 0x58, 0xC4, 0xDE, 0xFF,
  0xFD, 0xEC, 0x76, 0xF7, 0xBD, 0xB8, 0xEB, 0xBE, 0x88, 0x76, 0xF7, 0xBD,
  0xB8, 0x83, 0xEA, 0xAE, 0xAB, 0x76, 0x18, 0x61, 0xB8, 0xF9, 0x08, 0x42,
  0x10, 0xDE, 0xF7, 0xBD, 0xB8, 0xDE, 0xD4, 0xA7, 0x10, 0x8C, 0x6B, 0x5D,
  0xA8, 0xDA, 0x88, 0xE5, 0x6C, 0xDA, 0x94, 0x42, 0x10, 0x70, 0x88, 0xC4,
  0x7C, 0xF2, 0x49, 0x24, 0xE0, 0x42, 0x18, 0x42, 0x10, 0x42, 0x10, 0xE4,
  0x92, 0x49, 0xE0, 0x22, 0xB6, 0xF8, 0xB0, 0x71, 0x7D, 0x70, 0x88, 0xEB,
  0xBB, 0xE0, 0x7A, 0x30, 0x87, 0x80, 0x11, 0x7D, 0xDD, 0x70, 0x76, 0xFF,
  0x87, 0x00, 0x3B, 0x3E, 0xC6, 0x31, 0x80, 0x7D, 0xDD, 0x71, 0x70, 0x93,
  0xDB, 0x68, 0x60, 0x38, 0x42, 0x10, 0xE0, 0x30, 0x71, 0x11, 0x11, 0x60,
  0x88, 0xAC, 0xCA, 0xB0, 0xE1, 0x08, 0x42, 0x10, 0xE0, 0xF5, 0x6B, 0x18,
  0x80, 0xF6, 0xDA, 0x76, 0xF7, 0xB7, 0x00, 0xEB, 0xBB, 0xE8, 0x80, 0x7D,
  0xDD, 0x71, 0x10, 0xF8, 0x88, 0x80, 0xF3, 0x9E, 0x67, 0xD8, 0xC6, 0x1C,
  0xB6, 0xDE, 0xDA, 0x94, 0xE2, 0x00, 0x8D, 0x6A, 0xA5, 0x00, 0x53, 0x88,
  0xAD, 0x80, 0xDA, 0x94, 0xE2, 0x13, 0x00, 0xED, 0x4E, 0x69, 0x28, 0x92,
  0x60, 0xFF, 0x80, 0xC9, 0x22, 0x92, 0xC0, 0x6D, 0x80,
};

const GFXglyph UbuntuMono_Bold10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 3, 3, 5, 1, -7 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 5, 8, 5, 0, -7 },
  { 13, 5, 6, 5, 0, -6 },
  { 17, 5, 6, 5, 0, -6 },
  { 21, 1, 3, 5, 2, -7 },
  { 22, 3, 9, 5, 1, -7 },
  { 26, 3, 9, 5, 1, -7 },
  { 30, 5, 5, 5, 0, -6 },
  { 34, 5, 5, 5, 0, -5 },
  { 38, 2, 4, 5, 1, -2 },
  { 39, 3, 1, 5, 1, -3 },
  { 40, 1, 2, 5, 2, -2 },
  { 41, 5, 9, 5, 0, -7 },
  { 47, 5, 6, 5, 0, -6 },
  { 51, 5, 6, 5, 0, -6 },
  { 55, 5, 6, 5, 0, -6 },
  { 59, 5, 6, 5, 0, -6 },
  { 63, 5, 6, 5, 0, -6 },
  { 67, 4, 6, 5, 0, -6 },
  { 70, 5, 6, 5, 0, -6 },
  { 74, 5, 6, 5, 0, -6 },
  { 78, 5, 6, 5, 0, -6 },
  { 82, 5, 6, 5, 0, -6 },
  { 86, 1, 5, 5, 2, -5 },
  { 87, 2, 7, 5, 1, -5 },
  { 89, 5, 7, 5, 0, -7 },
  { 94, 5, 3, 5, 0, -4 },
  { 96, 5, 7, 5, 0, -7 },
  { 101, 3, 6, 5, 1, -6 },
  { 104, 5, 7, 5, 0, -6 },
  { 109, 5, 6, 5, 0, -6 },
  { 113, 4, 6, 5, 1, -6 },
  { 116, 5, 6, 5, 0, -6 },
  { 120, 4, 6, 5, 1, -6 },
  { 123, 4, 6, 5, 1, -6 },
  { 126, 3, 6, 5, 1, -6 },
  { 129, 5, 6, 5, 0, -6 },
  { 133, 5, 6, 5, 0, -6 },
  { 137, 3, 6, 5, 1, -6 },
  { 140, 4, 6, 5, 0, -6 },
  { 143, 5, 6, 5, 0, -6 },
  { 147, 4, 6, 5, 1, -6 },
  { 150, 5, 6, 5, 0, -6 },
  { 154, 5, 6, 5, 0, -6 },
  { 158, 5, 6, 5, 0, -6 },
  { 162, 4, 6, 5, 1, -6 },
  { 165, 5, 8, 5, 0, -6 },
  { 170, 4, 6, 5, 1, -6 },
  { 173, 5, 6, 5, 0, -6 },
  { 177, 5, 6, 5, 0, -6 },
  { 181, 5, 6, 5, 0, -6 },
  { 185, 5, 6, 5, 0, -6 },
  { 189, 5, 6, 5, 0, -6 },
  { 193, 5, 6, 5, 0, -6 },
  { 197, 5, 6, 5, 0, -6 },
  { 201, 5, 6, 5, 0, -6 },
  { 205, 3, 9, 5, 1, -7 },
  { 209, 5, 9, 5, 0, -7 },
  { 215, 3, 9, 5, 1, -7 },
  { 219, 5, 3, 5, 0, -6 },
  { 221, 5, 1, 5, 0, 1 },
  { 222, 2, 2, 5, 2, -7 },
  { 223, 4, 5, 5, 0, -5 },
  { 226, 4, 7, 5, 1, -7 },
  { 230, 5, 5, 5, 0, -5 },
  { 234, 4, 7, 5, 0, -7 },
  { 238, 5, 5, 5, 0, -5 },
  { 242, 5, 7, 5, 0, -7 },
  { 247, 4, 7, 5, 0, -5 },
  { 251, 3, 7, 5, 1, -7 },
  { 254, 5, 7, 5, 0, -7 },
  { 259, 4, 9, 5, 0, -7 },
  { 264, 4, 7, 5, 1, -7 },
  { 268, 5, 7, 5, 0, -7 },
  { 273, 5, 5, 5, 0, -5 },
  { 277, 3, 5, 5, 1, -5 },
  { 279, 5, 5, 5, 0, -5 },
  { 283, 4, 7, 5, 1, -5 },
  { 287, 4, 7, 5, 0, -5 },
  { 291, 4, 5, 5, 1, -5 },
  { 294, 3, 5, 5, 1, -5 },
  { 296, 5, 6, 5, 0, -6 },
  { 300, 3, 5, 5, 1, -5 },
  { 302, 5, 5, 5, 0, -5 },
  { 306, 5, 5, 5, 0, -5 },
  { 310, 5, 5, 5, 0, -5 },
  { 314, 5, 7, 5, 0, -5 },
  { 319, 3, 5, 5, 1, -5 },
  { 321, 3, 9, 5, 1, -7 },
  { 325, 1, 9, 5, 2, -7 },
  { 327, 3, 9, 5, 1, -7 },
  { 331, 5, 2, 5, 0, -4 },
};

const GFXfont UbuntuMono_Bold10pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold10pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold10pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _UBUNTUMONO_BOLD10PT7B_H_
