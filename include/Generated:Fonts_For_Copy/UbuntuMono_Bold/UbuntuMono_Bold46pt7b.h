#ifndef _UBUNTUMONO_BOLD46PT7B_H_
#define _UBUNTUMONO_BOLD46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0x3E, 0x7C, 0xF9, 0xF0, 0x00, 0x00, 0x0E, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF7, 0x80, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7,
  0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x1F, 0x78, 0x3E, 0xF0, 0x79, 0xE0, 0xF3,
  0xC1, 0xE7, 0x83, 0xC0, 0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0x78,
  0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x78, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0x0F, 0x80, 0xF8, 0x78, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xF0,
  0x0F, 0x0F, 0x80, 0xF8, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF,
  0xFE, 0x7F, 0xFF, 0xCF, 0xE0, 0x79, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x40, 0x07, 0xEF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0x00, 0x7D, 0xFF, 0x00, 0xF3, 0xFE, 0x03, 0xC7, 0xBC, 0x0F, 0x8E, 0x3C,
  0x1E, 0x3C, 0x78, 0x78, 0x78, 0xF1, 0xF0, 0xF1, 0xE3, 0xC0, 0xE3, 0xCF,
  0x01, 0xEF, 0xBE, 0x03, 0xFE, 0x78, 0x07, 0xFD, 0xE0, 0x07, 0xF7, 0xC0,
  0x07, 0xCF, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0xFB, 0xF8, 0x01, 0xEF, 0xF8,
  0x07, 0x9F, 0xF0, 0x1F, 0x7D, 0xE0, 0x3C, 0xF1, 0xC0, 0xF1, 0xE3, 0xC3,
  0xE3, 0xC7, 0x87, 0x87, 0x8F, 0x1E, 0x0F, 0x1C, 0x7C, 0x1E, 0x78, 0xF0,
  0x1F, 0xF3, 0xC0, 0x3F, 0xEF, 0x80, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0x8F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF1,
  0xF0, 0x07, 0xDF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0xF8,
  0x7F, 0x87, 0xC7, 0xFE, 0x3E, 0x7D, 0xF9, 0xF3, 0xE7, 0xEF, 0xBE, 0x1F,
  0xF9, 0xF0, 0x7F, 0xCF, 0x81, 0xFE, 0x7C, 0x07, 0xE3, 0xE0, 0x3F, 0x1F,
  0x83, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xF3,
  0xF0, 0x7E, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xBE, 0xFB, 0xEF,
  0x9E, 0x79, 0xC0, 0x00, 0x08, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0x18, 0x20, 0x00, 0x70, 0x01,
  0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x10, 0xF8, 0x67, 0x9F,
  0x3C, 0xF9, 0xCF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x3E,
  0x00, 0x1F, 0xF0, 0x07, 0xDF, 0x01, 0xFB, 0xF0, 0x7F, 0x3F, 0x07, 0xC7,
  0xC0, 0x78, 0x70, 0x02, 0x08, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0x07, 0xE3, 0xF8,
  0xFF, 0x3F, 0xCF, 0xF1, 0xFC, 0x3F, 0x07, 0xC1, 0xE0, 0xF8, 0xFC, 0xFE,
  0x3F, 0x0F, 0x83, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3E, 0x3F, 0x9F, 0xDF, 0xFF, 0xFB, 0xF9, 0xFC, 0x3C, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFE, 0x3F,
  0x9F, 0x83, 0xF7, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x71, 0xFF, 0x9F, 0x3F, 0xF3, 0xE7, 0xFE, 0x7C, 0xFF, 0xCF, 0x9F,
  0xF8, 0xE3, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFB, 0xF0, 0x7E, 0x7F, 0x1F, 0xC7, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7C, 0xF8, 0x06, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xF8, 0x3F, 0x8C, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7,
  0xFF, 0xFE, 0x07, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0x87,
  0xFF, 0xF8, 0x70, 0x7F, 0x08, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x70,
  0x1F, 0xCF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07,
  0xEF, 0xC0, 0x3E, 0x7E, 0x03, 0xE3, 0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0xFC,
  0x1F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF3, 0x01,
  0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFE, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF9, 0xC0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF7, 0xF1, 0xFE, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7E, 0xF8, 0x0F, 0xDF, 0x81, 0xF3, 0xF8, 0x7E, 0x3F, 0xFF,
  0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE,
  0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x1F, 0x9F, 0x01, 0xF7, 0xE0, 0x3F,
  0xFC, 0x07, 0xDF, 0x80, 0xF9, 0xF0, 0x1F, 0x3F, 0x07, 0xE7, 0xF9, 0xF8,
  0x7F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFF, 0x8F, 0xCF, 0xF9,
  0xF0, 0x7F, 0x7E, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFC, 0x3F, 0x9F, 0x03, 0xF7, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7E,
  0xFF, 0x3F, 0xDF, 0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xF8,
  0x07, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x03,
  0xE0, 0x00, 0x3E, 0x3F, 0x9F, 0xDF, 0xFF, 0xFB, 0xF9, 0xFC, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0xFE, 0x7F, 0x7F, 0xFF, 0xEF,
  0xE7, 0xF0, 0xF0, 0x0F, 0x83, 0xF8, 0x7F, 0x1F, 0xF3, 0xFE, 0x3F, 0x87,
  0xF0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0xFE, 0x1F, 0xC7, 0xF8, 0xFF, 0x8F, 0xF1, 0xFE, 0x1F, 0x80, 0xF0, 0x3E,
  0x0F, 0x87, 0xF1, 0xFC, 0x3F, 0x07, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x78, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x8F,
  0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x7F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x0F, 0x00, 0x01,
  0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0,
  0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x0F,
  0xC0, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xFE, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF3, 0xC1, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xF8, 0x3E,
  0x1F, 0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x80, 0x1E, 0x78, 0x00, 0xF3, 0xC0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC7, 0xE3, 0xFE, 0x3E, 0x1F, 0xF1, 0xF0, 0xFF, 0x8F, 0x87, 0xFC, 0x78,
  0x3F, 0xE3, 0xE1, 0xFF, 0x1F, 0x0F, 0xF8, 0xF8, 0x7F, 0xC7, 0xE3, 0xFF,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFB, 0xC3, 0xFF, 0xDF, 0x0F, 0xFE, 0xF8, 0x1F,
  0x83, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x81, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0x8F, 0x80,
  0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7E, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x83, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0x80,
  0x7E, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03,
  0xF3, 0xE0, 0x07, 0xE0, 0x3F, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xC1, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0x7C,
  0xFC, 0x07, 0xCF, 0xC0, 0x7C, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0xFF, 0xFF,
  0x8F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xC0,
  0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xFF,
  0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xE0, 0x78, 0xFE,
  0x00, 0x87, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x04, 0x3F, 0xC0,
  0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x8F, 0xC3, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0xFC, 0x07,
  0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0xFC, 0x1F, 0xCF,
  0xC3, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0,
  0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF,
  0xF3, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB,
  0xFF, 0xFD, 0xFF, 0xFE, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFE, 0x0E, 0x3F, 0x80, 0x23,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xF7, 0xC0, 0x1F, 0x7E, 0x01, 0xF7, 0xE0,
  0x1F, 0x7F, 0x01, 0xF3, 0xF0, 0x1F, 0x3F, 0xC1, 0xF1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFC, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF2, 0x01, 0xFD, 0xE0, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE1,
  0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0xFC, 0x07, 0xE7, 0xE0, 0x7F, 0x3F, 0x03,
  0xF1, 0xF8, 0x3F, 0x8F, 0xC1, 0xF8, 0x7E, 0x1F, 0x83, 0xF1, 0xFC, 0x1F,
  0x8F, 0xC0, 0xFC, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFD,
  0xFC, 0x07, 0xE7, 0xF0, 0x3F, 0x1F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC3, 0xF8,
  0x7E, 0x0F, 0xC3, 0xF0, 0x7F, 0x1F, 0x81, 0xFC, 0xFC, 0x07, 0xE7, 0xE0,
  0x3F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x03,
  0xE1, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F,
  0x83, 0xF9, 0xFC, 0x3F, 0xCF, 0xF1, 0xFE, 0x7B, 0x8E, 0xF3, 0xDC, 0xF7,
  0x9E, 0xF7, 0xBC, 0xF3, 0xB9, 0xE7, 0x9F, 0xCF, 0x3C, 0xFE, 0x79, 0xE7,
  0xF3, 0xCF, 0x1F, 0x1E, 0x78, 0xF8, 0xF7, 0xC7, 0xC7, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xF0,
  0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F,
  0xEF, 0x8F, 0xFD, 0xF1, 0xFF, 0x9F, 0x3F, 0xF3, 0xE7, 0xFE, 0x3E, 0xFF,
  0xC7, 0xDF, 0xF8, 0x7B, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xC7, 0xF1, 0xFC,
  0x1F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xE0, 0x0F, 0xBF, 0x00, 0x7D,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xE7,
  0xC0, 0x1F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xE0, 0xFC, 0x3F, 0x8F,
  0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xEF, 0xC0, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xEF, 0xC0,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xC7, 0xF0, 0xFC, 0x1F, 0x8F, 0xC0, 0x7E,
  0x7E, 0x03, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7D, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3F, 0x01,
  0xF9, 0xF8, 0x0F, 0xCF, 0xE0, 0xFE, 0x3F, 0x8F, 0xE1, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x0E, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7E, 0x1F, 0xE3, 0xF0, 0x3F, 0x1F,
  0x81, 0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x1F,
  0x8F, 0xC0, 0xFC, 0x7E, 0x1F, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0,
  0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0,
  0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x00, 0x03, 0xFC,
  0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFE, 0x0F,
  0x3F, 0x00, 0x47, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xFA, 0x00, 0x3F, 0x78, 0x0F, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFF, 0xC7, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x7E, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x3F, 0x80, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x3E, 0x01,
  0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F,
  0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F,
  0x01, 0xF1, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x0F,
  0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x3E, 0x3F, 0xF1, 0xF1, 0xE7, 0x8F, 0x8F, 0x3C, 0xFE, 0x79,
  0xE7, 0xF3, 0xCF, 0x3F, 0x9E, 0x79, 0xDC, 0xF3, 0xDE, 0xF7, 0x9E, 0xF3,
  0xBC, 0xF7, 0x1D, 0xE7, 0xF8, 0xFF, 0x3F, 0xC7, 0xF9, 0xFC, 0x1F, 0xCF,
  0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF0, 0x1F, 0x8F, 0x80, 0xF8, 0x7C, 0x07,
  0xC0, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x1F,
  0x80, 0xF8, 0x3F, 0x01, 0xF8, 0xFC, 0x01, 0xF1, 0xF0, 0x03, 0xF7, 0xE0,
  0x03, 0xEF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0xBF, 0x00, 0x3E, 0x3E, 0x00, 0xFC,
  0x7E, 0x01, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xFC, 0x3F, 0x01,
  0xF8, 0x7E, 0x03, 0xF1, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE0, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x7C, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x1F,
  0x81, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0xF8, 0x1F, 0x87, 0xC0, 0x7C, 0x7E,
  0x03, 0xF3, 0xE0, 0x0F, 0xBF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0x7E, 0x00, 0xFC, 0xF8, 0x07,
  0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0x3F, 0x1F, 0x80,
  0xFE, 0xFC, 0x01, 0xF9, 0xF0, 0x03, 0xC0, 0x80, 0x0C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x30, 0x0E, 0x07, 0xC3, 0xFC, 0x7F, 0x87, 0xF0, 0x78, 0x04, 0x0F,
  0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x84, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC1, 0xFF, 0xF1, 0xFF, 0xFC,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF1, 0xFF, 0xFC, 0x1F, 0xF8, 0x1C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF7, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xF0, 0xFE, 0xFC, 0x0F, 0xDF, 0x81, 0xFB,
  0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF,
  0xC1, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x7F, 0x80, 0x9F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x9F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x0F,
  0xDF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFB, 0xF8,
  0x7F, 0x7E, 0x07, 0xEF, 0xC0, 0xFD, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xEF, 0x80,
  0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xF8, 0x7E, 0x7F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xF8, 0x7E, 0x7F,
  0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x01, 0xF7, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xF8, 0x38,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFE, 0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xC3,
  0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE,
  0x0F, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFB,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF6, 0x03, 0xF9,
  0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC0, 0x7F, 0xC0, 0x1C,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x1F, 0xFF,
  0x8F, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFD, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0x80, 0x03, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x30, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x07, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x20, 0x3F, 0x78, 0x3F, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFC, 0x7F,
  0xF8, 0x0F, 0xE0, 0x1C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xEF, 0xC1, 0xF9, 0xF8, 0x7F,
  0x3F, 0x0F, 0xC7, 0xE3, 0xF0, 0xFC, 0xFC, 0x1F, 0xBF, 0x03, 0xF7, 0xC0,
  0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0,
  0xFD, 0xFC, 0x1F, 0x9F, 0x83, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xC3, 0xF9,
  0xF8, 0x3F, 0x3F, 0x03, 0xF7, 0xE0, 0x7F, 0xFC, 0x07, 0xE0, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x30, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x07, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xCF, 0x87, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7C, 0xFC, 0xFB, 0xE3, 0xE3, 0xFF,
  0x1F, 0x1F, 0xF8, 0xF8, 0xFF, 0xC7, 0xC7, 0xFE, 0x3E, 0x3F, 0xF1, 0xF1,
  0xFF, 0x8F, 0x8F, 0xFC, 0x7C, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF,
  0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3E, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xC3, 0xF1, 0xFC,
  0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0x80,
  0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0x8F, 0xC3, 0xF8, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF9, 0xF8, 0x7F,
  0x3F, 0x07, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x80, 0xFB, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xF7, 0xE0, 0x7E,
  0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x7E, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9,
  0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xEF, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE,
  0x7F, 0x0F, 0xDF, 0xC1, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xDF, 0x01, 0xFB,
  0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xFD, 0xFC, 0x1F, 0x9F, 0xFF, 0xF3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xBF, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xE0, 0x0B, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE,
  0x3F, 0xFF, 0x9F, 0xC0, 0xE7, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0x00, 0x07, 0xD0, 0x01, 0xF7, 0x80, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xE0, 0x3F, 0xE0, 0x01, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x06, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFF, 0x0F,
  0xDF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xF0, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0xF8, 0x03, 0xE7, 0xE0, 0x3F,
  0x3F, 0x01, 0xF8, 0xF8, 0x0F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xF8,
  0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x00, 0xF9, 0xF8, 0x07, 0xEF, 0xC0,
  0x1F, 0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x3C,
  0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xE0, 0x03, 0xE7, 0xC7, 0xC7, 0xCF,
  0x8F, 0x8F, 0x9F, 0x1F, 0x1F, 0x3E, 0x3E, 0x3E, 0x7C, 0xFE, 0x7C, 0xF9,
  0xFC, 0xF0, 0xF3, 0xF9, 0xE1, 0xE7, 0xF3, 0xC3, 0xDE, 0xF7, 0x87, 0xBD,
  0xEF, 0x0F, 0x7B, 0xDE, 0x1E, 0xE3, 0xBC, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F,
  0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3E, 0x01, 0xE0, 0x3C,
  0x00, 0xFC, 0x01, 0xFB, 0xF0, 0x1F, 0x8F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1,
  0xF8, 0xFC, 0x07, 0xEF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFB, 0xF0, 0x1F, 0x8F, 0xC0, 0xF8, 0x3F,
  0x0F, 0xC1, 0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x7E, 0x00, 0xFC, 0x7E,
  0x01, 0xFB, 0xF0, 0x0F, 0x9F, 0x80, 0xFC, 0x7C, 0x07, 0xE3, 0xF0, 0x3F,
  0x1F, 0x81, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xC0, 0xFC,
  0x3E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xF8, 0x03, 0xF7, 0xC0,
  0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x02, 0x1F, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0,
  0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0x0F,
  0x80, 0x60, 0xFF, 0x03, 0xCF, 0xFE, 0x3E, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7C, 0x3F, 0xFB, 0xE0, 0xFF, 0x86, 0x01, 0xF0,
};

const GFXglyph UbuntuMono_Bold46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 7, 29, 23, 8, -28 },
  { 27, 15, 13, 23, 4, -31 },
  { 52, 21, 28, 23, 1, -28 },
  { 126, 19, 36, 23, 2, -32 },
  { 212, 23, 30, 23, 0, -29 },
  { 299, 21, 29, 23, 1, -29 },
  { 376, 6, 14, 23, 9, -31 },
  { 387, 15, 41, 23, 4, -33 },
  { 464, 15, 41, 23, 4, -33 },
  { 541, 19, 17, 23, 2, -28 },
  { 582, 19, 21, 23, 2, -22 },
  { 632, 10, 16, 23, 6, -7 },
  { 652, 13, 6, 23, 5, -14 },
  { 662, 9, 8, 23, 7, -7 },
  { 671, 19, 40, 23, 2, -32 },
  { 766, 19, 30, 23, 2, -29 },
  { 838, 19, 28, 23, 2, -28 },
  { 905, 19, 29, 23, 2, -29 },
  { 974, 19, 30, 23, 2, -29 },
  { 1046, 21, 28, 23, 1, -28 },
  { 1120, 19, 29, 23, 2, -28 },
  { 1189, 19, 29, 23, 2, -28 },
  { 1258, 19, 28, 23, 2, -28 },
  { 1325, 19, 30, 23, 2, -29 },
  { 1397, 19, 29, 23, 2, -29 },
  { 1466, 9, 22, 23, 7, -21 },
  { 1491, 11, 30, 23, 5, -21 },
  { 1533, 19, 20, 23, 2, -22 },
  { 1581, 19, 14, 23, 2, -19 },
  { 1615, 19, 20, 23, 2, -22 },
  { 1663, 17, 30, 23, 3, -29 },
  { 1727, 21, 35, 23, 1, -29 },
  { 1819, 23, 28, 23, 0, -28 },
  { 1900, 20, 30, 23, 2, -29 },
  { 1975, 21, 30, 23, 1, -29 },
  { 2054, 20, 29, 23, 2, -28 },
  { 2127, 18, 28, 23, 3, -28 },
  { 2190, 17, 28, 23, 3, -28 },
  { 2250, 20, 30, 23, 1, -29 },
  { 2325, 19, 28, 23, 2, -28 },
  { 2392, 19, 28, 23, 2, -28 },
  { 2459, 18, 29, 23, 2, -28 },
  { 2525, 21, 28, 23, 2, -28 },
  { 2599, 18, 28, 23, 3, -28 },
  { 2662, 21, 28, 23, 1, -28 },
  { 2736, 19, 28, 23, 2, -28 },
  { 2803, 21, 30, 23, 1, -29 },
  { 2882, 20, 29, 23, 2, -29 },
  { 2955, 21, 37, 23, 1, -29 },
  { 3053, 21, 29, 23, 2, -29 },
  { 3130, 19, 30, 23, 2, -29 },
  { 3202, 21, 28, 23, 1, -28 },
  { 3276, 19, 29, 23, 2, -28 },
  { 3345, 21, 28, 23, 1, -28 },
  { 3419, 21, 28, 23, 1, -28 },
  { 3493, 23, 28, 23, 0, -28 },
  { 3574, 21, 28, 23, 1, -28 },
  { 3648, 19, 28, 23, 2, -28 },
  { 3715, 13, 40, 23, 5, -32 },
  { 3780, 19, 40, 23, 2, -32 },
  { 3875, 13, 40, 23, 5, -32 },
  { 3940, 22, 15, 23, 1, -28 },
  { 3982, 23, 5, 23, 0, 3 },
  { 3997, 10, 8, 23, 7, -32 },
  { 4007, 18, 24, 23, 2, -23 },
  { 4061, 19, 34, 23, 3, -33 },
  { 4142, 19, 24, 23, 2, -23 },
  { 4199, 19, 34, 23, 1, -33 },
  { 4280, 20, 24, 23, 1, -23 },
  { 4340, 21, 33, 23, 2, -33 },
  { 4427, 18, 32, 23, 2, -23 },
  { 4499, 17, 33, 23, 3, -33 },
  { 4570, 19, 33, 23, 2, -32 },
  { 4649, 16, 41, 23, 2, -32 },
  { 4731, 19, 33, 23, 3, -33 },
  { 4810, 19, 33, 23, 2, -32 },
  { 4889, 21, 23, 23, 1, -23 },
  { 4950, 17, 23, 23, 3, -23 },
  { 4999, 21, 24, 23, 1, -23 },
  { 5062, 19, 31, 23, 3, -23 },
  { 5136, 19, 31, 23, 1, -23 },
  { 5210, 17, 23, 23, 4, -23 },
  { 5259, 18, 24, 23, 2, -23 },
  { 5313, 20, 29, 23, 2, -28 },
  { 5386, 17, 23, 23, 3, -22 },
  { 5435, 21, 22, 23, 1, -22 },
  { 5493, 23, 22, 23, 0, -22 },
  { 5557, 21, 22, 23, 1, -22 },
  { 5615, 21, 31, 23, 1, -22 },
  { 5697, 17, 22, 23, 3, -22 },
  { 5744, 17, 40, 23, 3, -32 },
  { 5829, 5, 40, 23, 9, -32 },
  { 5854, 17, 40, 23, 3, -32 },
  { 5939, 21, 8, 23, 1, -16 },
};

const GFXfont UbuntuMono_Bold46pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold46pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold46pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _UBUNTUMONO_BOLD46PT7B_H_
