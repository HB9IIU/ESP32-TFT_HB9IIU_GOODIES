#ifndef _UBUNTUMONO_BOLD8PT7B_H_
#define _UBUNTUMONO_BOLD8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xC0, 0xF0, 0x5F, 0x6F, 0xA0, 0x27, 0x86, 0x1E, 0x40, 0xDE,
  0xF7, 0xB0, 0x6A, 0x5A, 0xF0, 0xD0, 0x7A, 0xA4, 0xB5, 0x58, 0xB6, 0x60,
  0x4F, 0x40, 0xE0, 0xC0, 0xC0, 0x22, 0x26, 0x44, 0x40, 0x69, 0xB9, 0x60,
  0x62, 0x22, 0x70, 0x62, 0x24, 0xF0, 0xE2, 0x61, 0xE0, 0x26, 0xAF, 0x20,
  0x64, 0x61, 0xE0, 0x64, 0xE9, 0x60, 0xF2, 0x24, 0x40, 0x69, 0x69, 0x60,
  0x69, 0x72, 0x60, 0xCC, 0xCE, 0x17, 0xCC, 0x71, 0xF0, 0xF0, 0x8E, 0x33,
  0xE8, 0xD8, 0xC0, 0x69, 0xBD, 0xB7, 0x66, 0x6F, 0x90, 0xE9, 0xE9, 0xE0,
  0x78, 0x88, 0x70, 0xE9, 0x99, 0xE0, 0xF8, 0xE8, 0xF0, 0xF8, 0xE8, 0x80,
  0x78, 0x99, 0x70, 0x99, 0xF9, 0x90, 0xF2, 0x22, 0xF0, 0x71, 0x12, 0xE0,
  0xAA, 0xCA, 0x90, 0x92, 0x4E, 0x9F, 0xF9, 0x90, 0x9D, 0xBB, 0x90, 0x69,
  0x99, 0x60, 0xE9, 0xE8, 0x80, 0x69, 0x99, 0x63, 0xE9, 0xEA, 0x90, 0x68,
  0x61, 0xE0, 0xF6, 0x66, 0x60, 0x99, 0x99, 0x60, 0x99, 0x66, 0x60, 0x99,
  0xFF, 0x90, 0x96, 0x66, 0x90, 0x96, 0x62, 0x20, 0xF2, 0x44, 0xF0, 0xEA,
  0xAC, 0x44, 0x42, 0x22, 0x20, 0xD5, 0x5C, 0x66, 0x90, 0xF0, 0xC0, 0x67,
  0x97, 0x88, 0xE9, 0x9E, 0x78, 0x87, 0x25, 0xDA, 0xC0, 0x69, 0xF6, 0x74,
  0xF4, 0x44, 0x79, 0x72, 0xE0, 0x88, 0xE9, 0x99, 0x40, 0xC4, 0x43, 0x21,
  0x92, 0x78, 0xCC, 0xEE, 0xED, 0xC4, 0x44, 0x43, 0xFD, 0x99, 0xE9, 0x99,
  0x69, 0x96, 0xE9, 0x9E, 0x80, 0x79, 0x97, 0x10, 0xF2, 0x40, 0x64, 0x2E,
  0x4F, 0x44, 0x70, 0x99, 0x97, 0x96, 0x66, 0x9B, 0xF6, 0x66, 0x69, 0x96,
  0x62, 0xC0, 0xDB, 0x34, 0x4C, 0x44, 0x30, 0xFE, 0xC2, 0x23, 0x22, 0xC0,
  0x5B,
};

const GFXglyph UbuntuMono_Bold8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 2, 2, 4, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 7, 4, 0, -6 },
  { 11, 4, 5, 4, 0, -5 },
  { 14, 4, 5, 4, 0, -5 },
  { 17, 2, 2, 4, 1, -5 },
  { 18, 2, 7, 4, 1, -6 },
  { 20, 2, 7, 4, 1, -6 },
  { 22, 4, 3, 4, 0, -5 },
  { 24, 4, 3, 4, 0, -4 },
  { 26, 2, 2, 4, 1, -1 },
  { 27, 2, 1, 4, 1, -3 },
  { 28, 2, 1, 4, 1, -1 },
  { 29, 4, 7, 4, 0, -6 },
  { 33, 4, 5, 4, 0, -5 },
  { 36, 4, 5, 4, 0, -5 },
  { 39, 4, 5, 4, 0, -5 },
  { 42, 4, 5, 4, 0, -5 },
  { 45, 4, 5, 4, 0, -5 },
  { 48, 4, 5, 4, 0, -5 },
  { 51, 4, 5, 4, 0, -5 },
  { 54, 4, 5, 4, 0, -5 },
  { 57, 4, 5, 4, 0, -5 },
  { 60, 4, 5, 4, 0, -5 },
  { 63, 2, 3, 4, 1, -3 },
  { 64, 2, 4, 4, 1, -3 },
  { 65, 4, 6, 4, 0, -6 },
  { 68, 4, 3, 4, 0, -3 },
  { 70, 4, 6, 4, 0, -6 },
  { 73, 2, 5, 4, 1, -5 },
  { 75, 4, 6, 4, 0, -5 },
  { 78, 4, 5, 4, 0, -5 },
  { 81, 4, 5, 4, 0, -5 },
  { 84, 4, 5, 4, 0, -5 },
  { 87, 4, 5, 4, 0, -5 },
  { 90, 4, 5, 4, 0, -5 },
  { 93, 4, 5, 4, 0, -5 },
  { 96, 4, 5, 4, 0, -5 },
  { 99, 4, 5, 4, 0, -5 },
  { 102, 4, 5, 4, 0, -5 },
  { 105, 4, 5, 4, 0, -5 },
  { 108, 4, 5, 4, 0, -5 },
  { 111, 3, 5, 4, 1, -5 },
  { 113, 4, 5, 4, 0, -5 },
  { 116, 4, 5, 4, 0, -5 },
  { 119, 4, 5, 4, 0, -5 },
  { 122, 4, 5, 4, 0, -5 },
  { 125, 4, 6, 4, 0, -5 },
  { 128, 4, 5, 4, 0, -5 },
  { 131, 4, 5, 4, 0, -5 },
  { 134, 4, 5, 4, 0, -5 },
  { 137, 4, 5, 4, 0, -5 },
  { 140, 4, 5, 4, 0, -5 },
  { 143, 4, 5, 4, 0, -5 },
  { 146, 4, 5, 4, 0, -5 },
  { 149, 4, 5, 4, 0, -5 },
  { 152, 4, 5, 4, 0, -5 },
  { 155, 2, 7, 4, 1, -6 },
  { 157, 4, 7, 4, 0, -6 },
  { 161, 2, 7, 4, 1, -6 },
  { 163, 4, 3, 4, 0, -5 },
  { 165, 4, 1, 4, 0, 0 },
  { 166, 2, 1, 4, 1, -6 },
  { 167, 4, 4, 4, 0, -4 },
  { 169, 4, 6, 4, 0, -6 },
  { 172, 4, 4, 4, 0, -4 },
  { 174, 3, 6, 4, 0, -6 },
  { 177, 4, 4, 4, 0, -4 },
  { 179, 4, 6, 4, 0, -6 },
  { 182, 4, 5, 4, 0, -4 },
  { 185, 4, 6, 4, 0, -6 },
  { 188, 4, 6, 4, 0, -6 },
  { 191, 3, 7, 4, 0, -6 },
  { 194, 4, 6, 4, 0, -6 },
  { 197, 4, 6, 4, 0, -6 },
  { 200, 4, 4, 4, 0, -4 },
  { 202, 4, 4, 4, 0, -4 },
  { 204, 4, 4, 4, 0, -4 },
  { 206, 4, 5, 4, 0, -4 },
  { 209, 4, 5, 4, 0, -4 },
  { 212, 3, 4, 4, 1, -4 },
  { 214, 4, 4, 4, 0, -4 },
  { 216, 4, 5, 4, 0, -5 },
  { 219, 4, 4, 4, 0, -4 },
  { 221, 4, 4, 4, 0, -4 },
  { 223, 4, 4, 4, 0, -4 },
  { 225, 4, 4, 4, 0, -4 },
  { 227, 4, 5, 4, 0, -4 },
  { 230, 2, 4, 4, 1, -4 },
  { 231, 4, 7, 4, 0, -6 },
  { 235, 1, 7, 4, 2, -6 },
  { 236, 4, 7, 4, 0, -6 },
  { 240, 4, 2, 4, 0, -3 },
};

const GFXfont UbuntuMono_Bold8pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold8pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold8pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _UBUNTUMONO_BOLD8PT7B_H_
