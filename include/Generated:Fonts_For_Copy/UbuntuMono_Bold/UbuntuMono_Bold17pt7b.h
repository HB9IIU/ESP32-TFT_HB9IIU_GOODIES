#ifndef _UBUNTUMONO_BOLD17PT7B_H_
#define _UBUNTUMONO_BOLD17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Bold.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Bold17pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0x1B, 0x00, 0xED, 0xB6, 0xD3, 0x4C, 0x13, 0x12,
  0x32, 0xFF, 0xFF, 0x36, 0xFF, 0xFF, 0x6C, 0x6C, 0x6C, 0x30, 0x61, 0xFF,
  0xEC, 0x1C, 0x3E, 0x1E, 0x0F, 0x0F, 0xFF, 0xE3, 0x06, 0x00, 0x61, 0xD3,
  0xD6, 0xD4, 0x6C, 0x18, 0x17, 0x35, 0x2D, 0x45, 0xC7, 0x38, 0x7C, 0x64,
  0x6C, 0x38, 0x7B, 0x5F, 0xCE, 0xC6, 0x7F, 0x3B, 0xFF, 0x40, 0x19, 0x98,
  0xCC, 0x63, 0x18, 0xC6, 0x31, 0xC7, 0x1C, 0x40, 0x41, 0x83, 0x06, 0x18,
  0x30, 0xC3, 0x0C, 0x31, 0x86, 0x31, 0xC4, 0x00, 0x30, 0x63, 0x57, 0xF3,
  0x8D, 0x92, 0x00, 0x30, 0x60, 0xC7, 0xFF, 0xE6, 0x0C, 0x18, 0x67, 0x73,
  0x6C, 0xFF, 0xC0, 0xDF, 0x00, 0x0E, 0x18, 0x30, 0xE1, 0x83, 0x0E, 0x18,
  0x30, 0x61, 0x83, 0x06, 0x18, 0x30, 0x00, 0x79, 0xFB, 0x3E, 0x3F, 0x76,
  0xF1, 0xE3, 0xCF, 0xF9, 0xE0, 0x18, 0xF3, 0xE6, 0xC1, 0x83, 0x06, 0x0C,
  0x19, 0xFF, 0xF8, 0x79, 0xFA, 0x30, 0x60, 0xC3, 0x0C, 0x30, 0xC1, 0xFF,
  0xF8, 0x79, 0xF8, 0x30, 0x63, 0xC7, 0x83, 0x03, 0x0F, 0xFB, 0xE0, 0x06,
  0x0E, 0x1E, 0x36, 0x66, 0x66, 0xFF, 0xFF, 0x06, 0x06, 0x06, 0x7C, 0xF9,
  0x82, 0x07, 0x9F, 0x83, 0x07, 0x0D, 0xFB, 0xE0, 0x1C, 0x79, 0xC7, 0x0F,
  0x9F, 0xB3, 0xE3, 0xCF, 0xF9, 0xE0, 0xFF, 0xFC, 0x30, 0xE1, 0x83, 0x0C,
  0x18, 0x30, 0xE1, 0x80, 0x79, 0xFB, 0x3E, 0x2E, 0xCF, 0x33, 0x63, 0xC7,
  0xF9, 0xE0, 0x79, 0xFB, 0x36, 0x3C, 0x7F, 0xDF, 0x86, 0x1D, 0xF3, 0x80,
  0xDF, 0x01, 0xBE, 0x67, 0x60, 0x06, 0x77, 0x36, 0xC0, 0x04, 0x1C, 0xFB,
  0xEF, 0x18, 0x3C, 0x3E, 0x3E, 0x1C, 0x10, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x81, 0xC3, 0xC3, 0xE1, 0xE1, 0xC7, 0xBE, 0xF1, 0xC2, 0x00, 0x7B,
  0xF0, 0xC3, 0x0C, 0x63, 0x0C, 0x00, 0xC3, 0x00, 0x1E, 0x22, 0x43, 0x4F,
  0xDF, 0xDB, 0xDB, 0xDB, 0xDF, 0x4F, 0x60, 0x3F, 0x1F, 0x1C, 0x1C, 0x3C,
  0x34, 0x36, 0x26, 0x7E, 0x7F, 0x63, 0x63, 0xC3, 0xF9, 0xFB, 0x36, 0x6F,
  0xDF, 0xB1, 0xE3, 0xC7, 0xFB, 0xE0, 0x1E, 0x3F, 0x71, 0x60, 0x60, 0xE0,
  0xE0, 0x60, 0x71, 0x3F, 0x1E, 0xF9, 0xFB, 0x3E, 0x3C, 0x78, 0xF1, 0xE3,
  0xCD, 0xFB, 0xE0, 0xFD, 0xFB, 0x06, 0x0F, 0xDF, 0xB0, 0x60, 0xC1, 0xFF,
  0xF8, 0xFF, 0xFF, 0x06, 0x0F, 0xDF, 0xB0, 0x60, 0xC1, 0x83, 0x00, 0x1F,
  0x3F, 0x71, 0x60, 0x60, 0xE3, 0xE3, 0x63, 0x63, 0x3F, 0x1F, 0xC7, 0x8F,
  0x1E, 0x3F, 0xFF, 0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0xFF, 0xFC, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x31, 0xFF, 0xF8, 0x7D, 0xF0, 0xC3, 0x0C, 0x30, 0xC3,
  0x8F, 0xF7, 0x80, 0xCF, 0x9B, 0x76, 0xCF, 0x1E, 0x3E, 0x6E, 0xCD, 0x9F,
  0x18, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xFF, 0xF8, 0x63,
  0x67, 0x77, 0x57, 0x5F, 0x5B, 0x5B, 0x43, 0xC3, 0xC3, 0xC3, 0xC7, 0x8F,
  0x9F, 0x3F, 0x7A, 0xF7, 0xE7, 0xCF, 0x9F, 0x18, 0x3C, 0x7E, 0x67, 0x63,
  0xE3, 0xE3, 0xE3, 0x63, 0x67, 0x7E, 0x3C, 0xF9, 0xFF, 0x1E, 0x3C, 0x7F,
  0xFE, 0x60, 0xC1, 0x83, 0x00, 0x3C, 0x7E, 0x67, 0x63, 0xE3, 0xE3, 0xE3,
  0x63, 0x67, 0x7E, 0x3C, 0x1C, 0x0F, 0x07, 0xF9, 0xFB, 0x36, 0x7C, 0xFF,
  0xBE, 0x6E, 0xCD, 0x9F, 0x18, 0x7D, 0xFB, 0x16, 0x0F, 0x0F, 0x87, 0x83,
  0x87, 0xFB, 0xE0, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0xF9, 0xE0,
  0xC3, 0x63, 0x63, 0x67, 0x66, 0x26, 0x36, 0x34, 0x3C, 0x1C, 0x18, 0xC3,
  0xC3, 0xC3, 0x43, 0x5B, 0x5B, 0x5F, 0x77, 0x77, 0x67, 0x63, 0x63, 0x66,
  0x36, 0x3C, 0x1C, 0x1C, 0x3C, 0x36, 0x76, 0x67, 0xE3, 0xE3, 0x63, 0x66,
  0x36, 0x36, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xF8, 0x30, 0xC1,
  0x86, 0x18, 0x30, 0xC1, 0xFF, 0xF8, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x7F, 0xE0, 0xC1, 0x81, 0x83, 0x06, 0x06, 0x0C, 0x18, 0x18,
  0x30, 0x60, 0xE0, 0xC1, 0x83, 0x80, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0xFF, 0xE0, 0x1C, 0x3C, 0x36, 0x76, 0x63, 0x43, 0xFF, 0xFF,
  0x9C, 0x80, 0x78, 0xF8, 0x33, 0xFF, 0xF9, 0xFF, 0xBF, 0xC1, 0x83, 0x06,
  0x0F, 0xDF, 0xB3, 0xE3, 0xC7, 0x9F, 0xF7, 0xC0, 0x3E, 0xFF, 0x86, 0x0C,
  0x1C, 0x1F, 0x9F, 0x06, 0x0C, 0x18, 0x33, 0xEF, 0xD9, 0xF3, 0xE6, 0xCD,
  0xF9, 0xF0, 0x79, 0xFB, 0x1F, 0xFF, 0xF8, 0x3F, 0x3E, 0x1E, 0x7D, 0xC3,
  0x0F, 0xFF, 0xD8, 0x30, 0x60, 0xC1, 0x83, 0x00, 0x7F, 0xFC, 0xF3, 0xCF,
  0x3F, 0xDF, 0x8F, 0xFF, 0x80, 0xC1, 0x83, 0x06, 0x0F, 0x9F, 0xB3, 0x66,
  0xCF, 0x9F, 0x3E, 0x70, 0x70, 0xE0, 0x07, 0x8F, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xF8, 0xF0, 0x18, 0x60, 0x3F, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x8F, 0xE7, 0x80, 0xC1, 0x83, 0x06, 0x0C, 0xFB, 0xB6, 0x78, 0xF9, 0xBB,
  0x36, 0x30, 0xF1, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xF8,
  0xF0, 0xFE, 0xFF, 0xDB, 0xDB, 0xDB, 0xC3, 0xC3, 0xC3, 0xF9, 0xFB, 0x36,
  0x6C, 0xF9, 0xF3, 0xE7, 0x3C, 0x7E, 0x67, 0x63, 0x63, 0x67, 0x7E, 0x3C,
  0xF9, 0xFB, 0x3E, 0x3C, 0x79, 0xFF, 0x7E, 0xC1, 0x83, 0x00, 0x7F, 0xFC,
  0xF3, 0xCF, 0x3F, 0xDF, 0x0C, 0x30, 0xC0, 0xFF, 0xFC, 0x30, 0xC3, 0x0C,
  0x30, 0x7D, 0xFB, 0x03, 0x83, 0xD1, 0xFF, 0x7C, 0x70, 0xE3, 0xFF, 0xF7,
  0x0E, 0x1C, 0x38, 0x3E, 0x7C, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xDF, 0xE3,
  0x63, 0x66, 0x66, 0x36, 0x3C, 0x1C, 0x18, 0xC1, 0xC3, 0xDB, 0x5B, 0x5F,
  0x57, 0x76, 0x66, 0x63, 0x76, 0x3C, 0x1C, 0x1C, 0x3E, 0x66, 0x63, 0x63,
  0x63, 0x66, 0x36, 0x36, 0x1C, 0x1C, 0x1C, 0x18, 0x78, 0xF0, 0xFF, 0xF1,
  0xCE, 0x31, 0x8F, 0xFF, 0x1C, 0xF3, 0x0C, 0x30, 0xCE, 0x38, 0x30, 0xC3,
  0x0C, 0x30, 0xF1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xF3, 0xC1, 0x86, 0x18,
  0x61, 0xC7, 0x18, 0x61, 0x86, 0x3B, 0xCF, 0x00, 0x71, 0x7F, 0xCE,
};

const GFXglyph UbuntuMono_Bold17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 11, 9, 3, -11 },
  { 6, 6, 5, 9, 1, -12 },
  { 10, 8, 11, 9, 0, -11 },
  { 21, 7, 14, 9, 1, -12 },
  { 34, 8, 11, 9, 0, -11 },
  { 45, 8, 11, 9, 0, -11 },
  { 56, 2, 5, 9, 3, -12 },
  { 58, 5, 15, 9, 2, -12 },
  { 68, 6, 15, 9, 1, -12 },
  { 80, 7, 7, 9, 1, -11 },
  { 87, 7, 8, 9, 1, -8 },
  { 94, 4, 6, 9, 2, -3 },
  { 97, 5, 2, 9, 2, -5 },
  { 99, 3, 3, 9, 3, -3 },
  { 101, 7, 15, 9, 1, -12 },
  { 115, 7, 11, 9, 1, -11 },
  { 125, 7, 11, 9, 1, -11 },
  { 135, 7, 11, 9, 1, -11 },
  { 145, 7, 11, 9, 1, -11 },
  { 155, 8, 11, 9, 0, -11 },
  { 166, 7, 11, 9, 1, -11 },
  { 176, 7, 11, 9, 1, -11 },
  { 186, 7, 11, 9, 1, -11 },
  { 196, 7, 11, 9, 1, -11 },
  { 206, 7, 11, 9, 1, -11 },
  { 216, 3, 8, 9, 3, -8 },
  { 219, 4, 11, 9, 2, -8 },
  { 225, 7, 11, 9, 1, -12 },
  { 235, 7, 6, 9, 1, -7 },
  { 241, 7, 11, 9, 1, -12 },
  { 251, 6, 11, 9, 1, -11 },
  { 260, 8, 13, 9, 0, -11 },
  { 273, 8, 11, 9, 0, -11 },
  { 284, 7, 11, 9, 1, -11 },
  { 294, 8, 11, 9, 0, -11 },
  { 305, 7, 11, 9, 1, -11 },
  { 315, 7, 11, 9, 1, -11 },
  { 325, 7, 11, 9, 1, -11 },
  { 335, 8, 11, 9, 0, -11 },
  { 346, 7, 11, 9, 1, -11 },
  { 356, 7, 11, 9, 1, -11 },
  { 366, 6, 11, 9, 1, -11 },
  { 375, 7, 11, 9, 1, -11 },
  { 385, 7, 11, 9, 1, -11 },
  { 395, 8, 11, 9, 0, -11 },
  { 406, 7, 11, 9, 1, -11 },
  { 416, 8, 11, 9, 0, -11 },
  { 427, 7, 11, 9, 1, -11 },
  { 437, 8, 14, 9, 0, -11 },
  { 451, 7, 11, 9, 1, -11 },
  { 461, 7, 11, 9, 1, -11 },
  { 471, 8, 11, 9, 0, -11 },
  { 482, 7, 11, 9, 1, -11 },
  { 492, 8, 11, 9, 0, -11 },
  { 503, 8, 11, 9, 0, -11 },
  { 514, 8, 11, 9, 0, -11 },
  { 525, 8, 11, 9, 0, -11 },
  { 536, 7, 11, 9, 1, -11 },
  { 546, 5, 15, 9, 2, -12 },
  { 556, 7, 15, 9, 1, -12 },
  { 570, 5, 15, 9, 2, -12 },
  { 580, 8, 6, 9, 0, -11 },
  { 586, 8, 2, 9, 0, 1 },
  { 588, 3, 3, 9, 3, -12 },
  { 590, 7, 8, 9, 1, -8 },
  { 597, 7, 12, 9, 1, -12 },
  { 608, 7, 8, 9, 1, -8 },
  { 615, 7, 12, 9, 0, -12 },
  { 626, 7, 8, 9, 1, -8 },
  { 633, 7, 12, 9, 1, -12 },
  { 644, 6, 11, 9, 1, -8 },
  { 653, 7, 12, 9, 1, -12 },
  { 664, 7, 12, 9, 1, -12 },
  { 675, 6, 15, 9, 1, -12 },
  { 687, 7, 12, 9, 1, -12 },
  { 698, 7, 12, 9, 1, -12 },
  { 709, 8, 8, 9, 0, -8 },
  { 717, 7, 8, 9, 1, -8 },
  { 724, 8, 8, 9, 0, -8 },
  { 732, 7, 11, 9, 1, -8 },
  { 742, 6, 11, 9, 1, -8 },
  { 751, 6, 8, 9, 2, -8 },
  { 757, 7, 8, 9, 1, -8 },
  { 764, 7, 10, 9, 1, -10 },
  { 773, 6, 8, 9, 1, -8 },
  { 779, 8, 8, 9, 0, -8 },
  { 787, 8, 8, 9, 0, -8 },
  { 795, 8, 8, 9, 0, -8 },
  { 803, 8, 11, 9, 0, -8 },
  { 814, 6, 8, 9, 1, -8 },
  { 820, 6, 15, 9, 1, -12 },
  { 832, 2, 15, 9, 3, -12 },
  { 836, 6, 15, 9, 1, -12 },
  { 848, 8, 3, 9, 0, -6 },
};

const GFXfont UbuntuMono_Bold17pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Bold17pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Bold17pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _UBUNTUMONO_BOLD17PT7B_H_
