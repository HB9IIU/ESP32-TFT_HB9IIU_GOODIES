#ifndef _NOTOSANS_CONDENSED_REGULAR46PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x00, 0x00, 0x4F, 0xFF, 0xFF, 0x78, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE,
  0x0F, 0xE0, 0xE6, 0x06, 0x00, 0xE0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x1C,
  0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00,
  0x70, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x0E, 0x07, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFC, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x01, 0xC0, 0xE0,
  0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x83, 0x83, 0x80, 0x0E, 0x0E,
  0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00,
  0x70, 0x38, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x07, 0xFC, 0x07, 0xFF,
  0xE3, 0xFF, 0xF9, 0xFB, 0x3C, 0x78, 0xC1, 0x3C, 0x30, 0x0F, 0x0C, 0x03,
  0xC3, 0x00, 0xF0, 0xC0, 0x3C, 0x30, 0x07, 0x8C, 0x01, 0xFB, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x33,
  0xE0, 0x0C, 0x78, 0x03, 0x0F, 0x00, 0xC3, 0xC0, 0x30, 0xF0, 0x0C, 0x3E,
  0x03, 0x1E, 0xE0, 0xCF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE1, 0xFF, 0xE0, 0x03,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1F, 0x00, 0x1E, 0x01, 0xFC, 0x00, 0xE0, 0x1F, 0xF0, 0x07, 0x00,
  0xE3, 0xC0, 0x70, 0x07, 0x0E, 0x03, 0x80, 0x70, 0x70, 0x3C, 0x03, 0x83,
  0x81, 0xC0, 0x1C, 0x1C, 0x0E, 0x00, 0xE0, 0xF0, 0xE0, 0x07, 0x07, 0x87,
  0x00, 0x38, 0x3C, 0x78, 0x01, 0xC1, 0xE3, 0x80, 0x0E, 0x0E, 0x3C, 0x00,
  0x70, 0x71, 0xC3, 0xE3, 0x83, 0x8E, 0x7F, 0x8E, 0x1C, 0xE3, 0xFC, 0x71,
  0xE7, 0x3C, 0x73, 0xFE, 0x79, 0xC3, 0x8F, 0xE3, 0x8E, 0x1C, 0x3E, 0x1C,
  0x70, 0xF0, 0x01, 0xC7, 0x83, 0x80, 0x0E, 0x3C, 0x1C, 0x00, 0xF1, 0xE0,
  0xE0, 0x07, 0x0F, 0x07, 0x00, 0x38, 0x78, 0x38, 0x03, 0x83, 0xC1, 0xC0,
  0x1C, 0x0E, 0x1E, 0x01, 0xE0, 0x70, 0xF0, 0x0E, 0x03, 0x87, 0x00, 0xF0,
  0x1C, 0x38, 0x07, 0x00, 0x7F, 0xC0, 0x38, 0x03, 0xFC, 0x03, 0x80, 0x0F,
  0xC0, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xF1, 0xF0,
  0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00,
  0x3C, 0x1E, 0x00, 0x38, 0x3C, 0x00, 0x78, 0x70, 0x00, 0xF1, 0xE0, 0x00,
  0xF7, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xE0, 0x78, 0xF3, 0xC0, 0xF3, 0xC3, 0xC1, 0xEF, 0x87,
  0xC7, 0x9E, 0x07, 0xCF, 0x3C, 0x07, 0x9E, 0x78, 0x07, 0xF8, 0xF0, 0x0F,
  0xF1, 0xE0, 0x0F, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x3F, 0x0F, 0x80, 0xFF,
  0x0F, 0x83, 0xFF, 0x1F, 0xFF, 0x9F, 0x1F, 0xFE, 0x1E, 0x1F, 0xF0, 0x3E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE6, 0x03, 0xC0, 0xE0, 0x78, 0x3C, 0x0F,
  0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x07,
  0x81, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xC0,
  0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E,
  0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x07, 0x83, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x06, 0x0E, 0x1B, 0xF7,
  0x7D, 0xFF, 0xFE, 0xFF, 0xFF, 0x81, 0xF0, 0x01, 0xF8, 0x01, 0xEE, 0x00,
  0xE7, 0x80, 0xF1, 0xE0, 0xF0, 0xF8, 0x38, 0x38, 0x08, 0x10, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0xF7, 0xDE, 0x79, 0xE7, 0x1C, 0xF3, 0x8E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x27, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x07, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0xF8, 0x3C, 0x0F,
  0x1F, 0x03, 0xC7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0xBC, 0x01, 0xEF,
  0x00, 0x7B, 0xC0, 0x0E, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7,
  0x80, 0x79, 0xE0, 0x3C, 0x3C, 0x0F, 0x0F, 0x87, 0x81, 0xFF, 0xE0, 0x3F,
  0xF0, 0x07, 0xF8, 0x00, 0x00, 0xE0, 0x3C, 0x1F, 0x87, 0xF1, 0xFE, 0x7D,
  0xDF, 0x3F, 0xC7, 0x71, 0xE4, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x0F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x9F, 0x87, 0xE7, 0x01,
  0xF1, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xF0, 0x1F, 0xFE, 0x3F, 0xFF, 0x9F, 0x07, 0xE6, 0x00, 0xF2,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F,
  0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF8, 0x00, 0xF7, 0x01, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0E, 0xF0, 0x01, 0xEF, 0x00, 0x1C,
  0xF0, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x07, 0x8F, 0x00, 0x70, 0xF0, 0x0F,
  0x0F, 0x00, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xC0, 0xF0, 0x38, 0x0F, 0x07,
  0x80, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3F,
  0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x30,
  0x3F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x80, 0x1F, 0x38, 0x0F, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0x04, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x70, 0x3C, 0xFF, 0x0F, 0x7F, 0xE3,
  0xFF, 0xFC, 0xFC, 0x0F, 0xBE, 0x01, 0xEF, 0x80, 0x7B, 0xC0, 0x0E, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x70, 0x03, 0xDE, 0x00,
  0xF7, 0x80, 0x79, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x87, 0xC1, 0xFF, 0xE0,
  0x3F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xFF,
  0x83, 0xFF, 0xF0, 0xF8, 0x7C, 0x78, 0x0F, 0x9E, 0x01, 0xE7, 0x80, 0x79,
  0xC0, 0x1E, 0x70, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x78, 0xF0, 0x3C, 0x3E,
  0x1E, 0x07, 0xCF, 0x80, 0xFF, 0xC0, 0x1F, 0xC0, 0x07, 0xF8, 0x07, 0xFF,
  0x03, 0xE3, 0xE1, 0xF0, 0x7C, 0x78, 0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF8,
  0x07, 0x9F, 0x03, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0xC7, 0xC7, 0x81, 0xF3, 0xC0, 0x7B,
  0xC0, 0x1D, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1E, 0xF0, 0x1F, 0x7C, 0x1F, 0x9F,
  0xBD, 0xCF, 0xFE, 0xE3, 0xFE, 0xF0, 0x7C, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC2, 0x07, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0x77, 0xFF,
  0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x4F, 0xFF,
  0xFF, 0xF8, 0x39, 0xF7, 0xDF, 0x7C, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xF7, 0xDE, 0x79, 0xE7, 0x3C, 0xF3,
  0x8E, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x0F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x0F, 0x80, 0x03, 0x80, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xC3, 0xFF, 0xCF,
  0xFF, 0xBC, 0x3E, 0x40, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xE0, 0x1E, 0x00, 0x7C, 0x00, 0x78,
  0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0xF1, 0xE0, 0x3F, 0x83, 0x8E, 0x07, 0xFE, 0x1C, 0xF0, 0x7F,
  0xF0, 0xF7, 0x07, 0x83, 0x83, 0xB8, 0x38, 0x3C, 0x1D, 0xC1, 0xC1, 0xE0,
  0xEE, 0x1E, 0x0F, 0x07, 0xF0, 0xE0, 0x78, 0x3F, 0x87, 0x03, 0xC1, 0xF8,
  0x38, 0x1E, 0x0F, 0xC1, 0xC0, 0xF0, 0x7E, 0x0E, 0x07, 0x83, 0xF8, 0x70,
  0x3C, 0x1F, 0xC3, 0xC1, 0xE1, 0xCE, 0x1E, 0x1F, 0x0E, 0x70, 0x78, 0xD8,
  0xF3, 0x83, 0xFE, 0xFF, 0x1C, 0x0F, 0xE3, 0xF0, 0xF0, 0x1C, 0x0E, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x04, 0x00, 0x3E, 0x00, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0E, 0xE0, 0x00,
  0x1D, 0xC0, 0x00, 0x3B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xE7, 0x00, 0x03,
  0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x70,
  0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x81, 0xE0, 0x1E, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x0F, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x78, 0x00, 0xF0,
  0xF0, 0x01, 0xE1, 0xE0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xFF, 0xE0, 0x3F, 0xFF,
  0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF0, 0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x7B,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0,
  0x0F, 0xBC, 0x07, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF,
  0xCF, 0x00, 0xFB, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xBC, 0x1F, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFE, 0x1E, 0x0F, 0x80, 0x21,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x0E, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xF0, 0x1F, 0x8F, 0x00,
  0x7C, 0xF0, 0x03, 0xCF, 0x00, 0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x01,
  0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x1F, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x3F, 0x83, 0xE0, 0xF8, 0x00, 0x83, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFB,
  0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBE,
  0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF8, 0x00, 0x78, 0xF8,
  0x00, 0xF0, 0xF8, 0x01, 0xE1, 0xFC, 0x07, 0xC1, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x00, 0xFF, 0xF8, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x87, 0xFB, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC1, 0xFF, 0xFB, 0xFE, 0xFF,
  0x1F, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0xFB, 0xC0, 0x1E, 0x78, 0x07, 0x8F,
  0x01, 0xF1, 0xE0, 0x3C, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x1E,
  0x1E, 0x03, 0xC3, 0xC0, 0x78, 0xF0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3D,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xF7, 0x80, 0x7C,
  0xF8, 0x0F, 0x0F, 0x01, 0xE1, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xE0, 0xF0,
  0x3C, 0x1E, 0x03, 0xC3, 0xC0, 0x7C, 0x78, 0x07, 0x8F, 0x00, 0xF9, 0xE0,
  0x0F, 0x3C, 0x01, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xEE, 0x00, 0x0F, 0xFE, 0xF0, 0x00, 0xEF, 0xEF,
  0x00, 0x0E, 0xFE, 0x70, 0x01, 0xEF, 0xE7, 0x80, 0x1E, 0xFE, 0x78, 0x01,
  0xCF, 0xE3, 0x80, 0x3C, 0xFE, 0x3C, 0x03, 0xCF, 0xE3, 0xC0, 0x38, 0xFE,
  0x1C, 0x07, 0x8F, 0xE1, 0xC0, 0x78, 0xFE, 0x1E, 0x07, 0x0F, 0xE1, 0xE0,
  0x70, 0xFE, 0x0E, 0x0F, 0x0F, 0xE0, 0xF0, 0xE0, 0xFE, 0x0F, 0x0E, 0x0F,
  0xE0, 0x71, 0xE0, 0xFE, 0x07, 0x9C, 0x0F, 0xE0, 0x79, 0xC0, 0xFE, 0x03,
  0xBC, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80,
  0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0xFE, 0x00, 0xF0, 0x0F, 0xE0,
  0x0F, 0x00, 0xF0, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFD, 0xE0, 0x0F,
  0xEF, 0x80, 0x7F, 0x3C, 0x03, 0xF9, 0xF0, 0x1F, 0xC7, 0x80, 0xFE, 0x3E,
  0x07, 0xF0, 0xF0, 0x3F, 0x87, 0xC1, 0xFC, 0x1E, 0x0F, 0xE0, 0xF0, 0x7F,
  0x03, 0xC3, 0xF8, 0x1E, 0x1F, 0xC0, 0x78, 0xFE, 0x03, 0xC7, 0xF0, 0x0F,
  0x3F, 0x80, 0x79, 0xFC, 0x01, 0xE7, 0xE0, 0x0F, 0x3F, 0x00, 0x3D, 0xF8,
  0x01, 0xEF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x0F, 0xE3, 0xF8, 0x1F, 0x00, 0xF8, 0x1E, 0x00, 0x7C,
  0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x3E,
  0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x0F, 0xC1, 0xF8,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x03, 0xF7, 0x80, 0x7B, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x3D, 0xE0, 0x3E, 0xF0, 0xFE, 0x7F, 0xFE, 0x3F,
  0xFE, 0x1F, 0xFC, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xE3, 0xF8, 0x1F, 0x00, 0xF8, 0x1E,
  0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x3C,
  0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x0F,
  0xC1, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0xFF,
  0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0x03, 0xF1, 0xE0,
  0x1E, 0x3C, 0x03, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0,
  0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF9, 0xE0, 0x1E, 0x3C, 0x07, 0xC7, 0x81,
  0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x78, 0x78, 0x0F, 0x0F,
  0x81, 0xE0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0xF0, 0x3E, 0x1E, 0x03,
  0xC3, 0xC0, 0x7C, 0x78, 0x07, 0x8F, 0x00, 0xF9, 0xE0, 0x0F, 0x3C, 0x01,
  0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0xCF, 0xFF,
  0xCF, 0xE3, 0xE7, 0xC0, 0x23, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE8, 0x01, 0xF7, 0xC1, 0xFB, 0xFF, 0xF9,
  0xFF, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0x70, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0xC0, 0x1F, 0x3C, 0x01,
  0xE3, 0xF0, 0x7E, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xE7, 0x80,
  0x07, 0x8F, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x3C, 0x00,
  0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x0F, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0,
  0x0F, 0x07, 0x80, 0x1E, 0x0E, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x78, 0x00,
  0x78, 0xF0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xCF, 0x00, 0x03,
  0xDC, 0x00, 0x07, 0xB8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x00, 0x1E, 0x78, 0x01, 0xF0, 0x01, 0xE7,
  0x80, 0x1F, 0x80, 0x1E, 0x78, 0x01, 0xF8, 0x01, 0xE7, 0x80, 0x1F, 0x80,
  0x1E, 0x3C, 0x01, 0xF8, 0x03, 0xC3, 0xC0, 0x3F, 0xC0, 0x3C, 0x3C, 0x03,
  0xFC, 0x03, 0xC3, 0xC0, 0x39, 0xC0, 0x3C, 0x1E, 0x03, 0x9C, 0x07, 0x81,
  0xE0, 0x79, 0xC0, 0x78, 0x1E, 0x07, 0x9E, 0x07, 0x81, 0xE0, 0x71, 0xE0,
  0x78, 0x0E, 0x07, 0x0E, 0x07, 0x80, 0xF0, 0x70, 0xE0, 0xF0, 0x0F, 0x0F,
  0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0xF0, 0xF0, 0x0F, 0x0E, 0x07, 0x0F, 0x00,
  0x70, 0xE0, 0x71, 0xE0, 0x07, 0x9E, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x79,
  0xE0, 0x07, 0x9C, 0x03, 0x9E, 0x00, 0x39, 0xC0, 0x39, 0xE0, 0x03, 0x9C,
  0x03, 0xBC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x78, 0x3C,
  0x03, 0xC1, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x1E, 0x00, 0xE0, 0xF0,
  0x07, 0x8F, 0x00, 0x3C, 0x78, 0x00, 0xF3, 0x80, 0x07, 0xBC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3D, 0xE0, 0x01, 0xEF,
  0x00, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x07,
  0x80, 0xF0, 0x3C, 0x07, 0x83, 0xC0, 0x3E, 0x1E, 0x00, 0xF1, 0xF0, 0x07,
  0xCF, 0x00, 0x1E, 0xF8, 0x00, 0xF8, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x78,
  0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x3C, 0x1E, 0x03, 0xC1,
  0xE0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0x78, 0xF0,
  0x07, 0x8E, 0x00, 0x79, 0xE0, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0x9C, 0x00, 0x79, 0xE0, 0x07, 0x0E,
  0x00, 0xF0, 0xF0, 0x0E, 0x07, 0x01, 0xE0, 0x78, 0x1C, 0x03, 0x83, 0xC0,
  0x3C, 0x38, 0x01, 0xC7, 0x80, 0x1E, 0x78, 0x00, 0xE7, 0x00, 0x0F, 0xF0,
  0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3C,
  0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xF0, 0x3F, 0xFC, 0x3F, 0xFE,
  0x1C, 0x3E, 0x10, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x01, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7E, 0x0F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x3F, 0x7F, 0xF7, 0x7F, 0xE7, 0x1F, 0xC7, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x1F, 0x83, 0xCF, 0xF8, 0xF7,
  0xFF, 0x3F, 0x87, 0xCF, 0xC0, 0xFB, 0xE0, 0x1E, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x01, 0xEF, 0xC0, 0x7B, 0xF8, 0x3E, 0xF7, 0xFF, 0x3D, 0xFF,
  0x8E, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xFC, 0x7F, 0xF1, 0xF8, 0xE3, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x87, 0xFF, 0x07, 0xFE,
  0x07, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x7E, 0x3C, 0x3F, 0xEF, 0x1F, 0xFF, 0xCF, 0x87, 0xF7, 0xC0, 0xFD,
  0xE0, 0x1F, 0x78, 0x07, 0xDE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x78, 0x03, 0xDE, 0x01, 0xF7, 0xC0, 0x7C,
  0xF8, 0x3F, 0x3F, 0xFD, 0xC7, 0xFE, 0x70, 0xFF, 0x1C, 0x03, 0xF0, 0x07,
  0xFE, 0x07, 0xFF, 0x87, 0xC3, 0xC3, 0xC0, 0xF3, 0xC0, 0x39, 0xE0, 0x1E,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x09, 0xF0, 0x18, 0x7F, 0xFC, 0x1F, 0xFE,
  0x07, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xE1, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xFF, 0x3F, 0xFC,
  0xFF, 0xF0, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0xE1, 0xC3, 0xFE, 0x71, 0xFF, 0xDC,
  0xF8, 0x77, 0x3C, 0x0F, 0xDE, 0x01, 0xF7, 0x80, 0x7D, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x3D,
  0xE0, 0x1F, 0x7C, 0x07, 0xCF, 0x83, 0xF3, 0xFF, 0xFC, 0x7F, 0xEF, 0x07,
  0xF3, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x80, 0x3E, 0x3C, 0x3F, 0x0F, 0xFF, 0xC3, 0xFF, 0xC0,
  0x3F, 0xC0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x7E, 0x1E, 0x7F, 0xCF, 0x7F, 0xF7, 0xF8, 0xFB, 0xF0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xE0, 0x7F, 0xFF, 0x70, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x0F,
  0x0F, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x9F, 0xFE, 0xFC, 0xF8, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x03, 0xDE, 0x03, 0xEF, 0x01, 0xE7, 0x81,
  0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0xF0, 0x78, 0xF0, 0x3C, 0x70, 0x1E,
  0x78, 0x0F, 0x78, 0x07, 0xBE, 0x03, 0xFF, 0x81, 0xFB, 0xC0, 0xF9, 0xF0,
  0x78, 0x78, 0x3C, 0x3E, 0x1E, 0x0F, 0x0F, 0x07, 0xC7, 0x81, 0xE3, 0xC0,
  0xF9, 0xE0, 0x3C, 0xF0, 0x1F, 0x78, 0x07, 0xBC, 0x03, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xF8, 0x1F, 0x87, 0x9F, 0xE1, 0xFF, 0x3D,
  0xFF, 0x9F, 0xF9, 0xFC, 0x7F, 0xE3, 0xEF, 0xC0, 0xFC, 0x0F, 0x7C, 0x07,
  0xC0, 0x7B, 0xE0, 0x3E, 0x01, 0xFE, 0x00, 0xF0, 0x0F, 0xF0, 0x07, 0x80,
  0x7F, 0x80, 0x38, 0x03, 0xFC, 0x01, 0xC0, 0x1F, 0xE0, 0x0E, 0x00, 0xFF,
  0x00, 0x70, 0x07, 0xF8, 0x03, 0x80, 0x3F, 0xC0, 0x1C, 0x01, 0xFE, 0x00,
  0xE0, 0x0F, 0xF0, 0x07, 0x00, 0x7F, 0x80, 0x38, 0x03, 0xFC, 0x01, 0xC0,
  0x1F, 0xE0, 0x0E, 0x00, 0xFF, 0x00, 0x70, 0x07, 0xF8, 0x03, 0x80, 0x3F,
  0xC0, 0x1C, 0x01, 0xFE, 0x00, 0xE0, 0x0F, 0xF0, 0x07, 0x00, 0x78, 0xE1,
  0xF8, 0x79, 0xFF, 0x3D, 0xFF, 0xDF, 0xE3, 0xEF, 0xC0, 0xFF, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0x8F, 0x83, 0xC0, 0x78, 0xF0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x1E,
  0xF0, 0x03, 0xDE, 0x00, 0x3B, 0xC0, 0x07, 0x78, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x77, 0x80, 0x0E, 0xF0, 0x03, 0xCF, 0x00, 0x79,
  0xE0, 0x0F, 0x3C, 0x03, 0xC3, 0xC0, 0x78, 0x7C, 0x1E, 0x07, 0xFF, 0xC0,
  0x7F, 0xF0, 0x07, 0xF8, 0x00, 0xE1, 0xF8, 0x3C, 0xFF, 0x8F, 0x7F, 0xF3,
  0xF8, 0x7C, 0xFC, 0x0F, 0xBE, 0x01, 0xEF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x1E, 0xFC, 0x07, 0xBF, 0x83, 0xEF, 0x7F, 0xF3, 0xDF, 0xF8, 0xF1,
  0xFC, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xE1, 0xC3, 0xFE, 0x71, 0xFF, 0xDC, 0xF8, 0x77, 0x3C,
  0x0F, 0xDE, 0x01, 0xF7, 0x80, 0x7D, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x1F, 0x7C,
  0x07, 0xCF, 0x83, 0xF3, 0xFF, 0xFC, 0x7F, 0xEF, 0x0F, 0xF3, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xE1,
  0xFE, 0x3F, 0xF7, 0xFF, 0x7F, 0xFE, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x00, 0x0F, 0xE0, 0xFF, 0xF7, 0xFF, 0xBE, 0x0E, 0xF0, 0x0B, 0xC0, 0x0E,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x3F, 0x01, 0xEF, 0xFF, 0xBF, 0xFC, 0x7F, 0xE0, 0x0C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xFE, 0xFF, 0xEF, 0xFE, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x1E, 0x01, 0xFF, 0x0F, 0xF0, 0x7F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01,
  0xF7, 0x80, 0xFB, 0xE1, 0xFD, 0xFF, 0xFE, 0x7F, 0xE7, 0x1F, 0xE3, 0x80,
  0xF0, 0x01, 0xFE, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C,
  0x70, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x1C, 0x07, 0x03, 0xC1, 0xE0,
  0x78, 0x3C, 0x0F, 0x07, 0x80, 0xE0, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80,
  0x38, 0xE0, 0x07, 0x3C, 0x00, 0xF7, 0x80, 0x1E, 0xE0, 0x01, 0xDC, 0x00,
  0x3B, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0xF0, 0x07, 0x80, 0x3D, 0xE0, 0x1F, 0x00, 0xF7, 0x80, 0x7C, 0x03, 0x9E,
  0x03, 0xF0, 0x1E, 0x78, 0x0F, 0xC0, 0x78, 0xE0, 0x3F, 0x81, 0xE3, 0xC0,
  0xEE, 0x07, 0x0F, 0x07, 0xB8, 0x3C, 0x3C, 0x1C, 0xE0, 0xF0, 0x70, 0x73,
  0x83, 0xC1, 0xE1, 0xCF, 0x0E, 0x07, 0x8F, 0x1C, 0x38, 0x1E, 0x38, 0x71,
  0xE0, 0x78, 0xE1, 0xC7, 0x80, 0xE3, 0x87, 0x9E, 0x03, 0xDE, 0x1E, 0x70,
  0x0F, 0x78, 0x39, 0xC0, 0x3D, 0xC0, 0xEF, 0x00, 0x77, 0x03, 0xBC, 0x01,
  0xDC, 0x0F, 0xE0, 0x07, 0x70, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x9E, 0x01, 0xE7, 0x80, 0xF0, 0xF0, 0x3C, 0x3C, 0x1E, 0x07, 0x87, 0x81,
  0xE3, 0xC0, 0x3C, 0xF0, 0x0F, 0x78, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0x78,
  0x03, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0xC7,
  0x80, 0xF3, 0xE0, 0x1E, 0xF0, 0x07, 0xC0, 0xF0, 0x01, 0xEE, 0x00, 0x39,
  0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0x78, 0x0F, 0x0F, 0x01, 0xE1,
  0xE0, 0x3C, 0x1C, 0x07, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x07, 0x07, 0x80,
  0xF0, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x38, 0xE0, 0x07, 0xBC, 0x00,
  0xF7, 0x80, 0x0E, 0xF0, 0x01, 0xDC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x9F,
  0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFD, 0xFF,
  0xF7, 0xFF, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0,
  0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x1F, 0x81,
  0xF8, 0x0F, 0x80, 0x7F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0x81, 0xFC, 0x1F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x01, 0xF0, 0x7F, 0x03, 0xF0, 0x1E, 0x00, 0x3F, 0x00, 0x7F,
  0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0xA0, 0x07, 0x80,
};

const GFXglyph NotoSans_Condensed_Regular46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 33, 11, 3, -33 },
  { 22, 12, 12, 18, 3, -33 },
  { 40, 22, 33, 24, 1, -33 },
  { 131, 18, 38, 22, 2, -35 },
  { 217, 29, 33, 33, 2, -33 },
  { 337, 23, 33, 25, 2, -33 },
  { 432, 4, 12, 10, 3, -33 },
  { 438, 10, 40, 14, 2, -33 },
  { 488, 10, 40, 14, 1, -33 },
  { 538, 17, 17, 20, 2, -35 },
  { 575, 18, 22, 22, 2, -27 },
  { 625, 6, 11, 11, 2, -5 },
  { 634, 11, 3, 13, 1, -14 },
  { 639, 5, 6, 11, 3, -6 },
  { 643, 16, 33, 17, 1, -33 },
  { 709, 18, 33, 22, 2, -33 },
  { 784, 11, 33, 22, 3, -33 },
  { 830, 17, 33, 22, 2, -33 },
  { 901, 17, 33, 22, 2, -33 },
  { 972, 20, 33, 22, 1, -33 },
  { 1055, 18, 33, 22, 2, -33 },
  { 1130, 18, 33, 22, 2, -33 },
  { 1205, 18, 33, 22, 2, -33 },
  { 1280, 18, 33, 22, 2, -33 },
  { 1355, 17, 33, 22, 2, -33 },
  { 1426, 5, 25, 11, 3, -25 },
  { 1442, 6, 31, 11, 2, -25 },
  { 1466, 18, 21, 22, 2, -27 },
  { 1514, 18, 13, 22, 2, -23 },
  { 1544, 18, 21, 22, 2, -27 },
  { 1592, 14, 33, 16, 1, -33 },
  { 1650, 29, 37, 33, 2, -33 },
  { 1785, 23, 33, 23, 0, -33 },
  { 1880, 18, 33, 24, 4, -33 },
  { 1955, 20, 33, 23, 2, -33 },
  { 2038, 20, 33, 27, 4, -33 },
  { 2121, 14, 33, 21, 4, -33 },
  { 2179, 14, 33, 19, 4, -33 },
  { 2237, 23, 33, 28, 2, -33 },
  { 2332, 20, 33, 27, 4, -33 },
  { 2415, 10, 33, 14, 2, -33 },
  { 2457, 10, 42, 11, -3, -33 },
  { 2510, 19, 33, 23, 4, -33 },
  { 2589, 14, 33, 19, 4, -33 },
  { 2647, 28, 33, 36, 4, -33 },
  { 2763, 21, 33, 29, 4, -33 },
  { 2850, 24, 33, 28, 2, -33 },
  { 2949, 17, 33, 23, 4, -33 },
  { 3020, 24, 41, 28, 2, -33 },
  { 3143, 19, 33, 23, 4, -33 },
  { 3222, 17, 33, 21, 2, -33 },
  { 3293, 19, 33, 20, 0, -33 },
  { 3372, 20, 33, 27, 3, -33 },
  { 3455, 23, 33, 23, 0, -33 },
  { 3550, 36, 33, 36, 0, -33 },
  { 3699, 21, 33, 21, 0, -33 },
  { 3786, 20, 33, 20, 0, -33 },
  { 3869, 17, 33, 20, 1, -33 },
  { 3940, 10, 40, 15, 3, -33 },
  { 3990, 16, 33, 17, 1, -33 },
  { 4056, 10, 40, 15, 1, -33 },
  { 4106, 20, 19, 22, 1, -33 },
  { 4154, 20, 3, 20, 0, 4 },
  { 4162, 9, 7, 12, 2, -35 },
  { 4170, 16, 25, 21, 2, -25 },
  { 4220, 18, 35, 23, 3, -35 },
  { 4299, 15, 25, 18, 2, -25 },
  { 4346, 18, 35, 23, 2, -35 },
  { 4425, 17, 25, 21, 2, -25 },
  { 4479, 14, 35, 13, 0, -35 },
  { 4541, 18, 36, 23, 2, -25 },
  { 4622, 17, 35, 23, 3, -35 },
  { 4697, 4, 34, 10, 3, -34 },
  { 4714, 8, 45, 10, -1, -34 },
  { 4759, 17, 35, 20, 3, -35 },
  { 4834, 4, 35, 10, 3, -35 },
  { 4852, 29, 25, 35, 3, -25 },
  { 4943, 17, 25, 23, 3, -25 },
  { 4997, 19, 25, 23, 2, -25 },
  { 5057, 18, 36, 23, 3, -25 },
  { 5138, 18, 36, 23, 2, -25 },
  { 5219, 12, 25, 16, 3, -25 },
  { 5257, 14, 25, 18, 2, -25 },
  { 5301, 12, 30, 13, 1, -30 },
  { 5346, 17, 25, 23, 3, -25 },
  { 5400, 19, 25, 19, 0, -25 },
  { 5460, 30, 25, 30, 0, -25 },
  { 5554, 18, 25, 19, 1, -25 },
  { 5611, 19, 36, 19, 0, -25 },
  { 5697, 14, 25, 16, 1, -25 },
  { 5741, 13, 40, 17, 2, -33 },
  { 5806, 3, 46, 21, 9, -35 },
  { 5824, 13, 40, 17, 2, -33 },
  { 5889, 18, 6, 22, 2, -19 },
};

const GFXfont NotoSans_Condensed_Regular46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular46pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_CONDENSED_REGULAR46PT7B_H_
