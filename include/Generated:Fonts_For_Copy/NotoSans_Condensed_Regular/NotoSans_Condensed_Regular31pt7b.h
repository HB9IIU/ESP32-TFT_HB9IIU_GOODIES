#ifndef _NOTOSANS_CONDENSED_REGULAR31PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular31pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x4E, 0xFE,
  0xE7, 0xE7, 0xE7, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0x06, 0x30, 0x18, 0xC0,
  0xC3, 0x03, 0x0C, 0x0C, 0x30, 0x30, 0xCF, 0xFF, 0xFF, 0xFF, 0x0C, 0x60,
  0x61, 0x81, 0x86, 0x06, 0x18, 0x18, 0xE3, 0xFF, 0xFF, 0xFF, 0xC6, 0x30,
  0x30, 0xC0, 0xC3, 0x03, 0x0C, 0x0C, 0x70, 0x31, 0x80, 0xC6, 0x00, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xFC, 0x3F, 0xF7, 0xEE, 0x66, 0x0E, 0x60, 0xE6,
  0x06, 0x60, 0x76, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x06, 0xE0, 0x67, 0x06,
  0x30, 0x63, 0x06, 0x3C, 0x67, 0xFF, 0xE7, 0xFC, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x3C, 0x07, 0x07, 0xE0, 0x60, 0x67, 0x0E, 0x06, 0x30, 0xC0,
  0xE3, 0x0C, 0x0C, 0x31, 0x80, 0xC3, 0x18, 0x0C, 0x33, 0x80, 0xE3, 0x31,
  0x06, 0x33, 0x7C, 0x67, 0x66, 0xE7, 0xE6, 0xE6, 0x3E, 0xCC, 0x70, 0x0C,
  0xC3, 0x01, 0xCC, 0x30, 0x18, 0xC3, 0x01, 0x8C, 0x30, 0x30, 0xC3, 0x03,
  0x0C, 0x70, 0x70, 0x66, 0x06, 0x07, 0xE0, 0xE0, 0x3C, 0x1F, 0x80, 0x1F,
  0xC0, 0x38, 0xC0, 0x30, 0xC0, 0x30, 0xE0, 0x38, 0xC0, 0x38, 0xC0, 0x19,
  0xC0, 0x1F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0x06, 0x73, 0x8E, 0x61,
  0xCE, 0xE1, 0xCC, 0xE0, 0xFC, 0xE0, 0x7C, 0xE0, 0x38, 0xE0, 0x78, 0x70,
  0xFC, 0x7F, 0xCE, 0x3F, 0x87, 0xFF, 0xFD, 0xB6, 0x0E, 0x18, 0x70, 0xC3,
  0x86, 0x1C, 0x38, 0x70, 0xC1, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0xC1,
  0xC3, 0x87, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x18, 0xE0, 0xC0, 0xC1, 0xC3,
  0x83, 0x07, 0x0E, 0x0C, 0x18, 0x30, 0x70, 0xE1, 0xC3, 0x87, 0x0C, 0x18,
  0x70, 0xE1, 0xC3, 0x0E, 0x18, 0x70, 0xC3, 0x80, 0x0E, 0x00, 0x60, 0x06,
  0x00, 0x60, 0xE6, 0xEF, 0xFE, 0x1F, 0x90, 0xF0, 0x1B, 0x83, 0x98, 0x31,
  0xC1, 0x08, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF,
  0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x3B,
  0x9C, 0xE6, 0x31, 0x98, 0xFF, 0xFF, 0xF8, 0x5F, 0xF0, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x18,
  0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x38,
  0x07, 0x01, 0xC0, 0x00, 0x1F, 0x83, 0xFC, 0x38, 0xE7, 0x06, 0x70, 0x76,
  0x07, 0x60, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x76, 0x07, 0x60, 0x77, 0x07, 0x70, 0xE3, 0x8E, 0x3F, 0xC1,
  0xF8, 0x07, 0x0F, 0x1F, 0x7F, 0xF7, 0x67, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x3F,
  0x8F, 0xFC, 0x60, 0xE4, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0x3F, 0x8F, 0xFC, 0x60,
  0xE4, 0x06, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC1, 0xF8, 0x1F,
  0x01, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x7C, 0x0E, 0xFF, 0xC7, 0xF8, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x6E, 0x03, 0x70, 0x33, 0x81, 0x9C, 0x18, 0xE1, 0xC7, 0x0C, 0x38, 0xE1,
  0xC6, 0x0E, 0x70, 0x73, 0x03, 0x9F, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xCF, 0xFB, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xCC, 0x1F, 0xF3, 0xFF, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x41, 0xEF, 0xF9, 0xFE, 0x00,
  0x07, 0xE1, 0xFE, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x67, 0x86, 0xFE, 0xF8, 0xEF, 0x07, 0xE0, 0x7E, 0x03, 0x60, 0x36, 0x03,
  0x60, 0x37, 0x07, 0x70, 0x73, 0x8E, 0x1F, 0xE0, 0xFC, 0xFF, 0xFF, 0xFF,
  0x00, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x1F, 0xC3, 0xFE, 0x70, 0xE7, 0x07,
  0x60, 0x76, 0x07, 0x70, 0x77, 0x0E, 0x39, 0xE1, 0xFC, 0x0F, 0x01, 0xFC,
  0x39, 0xE7, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x77, 0x0F,
  0x3F, 0xE1, 0xFC, 0x1F, 0x83, 0xFC, 0x70, 0xE7, 0x06, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x76, 0x07, 0x70, 0xF7, 0xDB, 0x3F, 0xF0, 0xE7,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x3C, 0x7F, 0x87, 0xF0,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xBF, 0xE0, 0x37, 0x77, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x77, 0x76, 0x6E, 0xC0, 0x00, 0x18, 0x03, 0xC0, 0x7C, 0x0F,
  0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x0C, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0,
  0x0E, 0x00, 0x40, 0x00, 0x7F, 0x3F, 0xE4, 0x1C, 0x07, 0x00, 0xC0, 0x30,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x60,
  0x00, 0x00, 0x00, 0x80, 0x70, 0x1C, 0x07, 0x00, 0x03, 0xFC, 0x01, 0xFF,
  0xC0, 0x70, 0x1C, 0x1C, 0x01, 0xC3, 0x00, 0x1C, 0xC0, 0x01, 0x98, 0x7E,
  0x37, 0x1F, 0xC7, 0xC3, 0x18, 0x78, 0xC3, 0x0F, 0x18, 0x61, 0xE3, 0x0C,
  0x3C, 0x61, 0x87, 0x8C, 0x30, 0xF1, 0x86, 0x3E, 0x31, 0xC6, 0xC7, 0x6D,
  0xD8, 0x7D, 0xF3, 0x82, 0x08, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x87, 0x00, 0x7F, 0xE0, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x06, 0xE0, 0x06, 0xE0, 0x0E, 0x60, 0x0E, 0x70,
  0x0C, 0x70, 0x0C, 0x30, 0x1C, 0x30, 0x1C, 0x38, 0x18, 0x38, 0x3F, 0xF8,
  0x3F, 0xFC, 0x38, 0x1C, 0x30, 0x1C, 0x70, 0x0C, 0x70, 0x0E, 0x70, 0x0E,
  0xE0, 0x0E, 0xE0, 0x07, 0xFF, 0xC7, 0xFF, 0x38, 0x3D, 0xC0, 0xEE, 0x03,
  0x70, 0x1F, 0x80, 0xDC, 0x0E, 0xE0, 0x77, 0xFF, 0x3F, 0xE1, 0xFF, 0xCE,
  0x07, 0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC1,
  0xEF, 0xFE, 0x7F, 0xE0, 0x0F, 0xF8, 0xFF, 0x8F, 0x04, 0xF0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x21, 0xFF, 0x07, 0xF8, 0xFF, 0x83, 0xFF, 0x8E, 0x1F, 0x38, 0x1E, 0xE0,
  0x3B, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1B, 0x80, 0xEE,
  0x07, 0x38, 0x7C, 0xFF, 0xE3, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x00, 0x07, 0xFC, 0x3F, 0xF8, 0xF0, 0x33, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0E, 0xE0,
  0x1D, 0xE0, 0x39, 0xE0, 0x71, 0xFF, 0xE1, 0xFF, 0x80, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x70,
  0xFE, 0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xCF, 0xFF, 0xC0, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0x7B, 0xF7, 0x80, 0xE0, 0x3B, 0x81,
  0xCE, 0x07, 0x38, 0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x38, 0x39, 0xC0, 0xE7,
  0x03, 0xB8, 0x0F, 0xE0, 0x3F, 0xC0, 0xF7, 0x03, 0x8E, 0x0E, 0x38, 0x38,
  0x70, 0xE0, 0xE3, 0x83, 0x8E, 0x07, 0x38, 0x1C, 0xE0, 0x3B, 0x80, 0xF0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xFC, 0x03, 0xFE, 0xC0, 0x37, 0xEC, 0x03, 0x7E, 0xE0, 0x77,
  0xE6, 0x06, 0x7E, 0x60, 0x67, 0xE7, 0x0E, 0x7E, 0x30, 0xC7, 0xE3, 0x0C,
  0x7E, 0x39, 0xC7, 0xE3, 0x98, 0x7E, 0x19, 0x87, 0xE1, 0xD8, 0x7E, 0x1F,
  0x87, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x06, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFD, 0x81, 0xFB, 0x83,
  0xF3, 0x07, 0xE7, 0x0F, 0xC6, 0x1F, 0x8E, 0x3F, 0x0C, 0x7E, 0x1C, 0xFC,
  0x19, 0xF8, 0x3B, 0xF0, 0x37, 0xE0, 0x77, 0xC0, 0x6F, 0x80, 0xFF, 0x00,
  0xFE, 0x01, 0xFC, 0x01, 0xC0, 0x0F, 0xE0, 0x3F, 0xF8, 0x38, 0x38, 0x70,
  0x1C, 0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x06, 0xE0, 0x06, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0x70, 0x0C, 0x70, 0x1C, 0x3C, 0x38, 0x1F, 0xF0, 0x0F,
  0xE0, 0xFF, 0x8F, 0xFC, 0xE1, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE1, 0xEF, 0xFC, 0xFF, 0x8E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0xE0,
  0x3F, 0xF8, 0x38, 0x3C, 0x70, 0x1C, 0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x06, 0xE0, 0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x06, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0x70, 0x0C, 0x70, 0x1C,
  0x3C, 0x38, 0x1F, 0xF8, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0xFF, 0x87, 0xFE, 0x38, 0x79, 0xC0, 0xEE, 0x07,
  0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x07, 0x39, 0xF9, 0xFF, 0x0F,
  0xF8, 0x71, 0xC3, 0x87, 0x1C, 0x38, 0xE0, 0xE7, 0x07, 0x38, 0x1D, 0xC0,
  0xEE, 0x03, 0xF0, 0x1C, 0x1F, 0xF3, 0xFE, 0x78, 0x67, 0x00, 0x60, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xEE, 0x1E, 0xFF, 0xC7,
  0xF8, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1D, 0x80, 0x77, 0x03, 0x9E, 0x1E,
  0x3F, 0xF0, 0x7F, 0x80, 0xE0, 0x0F, 0xC0, 0x1D, 0x80, 0x33, 0x80, 0xE7,
  0x01, 0xC6, 0x03, 0x8E, 0x06, 0x1C, 0x1C, 0x38, 0x38, 0x30, 0x70, 0x70,
  0xC0, 0xE3, 0x81, 0xC7, 0x01, 0x8C, 0x03, 0x98, 0x07, 0x70, 0x06, 0xE0,
  0x0D, 0x80, 0x1B, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x1C,
  0x07, 0x60, 0x3C, 0x07, 0x60, 0x3C, 0x06, 0x70, 0x3C, 0x06, 0x70, 0x3C,
  0x0E, 0x70, 0x3E, 0x0E, 0x30, 0x76, 0x0E, 0x38, 0x66, 0x0C, 0x38, 0x66,
  0x1C, 0x38, 0x67, 0x1C, 0x18, 0xE7, 0x1C, 0x18, 0xE3, 0x18, 0x1C, 0xC3,
  0x18, 0x1C, 0xC3, 0xB8, 0x1D, 0xC3, 0xB8, 0x0D, 0xC1, 0xB8, 0x0D, 0x81,
  0xB0, 0x0F, 0x81, 0xB0, 0x0F, 0x81, 0xB0, 0x07, 0x80, 0xF0, 0x07, 0x80,
  0xE0, 0x07, 0x00, 0xE0, 0x70, 0x1D, 0xC0, 0xE3, 0x83, 0x0E, 0x1C, 0x1C,
  0x70, 0x73, 0x80, 0xCE, 0x03, 0xB0, 0x07, 0xC0, 0x1E, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0xC0, 0x3F, 0x00, 0xCE, 0x07, 0x38, 0x18, 0x60, 0xE1, 0xC3,
  0x83, 0x1C, 0x0E, 0x70, 0x3B, 0x80, 0x70, 0xE0, 0x1D, 0x80, 0xE7, 0x03,
  0x9C, 0x0C, 0x38, 0x70, 0xE1, 0x81, 0x8E, 0x07, 0x38, 0x0C, 0xC0, 0x3F,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80,
  0x70, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xFF, 0xF8, 0xE0, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x06,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0,
  0xFF, 0xFC, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0xFF, 0xF8,
  0x06, 0x00, 0x38, 0x03, 0xC0, 0x1B, 0x01, 0xD8, 0x0C, 0x60, 0xE3, 0x06,
  0x0C, 0x70, 0x63, 0x03, 0x98, 0x0D, 0x80, 0x70, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE1, 0xC3, 0x86, 0x0C, 0x1F, 0x87, 0xF8, 0xC7, 0x80, 0x70, 0x0E, 0x00,
  0xC0, 0x18, 0x7F, 0x3F, 0xEE, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8,
  0x7B, 0xFB, 0x3E, 0x60, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x78, 0xEF, 0xCF, 0x9E, 0xF0, 0x7E, 0x07, 0xE0, 0x7E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xF0, 0x7F,
  0x0E, 0xFF, 0xEC, 0xFC, 0x0F, 0x87, 0xF3, 0xCD, 0xC0, 0x70, 0x18, 0x06,
  0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x84, 0xFF,
  0x1F, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE1, 0xE7, 0x3F, 0xB9, 0xEF, 0xDC, 0x1E, 0xE0, 0xF6, 0x03, 0xB0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xD8, 0x0E, 0xC0, 0x77, 0x07,
  0xBC, 0x7C, 0xFF, 0xE3, 0xF7, 0x0F, 0x81, 0xFC, 0x38, 0xE7, 0x06, 0x70,
  0x76, 0x07, 0x60, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x60, 0x06, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x21, 0xFE, 0x0F, 0xE0, 0x07, 0xC3, 0xE1, 0xF8, 0x70,
  0x18, 0x06, 0x01, 0x80, 0xFC, 0xFF, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x0F, 0x39, 0xFD, 0xCE, 0x3E, 0xE0, 0xF7, 0x07, 0xB0, 0x1D, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xC0, 0x76, 0x03, 0xB8, 0x3D,
  0xE3, 0xE7, 0xF7, 0x1F, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x20,
  0x79, 0xFF, 0x8F, 0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x78, 0xFF, 0xCF, 0x9E, 0xF0, 0xEE, 0x06, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0x7F, 0xA0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0C, 0x71, 0xC2, 0x00, 0x01, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0xFB, 0xE0,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x07, 0xE1,
  0xDC, 0x3B, 0x8E, 0x73, 0x8E, 0x61, 0xDC, 0x3F, 0x87, 0xF0, 0xF7, 0x1C,
  0xE3, 0x8E, 0x71, 0xCE, 0x1D, 0xC3, 0xB8, 0x3F, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0x87, 0x9B, 0xF9, 0xFB, 0xE7,
  0xE7, 0xF8, 0x78, 0x7E, 0x0E, 0x07, 0xC1, 0xC0, 0xF8, 0x18, 0x1F, 0x03,
  0x03, 0xE0, 0x60, 0x7C, 0x0C, 0x0F, 0x81, 0x81, 0xF0, 0x30, 0x3E, 0x06,
  0x07, 0xC0, 0xC0, 0xF8, 0x18, 0x1F, 0x03, 0x03, 0xE0, 0x60, 0x60, 0xC7,
  0x8D, 0xFC, 0xFD, 0xEF, 0x0E, 0xE0, 0x6E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x70, 0x0F, 0x80, 0xFF, 0x0F, 0x38, 0xE0, 0xE7, 0x03, 0x30, 0x1D, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xD8, 0x0E, 0xC0, 0x77, 0x03, 0x38, 0x38,
  0xE3, 0xC7, 0xFC, 0x0F, 0xC0, 0xC7, 0x8C, 0xFC, 0xF9, 0xEF, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0,
  0x7F, 0x07, 0xF0, 0xEF, 0xFE, 0xEF, 0xCE, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x39, 0xFD, 0xCF, 0x7E, 0xE0, 0xF7,
  0x07, 0xB0, 0x1D, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xC0,
  0x76, 0x03, 0xB8, 0x3D, 0xE3, 0xE7, 0xF7, 0x1F, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xC7, 0xCF, 0xDF, 0xF0,
  0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x1F, 0x1F, 0xF7, 0x1B, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xF0, 0x1E,
  0x03, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x7C, 0x3B, 0xFE, 0xFF, 0x00, 0x30,
  0x60, 0xC3, 0xFF, 0xEE, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE0, 0xF8, 0xF0, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1,
  0xDC, 0x7B, 0xFB, 0x3E, 0x60, 0xE0, 0x3F, 0x01, 0x98, 0x1C, 0xE0, 0xE7,
  0x06, 0x18, 0x30, 0xC3, 0x87, 0x1C, 0x38, 0xC0, 0xC6, 0x06, 0x70, 0x3B,
  0x00, 0xD8, 0x06, 0xC0, 0x3E, 0x01, 0xE0, 0x07, 0x00, 0xE0, 0x70, 0x36,
  0x07, 0x07, 0x60, 0xF0, 0x77, 0x0F, 0x06, 0x70, 0xF8, 0x67, 0x0D, 0x8E,
  0x31, 0xD8, 0xE3, 0x19, 0x8C, 0x39, 0x9C, 0xC3, 0x98, 0xCC, 0x1B, 0x8D,
  0xC1, 0xB0, 0xDC, 0x1B, 0x0D, 0x81, 0xF0, 0xF8, 0x0F, 0x07, 0x80, 0xE0,
  0x78, 0x0E, 0x07, 0x00, 0x70, 0x73, 0x83, 0x8E, 0x38, 0x71, 0xC1, 0xDC,
  0x0E, 0xE0, 0x3E, 0x00, 0xF0, 0x07, 0x00, 0x7C, 0x03, 0xE0, 0x3B, 0x81,
  0xCC, 0x1C, 0x70, 0xE1, 0x8E, 0x0E, 0xE0, 0x38, 0xE0, 0x3F, 0x01, 0x98,
  0x1C, 0xE0, 0xE7, 0x06, 0x18, 0x30, 0xE3, 0x87, 0x1C, 0x18, 0xC0, 0xC6,
  0x07, 0x70, 0x3B, 0x00, 0xD8, 0x06, 0xC0, 0x3E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x03, 0xF0, 0x1F, 0x00, 0xFF,
  0xFF, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x06,
  0x07, 0x03, 0x03, 0x81, 0xFF, 0xFF, 0x80, 0x03, 0x87, 0xC3, 0x81, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x8F, 0x87, 0x01, 0xE0,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x18, 0x0E, 0x03,
  0xC0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x7C,
  0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0xC0,
  0xF8, 0x1C, 0x3C, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x38, 0x7C, 0x38, 0x00, 0x38, 0x0F, 0xF8, 0xF1, 0xFF, 0x03, 0xC0,
};

const GFXglyph NotoSans_Condensed_Regular31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 22, 8, 2, -22 },
  { 12, 8, 8, 12, 2, -22 },
  { 20, 14, 22, 16, 1, -22 },
  { 59, 12, 26, 15, 1, -24 },
  { 98, 20, 22, 22, 1, -22 },
  { 153, 16, 22, 17, 1, -22 },
  { 197, 3, 8, 7, 2, -22 },
  { 200, 7, 27, 9, 1, -22 },
  { 224, 7, 27, 9, 1, -22 },
  { 248, 12, 12, 14, 1, -24 },
  { 266, 12, 14, 15, 1, -18 },
  { 287, 5, 8, 7, 1, -4 },
  { 292, 7, 3, 9, 1, -10 },
  { 295, 3, 4, 7, 2, -4 },
  { 297, 11, 22, 12, 0, -22 },
  { 328, 12, 22, 15, 1, -22 },
  { 361, 8, 22, 15, 2, -22 },
  { 383, 12, 22, 15, 1, -22 },
  { 416, 12, 22, 15, 1, -22 },
  { 449, 13, 22, 15, 1, -22 },
  { 485, 11, 22, 15, 2, -22 },
  { 516, 12, 22, 15, 1, -22 },
  { 549, 12, 22, 15, 1, -22 },
  { 582, 12, 22, 15, 1, -22 },
  { 615, 12, 22, 15, 1, -22 },
  { 648, 3, 17, 7, 2, -17 },
  { 655, 4, 21, 7, 1, -17 },
  { 666, 13, 14, 15, 1, -18 },
  { 689, 12, 8, 15, 1, -15 },
  { 701, 13, 14, 15, 1, -18 },
  { 724, 10, 22, 11, 0, -22 },
  { 752, 19, 25, 22, 2, -22 },
  { 812, 16, 22, 16, 0, -22 },
  { 856, 13, 22, 16, 2, -22 },
  { 892, 13, 22, 16, 2, -22 },
  { 928, 14, 22, 18, 2, -22 },
  { 967, 10, 22, 14, 2, -22 },
  { 995, 10, 22, 13, 2, -22 },
  { 1023, 15, 22, 19, 2, -22 },
  { 1065, 14, 22, 18, 2, -22 },
  { 1104, 7, 22, 9, 1, -22 },
  { 1124, 7, 28, 7, -2, -22 },
  { 1149, 14, 22, 15, 2, -22 },
  { 1188, 10, 22, 13, 2, -22 },
  { 1216, 20, 22, 24, 2, -22 },
  { 1271, 15, 22, 19, 2, -22 },
  { 1313, 16, 22, 19, 2, -22 },
  { 1357, 12, 22, 15, 2, -22 },
  { 1390, 16, 27, 19, 2, -22 },
  { 1444, 13, 22, 16, 2, -22 },
  { 1480, 12, 22, 14, 1, -22 },
  { 1513, 13, 22, 13, 0, -22 },
  { 1549, 14, 22, 18, 2, -22 },
  { 1588, 15, 22, 15, 0, -22 },
  { 1630, 24, 22, 24, 0, -22 },
  { 1696, 14, 22, 14, 0, -22 },
  { 1735, 14, 22, 14, 0, -22 },
  { 1774, 11, 22, 13, 1, -22 },
  { 1805, 7, 27, 10, 2, -22 },
  { 1829, 11, 22, 12, 0, -22 },
  { 1860, 7, 27, 10, 1, -22 },
  { 1884, 13, 12, 15, 1, -22 },
  { 1904, 14, 2, 14, 0, 3 },
  { 1908, 6, 5, 8, 1, -24 },
  { 1912, 11, 17, 14, 1, -17 },
  { 1936, 12, 24, 16, 2, -24 },
  { 1972, 10, 17, 12, 1, -17 },
  { 1994, 13, 24, 16, 1, -24 },
  { 2033, 12, 17, 14, 1, -17 },
  { 2059, 10, 24, 9, 0, -24 },
  { 2089, 13, 24, 16, 1, -17 },
  { 2128, 12, 24, 16, 2, -24 },
  { 2164, 3, 23, 7, 2, -23 },
  { 2173, 6, 30, 7, -1, -23 },
  { 2196, 11, 24, 14, 2, -24 },
  { 2229, 3, 24, 7, 2, -24 },
  { 2238, 19, 17, 24, 2, -17 },
  { 2279, 12, 17, 16, 2, -17 },
  { 2305, 13, 17, 15, 1, -17 },
  { 2333, 12, 24, 16, 2, -17 },
  { 2369, 13, 24, 16, 1, -17 },
  { 2408, 8, 17, 10, 2, -17 },
  { 2425, 10, 17, 12, 1, -17 },
  { 2447, 7, 20, 9, 1, -20 },
  { 2465, 11, 17, 16, 2, -17 },
  { 2489, 13, 17, 13, 0, -17 },
  { 2517, 20, 17, 20, 0, -17 },
  { 2560, 13, 17, 13, 0, -17 },
  { 2588, 13, 24, 13, 0, -17 },
  { 2627, 9, 17, 11, 1, -17 },
  { 2647, 9, 27, 11, 1, -22 },
  { 2678, 2, 31, 14, 6, -24 },
  { 2686, 9, 27, 11, 1, -22 },
  { 2717, 13, 4, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_Regular31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular31pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_CONDENSED_REGULAR31PT7B_H_
