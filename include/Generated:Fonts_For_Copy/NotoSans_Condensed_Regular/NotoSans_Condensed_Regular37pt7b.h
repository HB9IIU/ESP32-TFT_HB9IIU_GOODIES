#ifndef _NOTOSANS_CONDENSED_REGULAR37PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular37pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0x00, 0x01, 0xDF, 0xFB, 0x80, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0x61,
  0xD8, 0x76, 0x1D, 0x87, 0x61, 0xC0, 0x03, 0x0E, 0x01, 0x87, 0x00, 0xC3,
  0x00, 0xE1, 0x80, 0x70, 0xC0, 0x38, 0x60, 0x18, 0x30, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0xFF, 0xC3, 0x86, 0x01, 0xC3, 0x00, 0xE1, 0x80, 0x61, 0xC0,
  0x30, 0xE0, 0x18, 0x70, 0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0x0C, 0x03, 0x86,
  0x01, 0x87, 0x00, 0xC3, 0x80, 0x61, 0xC0, 0x30, 0xC0, 0x38, 0x60, 0x1C,
  0x30, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x03, 0xF8, 0x3F, 0xF9, 0xFF,
  0xEF, 0x30, 0xB8, 0xC0, 0xE3, 0x03, 0x8C, 0x0E, 0x30, 0x3C, 0xC0, 0x7B,
  0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x0C, 0xE0, 0x31, 0xC0,
  0xC7, 0x03, 0x1C, 0x0C, 0x78, 0x33, 0xBF, 0xFE, 0xFF, 0xF1, 0xFF, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0xFC, 0x03,
  0x81, 0xFC, 0x06, 0x07, 0x18, 0x1C, 0x0C, 0x30, 0x30, 0x18, 0x70, 0xE0,
  0x30, 0xE1, 0x80, 0x61, 0xC7, 0x00, 0xC3, 0x8E, 0x01, 0x87, 0x18, 0x03,
  0x0E, 0x70, 0x06, 0x1C, 0xC7, 0x8C, 0x33, 0x9F, 0x9C, 0x67, 0x73, 0x9F,
  0xCC, 0xE3, 0x3F, 0x39, 0x87, 0x1C, 0x63, 0x0E, 0x01, 0xC6, 0x1C, 0x03,
  0x8C, 0x38, 0x06, 0x18, 0x70, 0x1C, 0x30, 0xE0, 0x30, 0x61, 0xC0, 0xE0,
  0xC3, 0x81, 0x81, 0xC6, 0x07, 0x03, 0x9C, 0x0E, 0x03, 0xF0, 0x38, 0x03,
  0xE0, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xC7, 0x00, 0x1C,
  0x38, 0x03, 0x83, 0x80, 0x38, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x70, 0x01,
  0xC7, 0x00, 0x0E, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0xC1, 0xC3, 0x9E, 0x1C, 0x78, 0xE1, 0xC7, 0x07, 0x3C, 0xF0, 0x7B,
  0x8F, 0x03, 0xF8, 0xF0, 0x1F, 0x0F, 0x00, 0xF0, 0x70, 0x1F, 0x07, 0x83,
  0xF8, 0x7E, 0xFB, 0xC3, 0xFF, 0x1C, 0x1F, 0xE1, 0xF0, 0xFF, 0xFE, 0x66,
  0x66, 0x60, 0x07, 0x0E, 0x0C, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xF0, 0x70, 0x70, 0x78, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0xE0,
  0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x0E, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0x0E,
  0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xC0, 0x63, 0x1D, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x0F, 0xC0,
  0x3B, 0x81, 0xCE, 0x0F, 0x1C, 0x18, 0x60, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x3C, 0xE3, 0x8E, 0x71, 0xC7, 0x18, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x77, 0xFC, 0xE0, 0x00, 0x70, 0x07, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00,
  0x7F, 0x03, 0xFE, 0x1E, 0x3C, 0x70, 0x71, 0xC0, 0xEE, 0x03, 0xB8, 0x0E,
  0xE0, 0x3B, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0E, 0xE0, 0x3B, 0xC0,
  0xE7, 0x07, 0x9E, 0x1C, 0x3D, 0xF0, 0xFF, 0x81, 0xFC, 0x00, 0x07, 0x87,
  0xC7, 0xE7, 0x7F, 0x7F, 0x3D, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC0, 0x07, 0x80, 0x7F, 0xE1, 0xFF, 0xE3, 0x83, 0xC2,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x7F, 0xE3, 0xFF,
  0xE3, 0x83, 0xC2, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x07, 0x80, 0xFE, 0x01, 0xF8, 0x03, 0xFC, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x40, 0x1E, 0xF9, 0xF9, 0xFF, 0xE1, 0xFF, 0x80, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xB8, 0x03, 0xB8,
  0x03, 0x38, 0x07, 0x38, 0x06, 0x38, 0x0E, 0x38, 0x1C, 0x38, 0x1C, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x38, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x7F, 0xF1, 0xFF, 0xC7, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0F, 0xFC, 0x3F,
  0xF8, 0x7B, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE8, 0x07, 0xBC, 0xFC, 0xFF, 0xE1,
  0xFF, 0x00, 0x01, 0xF0, 0x1F, 0xC1, 0xFF, 0x0F, 0x80, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x18, 0x3B, 0xF8, 0xFF,
  0xF3, 0xE1, 0xEF, 0x03, 0xB8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0xF7, 0x03, 0x9E, 0x1E, 0x3D, 0xF0, 0x7F, 0xC0,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xE1, 0xE7, 0x81,
  0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x78, 0x1C, 0x70, 0x78, 0xF1, 0xE0,
  0xF7, 0x80, 0xFE, 0x00, 0xFC, 0x07, 0xFC, 0x1E, 0x3C, 0x78, 0x3C, 0xE0,
  0x39, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xDC, 0x03, 0xBC, 0x0E,
  0x7C, 0x7C, 0x7F, 0xF0, 0x3F, 0xC0, 0x0F, 0x00, 0xFF, 0x07, 0xFE, 0x1E,
  0x3C, 0xF0, 0x73, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC1, 0xF7, 0xDD, 0xCF, 0xFE, 0x1F, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78,
  0x47, 0xC1, 0xFF, 0x07, 0xF0, 0x00, 0x77, 0xBE, 0xE6, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x77, 0xFC, 0xE0, 0x39, 0xE7, 0xDE, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xE3, 0x9E, 0x71, 0xC7,
  0x18, 0xE0, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00,
  0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x00, 0x02, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x7C,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x78, 0x00, 0xC0,
  0x00, 0x0F, 0x07, 0xFC, 0xFF, 0xE6, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x78, 0x07, 0x01, 0xE0, 0x07, 0x03, 0x80, 0x07, 0x0E,
  0x00, 0x07, 0x18, 0x00, 0x0E, 0x70, 0x7F, 0x0C, 0xC1, 0xFE, 0x1D, 0x87,
  0x0C, 0x3F, 0x0E, 0x18, 0x7E, 0x38, 0x30, 0xFC, 0x70, 0x60, 0xF0, 0xE0,
  0xC3, 0xE1, 0xC3, 0x87, 0xC3, 0x87, 0x0F, 0xC7, 0x0E, 0x1F, 0x8E, 0x1C,
  0x37, 0x1C, 0x38, 0x6E, 0x1F, 0xDB, 0xDC, 0x1F, 0x3F, 0x18, 0x1C, 0x38,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x01, 0x00,
  0x78, 0x1C, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00,
  0xCE, 0x00, 0x39, 0xC0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x38, 0x70, 0x07,
  0x0F, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x07, 0x03, 0x80, 0xFF, 0xF8, 0x1F,
  0xFF, 0x07, 0xFF, 0xE0, 0xE0, 0x1E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0xF0,
  0x07, 0x1C, 0x00, 0xF3, 0x80, 0x0E, 0xF0, 0x01, 0xDC, 0x00, 0x3C, 0xFF,
  0xE1, 0xFF, 0xF3, 0x83, 0xE7, 0x01, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x07,
  0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x7B, 0x81, 0xE7, 0xFF, 0x8F, 0xFE, 0x1F,
  0xFF, 0x38, 0x0F, 0x70, 0x0E, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x01, 0xFC, 0x03, 0xB8, 0x0F, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC0,
  0x01, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0x06, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFC, 0xFF, 0xE0, 0x7F, 0xF8, 0x38, 0x7F,
  0x1C, 0x07, 0x8E, 0x01, 0xE7, 0x00, 0x73, 0x80, 0x3D, 0xC0, 0x0E, 0xE0,
  0x07, 0x70, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x03, 0xDC, 0x01,
  0xCE, 0x01, 0xE7, 0x00, 0xE3, 0x81, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF,
  0xEF, 0xFE, 0xFF, 0xEE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x78, 0x00, 0xFF,
  0xE0, 0xFF, 0xFC, 0x7C, 0x0E, 0x3E, 0x00, 0x8F, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xDE, 0x00, 0x73, 0xC0, 0x1C,
  0xF8, 0x07, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xF8, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xFF, 0xBF, 0x87, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0xFF, 0xFF, 0xC0, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F,
  0x0F, 0xFE, 0xFC, 0xF8, 0xE0, 0x1E, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x78,
  0xE0, 0x70, 0xE0, 0xE0, 0xE1, 0xE0, 0xE1, 0xC0, 0xE3, 0x80, 0xE7, 0x80,
  0xE7, 0x00, 0xEF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFB, 0x80, 0xF3, 0xC0,
  0xE1, 0xC0, 0xE1, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xE0, 0x78, 0xE0, 0x38,
  0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x1E, 0xE0, 0x0F, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x06, 0xFF, 0x80, 0x1D, 0xFB, 0x80, 0x3B, 0xF7, 0x00, 0x67, 0xEE, 0x01,
  0xCF, 0xCE, 0x03, 0x9F, 0x9C, 0x07, 0x3F, 0x38, 0x1C, 0x7E, 0x38, 0x38,
  0xFC, 0x70, 0x71, 0xF8, 0xE1, 0xC3, 0xF0, 0xC3, 0x87, 0xE1, 0xC7, 0x0F,
  0xC3, 0x8C, 0x1F, 0x83, 0x38, 0x3F, 0x07, 0x70, 0x7E, 0x0E, 0xC0, 0xFC,
  0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3C, 0x07, 0xE0, 0x78, 0x0F, 0xC0,
  0x70, 0x1C, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xF0, 0x1F, 0xB8, 0x0F, 0xDE, 0x07, 0xE7, 0x03, 0xF3, 0xC1, 0xF8,
  0xE0, 0xFC, 0x78, 0x7E, 0x1C, 0x3F, 0x0F, 0x1F, 0x83, 0x8F, 0xC1, 0xE7,
  0xE0, 0x73, 0xF0, 0x3D, 0xF8, 0x0E, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0x07, 0x83, 0xC0, 0x78, 0xF0, 0x07,
  0x1C, 0x00, 0xF3, 0x80, 0x0E, 0xF0, 0x01, 0xDE, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xB8, 0x00, 0xE7, 0x00, 0x1C,
  0xF0, 0x07, 0x8E, 0x00, 0xE1, 0xE0, 0x3C, 0x1F, 0xBF, 0x01, 0xFF, 0xC0,
  0x1F, 0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0xCE, 0x3F, 0xB8, 0x1E, 0xE0, 0x3B,
  0x80, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xB8, 0x1E,
  0xE0, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F, 0xC0, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0x07, 0x83, 0xC0,
  0x78, 0xF0, 0x07, 0x9C, 0x00, 0xF3, 0x80, 0x0E, 0xF0, 0x01, 0xDE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xB8, 0x00,
  0xE7, 0x00, 0x1C, 0xF0, 0x07, 0x8E, 0x00, 0xE1, 0xE0, 0x3C, 0x1F, 0xBF,
  0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0xFF, 0xC1, 0xFF, 0xE3,
  0x8F, 0xE7, 0x03, 0xCE, 0x03, 0xDC, 0x07, 0xB8, 0x07, 0x70, 0x0E, 0xE0,
  0x3D, 0xC0, 0x7B, 0x80, 0xE7, 0x03, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0,
  0x70, 0xE0, 0xE1, 0xE1, 0xC1, 0xC3, 0x83, 0xC7, 0x03, 0x8E, 0x07, 0x9C,
  0x07, 0x38, 0x0F, 0x70, 0x0E, 0xE0, 0x1F, 0xC0, 0x1C, 0x07, 0x80, 0xFF,
  0xDF, 0xFE, 0xF0, 0x6F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xF0, 0x0E,
  0xFF, 0xF7, 0xFF, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x0E, 0x78, 0x1E, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F,
  0xF0, 0xF0, 0x01, 0xDC, 0x00, 0xF7, 0x00, 0x39, 0xC0, 0x0E, 0x78, 0x07,
  0x8E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x3C, 0x0F, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x0E, 0x1E, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38,
  0x70, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0xF0, 0x07, 0x00, 0x7B, 0x80, 0x78, 0x03, 0x9C, 0x03, 0xE0, 0x1C, 0xE0,
  0x1F, 0x00, 0xE7, 0x80, 0xD8, 0x0F, 0x1C, 0x06, 0xC0, 0x70, 0xE0, 0x77,
  0x03, 0x87, 0x03, 0xB8, 0x1C, 0x38, 0x1D, 0xC0, 0xE1, 0xE0, 0xCE, 0x0F,
  0x07, 0x0E, 0x38, 0x70, 0x38, 0x71, 0xC3, 0x81, 0xC3, 0x8E, 0x1C, 0x0E,
  0x1C, 0x71, 0xE0, 0x39, 0xC1, 0x8E, 0x01, 0xCE, 0x0E, 0x70, 0x0E, 0x70,
  0x73, 0x80, 0x73, 0x83, 0x9C, 0x03, 0x98, 0x0D, 0xE0, 0x0F, 0xC0, 0x6E,
  0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00,
  0x78, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78,
  0x07, 0x1C, 0x07, 0x0E, 0x03, 0x83, 0x83, 0x81, 0xC1, 0xC0, 0x71, 0xE0,
  0x38, 0xE0, 0x0E, 0xF0, 0x07, 0x70, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0E, 0xE0, 0x07, 0x70, 0x07,
  0x1C, 0x03, 0x8E, 0x03, 0x87, 0x81, 0xC1, 0xC1, 0xE0, 0xF0, 0xE0, 0x38,
  0xF0, 0x1E, 0x70, 0x07, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x70, 0x0F, 0x78,
  0x0E, 0x38, 0x0E, 0x38, 0x1C, 0x3C, 0x1C, 0x1C, 0x3C, 0x1C, 0x38, 0x0E,
  0x38, 0x0E, 0x70, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF,
  0xFB, 0xFF, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x06, 0xE0, 0x0E, 0x70, 0x0C, 0x70, 0x1C, 0x38, 0x18, 0x38,
  0x38, 0x1C, 0x38, 0x1C, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x0F, 0xE1, 0xFF, 0x87,
  0x3E, 0x20, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x07, 0xF8, 0xFF,
  0xCF, 0x8E, 0xF0, 0x77, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0x70, 0x7B,
  0xC6, 0xCF, 0xF6, 0x7F, 0x30, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE7, 0xC3, 0xBF, 0xCF, 0xFF,
  0x3C, 0x1E, 0xF0, 0x3B, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xFC, 0x0E, 0xF0,
  0x3B, 0xF3, 0xED, 0xFF, 0x31, 0xF8, 0x0F, 0xE3, 0xFC, 0xFF, 0xBC, 0x07,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x8C, 0xFF, 0x8F, 0xF0, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x1F, 0x9C, 0xFF, 0x77, 0xFF, 0xDC, 0x0F, 0xF0, 0x3F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xFC, 0x0F, 0x70, 0x3D, 0xF3, 0xF3, 0xFD, 0xC7, 0xE3, 0x0F,
  0xC1, 0xFF, 0x0F, 0x3C, 0xE0, 0xE7, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x78, 0x09, 0xF1, 0xCF, 0xFE, 0x1F, 0xE0, 0x07, 0xE1, 0xFC, 0x3C,
  0x8F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3F, 0xDF, 0xFB, 0xFF, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x1F,
  0x8C, 0xFF, 0x77, 0xFF, 0xDC, 0x1F, 0xF0, 0x3F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xFC, 0x0F, 0x70, 0x3D, 0xF3, 0xF3, 0xFD, 0xC7, 0xE7, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3D, 0x01, 0xE7, 0xFF, 0x1F, 0xF8,
  0x1F, 0x80, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE7, 0xE7, 0x7F, 0xBF, 0xFD, 0xE0, 0xFF, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x70,
  0x7F, 0xF6, 0x00, 0x07, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x70, 0x0E, 0x3C, 0x78, 0x60, 0x00, 0x00, 0x07, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8F, 0x1D, 0xFB, 0xF7, 0x80, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x7F, 0x07, 0xB8, 0x39, 0xC3, 0x8E, 0x38, 0x73, 0xC3, 0x9C, 0x1D, 0xC0,
  0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xEF, 0x0E, 0x38, 0x71, 0xE3, 0x87, 0x1C,
  0x3C, 0xE0, 0xE7, 0x07, 0xB8, 0x1D, 0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC7, 0xC3, 0xF1, 0xBF, 0xCF,
  0xF3, 0x77, 0xFD, 0xF7, 0x83, 0xE0, 0xEE, 0x07, 0x81, 0xDC, 0x0F, 0x03,
  0xB8, 0x0E, 0x07, 0x70, 0x1C, 0x0F, 0xE0, 0x38, 0x1F, 0xC0, 0x70, 0x3F,
  0x80, 0xE0, 0x7F, 0x01, 0xC0, 0xFE, 0x03, 0x81, 0xFC, 0x07, 0x03, 0xF8,
  0x0E, 0x07, 0xF0, 0x1C, 0x0F, 0xE0, 0x38, 0x1F, 0xC0, 0x70, 0x3F, 0x80,
  0xE0, 0x7F, 0x01, 0xC0, 0xF0, 0xC7, 0xE6, 0x7F, 0xB7, 0xFD, 0xE0, 0xFF,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x70, 0x0F, 0xC0, 0x7F, 0xE0, 0xFB, 0xE3, 0x81, 0xC7, 0x03, 0xDC,
  0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x38, 0x1E, 0x70, 0x38, 0x79, 0xF0,
  0xFF, 0xC0, 0x7F, 0x00, 0xC7, 0xC3, 0x3F, 0xCD, 0xCF, 0xBC, 0x1E, 0xF0,
  0x3B, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xFC, 0x0E, 0xF0, 0x7B, 0xF3, 0xEF,
  0xFF, 0x39, 0xF8, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1F, 0x8C, 0xFF, 0x77, 0xFF,
  0xDC, 0x0F, 0xF0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x0F, 0x70,
  0x3D, 0xF3, 0xF3, 0xFD, 0xC7, 0xE7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0xC7, 0xE7,
  0xF7, 0xFB, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0x1F, 0xC3, 0xFF,
  0x79, 0xE7, 0x02, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3E, 0x01, 0xF8,
  0x0F, 0xC0, 0x3E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0xFF, 0x1E,
  0xFF, 0xC7, 0xF8, 0x18, 0x1C, 0x0E, 0x07, 0x07, 0xFF, 0xFF, 0xFE, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xE4, 0x7E, 0x3F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0xCF, 0xDF,
  0xEE, 0x7E, 0x70, 0xE0, 0x0E, 0xE0, 0x1D, 0xC0, 0x73, 0x80, 0xE7, 0x01,
  0xC7, 0x07, 0x8E, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0xE0, 0x71, 0xC0,
  0xE3, 0x80, 0xE7, 0x01, 0xDC, 0x03, 0xB8, 0x03, 0x70, 0x06, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x1C, 0x00, 0xF0, 0x3C, 0x07, 0x70, 0x3C, 0x07, 0x70,
  0x3C, 0x0E, 0x70, 0x3E, 0x0E, 0x70, 0x7E, 0x0E, 0x38, 0x76, 0x0E, 0x38,
  0x76, 0x0E, 0x38, 0x67, 0x1C, 0x38, 0xE7, 0x1C, 0x1C, 0xE7, 0x1C, 0x1C,
  0xE3, 0x1C, 0x1C, 0xC3, 0xB8, 0x1C, 0xC3, 0xB8, 0x1D, 0xC3, 0xB8, 0x0D,
  0xC1, 0xB8, 0x0F, 0xC1, 0xB0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07,
  0x81, 0xF0, 0x07, 0x80, 0xE0, 0xE0, 0x3D, 0xC0, 0xE7, 0x07, 0x8E, 0x1C,
  0x38, 0xE0, 0x73, 0x81, 0xDC, 0x03, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0xC0, 0x77, 0x03, 0xCE, 0x0E, 0x3C, 0x78, 0x71, 0xC1,
  0xEF, 0x03, 0xB8, 0x0F, 0xE0, 0x0E, 0xE0, 0x1D, 0xC0, 0x73, 0x80, 0xE7,
  0x81, 0xC7, 0x07, 0x8E, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0xE0, 0x71,
  0xC0, 0x73, 0x80, 0xE7, 0x01, 0xDC, 0x01, 0xB8, 0x03, 0x70, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x7F,
  0xEF, 0xFD, 0xFF, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01,
  0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x7C, 0x1E, 0x03, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x3F, 0x07,
  0x80, 0xFC, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0xC0, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF8, 0x1F, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xF8, 0x0F, 0x03,
  0xE0, 0xF0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x01, 0xE1, 0xF8, 0x3E, 0x07, 0x00, 0x7F, 0x03, 0xFF,
  0x8F, 0x8F, 0xFC, 0x07, 0xE0,
};

const GFXglyph NotoSans_Condensed_Regular37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 26, 9, 2, -26 },
  { 18, 10, 9, 14, 2, -26 },
  { 30, 17, 26, 19, 1, -26 },
  { 86, 14, 30, 17, 2, -28 },
  { 139, 23, 27, 26, 2, -27 },
  { 217, 20, 27, 20, 1, -27 },
  { 285, 4, 9, 8, 2, -26 },
  { 290, 8, 33, 11, 2, -27 },
  { 323, 8, 33, 11, 1, -27 },
  { 356, 14, 13, 16, 1, -28 },
  { 379, 15, 18, 18, 1, -22 },
  { 413, 6, 9, 9, 1, -4 },
  { 420, 9, 3, 11, 1, -11 },
  { 424, 5, 4, 9, 2, -4 },
  { 427, 12, 26, 14, 1, -26 },
  { 466, 14, 27, 17, 2, -27 },
  { 514, 9, 26, 17, 3, -26 },
  { 544, 15, 27, 17, 1, -27 },
  { 595, 15, 27, 17, 1, -27 },
  { 646, 16, 27, 17, 1, -27 },
  { 700, 14, 26, 17, 2, -26 },
  { 746, 14, 27, 17, 2, -27 },
  { 794, 15, 26, 17, 1, -26 },
  { 843, 15, 27, 17, 1, -27 },
  { 894, 14, 27, 17, 2, -27 },
  { 942, 5, 20, 9, 2, -20 },
  { 955, 6, 25, 9, 1, -20 },
  { 974, 15, 17, 18, 1, -22 },
  { 1006, 15, 10, 18, 1, -18 },
  { 1025, 15, 17, 18, 1, -22 },
  { 1057, 12, 27, 13, 0, -27 },
  { 1098, 23, 30, 27, 2, -27 },
  { 1185, 19, 26, 19, 0, -26 },
  { 1247, 15, 26, 20, 3, -26 },
  { 1296, 16, 27, 19, 2, -27 },
  { 1350, 17, 26, 21, 3, -26 },
  { 1406, 12, 26, 17, 3, -26 },
  { 1445, 12, 26, 16, 3, -26 },
  { 1484, 18, 27, 22, 2, -27 },
  { 1545, 16, 26, 22, 3, -26 },
  { 1597, 9, 26, 11, 1, -26 },
  { 1627, 8, 33, 9, -2, -26 },
  { 1660, 16, 26, 18, 3, -26 },
  { 1712, 12, 26, 15, 3, -26 },
  { 1751, 23, 26, 29, 3, -26 },
  { 1826, 17, 26, 23, 3, -26 },
  { 1882, 19, 27, 23, 2, -27 },
  { 1947, 14, 26, 18, 3, -26 },
  { 1993, 19, 33, 23, 2, -27 },
  { 2072, 15, 26, 19, 3, -26 },
  { 2121, 13, 27, 17, 2, -27 },
  { 2165, 16, 26, 16, 0, -26 },
  { 2217, 16, 26, 22, 3, -26 },
  { 2269, 18, 26, 18, 0, -26 },
  { 2328, 29, 26, 29, 0, -26 },
  { 2423, 17, 26, 17, 0, -26 },
  { 2479, 16, 26, 16, 0, -26 },
  { 2531, 14, 26, 16, 1, -26 },
  { 2577, 8, 33, 12, 3, -27 },
  { 2610, 12, 26, 14, 1, -26 },
  { 2649, 8, 33, 12, 1, -27 },
  { 2682, 16, 14, 18, 1, -26 },
  { 2710, 16, 2, 16, 0, 3 },
  { 2714, 8, 6, 10, 1, -28 },
  { 2720, 13, 20, 17, 1, -20 },
  { 2753, 14, 28, 19, 3, -28 },
  { 2802, 11, 20, 14, 2, -20 },
  { 2830, 14, 28, 19, 2, -28 },
  { 2879, 13, 20, 17, 2, -20 },
  { 2912, 11, 28, 10, 0, -28 },
  { 2951, 14, 29, 19, 2, -20 },
  { 3002, 13, 28, 19, 3, -28 },
  { 3048, 4, 27, 8, 2, -27 },
  { 3062, 7, 36, 8, -1, -27 },
  { 3094, 13, 28, 16, 3, -28 },
  { 3140, 3, 28, 8, 3, -28 },
  { 3151, 23, 20, 28, 3, -20 },
  { 3209, 13, 20, 19, 3, -20 },
  { 3242, 15, 20, 18, 2, -20 },
  { 3280, 14, 29, 19, 3, -20 },
  { 3331, 14, 29, 19, 2, -20 },
  { 3382, 9, 20, 12, 3, -20 },
  { 3405, 12, 20, 14, 1, -20 },
  { 3435, 9, 24, 11, 1, -24 },
  { 3462, 13, 20, 19, 3, -20 },
  { 3495, 15, 20, 15, 0, -20 },
  { 3533, 24, 20, 24, 0, -20 },
  { 3593, 14, 20, 16, 1, -20 },
  { 3628, 15, 29, 15, 0, -20 },
  { 3683, 11, 20, 13, 1, -20 },
  { 3711, 11, 32, 14, 1, -26 },
  { 3755, 3, 37, 17, 7, -28 },
  { 3769, 11, 32, 14, 1, -26 },
  { 3813, 15, 4, 18, 1, -15 },
};

const GFXfont NotoSans_Condensed_Regular37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular37pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_CONDENSED_REGULAR37PT7B_H_
