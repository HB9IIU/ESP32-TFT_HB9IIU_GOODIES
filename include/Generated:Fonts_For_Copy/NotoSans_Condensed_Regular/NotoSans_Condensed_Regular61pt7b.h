#ifndef _NOTOSANS_CONDENSED_REGULAR61PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular61pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xE3, 0xC3, 0x87, 0x0E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xE1, 0x00, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8,
  0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1E, 0x70,
  0x1E, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0xF0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF8, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x78, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0,
  0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0x73, 0xF1, 0xF0, 0xE0,
  0x67, 0xC1, 0xC0, 0x0F, 0x83, 0x80, 0x1F, 0x07, 0x00, 0x3E, 0x0E, 0x00,
  0x7C, 0x1C, 0x00, 0xF8, 0x38, 0x01, 0xF0, 0x70, 0x03, 0xF0, 0xE0, 0x03,
  0xF1, 0xC0, 0x07, 0xFB, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x01,
  0xDF, 0xE0, 0x03, 0x8F, 0xC0, 0x07, 0x0F, 0xC0, 0x0E, 0x0F, 0x80, 0x1C,
  0x1F, 0x00, 0x38, 0x3E, 0x00, 0x70, 0x7C, 0x00, 0xE0, 0xF8, 0x01, 0xC1,
  0xF8, 0x03, 0x87, 0xDC, 0x07, 0x1F, 0xBF, 0xEF, 0xFE, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x7F, 0xC0,
  0x01, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0x80, 0x1F, 0xFE, 0x00, 0x3E, 0x00,
  0x78, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0x0F, 0x03, 0xC0,
  0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x07, 0x81,
  0xE0, 0x00, 0xF0, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x3C, 0x00, 0x0F,
  0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x07, 0x87, 0xC0, 0x00, 0xF0, 0x1E, 0x1E,
  0x00, 0x03, 0xC0, 0x78, 0x78, 0x3C, 0x0F, 0x03, 0xE3, 0xC3, 0xFC, 0x3C,
  0x0F, 0x0F, 0x1F, 0xF8, 0xF0, 0x3C, 0x7C, 0x7F, 0xF1, 0xE0, 0xF1, 0xE3,
  0xE3, 0xC7, 0x87, 0xC7, 0x8F, 0x0F, 0x8F, 0xFE, 0x3C, 0x7C, 0x1E, 0x3F,
  0xF0, 0xF1, 0xE0, 0x78, 0x7F, 0xC7, 0xC7, 0x81, 0xF0, 0xFC, 0x1E, 0x1E,
  0x07, 0xC0, 0x00, 0xF8, 0x78, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x3C, 0x00,
  0x0F, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x78,
  0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0xF0, 0x00,
  0xF0, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x1F, 0x00, 0x1E, 0x01, 0xE0,
  0x7C, 0x00, 0xF8, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x0F, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x3E, 0x00, 0x78, 0x00, 0xF9, 0xF0, 0x01, 0xE0, 0x01, 0xFF,
  0xC0, 0x0F, 0x80, 0x03, 0xFE, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x7C, 0x1F, 0x9F, 0x80, 0xFC, 0x3F, 0x0F, 0xC0, 0xF8, 0x3E,
  0x07, 0xC0, 0xF8, 0x7E, 0x07, 0xE0, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x7C,
  0x01, 0xF9, 0xF0, 0xFC, 0x01, 0xF9, 0xF0, 0xF8, 0x00, 0xFF, 0xF0, 0xF8,
  0x00, 0x7F, 0xE0, 0xF8, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x3F, 0xC0, 0xFC,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x7F, 0xE0, 0x7E,
  0x00, 0xFF, 0xF0, 0x3F, 0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0xF9, 0xF8, 0x1F,
  0xFF, 0xF0, 0xFC, 0x0F, 0xFF, 0xC0, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0x00,
  0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xBD,
  0xCE, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x7C, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x10, 0x0E, 0x03, 0x3E, 0x1C, 0x3E, 0x7F, 0xBB, 0xFC, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xF7, 0xC0, 0x07, 0xC7, 0xC0, 0x1F, 0x8F,
  0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x80, 0x70, 0x1C, 0x00, 0x20, 0x30,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x8F, 0xC7, 0xC3,
  0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x87, 0x83, 0xC3,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7D, 0xFB,
  0xFF, 0xFF, 0xFF, 0x9F, 0x08, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF,
  0x01, 0xFE, 0xFF, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0x7C,
  0x7E, 0x00, 0xF8, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xEF,
  0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7C,
  0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0x87,
  0xC0, 0x3F, 0x0F, 0xC0, 0x7C, 0x0F, 0xC3, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x8F, 0xDF, 0x3F, 0x3F, 0xFC, 0x7D, 0xF0, 0xF9, 0xC1, 0xF1, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xCF,
  0xF8, 0x3E, 0x01, 0xFC, 0x38, 0x00, 0xFC, 0x10, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xFF, 0x87,
  0xF8, 0x7C, 0x01, 0xFC, 0x30, 0x00, 0xFC, 0x20, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0xC0, 0x00, 0xFC, 0xF8, 0x03, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x01, 0x68,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xCF, 0x80, 0x00,
  0x79, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0xF8, 0xF8,
  0x00, 0x1E, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3C,
  0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0,
  0x0F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00,
  0x7C, 0x03, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1E, 0x00, 0x3E, 0x07,
  0xC0, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x04, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x30, 0x00, 0xFE, 0x7C, 0x07,
  0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x01, 0xFF, 0xF0,
  0x00, 0x2C, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xC3, 0x81, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x0C, 0x01, 0xF0, 0xFF, 0x03, 0xE7, 0xFF, 0x87, 0xDF,
  0xFF, 0x8F, 0xBF, 0xFF, 0x9F, 0xF0, 0x7F, 0x3F, 0xC0, 0x3F, 0x7F, 0x00,
  0x3E, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7,
  0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x8F, 0xC0, 0x3E, 0x0F, 0xE1, 0xFC, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x1F, 0xC1, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x1F,
  0x00, 0x7C, 0x1F, 0x80, 0xF8, 0x0F, 0xC3, 0xF8, 0x07, 0xF7, 0xF0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x0F, 0xC7, 0xF8, 0x1F, 0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x3E,
  0x00, 0x7E, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x3F,
  0x80, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xE7, 0xF8, 0x3F, 0x81, 0xF8, 0x3F,
  0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x3E, 0x00, 0xFF, 0x3F,
  0x01, 0xFF, 0x1F, 0xFF, 0xDF, 0x1F, 0xFF, 0xDF, 0x0F, 0xFF, 0x9E, 0x07,
  0xFE, 0x3E, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x10, 0x1F, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x79, 0xFB, 0xFF, 0xFF,
  0xFF, 0xDF, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xEF, 0xFF, 0xFF, 0xFE,
  0x7C, 0x20, 0x1E, 0x1F, 0x8F, 0xE7, 0xF3, 0xF9, 0xFC, 0xFC, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE3, 0xF1, 0xF1, 0xF8,
  0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x0F, 0x87, 0xC3, 0xC1, 0xE1, 0xF0, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF7, 0xFC,
  0xE0, 0x1F, 0x90, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x7F, 0x80,
  0xF8, 0xF8, 0x07, 0xFF, 0x81, 0xE3, 0xC0, 0x3F, 0xFE, 0x07, 0x8F, 0x01,
  0xFF, 0xF8, 0x1F, 0x7C, 0x0F, 0xC1, 0xE0, 0x3D, 0xE0, 0x3E, 0x07, 0x80,
  0xF7, 0x81, 0xF0, 0x1E, 0x03, 0xDE, 0x07, 0xC0, 0x78, 0x0F, 0x78, 0x1E,
  0x01, 0xE0, 0x3F, 0xE0, 0x78, 0x07, 0x80, 0xFF, 0x03, 0xE0, 0x1E, 0x03,
  0xFC, 0x0F, 0x80, 0x78, 0x0F, 0xF0, 0x3E, 0x03, 0xE0, 0x3F, 0xC0, 0xF8,
  0x0F, 0x80, 0xFF, 0x03, 0xE0, 0x3E, 0x03, 0xFC, 0x0F, 0x80, 0xF8, 0x0F,
  0xF0, 0x3E, 0x03, 0xE0, 0x3F, 0xC0, 0xF8, 0x0F, 0x81, 0xEF, 0x01, 0xE0,
  0x3E, 0x07, 0xBE, 0x07, 0xC1, 0xF8, 0x1E, 0xF8, 0x1F, 0x0F, 0xF0, 0xF1,
  0xE0, 0x3F, 0xF9, 0xFF, 0xC7, 0x80, 0xFF, 0xE7, 0xFE, 0x1F, 0x01, 0xFF,
  0x0F, 0xF0, 0x7C, 0x01, 0xF8, 0x1F, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x02, 0x00, 0x03, 0xF8, 0x00, 0x70, 0x00, 0x07, 0xFF, 0x7F,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x07,
  0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x80, 0x03, 0xF0,
  0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x3F,
  0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x03, 0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xC0,
  0x1F, 0xE3, 0xE0, 0x03, 0xF9, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xE7,
  0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x7C,
  0x7C, 0x00, 0x7E, 0x3E, 0x00, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0xF8, 0x00,
  0xFE, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF, 0x80,
  0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xEF,
  0x80, 0x03, 0xF7, 0xC0, 0x03, 0xF3, 0xE0, 0x03, 0xF9, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFC, 0x00, 0xE0, 0xFE, 0x00, 0x08,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x08, 0x1F, 0xF0, 0x1E, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC1, 0xF0, 0x0F, 0xFC,
  0x3E, 0x00, 0x3F, 0x87, 0xC0, 0x03, 0xF8, 0xF8, 0x00, 0x3F, 0x9F, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFD,
  0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xF1, 0xF0, 0x01, 0xFC,
  0x3E, 0x00, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xDF, 0xF8, 0x1F, 0xE0,
  0x03, 0xC0, 0x7F, 0x00, 0x03, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x07, 0xDF,
  0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x1F, 0xC0, 0x00, 0x7C, 0x3F, 0x80,
  0x01, 0xF0, 0x7F, 0x00, 0x07, 0xC1, 0xFF, 0x80, 0x7F, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x3F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE8,
  0x3F, 0xBF, 0xFC, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x0F, 0x80, 0xF8, 0x00,
  0x1F, 0xBE, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x01, 0xF8, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0xC0,
  0xF8, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F,
  0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xE0,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xE7, 0xC0, 0x00, 0xFB, 0xF8, 0x00, 0x3E, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x7E, 0x00, 0x3F, 0x8F, 0x80, 0x0F, 0xC3,
  0xF0, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x0F,
  0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x3E, 0x00, 0xFC,
  0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00,
  0x3F, 0x0F, 0x80, 0x07, 0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x3E,
  0x00, 0x0F, 0xCF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0xF8, 0x00, 0x01, 0xEF, 0xFF, 0xC0, 0x00, 0x1F, 0x7F,
  0xFE, 0x00, 0x00, 0xFB, 0xFE, 0xF8, 0x00, 0x07, 0xBF, 0xF7, 0xC0, 0x00,
  0x7D, 0xFF, 0xBE, 0x00, 0x03, 0xEF, 0xFC, 0xF0, 0x00, 0x1E, 0x7F, 0xE7,
  0xC0, 0x01, 0xF3, 0xFF, 0x3E, 0x00, 0x0F, 0x9F, 0xF8, 0xF0, 0x00, 0x78,
  0xFF, 0xC7, 0xC0, 0x03, 0xC7, 0xFE, 0x3E, 0x00, 0x3E, 0x3F, 0xF0, 0xF0,
  0x01, 0xE1, 0xFF, 0x87, 0xC0, 0x0F, 0x0F, 0xFC, 0x3E, 0x00, 0xF8, 0x7F,
  0xE0, 0xF0, 0x07, 0xC3, 0xFF, 0x07, 0xC0, 0x3C, 0x1F, 0xF8, 0x3E, 0x03,
  0xE0, 0xFF, 0xC1, 0xF0, 0x1F, 0x07, 0xFE, 0x07, 0xC0, 0xF0, 0x3F, 0xF0,
  0x3E, 0x0F, 0x81, 0xFF, 0x81, 0xF0, 0x7C, 0x0F, 0xFC, 0x07, 0x83, 0xC0,
  0x7F, 0xE0, 0x3E, 0x3E, 0x03, 0xFF, 0x01, 0xF1, 0xF0, 0x1F, 0xF8, 0x07,
  0x8F, 0x00, 0xFF, 0xC0, 0x3E, 0x78, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0x3F,
  0xF0, 0x07, 0xBC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xF8,
  0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xFE, 0x00, 0x3E, 0x00,
  0x3F, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xF7, 0xC0,
  0x01, 0xFF, 0x7E, 0x00, 0x1F, 0xFB, 0xE0, 0x01, 0xFF, 0xBF, 0x00, 0x1F,
  0xF9, 0xF0, 0x01, 0xFF, 0x9F, 0x80, 0x1F, 0xF8, 0xF8, 0x01, 0xFF, 0x8F,
  0xC0, 0x1F, 0xF8, 0x7C, 0x01, 0xFF, 0x87, 0xE0, 0x1F, 0xF8, 0x3E, 0x01,
  0xFF, 0x83, 0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xFF, 0x81, 0xF8, 0x1F, 0xF8,
  0x0F, 0x81, 0xFF, 0x80, 0xFC, 0x1F, 0xF8, 0x07, 0xC1, 0xFF, 0x80, 0x7E,
  0x1F, 0xF8, 0x03, 0xE1, 0xFF, 0x80, 0x3F, 0x1F, 0xF8, 0x03, 0xF1, 0xFF,
  0x80, 0x1F, 0x1F, 0xF8, 0x01, 0xF9, 0xFF, 0x80, 0x0F, 0x8F, 0xF8, 0x00,
  0xFC, 0xFF, 0x80, 0x07, 0xCF, 0xF8, 0x00, 0x7E, 0xFF, 0x80, 0x03, 0xEF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8,
  0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC,
  0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0x80, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0x01, 0xFF, 0x3E, 0x00, 0x7E,
  0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xC0,
  0x07, 0xEF, 0x80, 0x1F, 0x9F, 0x00, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7C, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7E, 0x7C,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF8, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x05, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0xFF,
  0xA0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x07, 0xC0, 0x7F, 0xC3, 0xE0, 0x07, 0xF1, 0xF0, 0x01, 0xF8,
  0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x0F,
  0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x03, 0xF3, 0xE0, 0x01, 0xF9, 0xF0, 0x00,
  0xFC, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x1F, 0x00,
  0x3F, 0x0F, 0x80, 0x3F, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3E, 0x07, 0xC0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xE3, 0xE0, 0x01,
  0xF1, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0xBE, 0x00,
  0x07, 0xDF, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFC, 0x01, 0xC7, 0xE0, 0x01,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xEC, 0x00, 0x3F, 0xBF, 0x03, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x03, 0xD0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3E,
  0xFC, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xE7, 0xF0, 0x03, 0xF0, 0xFF, 0x03,
  0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xFC,
  0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07,
  0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x7C, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x1F,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80,
  0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0x7E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F,
  0x8F, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0x8F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xF8,
  0x00, 0x7E, 0x3E, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0xE0,
  0x01, 0xF0, 0x7C, 0x00, 0x7B, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF7, 0xC0,
  0x07, 0xC1, 0xF0, 0x01, 0xE7, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xCF, 0x00,
  0x3E, 0x03, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0x07, 0xC0, 0x1E, 0x3E, 0x00,
  0xF8, 0x0F, 0x80, 0x3C, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x78, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xE1, 0xF0, 0x1F,
  0x00, 0x7C, 0x07, 0x83, 0xE0, 0x3E, 0x00, 0xF8, 0x1F, 0x03, 0xC0, 0xFC,
  0x01, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x01, 0xF0, 0x7C, 0x0F, 0x83, 0xE0,
  0x03, 0xE0, 0xF0, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xE0, 0x3E, 0x0F, 0x80,
  0x0F, 0x87, 0xC0, 0x3C, 0x3F, 0x00, 0x1F, 0x8F, 0x80, 0x7C, 0x7C, 0x00,
  0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3C, 0x01, 0xF1, 0xF0, 0x00,
  0x7C, 0xF8, 0x01, 0xE3, 0xE0, 0x00, 0xF9, 0xF0, 0x03, 0xCF, 0x80, 0x00,
  0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0x80, 0x0F, 0xBE, 0x00, 0x03,
  0xEF, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xDE, 0x00, 0x1E, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC1,
  0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x01,
  0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x00,
  0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x7C,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE1, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFD, 0xF0, 0x00,
  0x1F, 0x3F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F,
  0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x07, 0xC0, 0x0F,
  0xC0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF1, 0xF8,
  0x00, 0x3E, 0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0x80, 0xF0,
  0x01, 0xF0, 0x1F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xE0,
  0x03, 0xC0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x00, 0xF8,
  0x7C, 0x00, 0x0F, 0x1F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1E, 0xF8, 0x00,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x01, 0xFF, 0x80, 0x3F, 0xFF,
  0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0x03, 0xF8, 0x30, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0x01, 0xF3, 0xF0, 0x07, 0xDF,
  0x80, 0x1F, 0x7C, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xC0, 0x1F, 0xDF, 0x00, 0x7F,
  0x7E, 0x07, 0xFD, 0xFF, 0xFD, 0xF3, 0xFF, 0xF3, 0xC7, 0xFF, 0x8F, 0x0F,
  0xF8, 0x3C, 0x03, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0xF8,
  0xFF, 0xE0, 0xF9, 0xFF, 0xF0, 0xFB, 0xFF, 0xF8, 0xFF, 0xC1, 0xFC, 0xFF,
  0x00, 0xFC, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFE,
  0x00, 0x3E, 0xFE, 0x00, 0x7E, 0xFF, 0x00, 0xFC, 0xFF, 0x81, 0xFC, 0xFB,
  0xFF, 0xF8, 0xF9, 0xFF, 0xF8, 0xF8, 0xFF, 0xF0, 0xF0, 0x7F, 0xC0, 0x00,
  0x06, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE1,
  0xFC, 0x1C, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x0E, 0x3F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x03, 0xFC, 0x1F, 0x07, 0xFF, 0x1F, 0x0F, 0xFF, 0x9F, 0x1F,
  0xFF, 0xDF, 0x3F, 0x83, 0xFF, 0x3F, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x3E,
  0x00, 0xFF, 0x3F, 0x81, 0xFF, 0x1F, 0xFF, 0xDF, 0x1F, 0xFF, 0x9F, 0x0F,
  0xFF, 0x1F, 0x03, 0xFE, 0x0F, 0x00, 0x30, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xF8, 0x3F, 0x07, 0xE0,
  0x3F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00,
  0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xDF, 0x00, 0x07,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x41, 0xFC, 0x03, 0x83, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x3F, 0xFF, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0x07,
  0xFF, 0x1F, 0x0F, 0xFF, 0x9F, 0x1F, 0xFF, 0xDF, 0x3F, 0x83, 0xFF, 0x3F,
  0x00, 0xFF, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C,
  0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x3E, 0x00, 0xFF, 0x3F, 0x81, 0xFF, 0x1F,
  0xFF, 0xDF, 0x1F, 0xFF, 0x9F, 0x0F, 0xFF, 0x1F, 0x03, 0xFE, 0x1F, 0x00,
  0x60, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x20,
  0x00, 0xFC, 0x38, 0x01, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x70, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xF8,
  0x3E, 0x3F, 0xF8, 0x7C, 0xFF, 0xF8, 0xFB, 0xFF, 0xF9, 0xFF, 0x87, 0xF3,
  0xFC, 0x03, 0xF7, 0xF0, 0x03, 0xEF, 0xE0, 0x07, 0xDF, 0x80, 0x0F, 0xBF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xC0, 0x7B, 0xEF, 0xFF,
  0xFF, 0xE7, 0x80, 0x00, 0x00, 0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE,
  0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE,
  0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xF8, 0x01, 0xE0, 0x3E, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFF, 0x03,
  0x80, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xBE, 0x00, 0x7C, 0xF8, 0x03, 0xE3,
  0xE0, 0x1F, 0x8F, 0x80, 0x7C, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x83, 0xE0,
  0xFC, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xE0,
  0x0F, 0x9F, 0x00, 0x3E, 0xFE, 0x00, 0xFB, 0xF8, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xCF, 0x80, 0xFE, 0x3E, 0x03, 0xF0, 0x7C, 0x0F, 0x81,
  0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7E,
  0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0xBE,
  0x00, 0x3E, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF0, 0x7F, 0x80, 0x7F, 0xC3, 0xE3, 0xFF, 0x83, 0xFF, 0x8F, 0x9F,
  0xFF, 0x1F, 0xFF, 0x3E, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0x83, 0xFF, 0xC3,
  0xFB, 0xFC, 0x07, 0xFC, 0x07, 0xEF, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0x80, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x00,
  0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0x07,
  0xFE, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x01,
  0xF0, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0x00, 0x1F,
  0xF8, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x07,
  0xC0, 0x07, 0xFE, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x7F,
  0xE0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0x1F,
  0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0x01, 0xFF,
  0x80, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0xF0, 0x3F, 0xC1, 0xF1, 0xFF, 0xC3, 0xE7, 0xFF, 0xC7, 0xDF,
  0xFF, 0xCF, 0xFC, 0x1F, 0xDF, 0xE0, 0x1F, 0xBF, 0x80, 0x1F, 0x7F, 0x00,
  0x3E, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3E, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xC3, 0xF8, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7E, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00,
  0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3F, 0x00,
  0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xF8, 0x3F, 0xC0, 0xF8, 0xFF,
  0xE0, 0xF9, 0xFF, 0xF0, 0xFB, 0xFF, 0xF8, 0xFF, 0xC1, 0xFC, 0xFF, 0x00,
  0xFC, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFE, 0x00,
  0x3E, 0xFE, 0x00, 0x7E, 0xFF, 0x00, 0xFC, 0xFF, 0x81, 0xFC, 0xFB, 0xFF,
  0xF8, 0xF9, 0xFF, 0xF0, 0xF8, 0xFF, 0xE0, 0xF8, 0x7F, 0xC0, 0xF8, 0x0E,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0x07, 0xFF,
  0x1F, 0x0F, 0xFF, 0x9F, 0x1F, 0xFF, 0xDF, 0x3F, 0x83, 0xFF, 0x3F, 0x00,
  0xFF, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00,
  0x7F, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0xFF, 0x3F, 0x81, 0xFF, 0x1F, 0xFF,
  0xDF, 0x1F, 0xFF, 0x9F, 0x0F, 0xFF, 0x1F, 0x03, 0xFE, 0x1F, 0x00, 0x60,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF9,
  0xFF, 0xF9, 0xFE, 0xFB, 0xFE, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x03, 0xFF, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xE0,
  0x3C, 0xF8, 0x01, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0xFD, 0xFF, 0xFF,
  0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x30, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x80,
  0x7F, 0x7F, 0x07, 0xFC, 0xFF, 0xFE, 0xF3, 0xFF, 0xF3, 0xC7, 0xFF, 0x8F,
  0x07, 0xFC, 0x3C, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x0F,
  0xDF, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xE0, 0x03, 0xF1, 0xF0, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0x80,
  0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0x01, 0xE0, 0x07, 0xC1, 0xF0, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00,
  0x1F, 0x1F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0,
  0x00, 0xFB, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0xFB,
  0xE0, 0x03, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xF0, 0x03, 0xE7, 0xC0, 0x1F,
  0xE0, 0x07, 0xCF, 0x80, 0x3F, 0xC0, 0x1F, 0x1F, 0x00, 0x7F, 0x80, 0x3E,
  0x3E, 0x00, 0xFF, 0x80, 0x7C, 0x3E, 0x03, 0xEF, 0x00, 0xF8, 0x7C, 0x07,
  0x9E, 0x01, 0xE0, 0xF8, 0x0F, 0x3C, 0x07, 0xC1, 0xF0, 0x1E, 0x7C, 0x0F,
  0x83, 0xE0, 0x7C, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0xF0, 0x3E, 0x07, 0xC1,
  0xE1, 0xE0, 0xF8, 0x0F, 0x83, 0xC3, 0xE1, 0xF0, 0x1F, 0x0F, 0x87, 0xC3,
  0xE0, 0x1F, 0x1F, 0x07, 0x87, 0xC0, 0x3E, 0x3C, 0x0F, 0x0F, 0x00, 0x7C,
  0x78, 0x1E, 0x3E, 0x00, 0xF8, 0xF0, 0x3E, 0x7C, 0x00, 0xF3, 0xE0, 0x7C,
  0xF8, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x03, 0xEF, 0x00, 0xF3, 0xC0, 0x07,
  0xDE, 0x01, 0xEF, 0x80, 0x0F, 0xBC, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3E, 0x7E, 0x00,
  0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x81,
  0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xE7,
  0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xEF,
  0xC0, 0x07, 0xE7, 0xC0, 0x07, 0xC7, 0xE0, 0x0F, 0xC3, 0xE0, 0x0F, 0x83,
  0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00,
  0xFC, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xE0,
  0x01, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x1F,
  0x00, 0x7E, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0,
  0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0xF7, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x03, 0xF0,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0xBF, 0xFC, 0x00, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xF6, 0x00, 0x7F, 0xF2, 0x00, 0x0F, 0xF0,
};

const GFXglyph NotoSans_Condensed_Regular61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 7, 45, 15, 4, -44 },
  { 41, 16, 16, 24, 4, -44 },
  { 73, 29, 44, 31, 1, -44 },
  { 233, 23, 50, 29, 3, -46 },
  { 377, 38, 45, 44, 3, -44 },
  { 591, 32, 45, 34, 2, -44 },
  { 771, 5, 16, 13, 4, -44 },
  { 781, 13, 54, 18, 3, -44 },
  { 869, 13, 54, 18, 2, -44 },
  { 957, 23, 22, 27, 2, -46 },
  { 1021, 25, 29, 29, 2, -36 },
  { 1112, 9, 15, 15, 2, -7 },
  { 1129, 14, 5, 18, 2, -19 },
  { 1138, 7, 8, 15, 4, -7 },
  { 1145, 21, 44, 23, 1, -44 },
  { 1261, 23, 45, 29, 3, -44 },
  { 1391, 15, 44, 29, 4, -44 },
  { 1474, 24, 44, 29, 2, -44 },
  { 1606, 24, 45, 29, 2, -44 },
  { 1741, 27, 44, 29, 1, -44 },
  { 1890, 23, 45, 29, 3, -44 },
  { 2020, 23, 45, 29, 3, -44 },
  { 2150, 24, 44, 29, 2, -44 },
  { 2282, 24, 45, 29, 2, -44 },
  { 2417, 24, 45, 29, 2, -44 },
  { 2552, 7, 34, 15, 4, -33 },
  { 2582, 9, 41, 15, 2, -33 },
  { 2629, 25, 28, 29, 2, -36 },
  { 2717, 24, 17, 29, 2, -30 },
  { 2768, 25, 28, 29, 2, -36 },
  { 2856, 19, 45, 22, 1, -44 },
  { 2963, 38, 49, 44, 3, -44 },
  { 3196, 31, 44, 31, 0, -44 },
  { 3367, 25, 44, 32, 5, -44 },
  { 3505, 26, 45, 31, 3, -44 },
  { 3652, 27, 44, 35, 5, -44 },
  { 3801, 19, 44, 27, 5, -44 },
  { 3906, 19, 44, 26, 5, -44 },
  { 4011, 30, 45, 37, 3, -44 },
  { 4180, 26, 44, 36, 5, -44 },
  { 4323, 14, 44, 18, 2, -44 },
  { 4400, 14, 56, 15, -4, -44 },
  { 4498, 26, 44, 30, 5, -44 },
  { 4641, 19, 44, 25, 5, -44 },
  { 4746, 37, 44, 47, 5, -44 },
  { 4950, 28, 44, 38, 5, -44 },
  { 5104, 32, 45, 38, 3, -44 },
  { 5284, 23, 44, 30, 5, -44 },
  { 5411, 32, 54, 38, 3, -44 },
  { 5627, 25, 44, 31, 5, -44 },
  { 5765, 22, 45, 28, 3, -44 },
  { 5889, 25, 44, 26, 1, -44 },
  { 6027, 26, 45, 36, 5, -44 },
  { 6174, 30, 44, 30, 0, -44 },
  { 6339, 47, 44, 48, 0, -44 },
  { 6598, 27, 44, 28, 0, -44 },
  { 6747, 27, 44, 27, 0, -44 },
  { 6896, 22, 44, 26, 2, -44 },
  { 7017, 13, 54, 19, 5, -44 },
  { 7105, 21, 44, 23, 1, -44 },
  { 7221, 13, 54, 19, 2, -44 },
  { 7309, 27, 25, 29, 1, -44 },
  { 7394, 27, 4, 27, 0, 5 },
  { 7408, 12, 10, 16, 2, -47 },
  { 7423, 22, 34, 28, 2, -33 },
  { 7517, 24, 47, 31, 4, -46 },
  { 7658, 19, 34, 24, 3, -33 },
  { 7739, 24, 47, 31, 3, -46 },
  { 7880, 23, 34, 28, 3, -33 },
  { 7978, 18, 47, 17, 1, -47 },
  { 8084, 24, 48, 31, 3, -33 },
  { 8228, 23, 46, 31, 4, -46 },
  { 8361, 6, 45, 14, 4, -45 },
  { 8395, 12, 60, 14, -2, -45 },
  { 8485, 22, 46, 27, 4, -46 },
  { 8612, 5, 46, 14, 4, -46 },
  { 8641, 38, 33, 46, 4, -33 },
  { 8798, 23, 33, 31, 4, -33 },
  { 8893, 24, 34, 30, 3, -33 },
  { 8995, 24, 48, 31, 4, -33 },
  { 9139, 24, 48, 31, 3, -33 },
  { 9283, 16, 33, 21, 4, -33 },
  { 9349, 19, 34, 23, 2, -33 },
  { 9430, 16, 41, 18, 1, -40 },
  { 9512, 22, 34, 31, 4, -33 },
  { 9606, 25, 33, 25, 0, -33 },
  { 9710, 39, 33, 40, 1, -33 },
  { 9871, 24, 33, 26, 1, -33 },
  { 9970, 25, 48, 25, 0, -33 },
  { 10120, 18, 33, 22, 2, -33 },
  { 10195, 18, 54, 22, 2, -44 },
  { 10317, 5, 61, 27, 11, -46 },
  { 10356, 18, 54, 22, 2, -44 },
  { 10478, 25, 7, 29, 2, -25 },
};

const GFXfont NotoSans_Condensed_Regular61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular61pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_CONDENSED_REGULAR61PT7B_H_
