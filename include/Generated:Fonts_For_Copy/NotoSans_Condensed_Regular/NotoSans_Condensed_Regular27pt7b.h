#ifndef _NOTOSANS_CONDENSED_REGULAR27PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0xB6, 0xDB, 0x6C, 0x80, 0xFF, 0x80, 0xCF, 0x9F, 0x1E,
  0x3C, 0x78, 0xB1, 0x00, 0x0C, 0x60, 0xC4, 0x08, 0xC0, 0x8C, 0x18, 0xCF,
  0xFF, 0xFF, 0xF1, 0x88, 0x18, 0x81, 0x18, 0x11, 0x8F, 0xFF, 0xFF, 0xF3,
  0x18, 0x31, 0x03, 0x10, 0x23, 0x02, 0x30, 0x63, 0x00, 0x04, 0x00, 0x80,
  0x10, 0x1F, 0xE7, 0xFC, 0xC8, 0xB1, 0x06, 0x20, 0xE4, 0x0E, 0x80, 0xF0,
  0x0F, 0x80, 0x7C, 0x09, 0x81, 0x38, 0x27, 0x04, 0xDC, 0xFB, 0xFE, 0x0E,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x04, 0x3E, 0x0C, 0x1B, 0x06, 0x18,
  0xC6, 0x0C, 0x63, 0x06, 0x31, 0x83, 0x19, 0x81, 0x8C, 0xC0, 0xC6, 0xCE,
  0x63, 0x6F, 0x9B, 0x36, 0x6F, 0xB2, 0x31, 0x1B, 0x18, 0x19, 0x8C, 0x0C,
  0xC6, 0x04, 0x63, 0x06, 0x11, 0x83, 0x0C, 0xC3, 0x06, 0xC1, 0x81, 0xE0,
  0x04, 0x00, 0x7C, 0x03, 0xB8, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x38,
  0x0E, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1D, 0x86, 0xE3, 0x3B, 0x8E,
  0xCC, 0x1F, 0x30, 0x3C, 0xE0, 0xE3, 0x87, 0xC7, 0xFB, 0x8F, 0xC7, 0xFF,
  0xFC, 0x1C, 0x63, 0x0C, 0x71, 0x86, 0x18, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x18, 0x61, 0x87, 0x0C, 0x38, 0x60, 0xC0, 0xC1, 0x87, 0x0C, 0x30, 0x61,
  0x86, 0x18, 0x71, 0xC7, 0x1C, 0x71, 0x86, 0x18, 0x63, 0x8C, 0x71, 0x8C,
  0x00, 0x0C, 0x03, 0x00, 0xC2, 0x31, 0xFF, 0xFF, 0xF1, 0xE0, 0xF8, 0x33,
  0x1C, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x3F, 0xF8,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x77, 0x66, 0xEC, 0xC0,
  0xFF, 0xF0, 0xFF, 0x80, 0x01, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0xC0,
  0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0,
  0x70, 0x18, 0x0E, 0x00, 0x04, 0x07, 0xE0, 0xFE, 0x38, 0xE6, 0x0C, 0xC1,
  0xB8, 0x37, 0x06, 0xE0, 0xD8, 0x1F, 0x03, 0xE0, 0x7E, 0x0D, 0xC1, 0xB8,
  0x33, 0x06, 0x61, 0xCE, 0x30, 0xFE, 0x0F, 0x80, 0x0C, 0x77, 0xFB, 0xCC,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0x08,
  0x1F, 0xCF, 0xF9, 0x07, 0x01, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0xE0,
  0x30, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x18, 0x0F, 0xFF, 0xFF,
  0x04, 0x1F, 0xCF, 0x79, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x03, 0x8F,
  0x83, 0xF0, 0x0E, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x7F, 0xFB,
  0xFC, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x2C, 0x06, 0xC0, 0xCC, 0x0C, 0xC1,
  0x8C, 0x18, 0xC3, 0x0C, 0x30, 0xC6, 0x0C, 0x60, 0xCF, 0xFF, 0xFF, 0xF0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x7F, 0x9F, 0xE6, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0xF8, 0x7F, 0x90, 0xF0, 0x1C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x07, 0x81, 0xFF, 0xE7, 0xF0, 0x01, 0x01, 0xF0, 0x7A, 0x1C, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xEF, 0x1F, 0xF3, 0xC7, 0x70, 0x6E, 0x0D,
  0xC1, 0xF8, 0x3B, 0x06, 0x60, 0xCE, 0x38, 0xFE, 0x0F, 0x80, 0xFF, 0xFF,
  0xFC, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0,
  0x00, 0x04, 0x07, 0xF1, 0xCF, 0x30, 0x66, 0x0C, 0xC1, 0x98, 0x33, 0x8E,
  0x3B, 0x83, 0xE0, 0x7C, 0x39, 0xC6, 0x1D, 0xC1, 0xB0, 0x3E, 0x07, 0xE0,
  0xFC, 0x19, 0xFF, 0x1F, 0x80, 0x04, 0x0F, 0xC7, 0xF9, 0x86, 0xE0, 0xF0,
  0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x37, 0x1D, 0xFF, 0x1C, 0xC0, 0x30, 0x0C,
  0x07, 0x01, 0x80, 0xE7, 0xF1, 0xF8, 0x5F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x27, 0x76, 0x00, 0x00, 0x00, 0x00, 0x76, 0x66, 0xCC, 0xC0, 0x00, 0x20,
  0x1C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x30, 0x02, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x80, 0x1C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x60, 0x08, 0x00, 0x08, 0x7F, 0x9F, 0xC8,
  0x70, 0x18, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x03, 0x03, 0x81, 0x80, 0xC0,
  0x60, 0x00, 0x00, 0x0C, 0x0E, 0x03, 0x00, 0x03, 0xF8, 0x07, 0x8E, 0x07,
  0x01, 0x87, 0x00, 0x63, 0x00, 0x33, 0x0F, 0x8D, 0x8E, 0xC6, 0xCE, 0x63,
  0x46, 0x31, 0xE3, 0x18, 0xF1, 0x8C, 0x78, 0xC6, 0x3C, 0x63, 0x1E, 0x31,
  0x8D, 0x8F, 0xFC, 0xC7, 0x9C, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0xC7, 0x00, 0x7F, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x03, 0x60, 0x0D,
  0x80, 0x33, 0x00, 0xCC, 0x06, 0x30, 0x18, 0xE0, 0x61, 0x83, 0x86, 0x0F,
  0xFC, 0x3F, 0xF0, 0xC0, 0xC7, 0x03, 0x18, 0x0E, 0x60, 0x1B, 0x80, 0x6E,
  0x01, 0xC0, 0xFF, 0x9F, 0xFB, 0x07, 0x60, 0x7C, 0x0F, 0x81, 0xF0, 0x36,
  0x0E, 0xFF, 0x9F, 0xF3, 0x07, 0x60, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x07,
  0xC1, 0xDF, 0xFB, 0xFC, 0x00, 0x01, 0x00, 0xFF, 0x1F, 0xE3, 0x80, 0x30,
  0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0xC1, 0x1F, 0xE0, 0xFE, 0xFF,
  0x0F, 0xFC, 0xC1, 0xEC, 0x0E, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x6C, 0x0E, 0xC1,
  0xCF, 0xF8, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xFF, 0x7F, 0xB0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x7F, 0xBF, 0xD8, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x00,
  0x00, 0x80, 0x3F, 0xE1, 0xFF, 0x8E, 0x02, 0x30, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x0F, 0xF8, 0x3F, 0x60, 0x1D, 0x80,
  0x76, 0x01, 0xDC, 0x07, 0x38, 0x1C, 0xF0, 0x71, 0xFF, 0xC1, 0xFE, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x30, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x31, 0xEF, 0xC0, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x7F,
  0xFE, 0xC0, 0xEC, 0x0C, 0xC1, 0x8C, 0x38, 0xC3, 0x0C, 0x60, 0xCE, 0x0C,
  0xC0, 0xDC, 0x0F, 0xC0, 0xFE, 0x0E, 0x60, 0xC7, 0x0C, 0x38, 0xC3, 0x8C,
  0x1C, 0xC0, 0xCC, 0x0E, 0xC0, 0x70, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x7F, 0xFF, 0xE0, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFB, 0x01,
  0xBD, 0x80, 0xDE, 0xC0, 0x6F, 0x70, 0x67, 0x98, 0x33, 0xCC, 0x19, 0xE7,
  0x18, 0xF1, 0x8C, 0x78, 0xC6, 0x3C, 0x66, 0x1E, 0x1B, 0x0F, 0x0D, 0x87,
  0x87, 0xC3, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x60, 0xE0, 0x1F, 0x80,
  0xFC, 0x07, 0xF0, 0x3D, 0x81, 0xEE, 0x0F, 0x30, 0x79, 0xC3, 0xC6, 0x1E,
  0x38, 0xF0, 0xC7, 0x87, 0x3C, 0x19, 0xE0, 0xEF, 0x03, 0x78, 0x1F, 0xC0,
  0x7E, 0x03, 0xF0, 0x0E, 0x01, 0x00, 0x3F, 0x81, 0xFF, 0x0E, 0x0E, 0x70,
  0x19, 0xC0, 0x76, 0x01, 0xD8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0x60, 0x0D, 0x80, 0x36, 0x01, 0xDC, 0x07, 0x30, 0x18, 0xE0, 0xE1,
  0xFF, 0x03, 0xF8, 0xFF, 0x3F, 0xEC, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC1, 0xFF, 0xEF, 0xF3, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x00, 0x01, 0x00, 0x3F, 0x81, 0xFF, 0x0E, 0x0E, 0x70, 0x19,
  0xC0, 0x76, 0x01, 0xD8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0x60, 0x0D, 0x80, 0x36, 0x01, 0xDC, 0x07, 0x30, 0x18, 0xE0, 0xE1, 0xFF,
  0x03, 0xF8, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0xFF,
  0x1F, 0xF3, 0x07, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x0E, 0xC3, 0x9F,
  0xF3, 0xF8, 0x63, 0x8C, 0x31, 0x87, 0x30, 0x66, 0x0E, 0xC0, 0xD8, 0x1F,
  0x01, 0x80, 0x04, 0x0F, 0xF7, 0xFD, 0x81, 0xE0, 0x38, 0x0E, 0x01, 0x80,
  0x78, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xE0,
  0x7F, 0xFB, 0xFC, 0xFF, 0xFF, 0xFC, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x06, 0x70, 0xE7, 0xFC, 0x1F, 0x80, 0xE0,
  0x1F, 0x01, 0xD8, 0x0C, 0xC0, 0x67, 0x07, 0x18, 0x38, 0xC1, 0x86, 0x0C,
  0x38, 0xE0, 0xC7, 0x06, 0x30, 0x39, 0x80, 0xDC, 0x06, 0xC0, 0x36, 0x01,
  0xB0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0xE0, 0x70, 0x3B, 0x03, 0x81, 0xD8,
  0x1C, 0x0C, 0xC0, 0xB0, 0x67, 0x0D, 0x83, 0x38, 0x6C, 0x38, 0xC3, 0x61,
  0x86, 0x1B, 0x0C, 0x31, 0x8C, 0x61, 0xCC, 0x67, 0x06, 0x63, 0x38, 0x33,
  0x19, 0x81, 0x98, 0x6C, 0x0D, 0x83, 0x60, 0x3C, 0x1F, 0x01, 0xE0, 0xF0,
  0x0F, 0x07, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x60, 0x77, 0x06, 0x30,
  0xE3, 0x8C, 0x19, 0xC1, 0xD8, 0x0F, 0x80, 0xF0, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xF8, 0x1D, 0x81, 0x9C, 0x38, 0xC3, 0x0E, 0x70, 0x66, 0x06, 0xE0,
  0x70, 0xE0, 0x76, 0x06, 0x70, 0xE3, 0x0C, 0x30, 0xC3, 0x9C, 0x19, 0x81,
  0x98, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xFF, 0xFF, 0xF0, 0x18, 0x0E, 0x03,
  0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x07,
  0x01, 0x80, 0xE0, 0x3F, 0xFF, 0xFC, 0xFF, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xC0,
  0xE0, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03,
  0x00, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x1C,
  0xFC, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1F, 0xFF, 0xC0, 0x0C, 0x01, 0xC0, 0x78, 0x0D, 0x83,
  0x30, 0x63, 0x1C, 0x63, 0x06, 0x60, 0xD8, 0x0F, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xE3, 0x0C, 0x30, 0x80, 0x0E, 0x1F, 0xE2, 0x38, 0x06, 0x01, 0xC0,
  0x70, 0xFC, 0xFF, 0x71, 0xF8, 0x7C, 0x1F, 0x07, 0xE3, 0xDF, 0xB7, 0xCC,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x33, 0x86, 0xFC, 0xF3,
  0x9C, 0x3B, 0x03, 0x60, 0x6C, 0x0D, 0x81, 0xF0, 0x36, 0x06, 0xC0, 0xDC,
  0x1B, 0x87, 0x7F, 0xCD, 0xF0, 0x0F, 0x1F, 0xDE, 0x4C, 0x06, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x07, 0x01, 0xFC, 0x7E, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC3, 0x19, 0xFB, 0x71, 0xEC, 0x1D,
  0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xEC, 0x1D, 0xC3,
  0x9F, 0xB3, 0xE6, 0x0E, 0x0F, 0xE7, 0x19, 0x83, 0x60, 0xF8, 0x3F, 0xFF,
  0xFF, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x4F, 0xF1, 0xF8, 0x06, 0x1F,
  0x19, 0x38, 0x38, 0x38, 0x3E, 0xFE, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x0C, 0x67, 0xED, 0xC7, 0xB0,
  0x76, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xB0, 0x77,
  0x0E, 0x7E, 0xCF, 0x98, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x3F, 0xE7, 0xF8,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0xE3, 0x7E, 0xF3, 0xB8,
  0x7C, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xC0, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x18, 0xC6, 0x00, 0x0C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0xFF,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x1B, 0x0E, 0xC3,
  0x31, 0x8C, 0xE3, 0x70, 0xD8, 0x3F, 0x0E, 0xC3, 0x38, 0xC6, 0x31, 0xCC,
  0x33, 0x0E, 0xC1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xCE, 0x1C,
  0x6F, 0x9F, 0xBC, 0xF9, 0xDC, 0x38, 0x6C, 0x1C, 0x3E, 0x0C, 0x1F, 0x06,
  0x0F, 0x83, 0x07, 0xC1, 0x83, 0xE0, 0xC1, 0xF0, 0x60, 0xF8, 0x30, 0x7C,
  0x18, 0x3E, 0x0C, 0x1F, 0x06, 0x0E, 0xCE, 0x37, 0xEF, 0x3B, 0x87, 0xC1,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0C, 0x0E, 0x07, 0xF1, 0xC7, 0x30, 0x66, 0x0F, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xB0, 0x77, 0x0C, 0x7F, 0x07, 0xC0, 0xCE, 0x1B,
  0xF3, 0xC6, 0x70, 0xEC, 0x0D, 0x81, 0xB0, 0x36, 0x07, 0xC0, 0xD8, 0x1B,
  0x03, 0x70, 0x6E, 0x1D, 0xFF, 0x37, 0xC6, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0x0C, 0x67, 0xED, 0xC7, 0xB0, 0x76, 0x0F, 0xC1, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xB0, 0x77, 0x0E, 0x7E, 0xCF, 0x98,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0xCF, 0xBF, 0xEF, 0x0E,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x00, 0x1E, 0x7F,
  0xE3, 0xC0, 0xC0, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x03, 0x03, 0x83, 0xFF,
  0xFE, 0x10, 0x20, 0xC1, 0xFF, 0xE6, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x1C, 0x3E, 0x3C, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE3, 0xDF, 0xB7, 0xCC,
  0xC0, 0x7C, 0x1D, 0x83, 0x30, 0x66, 0x0C, 0x63, 0x8C, 0x61, 0x8C, 0x39,
  0x83, 0x60, 0x6C, 0x0D, 0x80, 0xB0, 0x1C, 0x03, 0x80, 0xE0, 0xC1, 0xD8,
  0x70, 0x66, 0x1E, 0x19, 0x87, 0x86, 0x61, 0xE3, 0x9C, 0xD8, 0xC3, 0x33,
  0x30, 0xCC, 0xCC, 0x33, 0x33, 0x0C, 0x8D, 0x81, 0xE3, 0x60, 0x78, 0x78,
  0x1E, 0x1E, 0x07, 0x87, 0x00, 0xC1, 0xC0, 0x60, 0xEE, 0x18, 0xC7, 0x1C,
  0xC1, 0xB8, 0x3E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xE0, 0x6E, 0x1C, 0xC3,
  0x1C, 0xE1, 0xB8, 0x38, 0xC0, 0x7C, 0x1D, 0x83, 0x30, 0x67, 0x0C, 0x63,
  0x8C, 0x61, 0x8C, 0x19, 0x83, 0x60, 0x6C, 0x0D, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x5C, 0x0F, 0x00, 0xFF, 0xFF, 0x06,
  0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60, 0xE0, 0xFF, 0xFF,
  0x0F, 0x1F, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x70, 0xC0,
  0x70, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x0F, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0xF0, 0x38, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x0E, 0x07, 0x0E, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x38, 0xF0, 0xE0, 0x7C, 0x3F, 0xFE, 0x1F, 0x00,
};

const GFXglyph NotoSans_Condensed_Regular27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 19, 7, 2, -19 },
  { 9, 7, 7, 10, 2, -19 },
  { 16, 12, 19, 14, 1, -19 },
  { 45, 11, 23, 13, 1, -21 },
  { 77, 17, 20, 19, 1, -20 },
  { 120, 14, 20, 15, 1, -20 },
  { 155, 2, 7, 6, 2, -19 },
  { 157, 6, 23, 8, 1, -19 },
  { 175, 6, 23, 8, 1, -19 },
  { 193, 10, 10, 12, 1, -21 },
  { 206, 11, 13, 13, 1, -16 },
  { 224, 4, 7, 6, 1, -3 },
  { 228, 6, 2, 8, 1, -8 },
  { 230, 3, 3, 6, 2, -3 },
  { 232, 10, 19, 10, 0, -19 },
  { 256, 11, 20, 13, 1, -20 },
  { 284, 6, 19, 13, 2, -19 },
  { 299, 10, 20, 13, 1, -20 },
  { 324, 10, 20, 13, 1, -20 },
  { 349, 12, 19, 13, 0, -19 },
  { 378, 10, 19, 13, 1, -19 },
  { 402, 11, 20, 13, 1, -20 },
  { 430, 11, 19, 13, 1, -19 },
  { 457, 11, 20, 13, 1, -20 },
  { 485, 10, 20, 13, 1, -20 },
  { 510, 3, 15, 6, 2, -15 },
  { 516, 4, 19, 6, 1, -15 },
  { 526, 11, 13, 13, 1, -16 },
  { 544, 11, 7, 13, 1, -13 },
  { 554, 11, 13, 13, 1, -16 },
  { 572, 9, 20, 10, 0, -20 },
  { 595, 17, 21, 20, 1, -19 },
  { 640, 14, 19, 14, 0, -19 },
  { 674, 11, 19, 14, 2, -19 },
  { 701, 12, 20, 14, 1, -20 },
  { 731, 12, 19, 16, 2, -19 },
  { 760, 9, 19, 12, 2, -19 },
  { 782, 9, 19, 11, 2, -19 },
  { 804, 14, 20, 16, 1, -20 },
  { 839, 12, 19, 16, 2, -19 },
  { 868, 6, 19, 8, 1, -19 },
  { 883, 6, 24, 6, -2, -19 },
  { 901, 12, 19, 13, 2, -19 },
  { 930, 9, 19, 11, 2, -19 },
  { 952, 17, 19, 21, 2, -19 },
  { 993, 13, 19, 17, 2, -19 },
  { 1024, 14, 20, 17, 1, -20 },
  { 1059, 10, 19, 13, 2, -19 },
  { 1083, 14, 25, 17, 1, -20 },
  { 1127, 11, 19, 14, 2, -19 },
  { 1154, 10, 20, 12, 1, -20 },
  { 1179, 11, 19, 12, 0, -19 },
  { 1206, 12, 19, 16, 2, -19 },
  { 1235, 13, 19, 13, 0, -19 },
  { 1266, 21, 19, 21, 0, -19 },
  { 1316, 12, 19, 12, 0, -19 },
  { 1345, 12, 19, 12, 0, -19 },
  { 1374, 10, 19, 11, 1, -19 },
  { 1398, 6, 23, 9, 2, -19 },
  { 1416, 10, 19, 10, 0, -19 },
  { 1440, 6, 23, 9, 1, -19 },
  { 1458, 11, 11, 13, 1, -19 },
  { 1474, 12, 2, 12, 0, 2 },
  { 1477, 5, 5, 7, 1, -21 },
  { 1481, 10, 15, 12, 1, -15 },
  { 1500, 11, 21, 14, 2, -21 },
  { 1529, 9, 15, 10, 1, -15 },
  { 1546, 11, 21, 14, 1, -21 },
  { 1575, 10, 15, 12, 1, -15 },
  { 1594, 8, 21, 8, 0, -21 },
  { 1615, 11, 21, 14, 1, -15 },
  { 1644, 10, 21, 14, 2, -21 },
  { 1671, 2, 20, 6, 2, -20 },
  { 1676, 5, 26, 6, -1, -20 },
  { 1693, 10, 21, 12, 2, -21 },
  { 1720, 2, 21, 6, 2, -21 },
  { 1726, 17, 15, 20, 2, -15 },
  { 1758, 10, 15, 14, 2, -15 },
  { 1777, 11, 15, 13, 1, -15 },
  { 1798, 11, 21, 14, 2, -15 },
  { 1827, 11, 21, 14, 1, -15 },
  { 1856, 7, 15, 9, 2, -15 },
  { 1870, 8, 15, 10, 1, -15 },
  { 1885, 7, 18, 8, 0, -18 },
  { 1901, 10, 15, 14, 2, -15 },
  { 1920, 11, 15, 11, 0, -15 },
  { 1941, 18, 15, 18, 0, -15 },
  { 1975, 11, 15, 11, 0, -15 },
  { 1996, 11, 21, 11, 0, -15 },
  { 2025, 8, 15, 10, 1, -15 },
  { 2040, 8, 23, 10, 1, -19 },
  { 2063, 2, 27, 12, 5, -21 },
  { 2070, 8, 23, 10, 1, -19 },
  { 2093, 11, 3, 13, 1, -11 },
};

const GFXfont NotoSans_Condensed_Regular27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular27pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_CONDENSED_REGULAR27PT7B_H_
