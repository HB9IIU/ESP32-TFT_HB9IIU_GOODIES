#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_Condensed_Regular
// Headers: 67

#include "NotoSans_Condensed_Regular6pt7b.h"
#include "NotoSans_Condensed_Regular7pt7b.h"
#include "NotoSans_Condensed_Regular8pt7b.h"
#include "NotoSans_Condensed_Regular9pt7b.h"
#include "NotoSans_Condensed_Regular10pt7b.h"
#include "NotoSans_Condensed_Regular11pt7b.h"
#include "NotoSans_Condensed_Regular12pt7b.h"
#include "NotoSans_Condensed_Regular13pt7b.h"
#include "NotoSans_Condensed_Regular14pt7b.h"
#include "NotoSans_Condensed_Regular15pt7b.h"
#include "NotoSans_Condensed_Regular16pt7b.h"
#include "NotoSans_Condensed_Regular17pt7b.h"
#include "NotoSans_Condensed_Regular18pt7b.h"
#include "NotoSans_Condensed_Regular19pt7b.h"
#include "NotoSans_Condensed_Regular20pt7b.h"
#include "NotoSans_Condensed_Regular21pt7b.h"
#include "NotoSans_Condensed_Regular22pt7b.h"
#include "NotoSans_Condensed_Regular23pt7b.h"
#include "NotoSans_Condensed_Regular24pt7b.h"
#include "NotoSans_Condensed_Regular25pt7b.h"
#include "NotoSans_Condensed_Regular26pt7b.h"
#include "NotoSans_Condensed_Regular27pt7b.h"
#include "NotoSans_Condensed_Regular28pt7b.h"
#include "NotoSans_Condensed_Regular29pt7b.h"
#include "NotoSans_Condensed_Regular30pt7b.h"
#include "NotoSans_Condensed_Regular31pt7b.h"
#include "NotoSans_Condensed_Regular32pt7b.h"
#include "NotoSans_Condensed_Regular33pt7b.h"
#include "NotoSans_Condensed_Regular34pt7b.h"
#include "NotoSans_Condensed_Regular35pt7b.h"
#include "NotoSans_Condensed_Regular36pt7b.h"
#include "NotoSans_Condensed_Regular37pt7b.h"
#include "NotoSans_Condensed_Regular38pt7b.h"
#include "NotoSans_Condensed_Regular39pt7b.h"
#include "NotoSans_Condensed_Regular40pt7b.h"
#include "NotoSans_Condensed_Regular41pt7b.h"
#include "NotoSans_Condensed_Regular42pt7b.h"
#include "NotoSans_Condensed_Regular43pt7b.h"
#include "NotoSans_Condensed_Regular44pt7b.h"
#include "NotoSans_Condensed_Regular45pt7b.h"
#include "NotoSans_Condensed_Regular46pt7b.h"
#include "NotoSans_Condensed_Regular47pt7b.h"
#include "NotoSans_Condensed_Regular48pt7b.h"
#include "NotoSans_Condensed_Regular49pt7b.h"
#include "NotoSans_Condensed_Regular50pt7b.h"
#include "NotoSans_Condensed_Regular51pt7b.h"
#include "NotoSans_Condensed_Regular52pt7b.h"
#include "NotoSans_Condensed_Regular53pt7b.h"
#include "NotoSans_Condensed_Regular54pt7b.h"
#include "NotoSans_Condensed_Regular55pt7b.h"
#include "NotoSans_Condensed_Regular56pt7b.h"
#include "NotoSans_Condensed_Regular57pt7b.h"
#include "NotoSans_Condensed_Regular58pt7b.h"
#include "NotoSans_Condensed_Regular59pt7b.h"
#include "NotoSans_Condensed_Regular60pt7b.h"
#include "NotoSans_Condensed_Regular61pt7b.h"
#include "NotoSans_Condensed_Regular62pt7b.h"
#include "NotoSans_Condensed_Regular63pt7b.h"
#include "NotoSans_Condensed_Regular64pt7b.h"
#include "NotoSans_Condensed_Regular65pt7b.h"
#include "NotoSans_Condensed_Regular66pt7b.h"
#include "NotoSans_Condensed_Regular67pt7b.h"
#include "NotoSans_Condensed_Regular68pt7b.h"
#include "NotoSans_Condensed_Regular69pt7b.h"
#include "NotoSans_Condensed_Regular70pt7b.h"
#include "NotoSans_Condensed_Regular71pt7b.h"
#include "NotoSans_Condensed_Regular72pt7b.h"
