#ifndef _NOTOSANS_CONDENSED_REGULAR41PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x76, 0x66, 0x66, 0x60,
  0x00, 0x6F, 0xFF, 0xF0, 0xF0, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE1,
  0xDC, 0x3B, 0x87, 0x70, 0xEE, 0x1C, 0x01, 0x83, 0x80, 0x70, 0x60, 0x0E,
  0x0C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xC1, 0xC0, 0x18,
  0x38, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x83, 0x87, 0x00, 0x70,
  0xE0, 0x0C, 0x1C, 0x01, 0x83, 0x80, 0x70, 0x60, 0x0E, 0x0C, 0x01, 0xC3,
  0x83, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0xC1, 0xC0, 0x18, 0x30, 0x07, 0x06,
  0x00, 0xE0, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0C, 0x1C,
  0x01, 0x83, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x1F,
  0xFC, 0x3F, 0xFE, 0x7D, 0xBC, 0xF1, 0x84, 0xE1, 0x80, 0xE1, 0x80, 0xE1,
  0x80, 0xE1, 0x80, 0xF1, 0x80, 0x79, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x0F,
  0xF0, 0x01, 0xFC, 0x01, 0xBE, 0x01, 0x9E, 0x01, 0x8E, 0x01, 0x8F, 0x01,
  0x8F, 0x01, 0x8E, 0x81, 0x8E, 0xE1, 0xBE, 0xFF, 0xFC, 0xFF, 0xF0, 0x1F,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x0F, 0xC0, 0x1C, 0x07, 0xF8, 0x0E, 0x01, 0xCE, 0x03, 0x80, 0xE1, 0x80,
  0xE0, 0x38, 0x70, 0x70, 0x0E, 0x1C, 0x1C, 0x03, 0x87, 0x0E, 0x00, 0xE1,
  0xC3, 0x80, 0x38, 0x70, 0xC0, 0x0E, 0x1C, 0x70, 0x03, 0x87, 0x1C, 0x00,
  0xE1, 0xCE, 0x3C, 0x38, 0x73, 0x9F, 0xCE, 0x18, 0xCF, 0xF1, 0xCE, 0x73,
  0x8E, 0x7F, 0x9C, 0xC3, 0x8F, 0xCE, 0x70, 0xE0, 0xC3, 0x9C, 0x18, 0x01,
  0xC7, 0x06, 0x00, 0x71, 0xC1, 0xC0, 0x1C, 0x70, 0x70, 0x0E, 0x1C, 0x1C,
  0x03, 0x87, 0x06, 0x01, 0xC1, 0xC3, 0x80, 0x70, 0x30, 0xE0, 0x18, 0x0E,
  0x38, 0x0E, 0x03, 0x9C, 0x03, 0x80, 0x7F, 0x01, 0xC0, 0x0F, 0x80, 0x01,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0x8F, 0x00, 0x1C, 0x1C,
  0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00,
  0x78, 0xF0, 0x00, 0xE3, 0x80, 0x03, 0xDE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x1E, 0xE0, 0x70, 0xF3, 0xC1,
  0xC7, 0x87, 0x8F, 0x1E, 0x0F, 0x3C, 0x70, 0x3C, 0xE3, 0xC0, 0x7F, 0x8F,
  0x00, 0xFC, 0x3C, 0x01, 0xF0, 0x70, 0x07, 0x81, 0xE0, 0x3F, 0x07, 0xC1,
  0xFE, 0x0F, 0xFF, 0xBC, 0x1F, 0xF8, 0xF8, 0x3F, 0xC1, 0xF0, 0xF7, 0x77,
  0x77, 0x77, 0x77, 0x07, 0x87, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0,
  0x78, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x38, 0x1E, 0x0F, 0x03, 0x81,
  0xE0, 0x70, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0E, 0x07, 0x81,
  0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0xF0, 0x78, 0x3C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x03,
  0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x38, 0x38, 0x3C, 0x3C, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x0E, 0x00, 0x18, 0x08, 0x30, 0x5F, 0x67, 0xBF, 0xFF,
  0x7F, 0xFF, 0x07, 0x80, 0x1F, 0x80, 0x73, 0x80, 0xE7, 0x83, 0xC7, 0x0F,
  0x0F, 0x02, 0x08, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x7B, 0xDE, 0xF7,
  0x3B, 0xDC, 0xE6, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x6F, 0xFF, 0xF0,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x0F, 0xE0, 0x1F, 0xF8, 0x3E, 0xF8, 0x78,
  0x3C, 0x78, 0x1C, 0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x0E, 0xF0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0,
  0x1E, 0xF0, 0x1E, 0x70, 0x1C, 0x78, 0x3C, 0x3C, 0x3C, 0x3F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xE0, 0x03, 0xC1, 0xF0, 0xFC, 0x7F, 0x3F, 0xFE, 0xFF, 0x3D,
  0x8F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0x07, 0x80, 0x7F, 0xE1, 0xFF, 0xE7, 0xEF, 0xC6,
  0x03, 0xC8, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0x00, 0x7F, 0xE3, 0xFF, 0xE7, 0xC7, 0xE6, 0x03, 0xC8, 0x03,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x07, 0x83, 0xFE, 0x07, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0xF7, 0xFF, 0xCF, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x77, 0x00,
  0x1D, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x38,
  0x70, 0x0E, 0x1C, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x1C,
  0x1C, 0x07, 0x0F, 0x01, 0xC3, 0x80, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x08, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3D, 0x80, 0xFB, 0xFF, 0xE7, 0xFF, 0x87, 0xFE, 0x00, 0x00,
  0x78, 0x03, 0xFC, 0x0F, 0xFC, 0x1F, 0x84, 0x1E, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE7,
  0xF0, 0xEF, 0xF8, 0xEF, 0xFC, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x0E, 0xF0,
  0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x78, 0x1E, 0x3C, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7C, 0x7C, 0x78, 0x1E, 0x70,
  0x1E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0x70, 0x1E, 0x78, 0x1C, 0x3C,
  0x3C, 0x3E, 0x78, 0x1F, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x3E, 0xF8, 0x7C,
  0x7C, 0x70, 0x3E, 0xF0, 0x1E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x0E, 0xF8, 0x1E, 0x7E, 0xFC, 0x3F, 0xF8, 0x1F,
  0xF0, 0x03, 0x80, 0x3F, 0xC0, 0xFF, 0xC3, 0xF7, 0xC7, 0x83, 0xDE, 0x03,
  0xBC, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFE, 0x03, 0xFC, 0x07, 0xBC, 0x1F, 0x7F, 0xEE, 0x7F, 0xDC, 0x7E,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x03, 0xC3, 0xFF, 0x87, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xFF, 0x3C, 0xF3, 0xCF,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xCF,
  0x3C, 0xE7, 0x9E, 0x71, 0xCE, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x78, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x20,
  0x00, 0x00, 0x07, 0x00, 0xFF, 0x8F, 0xFF, 0x1F, 0x7E, 0x20, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x3E, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x38, 0x3F, 0xC3,
  0x9C, 0x1F, 0xF0, 0xE7, 0x0F, 0x1C, 0x19, 0xC3, 0x87, 0x07, 0xE1, 0xC1,
  0xC1, 0xF8, 0x70, 0x70, 0x7E, 0x1C, 0x1C, 0x1F, 0x87, 0x07, 0x07, 0xE1,
  0xC1, 0xC1, 0xF8, 0x70, 0x70, 0x7E, 0x1C, 0x1C, 0x1B, 0x87, 0x07, 0x0E,
  0xE1, 0xC3, 0xC3, 0xB8, 0x38, 0xF9, 0xC7, 0x0F, 0xE7, 0xF1, 0xC1, 0xF1,
  0xF8, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x10, 0x03, 0xE0, 0x38, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x0F, 0x70, 0x00, 0x73, 0xC0,
  0x03, 0x8E, 0x00, 0x1C, 0x70, 0x01, 0xE3, 0x80, 0x0E, 0x1E, 0x00, 0x70,
  0x70, 0x07, 0x83, 0x80, 0x3C, 0x1E, 0x01, 0xC0, 0xF0, 0x0E, 0x03, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xC0, 0x1C, 0x1E, 0x00,
  0xF0, 0xF0, 0x07, 0x87, 0x00, 0x1C, 0x78, 0x00, 0xE3, 0xC0, 0x07, 0x9C,
  0x00, 0x3D, 0xE0, 0x00, 0xEF, 0x00, 0x07, 0x80, 0xFF, 0xF0, 0x7F, 0xFE,
  0x3F, 0xFF, 0x9E, 0x03, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x1D, 0xE0,
  0x0E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0x9E, 0x03, 0xCF, 0xFF, 0xC7,
  0xFF, 0x83, 0xFF, 0xF1, 0xE0, 0x7C, 0xF0, 0x0F, 0x78, 0x03, 0xBC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x0F, 0x78, 0x0F, 0xBF, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x78,
  0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xBE, 0x1F, 0x01, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x08, 0x3F,
  0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xF8, 0x78, 0x1F, 0x8F, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80,
  0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x07, 0x78, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3B, 0xC0, 0x07, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x01,
  0xE7, 0x80, 0x7C, 0xF0, 0x1F, 0x1E, 0x0F, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC,
  0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xF0, 0xFF,
  0x7E, 0x1F, 0x00, 0x61, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0x70, 0x00, 0x77, 0x80, 0x07, 0x78, 0x00,
  0x73, 0xC0, 0x07, 0x3C, 0x00, 0x71, 0xE0, 0x07, 0x1F, 0x80, 0x70, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFC, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xC0,
  0xFF, 0xFF, 0xF1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xF3, 0xFF, 0xFF,
  0xC0, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0E, 0x0F, 0x4F, 0xBF, 0x9F, 0xCF, 0x80, 0xF0, 0x07, 0xBC, 0x03, 0xCF,
  0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x0E, 0x0F, 0x07, 0x83, 0xC3,
  0xC0, 0xF0, 0xE0, 0x3C, 0x78, 0x0F, 0x3C, 0x03, 0xCE, 0x00, 0xF7, 0x80,
  0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xF9, 0xE0, 0x3C, 0x78, 0x0F,
  0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x78, 0x3C, 0x0E, 0x0F, 0x03, 0xC3, 0xC0,
  0x78, 0xF0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x1E, 0xF0, 0x07,
  0xC0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xEE, 0x00, 0x1F, 0xFB, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xBF,
  0xDC, 0x00, 0xEF, 0xF7, 0x00, 0x3B, 0xFD, 0xC0, 0x1C, 0xFF, 0x78, 0x07,
  0x3F, 0xCE, 0x01, 0xCF, 0xF3, 0x80, 0xF3, 0xFC, 0xF0, 0x38, 0xFF, 0x1C,
  0x0E, 0x3F, 0xC7, 0x07, 0x8F, 0xF1, 0xE1, 0xC3, 0xFC, 0x38, 0x70, 0xFF,
  0x0E, 0x1C, 0x3F, 0xC3, 0xCE, 0x0F, 0xF0, 0x73, 0x83, 0xFC, 0x1C, 0xE0,
  0xFF, 0x07, 0x70, 0x3F, 0xC0, 0xFC, 0x0F, 0xF0, 0x3F, 0x03, 0xFC, 0x0F,
  0x80, 0xFF, 0x03, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xC0,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F,
  0xDC, 0x01, 0xFB, 0xC0, 0x3F, 0x38, 0x07, 0xF7, 0x80, 0xFE, 0x70, 0x1F,
  0xCF, 0x03, 0xF8, 0xE0, 0x7F, 0x1E, 0x0F, 0xE1, 0xC1, 0xFC, 0x3C, 0x3F,
  0x83, 0x87, 0xF0, 0x78, 0xFE, 0x07, 0x1F, 0xC0, 0xF3, 0xF8, 0x0E, 0x7F,
  0x01, 0xEF, 0xE0, 0x1D, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1E, 0x00, 0x70, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xE0, 0x3E, 0x1E, 0x00,
  0xF0, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0x73, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xF7, 0x00, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xCF, 0x00, 0x1E,
  0x3C, 0x00, 0xF1, 0xF0, 0x0F, 0x07, 0xC0, 0xF0, 0x1F, 0xFF, 0x80, 0x7F,
  0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x3E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF3, 0xFC, 0xFF, 0xF8,
  0xFF, 0xE0, 0xFF, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x81, 0xE0, 0x3E, 0x1E, 0x00, 0xF0, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0x78,
  0x00, 0x73, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0xBC, 0x00, 0x3D,
  0xE0, 0x01, 0xCF, 0x00, 0x1E, 0x3C, 0x00, 0xF1, 0xF0, 0x0F, 0x07, 0xC0,
  0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1E, 0x07,
  0xCF, 0x01, 0xE7, 0x80, 0x73, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78,
  0x07, 0xBC, 0x03, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x83, 0xE3, 0xFF, 0xE1,
  0xFF, 0xE0, 0xFF, 0xE0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x0F, 0x07,
  0x87, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x07, 0xBC,
  0x03, 0xDE, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x3F, 0xFC, 0xFF, 0xF3,
  0xFF, 0xE7, 0x80, 0xDE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF8,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7B, 0x01, 0xF7, 0xFF, 0xCF, 0xFF,
  0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3D, 0xC0, 0x0E, 0x78,
  0x07, 0x9F, 0x03, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0x70, 0x00, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE3,
  0x80, 0x1C, 0x38, 0x01, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC1, 0xC0, 0x38,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x07, 0x80, 0xE0, 0x70, 0x0F, 0x0F,
  0x00, 0xF0, 0xF0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x9E, 0x00, 0x79,
  0xE0, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x70, 0x03, 0xC0, 0x0E, 0x70, 0x03, 0xC0, 0x0E,
  0x78, 0x07, 0xE0, 0x1E, 0x78, 0x07, 0xE0, 0x1E, 0x38, 0x07, 0xE0, 0x1E,
  0x38, 0x07, 0xE0, 0x1C, 0x3C, 0x07, 0xF0, 0x1C, 0x3C, 0x0E, 0x70, 0x3C,
  0x3C, 0x0E, 0x70, 0x3C, 0x1C, 0x0E, 0x70, 0x38, 0x1C, 0x0E, 0x70, 0x38,
  0x1E, 0x1E, 0x78, 0x78, 0x1E, 0x1C, 0x38, 0x78, 0x0E, 0x1C, 0x38, 0x78,
  0x0E, 0x1C, 0x38, 0x70, 0x0E, 0x3C, 0x3C, 0x70, 0x0F, 0x38, 0x1C, 0xF0,
  0x0F, 0x38, 0x1C, 0xF0, 0x07, 0x38, 0x1C, 0xE0, 0x07, 0x38, 0x1C, 0xE0,
  0x07, 0x70, 0x0E, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xE0,
  0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0,
  0x01, 0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x03, 0xCE, 0x00,
  0xE3, 0xC0, 0x78, 0x70, 0x1C, 0x1E, 0x0F, 0x03, 0x83, 0x80, 0xF1, 0xE0,
  0x1C, 0x70, 0x07, 0x9C, 0x00, 0xEF, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0xEE,
  0x00, 0x7B, 0xC0, 0x1C, 0x70, 0x0F, 0x1E, 0x03, 0x87, 0x81, 0xE0, 0xE0,
  0x70, 0x3C, 0x3C, 0x07, 0x0E, 0x01, 0xE7, 0x80, 0x39, 0xE0, 0x0F, 0xF0,
  0x03, 0xC0, 0xF0, 0x03, 0xDC, 0x00, 0xE7, 0x80, 0x78, 0xE0, 0x1E, 0x3C,
  0x07, 0x0F, 0x03, 0xC1, 0xC0, 0xE0, 0x78, 0x78, 0x0E, 0x1E, 0x03, 0xC7,
  0x00, 0xF3, 0xC0, 0x1C, 0xE0, 0x07, 0xB8, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0xFF,
  0xFF, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x07, 0x70, 0x01, 0xCE, 0x00, 0xF3, 0x80, 0x38, 0xF0, 0x0E, 0x1C,
  0x07, 0x07, 0x81, 0xC0, 0xE0, 0xE0, 0x3C, 0x38, 0x07, 0x1C, 0x01, 0xE7,
  0x00, 0x3B, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0,
  0xF0, 0xE0, 0xE1, 0xE1, 0xC0, 0x1F, 0xE1, 0xFF, 0xE3, 0xEF, 0x88, 0x0F,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x3F, 0xF3, 0xFF,
  0xDF, 0x87, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFF, 0x07, 0xFE, 0x77, 0x7F, 0xDC, 0xFE, 0x70, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE7, 0xF0, 0xEF, 0xF8, 0xEF, 0xFC, 0xF8, 0x1E, 0xF0, 0x1E,
  0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E,
  0xF0, 0x1E, 0xF8, 0x1E, 0xEF, 0xFC, 0xEF, 0xF8, 0xE7, 0xF0, 0x0F, 0xF8,
  0xFF, 0xCF, 0xFC, 0xF8, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x1F, 0x02, 0x7F, 0xF1, 0xFF, 0x87, 0xF8, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x0F, 0xC7, 0x1F, 0xF7, 0x3F, 0xF7, 0x78, 0x1F,
  0x78, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0x78, 0x1F, 0x78, 0x1F, 0x3E, 0xF7, 0x1F, 0xF7, 0x0F, 0xC7,
  0x0F, 0xE0, 0x3F, 0xE0, 0xFB, 0xE3, 0xC1, 0xE7, 0x01, 0xCE, 0x03, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x11,
  0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xFF, 0x3F, 0xF9,
  0xFF, 0xC1, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0xC7, 0x1F,
  0xF7, 0x3F, 0xF7, 0x78, 0x3F, 0x78, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1F, 0x78, 0x1F, 0x3F,
  0xF7, 0x1F, 0xE7, 0x0F, 0xC7, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x40, 0x1E, 0x70, 0x3E, 0x7F, 0xFC, 0x7F, 0xF8, 0x0F,
  0xC0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xCF, 0xE3, 0xBF, 0xE7, 0x7F, 0xEF,
  0x83, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0x80,
  0xEF, 0xFE, 0x00, 0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0x0E, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x9E, 0xFE, 0xFC, 0xF0, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x7B, 0x80, 0xE7, 0x03, 0xCE, 0x0F, 0x1C, 0x3C, 0x38, 0x70, 0x71,
  0xE0, 0xE7, 0x81, 0xCE, 0x03, 0xBC, 0x07, 0xFC, 0x0F, 0xB8, 0x1F, 0x78,
  0x3C, 0x70, 0x70, 0xF0, 0xE0, 0xE1, 0xC1, 0xE3, 0x81, 0xC7, 0x03, 0xCE,
  0x03, 0xDC, 0x07, 0xB8, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE7, 0xF0, 0xFE, 0x77, 0xFC, 0xFF,
  0xBF, 0xFE, 0xFF, 0xDF, 0x07, 0xE0, 0xFF, 0x03, 0xE0, 0x7F, 0x80, 0xF0,
  0x1F, 0xC0, 0x78, 0x0F, 0xC0, 0x38, 0x07, 0xE0, 0x1C, 0x03, 0xF0, 0x0E,
  0x01, 0xF8, 0x07, 0x00, 0xFC, 0x03, 0x80, 0x7E, 0x01, 0xC0, 0x3F, 0x00,
  0xE0, 0x1F, 0x80, 0x70, 0x0F, 0xC0, 0x38, 0x07, 0xE0, 0x1C, 0x03, 0xF0,
  0x0E, 0x01, 0xF8, 0x07, 0x00, 0xFC, 0x03, 0x80, 0x7E, 0x01, 0xC0, 0x3F,
  0x00, 0xE0, 0x1C, 0xE7, 0xF1, 0xDF, 0xF3, 0xBF, 0xF7, 0xC1, 0xEF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xC0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x78, 0x1E, 0x78, 0x0E, 0x70, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x3F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xE7, 0xF0, 0xEF, 0xF8, 0xEF, 0xFC, 0xF8,
  0x1E, 0xF0, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xF8, 0x1E, 0xEF, 0xFC, 0xEF, 0xF8, 0xE3,
  0xF0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0F, 0xC7, 0x1F,
  0xF7, 0x3F, 0xF7, 0x78, 0x1F, 0x78, 0x1F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1F, 0x78, 0x1F, 0x3F,
  0xF7, 0x1F, 0xE7, 0x0F, 0xC7, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0xE3, 0xF9, 0xFE, 0xFF, 0xF0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x00, 0x3F, 0xE7, 0xFF, 0xFD, 0xEE, 0x02, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03,
  0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0xFF, 0xFE, 0xFF,
  0xEF, 0xF8, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x1F, 0xFF, 0xFF, 0xFF,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x3F, 0xC7, 0xF0, 0xFC,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC1, 0xFB,
  0xFF, 0x77, 0xFC, 0xE7, 0xF1, 0xC0, 0xF0, 0x07, 0xB8, 0x03, 0x9C, 0x01,
  0xCF, 0x01, 0xE7, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x78, 0x78, 0x3C, 0x1C,
  0x1C, 0x0E, 0x0E, 0x07, 0x0F, 0x03, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0,
  0x3D, 0xE0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0xF0, 0x0F, 0x01, 0xEE, 0x03, 0xE0, 0x39,
  0xC0, 0x7C, 0x07, 0x3C, 0x0F, 0x81, 0xE7, 0x81, 0xB0, 0x3C, 0x70, 0x77,
  0x07, 0x0E, 0x0E, 0xE0, 0xE1, 0xE1, 0xDC, 0x1C, 0x3C, 0x3B, 0x87, 0x83,
  0x8E, 0x38, 0xE0, 0x71, 0xC7, 0x1C, 0x0E, 0x38, 0xE3, 0x81, 0xE7, 0x1C,
  0xF0, 0x1D, 0xC1, 0xDC, 0x03, 0xB8, 0x3B, 0x80, 0x77, 0x07, 0x70, 0x0E,
  0xE0, 0xEE, 0x01, 0xD8, 0x1D, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3E,
  0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x00, 0xF0, 0x1E, 0x70, 0x1E,
  0x78, 0x3C, 0x38, 0x3C, 0x3C, 0x78, 0x1C, 0x70, 0x1E, 0xF0, 0x0E, 0xE0,
  0x0F, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0E, 0xF0, 0x1E, 0x70, 0x1C, 0x78, 0x3C, 0x38, 0x78, 0x3C, 0x78, 0x1C,
  0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x07, 0xB8, 0x03, 0x9C, 0x01, 0xCF, 0x01,
  0xE3, 0x80, 0xE1, 0xC0, 0x70, 0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x1C, 0x0E,
  0x0E, 0x07, 0x8F, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x1D, 0xE0,
  0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF0, 0x00,
  0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x7C,
  0x1F, 0x87, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0xFC, 0x1C, 0x03, 0xE0, 0x1E,
  0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0xC0, 0xFC, 0x07, 0x80, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF0, 0x0F, 0x80, 0xFC, 0x01, 0xE0, 0x1E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0F, 0x00, 0xF0, 0x07, 0xF0, 0x0F, 0x03, 0xF0, 0x78, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xE0, 0x7C, 0x0F, 0xC0, 0xF0, 0x08, 0x00, 0x3F, 0x00, 0xBF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x03, 0xE0,
};

const GFXglyph NotoSans_Condensed_Regular41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 29, 10, 3, -29 },
  { 16, 11, 10, 16, 2, -29 },
  { 30, 19, 29, 21, 1, -29 },
  { 99, 16, 33, 19, 2, -31 },
  { 165, 26, 30, 29, 2, -30 },
  { 263, 22, 30, 23, 1, -30 },
  { 346, 4, 10, 9, 2, -29 },
  { 351, 9, 35, 12, 2, -29 },
  { 391, 9, 35, 12, 1, -29 },
  { 431, 15, 15, 18, 2, -31 },
  { 460, 17, 19, 19, 1, -24 },
  { 501, 5, 10, 10, 2, -5 },
  { 508, 10, 4, 12, 1, -13 },
  { 513, 4, 5, 10, 3, -5 },
  { 516, 14, 29, 15, 1, -29 },
  { 567, 16, 30, 19, 2, -30 },
  { 627, 10, 29, 19, 3, -29 },
  { 664, 15, 30, 19, 2, -30 },
  { 721, 15, 30, 19, 2, -30 },
  { 778, 18, 29, 19, 1, -29 },
  { 844, 15, 29, 19, 2, -29 },
  { 899, 16, 30, 19, 2, -30 },
  { 959, 17, 29, 19, 1, -29 },
  { 1021, 16, 30, 19, 2, -30 },
  { 1081, 15, 30, 19, 2, -30 },
  { 1138, 4, 22, 10, 3, -22 },
  { 1149, 6, 27, 10, 1, -22 },
  { 1170, 17, 19, 19, 1, -24 },
  { 1211, 16, 11, 19, 2, -20 },
  { 1233, 17, 19, 19, 1, -24 },
  { 1274, 14, 30, 14, 0, -30 },
  { 1327, 26, 32, 30, 2, -29 },
  { 1431, 21, 29, 21, 0, -29 },
  { 1508, 17, 29, 22, 3, -29 },
  { 1570, 18, 30, 21, 2, -30 },
  { 1638, 19, 29, 24, 3, -29 },
  { 1707, 13, 29, 18, 3, -29 },
  { 1755, 13, 29, 17, 3, -29 },
  { 1803, 20, 30, 25, 2, -30 },
  { 1878, 18, 29, 24, 3, -29 },
  { 1944, 10, 29, 12, 1, -29 },
  { 1981, 9, 37, 10, -2, -29 },
  { 2023, 18, 29, 20, 3, -29 },
  { 2089, 13, 29, 17, 3, -29 },
  { 2137, 26, 29, 32, 3, -29 },
  { 2232, 19, 29, 26, 3, -29 },
  { 2301, 21, 30, 25, 2, -30 },
  { 2380, 16, 29, 20, 3, -29 },
  { 2438, 21, 37, 25, 2, -30 },
  { 2536, 17, 29, 21, 3, -29 },
  { 2598, 15, 30, 19, 2, -30 },
  { 2655, 17, 29, 18, 0, -29 },
  { 2717, 18, 29, 24, 3, -29 },
  { 2783, 20, 29, 20, 0, -29 },
  { 2856, 32, 29, 32, 0, -29 },
  { 2972, 18, 29, 19, 0, -29 },
  { 3038, 18, 29, 18, 0, -29 },
  { 3104, 15, 29, 17, 1, -29 },
  { 3159, 9, 36, 13, 3, -29 },
  { 3200, 14, 29, 15, 1, -29 },
  { 3251, 9, 36, 13, 1, -29 },
  { 3292, 18, 16, 20, 1, -29 },
  { 3328, 18, 3, 18, 0, 3 },
  { 3335, 7, 6, 11, 2, -31 },
  { 3341, 14, 22, 19, 2, -22 },
  { 3380, 16, 31, 21, 3, -31 },
  { 3442, 13, 22, 16, 2, -22 },
  { 3478, 16, 31, 21, 2, -31 },
  { 3540, 15, 22, 19, 2, -22 },
  { 3582, 13, 31, 11, 0, -31 },
  { 3633, 16, 32, 21, 2, -22 },
  { 3697, 15, 31, 21, 3, -31 },
  { 3756, 4, 30, 9, 3, -30 },
  { 3771, 8, 40, 9, -1, -30 },
  { 3811, 15, 31, 18, 3, -31 },
  { 3870, 3, 31, 9, 3, -31 },
  { 3882, 25, 22, 31, 3, -22 },
  { 3951, 15, 22, 21, 3, -22 },
  { 3993, 16, 22, 20, 2, -22 },
  { 4037, 16, 32, 21, 3, -22 },
  { 4101, 16, 32, 21, 2, -22 },
  { 4165, 10, 22, 14, 3, -22 },
  { 4193, 12, 22, 16, 2, -22 },
  { 4226, 10, 27, 12, 1, -27 },
  { 4260, 15, 22, 21, 3, -22 },
  { 4302, 17, 22, 17, 0, -22 },
  { 4349, 27, 22, 27, 0, -22 },
  { 4424, 16, 22, 17, 1, -22 },
  { 4468, 17, 32, 17, 0, -22 },
  { 4536, 12, 22, 14, 1, -22 },
  { 4569, 11, 36, 15, 2, -29 },
  { 4619, 3, 41, 18, 8, -31 },
  { 4635, 12, 36, 15, 2, -29 },
  { 4689, 17, 5, 19, 1, -17 },
};

const GFXfont NotoSans_Condensed_Regular41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular41pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_CONDENSED_REGULAR41PT7B_H_
