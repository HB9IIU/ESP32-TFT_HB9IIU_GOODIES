#ifndef _NOTOSANS_CONDENSED_REGULAR9PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x5F, 0x5F, 0x66, 0x27, 0xA4, 0x3B, 0x42, 0x42, 0xAB,
  0x2F, 0x6C, 0xB2, 0xC0, 0x23, 0x18, 0xCA, 0xC9, 0xA0, 0xC0, 0x5A, 0x94,
  0xD5, 0x5C, 0x4F, 0x60, 0x2F, 0x22, 0x60, 0xC0, 0x80, 0x25, 0x25, 0x00,
  0x25, 0x99, 0x99, 0x60, 0xD5, 0x50, 0x69, 0x12, 0x24, 0xF0, 0x69, 0x16,
  0x11, 0xE0, 0x26, 0x6A, 0xF2, 0x68, 0x61, 0x1E, 0x24, 0x8E, 0x99, 0x60,
  0xF1, 0x22, 0x44, 0x69, 0x96, 0x99, 0x70, 0x69, 0x99, 0x71, 0x60, 0x88,
  0x40, 0x60, 0x3C, 0x61, 0xFF, 0xC3, 0x68, 0x54, 0xA4, 0x10, 0x7D, 0x5A,
  0xEB, 0xBD, 0x03, 0x80, 0x23, 0x14, 0xE9, 0x4C, 0xF7, 0x5B, 0xC0, 0x34,
  0x48, 0x84, 0x70, 0xE9, 0x99, 0x9E, 0xF3, 0x49, 0xC0, 0xF3, 0x49, 0x00,
  0x32, 0x51, 0x28, 0xA5, 0xE0, 0x99, 0xF9, 0x99, 0xD5, 0x70, 0x55, 0x57,
  0xAC, 0xCC, 0xAB, 0x92, 0x49, 0xC0, 0x8C, 0xF7, 0xBA, 0xD4, 0x9D, 0xDB,
  0xB9, 0x32, 0x63, 0x18, 0xA5, 0xC0, 0xF6, 0xE9, 0x00, 0x32, 0x63, 0x18,
  0xA5, 0xC2, 0x08, 0xF6, 0xEB, 0x40, 0x2D, 0x86, 0x11, 0xE0, 0xF4, 0x44,
  0x44, 0x99, 0x99, 0x9E, 0x99, 0x56, 0x62, 0x93, 0x25, 0xB3, 0x66, 0xC8,
  0x80, 0xD6, 0x26, 0x69, 0x96, 0x64, 0x44, 0xF2, 0x24, 0x4F, 0xEA, 0xAC,
  0x89, 0x22, 0x40, 0xD5, 0x5C, 0x66, 0x90, 0xF0, 0xD0, 0x61, 0x79, 0x70,
  0x93, 0xDB, 0x78, 0x72, 0x46, 0x11, 0x79, 0x99, 0x70, 0x69, 0xF8, 0x70,
  0x6B, 0x24, 0x90, 0x79, 0x99, 0x71, 0x70, 0x93, 0xDB, 0x68, 0xBE, 0xBF,
  0x80, 0x92, 0xED, 0xA8, 0xFE, 0xDD, 0x6B, 0x5A, 0x80, 0xF6, 0xDA, 0x69,
  0x99, 0x60, 0xF6, 0xDF, 0x20, 0x79, 0x99, 0x71, 0x10, 0xEA, 0x80, 0x71,
  0x1E, 0x75, 0x50, 0xB6, 0xDE, 0x9A, 0x66, 0x40, 0xA6, 0xDB, 0x96, 0x48,
  0x96, 0x46, 0xB0, 0x9A, 0x66, 0x44, 0xC0, 0xE5, 0x2E, 0x69, 0x44, 0x98,
  0xFF, 0x80, 0xC9, 0x14, 0xB0, 0xF0,
};

const GFXglyph NotoSans_Condensed_Regular9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 1, -6 },
  { 2, 2, 2, 3, 1, -6 },
  { 3, 4, 6, 5, 0, -6 },
  { 6, 4, 8, 4, 0, -7 },
  { 10, 6, 7, 6, 0, -7 },
  { 16, 5, 7, 5, 0, -7 },
  { 21, 1, 2, 2, 0, -6 },
  { 22, 2, 7, 3, 0, -6 },
  { 24, 2, 7, 3, 0, -6 },
  { 26, 4, 3, 4, 0, -7 },
  { 28, 4, 4, 4, 0, -5 },
  { 30, 2, 2, 2, 0, -1 },
  { 31, 2, 1, 3, 0, -3 },
  { 32, 1, 1, 2, 1, -1 },
  { 33, 3, 6, 3, 0, -6 },
  { 36, 4, 7, 4, 0, -7 },
  { 40, 2, 6, 4, 1, -6 },
  { 42, 4, 7, 4, 0, -7 },
  { 46, 4, 7, 4, 0, -7 },
  { 50, 4, 6, 4, 0, -6 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 7, 4, 0, -7 },
  { 60, 4, 6, 4, 0, -6 },
  { 63, 4, 7, 4, 0, -7 },
  { 67, 4, 7, 4, 0, -7 },
  { 71, 1, 5, 2, 1, -5 },
  { 72, 2, 6, 2, 0, -5 },
  { 74, 4, 4, 4, 0, -5 },
  { 76, 4, 2, 4, 0, -4 },
  { 77, 4, 4, 4, 0, -5 },
  { 79, 3, 7, 3, 0, -7 },
  { 82, 6, 7, 7, 0, -6 },
  { 88, 5, 6, 5, 0, -6 },
  { 92, 3, 6, 5, 1, -6 },
  { 95, 4, 7, 5, 0, -7 },
  { 99, 4, 6, 5, 1, -6 },
  { 102, 3, 6, 4, 1, -6 },
  { 105, 3, 6, 4, 1, -6 },
  { 108, 5, 7, 5, 0, -7 },
  { 113, 4, 6, 5, 1, -6 },
  { 116, 2, 6, 3, 0, -6 },
  { 118, 2, 8, 2, -1, -6 },
  { 120, 4, 6, 4, 1, -6 },
  { 123, 3, 6, 4, 1, -6 },
  { 126, 5, 6, 7, 1, -6 },
  { 130, 4, 6, 6, 1, -6 },
  { 133, 5, 7, 6, 0, -7 },
  { 138, 3, 6, 4, 1, -6 },
  { 141, 5, 9, 6, 0, -7 },
  { 147, 3, 6, 5, 1, -6 },
  { 150, 4, 7, 4, 0, -7 },
  { 154, 4, 6, 4, 0, -6 },
  { 157, 4, 6, 5, 1, -6 },
  { 160, 4, 6, 4, 0, -6 },
  { 163, 7, 6, 7, 0, -6 },
  { 169, 4, 6, 4, 0, -6 },
  { 172, 4, 6, 4, 0, -6 },
  { 175, 4, 6, 4, 0, -6 },
  { 178, 2, 7, 3, 1, -6 },
  { 180, 3, 6, 3, 0, -6 },
  { 183, 2, 7, 3, 0, -6 },
  { 185, 4, 3, 4, 0, -6 },
  { 187, 4, 1, 4, 0, 1 },
  { 188, 2, 2, 2, 0, -7 },
  { 189, 4, 5, 4, 0, -5 },
  { 192, 3, 7, 5, 1, -7 },
  { 195, 3, 5, 3, 0, -5 },
  { 197, 4, 7, 5, 0, -7 },
  { 201, 4, 5, 4, 0, -5 },
  { 204, 3, 7, 3, 0, -7 },
  { 207, 4, 7, 5, 0, -5 },
  { 211, 3, 7, 5, 1, -7 },
  { 214, 1, 7, 2, 1, -7 },
  { 215, 1, 9, 2, 0, -7 },
  { 217, 3, 7, 4, 1, -7 },
  { 220, 1, 7, 2, 1, -7 },
  { 221, 5, 5, 7, 1, -5 },
  { 225, 3, 5, 5, 1, -5 },
  { 227, 4, 5, 4, 0, -5 },
  { 230, 3, 7, 5, 1, -5 },
  { 233, 4, 7, 5, 0, -5 },
  { 237, 2, 5, 3, 1, -5 },
  { 239, 3, 5, 3, 0, -5 },
  { 241, 2, 6, 3, 0, -6 },
  { 243, 3, 5, 5, 1, -5 },
  { 245, 4, 5, 4, 0, -5 },
  { 248, 6, 5, 6, 0, -5 },
  { 252, 4, 5, 4, 0, -5 },
  { 255, 4, 7, 4, 0, -5 },
  { 259, 3, 5, 3, 0, -5 },
  { 261, 3, 7, 3, 0, -6 },
  { 264, 1, 9, 4, 2, -7 },
  { 266, 3, 7, 3, 0, -6 },
  { 269, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_Condensed_Regular9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular9pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_CONDENSED_REGULAR9PT7B_H_
