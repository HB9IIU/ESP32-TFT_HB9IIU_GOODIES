#ifndef _NOTOSANS_CONDENSED_REGULAR15PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xAA, 0x3C, 0x99, 0x99, 0x14, 0x28, 0x93, 0xF2, 0x44, 0x89,
  0x7F, 0x28, 0x91, 0x20, 0x23, 0xE9, 0x4E, 0x38, 0xE5, 0x2F, 0xC8, 0x40,
  0x62, 0x51, 0x29, 0x14, 0x8A, 0x95, 0x55, 0xF2, 0x29, 0x14, 0x92, 0x48,
  0xC0, 0x70, 0xA3, 0x62, 0x87, 0x0C, 0x2D, 0xCE, 0x8D, 0x1B, 0xD8, 0xF0,
  0x29, 0x49, 0x24, 0x93, 0x26, 0xC4, 0x22, 0x23, 0x33, 0x32, 0x26, 0xC0,
  0x25, 0x7C, 0xAD, 0x00, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x00, 0xEA, 0xFF,
  0xB0, 0x08, 0x46, 0x21, 0x10, 0x84, 0x42, 0x30, 0x76, 0xE3, 0x18, 0xC6,
  0x31, 0x8E, 0xDC, 0x37, 0xF3, 0x33, 0x33, 0x33, 0x30, 0x74, 0xC2, 0x11,
  0x88, 0xCC, 0x44, 0x3E, 0x74, 0xC2, 0x11, 0xB0, 0x61, 0x0C, 0xFC, 0x0C,
  0x18, 0x71, 0xE2, 0xCD, 0x93, 0x46, 0xFE, 0x18, 0x30, 0xFC, 0x21, 0x0E,
  0x7C, 0x21, 0x0C, 0xFC, 0x3B, 0x31, 0x0B, 0x6E, 0x31, 0x8E, 0x5C, 0xF8,
  0x42, 0x31, 0x08, 0xC4, 0x22, 0x10, 0x73, 0x68, 0xA2, 0x59, 0xCD, 0xA2,
  0x8E, 0x2F, 0x80, 0x76, 0xE3, 0x18, 0xCD, 0xE1, 0x08, 0xBC, 0xE0, 0x0B,
  0xE0, 0x0E, 0xA0, 0x04, 0x66, 0x20, 0xE0, 0xE0, 0xC0, 0xFC, 0x00, 0x3F,
  0x83, 0x03, 0x03, 0x3B, 0x88, 0x00, 0x74, 0xC2, 0x11, 0x18, 0x84, 0x01,
  0x18, 0x1C, 0x11, 0x90, 0x53, 0x99, 0x4D, 0x26, 0x93, 0x49, 0x9B, 0x40,
  0x10, 0x07, 0xC0, 0x18, 0x18, 0x38, 0x28, 0x2C, 0x24, 0x7C, 0x7E, 0x42,
  0xC2, 0x83, 0xF2, 0x38, 0x61, 0x8F, 0xE8, 0xE1, 0x86, 0x3F, 0x80, 0x3D,
  0x9C, 0x20, 0x82, 0x08, 0x20, 0xC1, 0x03, 0xC0, 0xF1, 0x3A, 0x14, 0x38,
  0x30, 0x60, 0xC3, 0x85, 0x1B, 0xE0, 0xFC, 0x21, 0x08, 0x7E, 0x10, 0x84,
  0x3E, 0xFC, 0x21, 0x08, 0x7E, 0x10, 0x84, 0x20, 0x3C, 0xC7, 0x04, 0x08,
  0x11, 0xE0, 0xC1, 0xC2, 0xC4, 0xF8, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xE1,
  0xC3, 0x87, 0x0E, 0x18, 0xE9, 0x24, 0x92, 0x4B, 0x80, 0x24, 0x92, 0x49,
  0x24, 0x93, 0xC0, 0x85, 0x1A, 0x24, 0x8B, 0x16, 0x34, 0x4C, 0x89, 0x1A,
  0x18, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x3E, 0xC0, 0xE0, 0xE8, 0x74,
  0x3A, 0x2C, 0x96, 0x4B, 0x29, 0x9C, 0xC6, 0x63, 0x20, 0xC3, 0x86, 0x8D,
  0x1B, 0x32, 0x66, 0xC5, 0x8F, 0x0E, 0x18, 0x38, 0x64, 0xC2, 0x82, 0x82,
  0x83, 0x82, 0x82, 0xC2, 0x46, 0x3C, 0xF2, 0x68, 0xE3, 0x8E, 0x6F, 0x20,
  0x82, 0x08, 0x00, 0x38, 0x64, 0xC2, 0x82, 0x82, 0x83, 0x82, 0x82, 0xC2,
  0x46, 0x3C, 0x0C, 0x04, 0x06, 0xF2, 0x68, 0xE3, 0x8F, 0xEF, 0x26, 0x8A,
  0x38, 0x40, 0x7E, 0x61, 0x0C, 0x38, 0x61, 0x0C, 0xFC, 0xFC, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x00, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0xC7, 0x89, 0xF0, 0x83, 0x85, 0x1A, 0x24, 0x4C, 0x8B, 0x14, 0x28,
  0x30, 0x40, 0x86, 0x3C, 0x62, 0x46, 0x24, 0x62, 0x4A, 0x66, 0x94, 0x69,
  0x42, 0x94, 0x31, 0x43, 0x1C, 0x30, 0x80, 0xC6, 0x89, 0xB1, 0x43, 0x82,
  0x0E, 0x14, 0x6C, 0x8B, 0x18, 0x87, 0x89, 0x33, 0x42, 0x87, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x7C, 0x30, 0x86, 0x10, 0x42, 0x08, 0x61, 0x0F, 0xC0,
  0xF2, 0x49, 0x24, 0x92, 0x4E, 0xC2, 0x10, 0xC2, 0x10, 0x42, 0x10, 0x42,
  0xF3, 0x33, 0x33, 0x33, 0x33, 0x33, 0xF0, 0x10, 0x30, 0xA1, 0x64, 0x58,
  0xC0, 0xFE, 0xD0, 0xF0, 0xC2, 0xF8, 0xC6, 0x7D, 0x82, 0x08, 0x2E, 0xCE,
  0x18, 0x61, 0x87, 0x3B, 0x80, 0x7C, 0x88, 0x88, 0xC7, 0x0C, 0x30, 0xDF,
  0x8E, 0x38, 0xE3, 0x8E, 0x37, 0xC0, 0x74, 0x63, 0xF8, 0x43, 0x0F, 0x3B,
  0x19, 0xE6, 0x31, 0x8C, 0x63, 0x18, 0x7E, 0x38, 0xE3, 0x8E, 0x38, 0xDF,
  0x0C, 0x2D, 0x98, 0x82, 0x08, 0x2E, 0xCA, 0x38, 0xE3, 0x8E, 0x38, 0xC0,
  0xDF, 0xE0, 0x51, 0x55, 0x55, 0x78, 0x82, 0x08, 0x22, 0x92, 0x8A, 0x3C,
  0x92, 0x68, 0xC0, 0xFF, 0xE0, 0xBB, 0xE6, 0x62, 0x31, 0x18, 0x8C, 0x46,
  0x23, 0x11, 0xBB, 0x28, 0xE3, 0x8E, 0x38, 0xE3, 0x7A, 0x28, 0xE3, 0x8E,
  0x3C, 0x9E, 0xBB, 0x38, 0x61, 0x86, 0x1C, 0xEE, 0x82, 0x08, 0x20, 0x7E,
  0x38, 0xE3, 0x8E, 0x38, 0xDF, 0x0C, 0x30, 0xC3, 0xBC, 0x88, 0x88, 0x88,
  0xF8, 0x8C, 0x31, 0x9F, 0x44, 0xF4, 0x44, 0x44, 0x43, 0x8E, 0x38, 0xE3,
  0x8E, 0x3C, 0xDF, 0x87, 0x34, 0x92, 0x68, 0xE3, 0x0C, 0xCC, 0xD3, 0x24,
  0xC9, 0x52, 0x53, 0x9C, 0xC3, 0x30, 0xCC, 0xCD, 0x23, 0x8C, 0x30, 0xE4,
  0xB3, 0xC5, 0x34, 0x92, 0x68, 0xE3, 0x0C, 0x30, 0x8E, 0x30, 0x78, 0x84,
  0x62, 0x31, 0x1F, 0x16, 0x44, 0x44, 0xC4, 0x44, 0x44, 0x30, 0xFF, 0xFE,
  0x84, 0x44, 0x44, 0x36, 0x44, 0x44, 0xC0, 0xE6, 0x60,
};

const GFXglyph NotoSans_Condensed_Regular15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 4, 4, 6, 1, -11 },
  { 6, 7, 11, 8, 0, -11 },
  { 16, 5, 12, 7, 1, -11 },
  { 24, 9, 11, 11, 1, -11 },
  { 37, 7, 11, 8, 1, -11 },
  { 47, 1, 4, 3, 1, -11 },
  { 48, 3, 13, 4, 1, -11 },
  { 53, 4, 13, 4, 0, -11 },
  { 60, 5, 5, 7, 1, -11 },
  { 64, 6, 7, 7, 1, -9 },
  { 70, 2, 4, 4, 1, -2 },
  { 71, 4, 2, 4, 0, -5 },
  { 72, 2, 2, 4, 1, -2 },
  { 73, 5, 11, 6, 0, -11 },
  { 80, 5, 11, 7, 1, -11 },
  { 87, 4, 11, 7, 1, -11 },
  { 93, 5, 11, 7, 1, -11 },
  { 100, 5, 11, 7, 1, -11 },
  { 107, 7, 11, 7, 0, -11 },
  { 117, 5, 11, 7, 1, -11 },
  { 124, 5, 11, 7, 1, -11 },
  { 131, 5, 11, 7, 1, -11 },
  { 138, 6, 11, 7, 1, -11 },
  { 147, 5, 11, 7, 1, -11 },
  { 154, 2, 8, 4, 1, -8 },
  { 156, 2, 10, 4, 1, -8 },
  { 159, 6, 7, 7, 1, -9 },
  { 165, 6, 4, 7, 1, -7 },
  { 168, 6, 7, 7, 1, -9 },
  { 174, 5, 11, 5, 0, -11 },
  { 181, 9, 12, 11, 1, -11 },
  { 195, 8, 11, 8, 0, -11 },
  { 206, 6, 11, 8, 1, -11 },
  { 215, 6, 11, 8, 1, -11 },
  { 224, 7, 11, 9, 1, -11 },
  { 234, 5, 11, 7, 1, -11 },
  { 241, 5, 11, 6, 1, -11 },
  { 248, 7, 11, 9, 1, -11 },
  { 258, 7, 11, 9, 1, -11 },
  { 268, 3, 11, 5, 1, -11 },
  { 273, 3, 14, 4, -1, -11 },
  { 279, 7, 11, 7, 1, -11 },
  { 289, 5, 11, 6, 1, -11 },
  { 296, 9, 11, 12, 1, -11 },
  { 309, 7, 11, 9, 1, -11 },
  { 319, 8, 11, 9, 1, -11 },
  { 330, 6, 11, 7, 1, -11 },
  { 339, 8, 14, 9, 1, -11 },
  { 353, 6, 11, 8, 1, -11 },
  { 362, 5, 11, 7, 1, -11 },
  { 369, 6, 11, 7, 0, -11 },
  { 378, 7, 11, 9, 1, -11 },
  { 388, 7, 11, 7, 0, -11 },
  { 398, 12, 11, 12, 0, -11 },
  { 415, 7, 11, 7, 0, -11 },
  { 425, 7, 11, 7, 0, -11 },
  { 435, 6, 11, 6, 0, -11 },
  { 444, 3, 13, 5, 1, -11 },
  { 449, 5, 11, 6, 0, -11 },
  { 456, 4, 13, 5, 0, -11 },
  { 463, 7, 6, 7, 0, -11 },
  { 469, 7, 1, 7, 0, 1 },
  { 470, 2, 2, 4, 1, -11 },
  { 471, 5, 8, 7, 1, -8 },
  { 476, 6, 11, 8, 1, -11 },
  { 485, 4, 8, 6, 1, -8 },
  { 489, 6, 11, 8, 1, -11 },
  { 498, 5, 8, 7, 1, -8 },
  { 503, 5, 11, 4, 0, -11 },
  { 510, 6, 12, 8, 1, -8 },
  { 519, 6, 11, 8, 1, -11 },
  { 528, 1, 11, 3, 1, -11 },
  { 530, 2, 15, 3, 0, -11 },
  { 534, 6, 11, 7, 1, -11 },
  { 543, 1, 11, 3, 1, -11 },
  { 545, 9, 8, 11, 1, -8 },
  { 554, 6, 8, 8, 1, -8 },
  { 560, 6, 8, 7, 1, -8 },
  { 566, 6, 12, 8, 1, -8 },
  { 575, 6, 12, 8, 1, -8 },
  { 584, 4, 8, 5, 1, -8 },
  { 588, 4, 8, 6, 1, -8 },
  { 592, 4, 10, 4, 0, -10 },
  { 597, 6, 8, 8, 1, -8 },
  { 603, 6, 8, 6, 0, -8 },
  { 609, 10, 8, 10, 0, -8 },
  { 619, 6, 8, 6, 0, -8 },
  { 625, 6, 12, 6, 0, -8 },
  { 634, 5, 8, 5, 0, -8 },
  { 639, 4, 13, 6, 1, -11 },
  { 646, 1, 15, 7, 3, -11 },
  { 648, 4, 13, 6, 1, -11 },
  { 655, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_Condensed_Regular15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular15pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_CONDENSED_REGULAR15PT7B_H_
