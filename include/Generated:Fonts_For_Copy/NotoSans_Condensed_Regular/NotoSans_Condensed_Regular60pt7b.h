#ifndef _NOTOSANS_CONDENSED_REGULAR60PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular60pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x87, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xDF, 0xBF, 0xFF,
  0xFF, 0xF9, 0xF0, 0x80, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E,
  0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E,
  0xF8, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x1E,
  0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1C, 0x07, 0x80, 0x01, 0xE0,
  0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x1C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x3C, 0x07, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0x01, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x1C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78,
  0x0F, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xF8, 0xE1, 0xE7, 0xE1, 0xC0, 0x4F, 0x83,
  0x80, 0x1F, 0x07, 0x00, 0x3C, 0x0E, 0x00, 0x78, 0x1C, 0x00, 0xF0, 0x38,
  0x01, 0xF0, 0x70, 0x03, 0xE0, 0xE0, 0x03, 0xE1, 0xC0, 0x07, 0xF3, 0x80,
  0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0x9F, 0xC0,
  0x07, 0x0F, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x1F, 0x00, 0x38, 0x3E, 0x00,
  0x70, 0x7C, 0x00, 0xE0, 0xF8, 0x01, 0xC3, 0xE8, 0x03, 0x87, 0xDC, 0x07,
  0x1F, 0x3F, 0x8F, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x00,
  0x78, 0x01, 0xFF, 0x80, 0x03, 0xC0, 0x0F, 0xFC, 0x00, 0x3C, 0x00, 0xF9,
  0xF0, 0x01, 0xE0, 0x07, 0x87, 0x80, 0x1F, 0x00, 0x7C, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0xF0, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x3C,
  0x03, 0xC0, 0x07, 0x81, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x81, 0xE0, 0x01,
  0xE0, 0x7C, 0x1F, 0x00, 0x0F, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x1F, 0x07,
  0x80, 0x03, 0xC0, 0xF8, 0x78, 0x00, 0x1E, 0x07, 0xC3, 0xC0, 0x00, 0xF0,
  0x3E, 0x3E, 0x00, 0x07, 0x81, 0xE1, 0xE1, 0xFC, 0x3C, 0x0F, 0x0F, 0x1F,
  0xF1, 0xE0, 0x78, 0xF1, 0xFF, 0xCF, 0x83, 0xC7, 0x8F, 0x9E, 0x3C, 0x3C,
  0x7C, 0xF8, 0x79, 0xF3, 0xE3, 0xC7, 0x83, 0xC7, 0xFE, 0x1E, 0x3C, 0x1F,
  0x1F, 0xF1, 0xE1, 0xE0, 0x78, 0x7E, 0x0F, 0x1F, 0x03, 0xC0, 0x00, 0xF0,
  0xF0, 0x1E, 0x00, 0x07, 0x87, 0x80, 0xF0, 0x00, 0x7C, 0x3C, 0x07, 0x80,
  0x03, 0xC1, 0xE0, 0x3C, 0x00, 0x1E, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x78,
  0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x78, 0x00, 0xF8, 0x1E, 0x03, 0xC0, 0x07,
  0x80, 0xF8, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x1E, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x07, 0xC3, 0xC0, 0x0F, 0x00,
  0x1F, 0x3E, 0x00, 0x78, 0x00, 0xFF, 0xE0, 0x07, 0x80, 0x03, 0xFE, 0x00,
  0x3C, 0x00, 0x0F, 0xE0, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x3E, 0x0F, 0xCF, 0x80, 0x7C, 0x3F, 0x1F, 0x80, 0xF8, 0x7C, 0x1F,
  0x81, 0xF1, 0xF8, 0x1F, 0x87, 0xC3, 0xE0, 0x1F, 0x0F, 0x87, 0xC0, 0x3F,
  0x1F, 0x1F, 0x80, 0x3F, 0x7E, 0x3E, 0x00, 0x3F, 0xF8, 0x7C, 0x00, 0x7F,
  0xF0, 0xF8, 0x00, 0x7F, 0xC1, 0xF0, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0x7E,
  0x07, 0xE0, 0x01, 0xFC, 0x07, 0xC0, 0x07, 0xFC, 0x0F, 0xC0, 0x1F, 0xFC,
  0x0F, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xFD, 0xFC, 0x1F, 0xFF, 0xE1, 0xF8,
  0x1F, 0xFF, 0x81, 0xF8, 0x1F, 0xFC, 0x01, 0xF8, 0x01, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x39, 0xCE, 0x00, 0xF8,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xF0, 0xF8,
  0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x1C, 0x1E, 0x07, 0x7E, 0x78,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFB, 0xC0, 0x07, 0xCF, 0x80, 0x1F,
  0x1F, 0x00, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0x03, 0xE0, 0x0C, 0x06,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x1F, 0x8F, 0xC7, 0xC3, 0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3E,
  0x1F, 0x0F, 0x07, 0x83, 0xC3, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x79, 0xFB, 0xF7, 0xFF, 0xFF, 0x9F, 0x08, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xF8, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0x80, 0x7C, 0x3F,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x01, 0xF7, 0xC0,
  0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00,
  0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xEF,
  0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xFC,
  0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xF0, 0x07, 0xC3, 0xE0,
  0x1F, 0x87, 0xE0, 0x7E, 0x0F, 0xE1, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC7, 0xEF, 0x9F,
  0xDF, 0x7F, 0x3F, 0xF8, 0x7D, 0xE0, 0xF9, 0x81, 0xF1, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xF0, 0x7F, 0x87, 0x80, 0x3F,
  0x04, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x87, 0xE0,
  0x3F, 0x87, 0x00, 0x3F, 0x8C, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xD8, 0x00, 0x3F,
  0xBE, 0x00, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x80,
  0xFF, 0xFC, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0x78, 0x00,
  0x07, 0x9E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x7C, 0xF8,
  0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x01, 0xE0,
  0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07,
  0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xC0, 0x0F, 0x81, 0xF0, 0x03,
  0xE0, 0x78, 0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFB, 0x00, 0x0F, 0xEF, 0x00,
  0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x03, 0xFF, 0xE0,
  0x00, 0xB0, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x7F, 0x01, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x3F, 0x01, 0xF1, 0xFF, 0x83, 0xE7, 0xFF, 0x87, 0xDF, 0xFF,
  0x8F, 0xFC, 0x7F, 0x9F, 0xE0, 0x3F, 0x3F, 0x80, 0x3F, 0x7E, 0x00, 0x3E,
  0xFC, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x7C,
  0x00, 0x7E, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xF0, 0x03, 0xE3, 0xE0,
  0x0F, 0xC7, 0xE0, 0x3F, 0x07, 0xE0, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0x81, 0xFC, 0x3F, 0x00,
  0xFC, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xE7,
  0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xEF, 0xF0, 0x1F, 0x83, 0xF8, 0x3F, 0x01,
  0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7E, 0x00,
  0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFC, 0x3F, 0x07, 0xE0, 0x3F,
  0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0,
  0x00, 0xFB, 0xF0, 0x03, 0xF3, 0xE0, 0x0F, 0xE7, 0xE0, 0x3F, 0xCF, 0xF0,
  0xFF, 0x8F, 0xFF, 0xDF, 0x0F, 0xFF, 0xBE, 0x0F, 0xFE, 0x7C, 0x07, 0xF0,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x08, 0x07, 0xF8, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x1C,
  0x00, 0x00, 0x10, 0xFB, 0xF7, 0xFF, 0xFF, 0xBF, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE7, 0xEF, 0xDF, 0xFF, 0xFE, 0x7C, 0x20, 0x04, 0x0F, 0x8F, 0xC7,
  0xF3, 0xF9, 0xF8, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE3, 0xE1, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x0F,
  0x87, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xC1,
  0xFC, 0xC0, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0xFF, 0xC0, 0xF0,
  0xF0, 0x0F, 0xFF, 0x83, 0xE3, 0xC0, 0x7F, 0xFE, 0x07, 0x9F, 0x03, 0xF0,
  0x78, 0x1E, 0x78, 0x0F, 0x83, 0xE0, 0x79, 0xE0, 0x7C, 0x0F, 0x81, 0xE7,
  0x81, 0xE0, 0x3E, 0x07, 0xBE, 0x07, 0x80, 0xF8, 0x1E, 0xF0, 0x3E, 0x03,
  0xE0, 0x3F, 0xC0, 0xF8, 0x0F, 0x80, 0xFF, 0x03, 0xC0, 0x3E, 0x03, 0xFC,
  0x0F, 0x00, 0xF0, 0x1E, 0xF0, 0x3C, 0x03, 0xC0, 0x7B, 0xC0, 0xF0, 0x0F,
  0x01, 0xEF, 0x03, 0xC0, 0x3C, 0x07, 0xBC, 0x0F, 0x00, 0xF0, 0x1E, 0xF0,
  0x3C, 0x07, 0xC0, 0x7B, 0xC0, 0xF8, 0x1F, 0x01, 0xEF, 0x81, 0xE0, 0x7E,
  0x0F, 0x3E, 0x07, 0xC3, 0xB8, 0x7C, 0x78, 0x1F, 0xDE, 0xFB, 0xE1, 0xE0,
  0x3F, 0xF3, 0xFF, 0x87, 0x80, 0x7F, 0xC7, 0xFC, 0x1F, 0x00, 0xFC, 0x0F,
  0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0x00, 0x00, 0xFE,
  0x00, 0x3C, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xBC, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xE0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF0,
  0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x07,
  0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xC0, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xF8, 0x01, 0xFC, 0xF8, 0x00,
  0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0xF8, 0x01, 0xFC, 0xF8, 0x00, 0xFE, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFE, 0xF8, 0x0F,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0x07, 0xC0, 0xFF, 0x00, 0x30,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x08, 0x1F, 0xF0, 0x1C, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xF0, 0x07, 0xF8,
  0x3E, 0x00, 0x3F, 0x87, 0xC0, 0x03, 0xF8, 0xF8, 0x00, 0x3F, 0x1F, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFD,
  0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xF3, 0xE0,
  0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xE1, 0xF0, 0x07, 0xF8,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF7, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF,
  0xDF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xE0, 0x7F, 0x03, 0xF8, 0x00, 0x38, 0x3F, 0x80, 0x00, 0x83, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xF8,
  0x00, 0x7C, 0x1F, 0xF0, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF4, 0x3F, 0xBF, 0xF9, 0xFF,
  0xCF, 0xFC, 0x7F, 0x80, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xBE, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x0F,
  0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0x7C, 0x03,
  0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC1,
  0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xBF, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFE, 0xF8, 0x00, 0xFE, 0x7E, 0x00,
  0x7E, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x0F, 0x81, 0xF8,
  0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0xF8, 0x03,
  0xE0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x0F, 0x80,
  0x0F, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0xFC, 0xF8,
  0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0xF0, 0x00, 0x03, 0xFF, 0xF7, 0xC0, 0x00, 0x1E, 0xFF, 0xBE, 0x00,
  0x01, 0xF7, 0xFE, 0xF0, 0x00, 0x0F, 0xBF, 0xF7, 0xC0, 0x00, 0x79, 0xFF,
  0xBE, 0x00, 0x07, 0xCF, 0xFC, 0xF0, 0x00, 0x3E, 0x7F, 0xE7, 0xC0, 0x01,
  0xE3, 0xFF, 0x3E, 0x00, 0x1F, 0x1F, 0xF8, 0xF0, 0x00, 0xF8, 0xFF, 0xC7,
  0xC0, 0x07, 0x87, 0xFE, 0x3E, 0x00, 0x3C, 0x3F, 0xF0, 0xF0, 0x03, 0xE1,
  0xFF, 0x87, 0xC0, 0x1E, 0x0F, 0xFC, 0x3E, 0x00, 0xF0, 0x7F, 0xE1, 0xF0,
  0x0F, 0x83, 0xFF, 0x07, 0x80, 0x7C, 0x1F, 0xF8, 0x3E, 0x03, 0xC0, 0xFF,
  0xC1, 0xF0, 0x3E, 0x07, 0xFE, 0x07, 0x81, 0xF0, 0x3F, 0xF0, 0x3E, 0x0F,
  0x01, 0xFF, 0x81, 0xF0, 0xF8, 0x0F, 0xFC, 0x07, 0x87, 0xC0, 0x7F, 0xE0,
  0x3E, 0x3C, 0x03, 0xFF, 0x01, 0xF3, 0xE0, 0x1F, 0xF8, 0x07, 0x9F, 0x00,
  0xFF, 0xC0, 0x3E, 0xF0, 0x07, 0xFE, 0x01, 0xF7, 0x80, 0x3F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x01, 0xF8,
  0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x3E, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xF7, 0xC0, 0x01, 0xFF, 0x7E, 0x00, 0x1F, 0xF3, 0xE0,
  0x01, 0xFF, 0x3F, 0x00, 0x1F, 0xF9, 0xF0, 0x01, 0xFF, 0x9F, 0x80, 0x1F,
  0xF8, 0xF8, 0x01, 0xFF, 0x8F, 0xC0, 0x1F, 0xF8, 0x7C, 0x01, 0xFF, 0x87,
  0xE0, 0x1F, 0xF8, 0x3E, 0x01, 0xFF, 0x83, 0xF0, 0x1F, 0xF8, 0x1F, 0x01,
  0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x0F, 0x81, 0xFF, 0x80, 0xF8, 0x1F, 0xF8,
  0x07, 0xC1, 0xFF, 0x80, 0x7C, 0x1F, 0xF8, 0x03, 0xE1, 0xFF, 0x80, 0x3E,
  0x1F, 0xF8, 0x01, 0xF1, 0xFF, 0x80, 0x1F, 0x1F, 0xF8, 0x00, 0xF9, 0xFF,
  0x80, 0x0F, 0x9F, 0xF8, 0x00, 0xFD, 0xFF, 0x80, 0x07, 0xDF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xC3,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x01,
  0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x0F, 0x9F, 0x80, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7E, 0x3E, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xFE, 0x07,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x2A, 0x00, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xE0,
  0x1F, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xBE, 0x00, 0x7E, 0xF8, 0x03, 0xFB, 0xE0, 0x7F, 0xCF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xC3, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x0F,
  0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7E,
  0x3E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x01,
  0xFE, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x07, 0xC0, 0x3F, 0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0xF8,
  0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F,
  0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x7E,
  0x0F, 0x80, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x1F, 0x01,
  0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x81, 0xF0,
  0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x1F,
  0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x01, 0xF9,
  0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0xFF, 0x0F, 0xC7, 0xF0, 0x03, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xFA, 0x00, 0x07, 0xEC, 0x00, 0x3F,
  0x3F, 0x03, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F,
  0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xF8, 0x7F, 0x00, 0x3F, 0x07, 0xF8,
  0x1F, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7C,
  0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF0, 0x3E,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00,
  0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xFC,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x01,
  0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC7, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xF8, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0xF0, 0x00, 0xF8,
  0x7E, 0x00, 0x3D, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7B, 0xC0, 0x07, 0xC0,
  0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x03,
  0xF0, 0x07, 0x9F, 0x00, 0x7E, 0x03, 0xE0, 0x0F, 0x1E, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xE0, 0xF0, 0x1F, 0x00, 0x3E,
  0x07, 0xC1, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x00, 0xF8,
  0x1F, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3C, 0x0F, 0x83, 0xF0, 0x01, 0xF0,
  0x78, 0x0F, 0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0x07, 0xC3,
  0xE0, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0x80, 0x7C, 0x3E, 0x00, 0x0F, 0x0F,
  0x00, 0x78, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0xF1, 0xF0, 0x00, 0x3E, 0x7C,
  0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xE0,
  0x03, 0xCF, 0x80, 0x00, 0xF3, 0xC0, 0x07, 0xBE, 0x00, 0x01, 0xF7, 0x80,
  0x0F, 0x7C, 0x00, 0x03, 0xFF, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC7,
  0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF8, 0x01,
  0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x00, 0xF8, 0x7C,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x07, 0xC0, 0x7C, 0x00,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x81, 0xF8, 0x01,
  0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x00, 0x7C, 0x3E,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x01,
  0xF8, 0x1F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x03,
  0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0xC1, 0xF0, 0x00, 0xF8, 0x3E,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0x87, 0xC0, 0x01,
  0xF0, 0x78, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x80, 0xF0, 0x01, 0xE0, 0x1F,
  0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x03, 0xC0, 0x7C,
  0x00, 0x7C, 0x0F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x0F,
  0x1F, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x3F,
  0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00,
  0x7E, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFC, 0xFF,
  0x06, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0x03, 0xCF, 0xC0,
  0x1E, 0xFC, 0x00, 0xF7, 0xC0, 0x07, 0xBE, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7E, 0xF8, 0x07,
  0xF7, 0xE0, 0x7F, 0xBF, 0xCF, 0xBC, 0xFF, 0xF9, 0xE3, 0xFF, 0x8F, 0x0F,
  0xF8, 0x38, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x7F, 0xC0, 0xF9, 0xFF, 0xE0, 0xFB, 0xFF, 0xF0, 0xFB, 0xFF, 0xF8, 0xFF,
  0x81, 0xFC, 0xFF, 0x00, 0xFC, 0xFE, 0x00, 0x7C, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x7E, 0xFE, 0x00, 0x7C, 0xFF, 0x00, 0xFC, 0xFF, 0x81, 0xF8, 0xFB,
  0xFF, 0xF8, 0xFB, 0xFF, 0xF0, 0xF1, 0xFF, 0xE0, 0xF0, 0x7F, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE1,
  0xFF, 0xFC, 0x7F, 0x01, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x0C, 0x3F,
  0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x02, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x1F, 0x07, 0xC1, 0xFF, 0x8F, 0x87, 0xFF, 0x9F, 0x1F, 0xFF, 0xBE,
  0x3F, 0xFF, 0xFC, 0xFC, 0x07, 0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x07, 0xEF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x07,
  0xDF, 0x00, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0xFE, 0x7E, 0x03, 0xFC,
  0x7F, 0xFF, 0x78, 0xFF, 0xFC, 0xF0, 0xFF, 0xF1, 0xE0, 0x7F, 0xC3, 0xC0,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x03,
  0xFF, 0xF8, 0x1F, 0xCF, 0xE0, 0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0x9F, 0x00,
  0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x02, 0x1F, 0x80, 0x38, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x78,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xF3,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xFF, 0xE3, 0xFF,
  0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xFC, 0x3C, 0x3F, 0xFC, 0x78, 0xFF, 0xFC, 0xF1, 0xFF, 0xFD, 0xE7,
  0xE0, 0x3F, 0xDF, 0x80, 0x3F, 0xBF, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0xFD,
  0xF8, 0x01, 0xF9, 0xF0, 0x07, 0xF3, 0xF0, 0x1F, 0xE3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xEF, 0x87, 0xFF, 0x9F, 0x03, 0xFE, 0x3E, 0x00, 0xC0, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x40, 0x01, 0xF8, 0xF0, 0x0F,
  0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xC0,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x7C, 0x0F, 0x8F, 0xFC, 0x3E, 0x7F, 0xF8, 0xFB, 0xFF, 0xF3,
  0xEF, 0xFF, 0xEF, 0xF8, 0x1F, 0xBF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0x7B, 0xEF, 0xFF, 0xFD,
  0xE3, 0x00, 0x00, 0x00, 0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x01, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x1E, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE8, 0x7E, 0xFF, 0xCF, 0xFC, 0xFF, 0x8F, 0xF0, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x1F, 0xBE, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7C,
  0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x0F, 0x83, 0xE0, 0x3E,
  0x1F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0xFC,
  0x00, 0xFB, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xDF, 0x80,
  0xFE, 0x3E, 0x03, 0xF0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xF8,
  0x0F, 0x83, 0xE0, 0x3F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF8, 0xF8, 0x03,
  0xE3, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7E, 0xF8, 0x00, 0xFB,
  0xE0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x3E,
  0x07, 0x87, 0xFE, 0x07, 0xFE, 0x3E, 0x7F, 0xF8, 0x7F, 0xF9, 0xF7, 0xFF,
  0xE7, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0x81, 0xFF, 0x81, 0xFF,
  0xF8, 0x07, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xFC, 0x00, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xF8,
  0x01, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xFC, 0x00, 0x7C, 0x00,
  0x7F, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x00,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x3F,
  0xF0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xFC, 0x00, 0x7C,
  0x00, 0x7F, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xF8,
  0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x00,
  0x3F, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xFC, 0x00,
  0x7C, 0x00, 0x7F, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x1F,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x03, 0xC3, 0xFF, 0x0F, 0x9F,
  0xFF, 0x3E, 0xFF, 0xFC, 0xFB, 0xFF, 0xFB, 0xFE, 0x07, 0xEF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x3F, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0x7C,
  0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0xFC,
  0x3F, 0x81, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0xFF, 0xC0,
  0xF9, 0xFF, 0xE0, 0xFB, 0xFF, 0xF0, 0xFB, 0xF7, 0xF8, 0xFF, 0x01, 0xFC,
  0xFE, 0x00, 0xFC, 0xFE, 0x00, 0x7C, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3E,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E,
  0xFE, 0x00, 0x7C, 0xFF, 0x00, 0xFC, 0xFF, 0x81, 0xF8, 0xFB, 0xFF, 0xF8,
  0xFB, 0xFF, 0xF0, 0xF9, 0xFF, 0xE0, 0xF8, 0x7F, 0xC0, 0xF8, 0x0C, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFC, 0x3C, 0x3F, 0xFC, 0x78,
  0xFF, 0xFC, 0xF1, 0xFF, 0xFD, 0xE7, 0xE0, 0x3F, 0xDF, 0x80, 0x3F, 0xBF,
  0x00, 0x3F, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xF9, 0xF0, 0x07, 0xF3,
  0xF0, 0x1F, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xEF, 0x87, 0xFF, 0x9F, 0x03,
  0xFE, 0x3E, 0x00, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xF0, 0x7E, 0xF0,
  0xFE, 0xF9, 0xFE, 0xFB, 0xFE, 0xFB, 0xC2, 0xFF, 0x80, 0xFF, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xF8,
  0xF8, 0xF8, 0x03, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x03, 0xEF, 0x00, 0xFD, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0x80,
  0x18, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07,
  0xF7, 0xC0, 0x1F, 0xDF, 0x81, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFC, 0xF1,
  0xFF, 0xE3, 0xC3, 0xFF, 0x0F, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xBE,
  0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xE1,
  0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x7C,
  0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1,
  0xF0, 0x03, 0xE0, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E,
  0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xEF, 0x80, 0x01,
  0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x1F,
  0xC0, 0x0F, 0xBE, 0x00, 0x7F, 0x00, 0x3E, 0x7C, 0x01, 0xFE, 0x00, 0xF9,
  0xF0, 0x07, 0xF8, 0x03, 0xE7, 0xC0, 0x3F, 0xE0, 0x0F, 0x1F, 0x00, 0xF7,
  0x80, 0x7C, 0x3E, 0x03, 0xDF, 0x01, 0xF0, 0xF8, 0x0F, 0x3C, 0x07, 0xC3,
  0xE0, 0x7C, 0xF0, 0x1E, 0x0F, 0x81, 0xF3, 0xC0, 0xF8, 0x1E, 0x07, 0x8F,
  0x83, 0xE0, 0x7C, 0x1E, 0x3E, 0x0F, 0x81, 0xF0, 0x78, 0x78, 0x3E, 0x07,
  0xC3, 0xE1, 0xE0, 0xF0, 0x1F, 0x0F, 0x07, 0x87, 0xC0, 0x3C, 0x3C, 0x1F,
  0x1F, 0x00, 0xF8, 0xF0, 0x3C, 0x7C, 0x03, 0xE7, 0xC0, 0xF1, 0xE0, 0x0F,
  0x9E, 0x03, 0xCF, 0x80, 0x1E, 0x78, 0x0F, 0xBE, 0x00, 0x79, 0xE0, 0x3E,
  0xF8, 0x01, 0xF7, 0x80, 0x7B, 0xC0, 0x07, 0xFE, 0x01, 0xEF, 0x00, 0x0F,
  0xF0, 0x07, 0xBC, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x03, 0xF0,
  0x3E, 0x03, 0xE0, 0xF8, 0x07, 0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x07, 0xCF,
  0x80, 0x0F, 0xBE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0xFC, 0xF8, 0x01,
  0xF1, 0xF0, 0x07, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x3F, 0x03, 0xE0, 0x7C,
  0x07, 0xC1, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x8F, 0xC0, 0x0F, 0x9F, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x9F, 0x00,
  0x07, 0xCF, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xE0, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x3E,
  0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF7, 0x80, 0x00, 0x7B,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0xFF, 0xC0,
  0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0,
  0x03, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0x3F, 0xF0, 0x01,
  0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE,
  0x80, 0x07, 0xFC, 0x80, 0x00, 0x60,
};

const GFXglyph NotoSans_Condensed_Regular60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 44, 15, 4, -43 },
  { 40, 16, 16, 23, 4, -43 },
  { 72, 29, 43, 31, 1, -43 },
  { 228, 23, 49, 28, 3, -46 },
  { 369, 37, 44, 43, 3, -43 },
  { 573, 31, 44, 33, 2, -43 },
  { 744, 5, 16, 13, 4, -43 },
  { 754, 13, 52, 18, 3, -43 },
  { 839, 13, 52, 18, 2, -43 },
  { 924, 22, 22, 27, 2, -46 },
  { 985, 24, 28, 28, 2, -35 },
  { 1069, 9, 15, 14, 2, -7 },
  { 1086, 13, 5, 17, 2, -19 },
  { 1095, 7, 8, 14, 4, -7 },
  { 1102, 21, 43, 22, 1, -43 },
  { 1215, 23, 44, 28, 3, -43 },
  { 1342, 15, 43, 28, 4, -43 },
  { 1423, 23, 43, 28, 2, -43 },
  { 1547, 23, 44, 28, 2, -43 },
  { 1674, 26, 43, 28, 1, -43 },
  { 1814, 22, 44, 28, 3, -43 },
  { 1935, 23, 44, 28, 3, -43 },
  { 2062, 24, 43, 28, 2, -43 },
  { 2191, 24, 44, 28, 2, -43 },
  { 2323, 23, 44, 28, 2, -43 },
  { 2450, 7, 34, 14, 4, -33 },
  { 2480, 9, 41, 14, 2, -33 },
  { 2527, 24, 27, 28, 2, -35 },
  { 2608, 24, 16, 28, 2, -29 },
  { 2656, 24, 27, 28, 2, -35 },
  { 2737, 19, 44, 21, 1, -43 },
  { 2842, 38, 48, 44, 3, -43 },
  { 3070, 30, 43, 30, 0, -43 },
  { 3232, 24, 43, 32, 5, -43 },
  { 3361, 26, 45, 30, 3, -44 },
  { 3508, 27, 43, 35, 5, -43 },
  { 3654, 19, 43, 27, 5, -43 },
  { 3757, 19, 43, 25, 5, -43 },
  { 3860, 29, 44, 36, 3, -43 },
  { 4020, 26, 43, 36, 5, -43 },
  { 4160, 14, 43, 18, 2, -43 },
  { 4236, 13, 55, 14, -3, -43 },
  { 4326, 25, 43, 30, 5, -43 },
  { 4461, 19, 43, 25, 5, -43 },
  { 4564, 37, 43, 47, 5, -43 },
  { 4763, 28, 43, 38, 5, -43 },
  { 4914, 31, 44, 37, 3, -43 },
  { 5085, 22, 43, 30, 5, -43 },
  { 5204, 31, 53, 37, 3, -43 },
  { 5410, 25, 43, 31, 5, -43 },
  { 5545, 22, 45, 27, 3, -44 },
  { 5669, 24, 43, 26, 1, -43 },
  { 5798, 27, 44, 35, 4, -43 },
  { 5947, 29, 43, 29, 0, -43 },
  { 6103, 47, 43, 47, 0, -43 },
  { 6356, 27, 43, 27, 0, -43 },
  { 6502, 27, 43, 27, 0, -43 },
  { 6648, 22, 43, 25, 2, -43 },
  { 6767, 13, 53, 19, 4, -43 },
  { 6854, 21, 43, 22, 1, -43 },
  { 6967, 13, 53, 19, 2, -43 },
  { 7054, 27, 24, 29, 1, -43 },
  { 7135, 26, 4, 26, 0, 5 },
  { 7148, 12, 10, 16, 2, -46 },
  { 7163, 21, 34, 28, 2, -33 },
  { 7253, 24, 47, 30, 4, -46 },
  { 7394, 19, 34, 23, 3, -33 },
  { 7475, 23, 47, 30, 3, -46 },
  { 7611, 22, 34, 28, 3, -33 },
  { 7705, 18, 46, 17, 1, -46 },
  { 7809, 23, 47, 30, 3, -33 },
  { 7945, 22, 46, 30, 4, -46 },
  { 8072, 6, 44, 14, 4, -44 },
  { 8105, 12, 58, 14, -2, -44 },
  { 8192, 22, 46, 26, 4, -46 },
  { 8319, 5, 46, 13, 4, -46 },
  { 8348, 37, 33, 45, 4, -33 },
  { 8501, 22, 33, 30, 4, -33 },
  { 8592, 24, 34, 30, 3, -33 },
  { 8694, 24, 47, 30, 4, -33 },
  { 8835, 23, 47, 30, 3, -33 },
  { 8971, 16, 33, 20, 4, -33 },
  { 9037, 19, 34, 23, 2, -33 },
  { 9118, 15, 40, 17, 1, -39 },
  { 9193, 22, 33, 30, 4, -32 },
  { 9284, 25, 32, 25, 0, -32 },
  { 9384, 38, 32, 40, 1, -32 },
  { 9536, 23, 32, 25, 1, -32 },
  { 9628, 25, 46, 25, 0, -32 },
  { 9772, 18, 32, 21, 2, -32 },
  { 9844, 18, 53, 22, 2, -43 },
  { 9964, 5, 60, 27, 11, -46 },
  { 10002, 18, 53, 22, 2, -43 },
  { 10122, 24, 8, 28, 2, -25 },
};

const GFXfont NotoSans_Condensed_Regular60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular60pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_CONDENSED_REGULAR60PT7B_H_
