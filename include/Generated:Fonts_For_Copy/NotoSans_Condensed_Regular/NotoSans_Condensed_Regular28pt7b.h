#ifndef _NOTOSANS_CONDENSED_REGULAR28PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0x64, 0x80, 0x1F, 0xF0, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0x80, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x18, 0xC0, 0x84,
  0x0C, 0x63, 0xFF, 0xFF, 0xFF, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x21, 0x0F,
  0xFF, 0x7F, 0xF8, 0xC6, 0x06, 0x30, 0x31, 0x81, 0x8C, 0x08, 0x40, 0xC6,
  0x00, 0x04, 0x00, 0x80, 0x7E, 0x1F, 0xF7, 0x45, 0xC8, 0x31, 0x07, 0x20,
  0x64, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x5C, 0x09, 0xC1, 0x18, 0x23, 0x84,
  0xFE, 0xFB, 0xFE, 0x0E, 0x00, 0x40, 0x08, 0x01, 0x00, 0x3C, 0x0C, 0x1F,
  0x06, 0x06, 0x61, 0x83, 0x18, 0x60, 0xC6, 0x30, 0x31, 0x8C, 0x0C, 0x66,
  0x03, 0x19, 0x80, 0xC6, 0x6F, 0x19, 0xB3, 0xE7, 0xCD, 0x98, 0xF6, 0x63,
  0x01, 0x98, 0xC0, 0x66, 0x30, 0x31, 0x8C, 0x0C, 0x63, 0x06, 0x18, 0xC1,
  0x86, 0x60, 0x40, 0xF8, 0x30, 0x3C, 0x1F, 0x00, 0x7F, 0x00, 0xC6, 0x01,
  0x8C, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x0D, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0xF8, 0x73, 0xB8, 0xCE, 0x39, 0x9C, 0x3F, 0x30, 0x3C, 0x60, 0x78,
  0xE0, 0xF1, 0xC3, 0xF1, 0xFE, 0xE1, 0xF8, 0xF0, 0xFF, 0xFC, 0x0C, 0x61,
  0x8C, 0x31, 0xC6, 0x18, 0x63, 0x8E, 0x38, 0xE3, 0x8E, 0x18, 0x61, 0x87,
  0x1C, 0x30, 0xE1, 0x83, 0xC1, 0x87, 0x0C, 0x38, 0x61, 0x86, 0x1C, 0x71,
  0xC3, 0x0C, 0x71, 0xC7, 0x1C, 0x61, 0x8E, 0x31, 0xC6, 0x38, 0x0C, 0x03,
  0x00, 0xC3, 0xB7, 0xFF, 0xC3, 0x81, 0xE0, 0xEC, 0x73, 0x8C, 0x40, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x3F, 0xFF, 0xFF, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x77, 0x66, 0x6C, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0x80, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0,
  0x70, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x80, 0xC0,
  0x30, 0x1C, 0x06, 0x03, 0x80, 0x1F, 0x07, 0xF1, 0xC7, 0x30, 0x66, 0x0C,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1,
  0xF8, 0x3B, 0x06, 0x60, 0xCE, 0x38, 0xFE, 0x0F, 0x80, 0x0E, 0x3C, 0xFB,
  0xFE, 0xE9, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0x3F, 0x1F, 0xF1, 0x87, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01,
  0xC0, 0x70, 0x0C, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0x1F, 0xF1, 0x07, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x07, 0x87, 0xC0, 0xFE, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xD0, 0x3B, 0xFE, 0x7F, 0x80, 0x00,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x6C, 0x03, 0x60, 0x33, 0x01, 0x98,
  0x18, 0xC0, 0xC6, 0x0C, 0x30, 0x61, 0x86, 0x0C, 0x30, 0x63, 0xFF, 0xFF,
  0xFF, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x7F, 0xCF, 0xF9, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F, 0x0F, 0xF8, 0x07, 0x00,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xD0, 0x3B, 0xFE, 0x3F, 0x80,
  0x0F, 0xC3, 0xF8, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x10, 0xEF,
  0x9F, 0x7B, 0xC3, 0xF0, 0x7E, 0x07, 0xC0, 0xD8, 0x1B, 0x07, 0x70, 0xEE,
  0x18, 0xFF, 0x0F, 0xC0, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x60, 0x0C, 0x03,
  0x80, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03,
  0x80, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x00, 0x1F, 0x87, 0xF9, 0xC3,
  0x30, 0x76, 0x0E, 0xC1, 0xD8, 0x31, 0x8E, 0x3F, 0x81, 0xC0, 0xFE, 0x38,
  0xE6, 0x0F, 0xC1, 0xF0, 0x1E, 0x03, 0xE0, 0xEC, 0x1D, 0xFF, 0x1F, 0xC0,
  0x1F, 0x07, 0xF1, 0xC7, 0x30, 0x6E, 0x0D, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xEC, 0x1D, 0xEF, 0x9F, 0xF0, 0xCE, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80,
  0x71, 0xFC, 0x3F, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x77, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x77, 0x66, 0xEC, 0xC0, 0x00, 0x60, 0x3C, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0x38, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80,
  0x30, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x38, 0x1E, 0x0F,
  0x07, 0x83, 0xC0, 0x60, 0x00, 0x7E, 0x7F, 0x90, 0xE0, 0x30, 0x18, 0x0C,
  0x06, 0x07, 0x07, 0x07, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x00, 0x00, 0x00,
  0x0C, 0x07, 0x03, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0xC0, 0x70, 0x60,
  0x0C, 0x30, 0x01, 0x8C, 0x3C, 0x66, 0x1F, 0x8D, 0x8C, 0x63, 0x63, 0x18,
  0xD1, 0x86, 0x3C, 0x61, 0x8F, 0x18, 0x63, 0xC6, 0x18, 0xF1, 0x8E, 0x26,
  0x72, 0x99, 0x8F, 0xBE, 0x61, 0xC6, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0x38, 0x01, 0xFE, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0E, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x38, 0x1C, 0x60, 0x61, 0x81,
  0x86, 0x0E, 0x1C, 0x3F, 0xF0, 0xFF, 0xC3, 0x03, 0x9C, 0x0E, 0x70, 0x19,
  0x80, 0x6E, 0x01, 0xF8, 0x07, 0xFF, 0x0F, 0xFC, 0xE1, 0xEE, 0x0E, 0xE0,
  0x6E, 0x06, 0xE0, 0xEE, 0x0E, 0xE3, 0xCF, 0xF0, 0xFF, 0xCE, 0x0E, 0xE0,
  0x6E, 0x07, 0xE0, 0x7E, 0x06, 0xE0, 0x6E, 0x0E, 0xFF, 0xCF, 0xF8, 0x07,
  0xF1, 0xFF, 0x3C, 0x13, 0x80, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x03, 0xC1, 0x1F, 0xF0, 0x7F, 0xFF, 0x07, 0xFE, 0x38, 0x79, 0xC1, 0xCE,
  0x07, 0x70, 0x1B, 0x80, 0xDC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1B, 0x80, 0xDC, 0x0E, 0xE0, 0xE7, 0x0F, 0x3F, 0xF1,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x00,
  0x07, 0xF8, 0x3F, 0xF1, 0xC0, 0x8E, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x83, 0xFE, 0x0F, 0xD8, 0x3F, 0x60, 0x0D, 0x80,
  0x37, 0x00, 0xDC, 0x03, 0x38, 0x0C, 0x70, 0x31, 0xFF, 0xC1, 0xFF, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xCF, 0xFF, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0x83, 0x7E, 0xF8, 0xE0, 0x7E, 0x0E, 0xE0, 0xCE, 0x18,
  0xE3, 0x8E, 0x30, 0xE6, 0x0E, 0xE0, 0xEC, 0x0F, 0xC0, 0xFE, 0x0E, 0x60,
  0xE7, 0x0E, 0x30, 0xE3, 0x8E, 0x1C, 0xE1, 0xCE, 0x0E, 0xE0, 0xEE, 0x07,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0xFF, 0xF0, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFB, 0x00, 0xFD, 0x80, 0x7E, 0xC0, 0x6F,
  0xB0, 0x37, 0xD8, 0x1B, 0xEC, 0x19, 0xF7, 0x0C, 0xF9, 0x86, 0x7C, 0xC7,
  0x3E, 0x73, 0x1F, 0x19, 0x8F, 0x8D, 0xC7, 0xC7, 0xC3, 0xE1, 0xE1, 0xF0,
  0xF0, 0xF8, 0x70, 0x7C, 0x18, 0x30, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xF0,
  0x3D, 0x81, 0xEE, 0x0F, 0x30, 0x7D, 0xC3, 0xE6, 0x1F, 0x38, 0xF8, 0xC7,
  0xC7, 0x3E, 0x19, 0xF0, 0xEF, 0x83, 0x7C, 0x1F, 0xE0, 0x7F, 0x03, 0xF8,
  0x0F, 0xC0, 0x70, 0x0F, 0xE0, 0x3F, 0xE0, 0xF0, 0xE1, 0x80, 0xE7, 0x01,
  0xCE, 0x01, 0x98, 0x03, 0xB0, 0x07, 0x60, 0x0F, 0xC0, 0x1F, 0x80, 0x3B,
  0x00, 0x76, 0x00, 0xEC, 0x01, 0xDC, 0x03, 0x38, 0x0E, 0x30, 0x1C, 0x70,
  0x70, 0x7F, 0xC0, 0x7F, 0x00, 0xFF, 0x1F, 0xF3, 0x8F, 0x70, 0x6E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xDC, 0x3B, 0xFE, 0x7F, 0x8E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x0F, 0xE0, 0x3F,
  0xE0, 0xF0, 0xE1, 0x80, 0xE7, 0x01, 0xCE, 0x01, 0x98, 0x03, 0xB0, 0x07,
  0x60, 0x0F, 0xC0, 0x1F, 0x80, 0x3B, 0x00, 0x76, 0x00, 0xEC, 0x01, 0xDC,
  0x03, 0x38, 0x0E, 0x30, 0x1C, 0x70, 0x70, 0x7F, 0xC0, 0x7F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0xFE, 0x0F, 0xF8, 0xE3,
  0xCE, 0x0C, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1, 0xCE, 0x3C, 0xFF,
  0x0F, 0xF0, 0xE3, 0x0E, 0x38, 0xE1, 0x8E, 0x1C, 0xE0, 0xCE, 0x0E, 0xE0,
  0xEE, 0x07, 0x1F, 0xC7, 0xF9, 0xC1, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07,
  0x00, 0xD0, 0x3B, 0xFE, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x77, 0x0E, 0x3F, 0xE1, 0xFC, 0xE0, 0x1F, 0x80, 0x66, 0x03, 0x98,
  0x0E, 0x70, 0x30, 0xC0, 0xC3, 0x07, 0x0C, 0x1C, 0x38, 0x60, 0x61, 0x81,
  0x8E, 0x07, 0x38, 0x1C, 0xC0, 0x33, 0x00, 0xDC, 0x03, 0x60, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0xE0, 0x30, 0x1D, 0x81, 0xC0, 0x66, 0x07,
  0x81, 0x98, 0x1E, 0x06, 0x70, 0x78, 0x39, 0xC3, 0xE0, 0xE3, 0x0D, 0xC3,
  0x0C, 0x33, 0x0C, 0x30, 0xCC, 0x70, 0xE3, 0x31, 0xC1, 0x9C, 0xE6, 0x06,
  0x61, 0x98, 0x19, 0x86, 0x60, 0x66, 0x1B, 0x81, 0xD8, 0x6E, 0x03, 0xC0,
  0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x01, 0x80, 0xE0,
  0x60, 0x33, 0x83, 0x8C, 0x18, 0x71, 0xC1, 0x8C, 0x0E, 0xE0, 0x36, 0x01,
  0xB0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1F, 0x00, 0xD8, 0x0E, 0xE0, 0x63,
  0x07, 0x1C, 0x30, 0xE3, 0x83, 0x18, 0x1D, 0xC0, 0x70, 0xE0, 0x36, 0x07,
  0x70, 0x67, 0x06, 0x30, 0xE3, 0x8C, 0x19, 0xC1, 0x98, 0x1D, 0x80, 0xF8,
  0x0F, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0xFF, 0xFF, 0xF0, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70,
  0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x60,
  0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xE0, 0x18,
  0x07, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xE0,
  0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x03, 0xFF,
  0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xFF, 0x06, 0x00, 0xE0, 0x0F, 0x01, 0xB0, 0x1B,
  0x83, 0x18, 0x31, 0xC7, 0x0C, 0x60, 0xEE, 0x06, 0xC0, 0x70, 0xFF, 0xFF,
  0xFF, 0xE3, 0x8E, 0x30, 0x3F, 0x1F, 0xE2, 0x1C, 0x03, 0x00, 0xC0, 0x31,
  0xFD, 0xFF, 0x60, 0xF8, 0x3C, 0x0F, 0x07, 0xE1, 0xDF, 0xB7, 0xCC, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x33, 0xE6, 0xFE, 0xF1, 0xDC,
  0x1B, 0x83, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xE0, 0xFC, 0x1B,
  0xC7, 0x6F, 0xCC, 0xF8, 0x1F, 0x9F, 0xDC, 0x0C, 0x06, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x18, 0x0C, 0x07, 0x01, 0xFC, 0x7E, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC7, 0xD9, 0xFF, 0x70, 0xEC, 0x1D, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0x60, 0x6C, 0x1D, 0xC3, 0x9F,
  0xF1, 0xF6, 0x1F, 0x07, 0xF1, 0xC7, 0x30, 0x66, 0x0F, 0xC1, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x07, 0x04, 0x7F, 0x87, 0xF0, 0x0F,
  0x8F, 0x86, 0x07, 0x03, 0x81, 0xC1, 0xFD, 0xFE, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x1F,
  0x67, 0xFD, 0xC3, 0xB0, 0x76, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0D, 0x81, 0xB0, 0x77, 0x0E, 0x7F, 0xC7, 0xD8, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0xB8, 0xE7, 0xF8, 0x3C, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0xFB, 0x7E, 0xF1, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0x5F, 0x20, 0x36,
  0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x08, 0x71, 0x82, 0x00, 0x01, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x1A,
  0xEF, 0x98, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x1F, 0x0E,
  0xC7, 0x31, 0x8C, 0xE3, 0x70, 0xDC, 0x3F, 0x0E, 0xE3, 0x18, 0xC7, 0x30,
  0xCC, 0x3B, 0x06, 0xC1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xDF,
  0x1F, 0x6F, 0xDF, 0xF8, 0x78, 0xFC, 0x38, 0x3E, 0x1C, 0x1E, 0x0E, 0x0F,
  0x07, 0x07, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x38,
  0x3C, 0x1C, 0x1E, 0x0E, 0x0F, 0x07, 0x06, 0xCF, 0xB7, 0xFE, 0x1F, 0x83,
  0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0C, 0x1F, 0x83, 0xFC, 0x70, 0xE6, 0x0E, 0x60, 0x6E, 0x06, 0xE0,
  0x6E, 0x07, 0xE0, 0x6E, 0x06, 0x60, 0x66, 0x0E, 0x70, 0xC3, 0xFC, 0x1F,
  0x80, 0xCF, 0x9B, 0xFB, 0x87, 0x70, 0x6E, 0x0F, 0x81, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x1F, 0x83, 0xF0, 0x6F, 0x1D, 0xBF, 0x33, 0xE6, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x1F, 0x67, 0xFD, 0xC3,
  0xB0, 0x76, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0D, 0x81, 0xB0,
  0x77, 0x0E, 0x7F, 0xC7, 0xD8, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0xCF, 0xBF, 0xC7, 0x0E, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x00, 0x3F, 0xBF, 0xB8, 0x58, 0x0E, 0x07, 0x81,
  0xE0, 0x7C, 0x0F, 0x01, 0x80, 0xE0, 0x78, 0x37, 0xFB, 0xF8, 0x10, 0x30,
  0x30, 0x7E, 0xFE, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x38, 0x3F, 0x1F, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x87, 0xE1, 0xDF, 0xF3, 0xEC, 0xE0,
  0x6C, 0x0D, 0x83, 0xB0, 0x67, 0x0C, 0x61, 0x8C, 0x71, 0xCC, 0x19, 0x83,
  0x70, 0x6C, 0x0F, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0xE0, 0xD8, 0x38,
  0x36, 0x1E, 0x1D, 0x87, 0x86, 0x71, 0xB1, 0x8C, 0x6C, 0x63, 0x33, 0x38,
  0xCC, 0xCC, 0x33, 0x3B, 0x0E, 0xC6, 0xC1, 0xA1, 0xB0, 0x78, 0x78, 0x1E,
  0x1E, 0x07, 0x83, 0x80, 0xE0, 0xE0, 0x60, 0xEE, 0x18, 0xC7, 0x0C, 0xC1,
  0xB8, 0x1E, 0x03, 0xC0, 0x70, 0x0F, 0x03, 0xE0, 0x66, 0x1C, 0xC3, 0x0C,
  0xE1, 0xF8, 0x18, 0xE0, 0x6C, 0x0D, 0x83, 0xB8, 0x67, 0x0C, 0x61, 0x8C,
  0x71, 0xCC, 0x19, 0x83, 0x70, 0x6C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0x80,
  0x70, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x0F, 0x81, 0xC0, 0x00, 0xFF, 0xFF,
  0x07, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60, 0xE0, 0xFF,
  0xFF, 0x07, 0x0F, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38,
  0xF0, 0xE0, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x0F,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x38, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x0F, 0x07, 0x0C, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xF8, 0xF0, 0x30, 0x3F, 0xC7, 0x3F,
  0xC1, 0xE0,
};

const GFXglyph NotoSans_Condensed_Regular28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 20, 7, 2, -20 },
  { 9, 7, 7, 11, 2, -20 },
  { 16, 13, 20, 14, 1, -20 },
  { 49, 11, 23, 13, 1, -21 },
  { 81, 18, 20, 20, 1, -20 },
  { 126, 15, 20, 15, 1, -20 },
  { 164, 2, 7, 6, 2, -20 },
  { 166, 6, 24, 8, 1, -20 },
  { 184, 6, 24, 8, 1, -20 },
  { 202, 10, 10, 12, 1, -21 },
  { 215, 11, 14, 13, 1, -17 },
  { 235, 4, 7, 7, 1, -3 },
  { 239, 6, 3, 8, 1, -9 },
  { 242, 3, 3, 7, 2, -3 },
  { 244, 10, 20, 10, 0, -20 },
  { 269, 11, 20, 13, 1, -20 },
  { 297, 7, 20, 13, 2, -20 },
  { 315, 11, 20, 13, 1, -20 },
  { 343, 11, 20, 13, 1, -20 },
  { 371, 13, 20, 13, 0, -20 },
  { 404, 11, 20, 13, 1, -20 },
  { 432, 11, 20, 13, 1, -20 },
  { 460, 11, 20, 13, 1, -20 },
  { 488, 11, 20, 13, 1, -20 },
  { 516, 11, 20, 13, 1, -20 },
  { 544, 3, 15, 7, 2, -15 },
  { 550, 4, 19, 7, 1, -15 },
  { 560, 11, 12, 13, 1, -16 },
  { 577, 11, 8, 13, 1, -14 },
  { 588, 11, 12, 13, 1, -16 },
  { 605, 9, 20, 10, 0, -20 },
  { 628, 18, 22, 20, 1, -20 },
  { 678, 14, 20, 14, 0, -20 },
  { 713, 12, 20, 15, 2, -20 },
  { 743, 12, 20, 14, 1, -20 },
  { 773, 13, 20, 16, 2, -20 },
  { 806, 9, 20, 13, 2, -20 },
  { 829, 9, 20, 12, 2, -20 },
  { 852, 14, 20, 17, 1, -20 },
  { 887, 12, 20, 17, 2, -20 },
  { 917, 6, 20, 8, 1, -20 },
  { 932, 7, 25, 7, -2, -20 },
  { 954, 12, 20, 14, 2, -20 },
  { 984, 9, 20, 12, 2, -20 },
  { 1007, 17, 20, 22, 2, -20 },
  { 1050, 13, 20, 18, 2, -20 },
  { 1083, 15, 20, 17, 1, -20 },
  { 1121, 11, 20, 14, 2, -20 },
  { 1149, 15, 25, 17, 1, -20 },
  { 1196, 12, 20, 14, 2, -20 },
  { 1226, 11, 20, 13, 1, -20 },
  { 1254, 12, 20, 12, 0, -20 },
  { 1284, 12, 20, 16, 2, -20 },
  { 1314, 14, 20, 14, 0, -20 },
  { 1349, 22, 20, 22, 0, -20 },
  { 1404, 13, 20, 13, 0, -20 },
  { 1437, 12, 20, 12, 0, -20 },
  { 1467, 10, 20, 12, 1, -20 },
  { 1492, 6, 24, 9, 2, -20 },
  { 1510, 10, 20, 10, 0, -20 },
  { 1535, 6, 24, 9, 1, -20 },
  { 1553, 12, 11, 13, 1, -20 },
  { 1570, 12, 2, 12, 0, 2 },
  { 1573, 5, 4, 8, 1, -21 },
  { 1576, 10, 15, 13, 1, -15 },
  { 1595, 11, 21, 14, 2, -21 },
  { 1624, 9, 15, 11, 1, -15 },
  { 1641, 11, 21, 14, 1, -21 },
  { 1670, 11, 15, 13, 1, -15 },
  { 1691, 9, 21, 8, 0, -21 },
  { 1715, 11, 22, 14, 1, -15 },
  { 1746, 10, 21, 14, 2, -21 },
  { 1773, 3, 21, 6, 2, -21 },
  { 1781, 6, 28, 6, -1, -21 },
  { 1802, 10, 21, 12, 2, -21 },
  { 1829, 2, 21, 6, 2, -21 },
  { 1835, 17, 15, 21, 2, -15 },
  { 1867, 10, 15, 14, 2, -15 },
  { 1886, 12, 15, 14, 1, -15 },
  { 1909, 11, 22, 14, 2, -15 },
  { 1940, 11, 22, 14, 1, -15 },
  { 1971, 7, 15, 9, 2, -15 },
  { 1985, 9, 15, 11, 1, -15 },
  { 2002, 8, 18, 8, 0, -18 },
  { 2020, 10, 15, 14, 2, -15 },
  { 2039, 11, 15, 12, 0, -15 },
  { 2060, 18, 15, 18, 0, -15 },
  { 2094, 11, 15, 12, 0, -15 },
  { 2115, 11, 22, 12, 0, -15 },
  { 2146, 8, 15, 10, 1, -15 },
  { 2161, 8, 24, 10, 1, -20 },
  { 2185, 2, 28, 13, 5, -21 },
  { 2192, 8, 24, 10, 1, -20 },
  { 2216, 11, 4, 13, 1, -12 },
};

const GFXfont NotoSans_Condensed_Regular28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular28pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_CONDENSED_REGULAR28PT7B_H_
