#ifndef _NOTOSANS_CONDENSED_REGULAR56PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular56pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x00,
  0x00, 0x00, 0xCF, 0xBF, 0xFF, 0xFF, 0xFE, 0x20, 0xFC, 0x3F, 0xF8, 0x7D,
  0xE0, 0xFB, 0xC1, 0xF7, 0x83, 0xEF, 0x07, 0xDE, 0x07, 0xBC, 0x0F, 0x78,
  0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xC0, 0x00,
  0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF8, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC0, 0x78, 0x1E,
  0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF3, 0xFB, 0x9F, 0x3F, 0x1C, 0x09, 0xF0, 0xE0, 0x0F, 0x07, 0x00,
  0x78, 0x38, 0x03, 0xC1, 0xC0, 0x1E, 0x0E, 0x00, 0xF0, 0x70, 0x07, 0xC3,
  0x80, 0x3F, 0x1C, 0x00, 0xFE, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1C,
  0xFC, 0x00, 0xE3, 0xE0, 0x07, 0x0F, 0x80, 0x38, 0x3C, 0x01, 0xC1, 0xE0,
  0x0E, 0x0F, 0x00, 0x70, 0xF8, 0x03, 0x87, 0xE0, 0x1C, 0x7D, 0xE0, 0xEF,
  0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0x00,
  0x1F, 0xF0, 0x00, 0xF0, 0x03, 0xFF, 0x80, 0x1E, 0x00, 0x3C, 0x78, 0x01,
  0xE0, 0x07, 0x83, 0x80, 0x3C, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0x07, 0x83,
  0xC0, 0x38, 0x00, 0x70, 0x3C, 0x07, 0x80, 0x07, 0x03, 0xC0, 0x78, 0x00,
  0xF0, 0x1C, 0x0F, 0x00, 0x0F, 0x01, 0xC0, 0xF0, 0x00, 0xF0, 0x1E, 0x0E,
  0x00, 0x0F, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x1C, 0x1E, 0x00, 0x0F, 0x01,
  0xC3, 0xC0, 0x00, 0x70, 0x3C, 0x3C, 0x0C, 0x07, 0x03, 0xC7, 0x87, 0xF0,
  0x78, 0x3C, 0x78, 0xFF, 0x87, 0x83, 0xC7, 0x9F, 0xFC, 0x78, 0x38, 0xF1,
  0xE3, 0xC3, 0xC7, 0x8F, 0x3C, 0x1E, 0x3F, 0xF9, 0xE3, 0xC1, 0xE1, 0xFF,
  0x1E, 0x3C, 0x1E, 0x0F, 0xE1, 0xC3, 0xC1, 0xE0, 0x30, 0x3C, 0x3C, 0x0E,
  0x00, 0x03, 0xC3, 0x80, 0xF0, 0x00, 0x78, 0x38, 0x0F, 0x00, 0x07, 0x83,
  0x80, 0xF0, 0x00, 0x70, 0x38, 0x0F, 0x00, 0x0F, 0x03, 0x80, 0xF0, 0x00,
  0xF0, 0x38, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0x3C, 0x1E,
  0x00, 0x3C, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0x3C, 0x1E, 0x00, 0x3C, 0x01,
  0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x3C, 0x00, 0x78, 0x01, 0xFF, 0xC0, 0x0F,
  0x00, 0x0F, 0xF8, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x0F,
  0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7E, 0xF8, 0x0F, 0x87,
  0xE7, 0xE0, 0x7C, 0x3E, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x1E, 0x1F, 0x03,
  0xF0, 0xF1, 0xF0, 0x0F, 0xCF, 0x8F, 0x80, 0x3E, 0x7C, 0x7C, 0x00, 0xFF,
  0xC3, 0xE0, 0x07, 0xFE, 0x1F, 0x00, 0x1F, 0xE0, 0xF8, 0x00, 0x7F, 0x07,
  0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0xC0, 0xF8, 0x03, 0xFF, 0x07, 0xE0,
  0x3F, 0xFC, 0x1F, 0xFF, 0xF3, 0xE0, 0xFF, 0xFF, 0x1F, 0x83, 0xFF, 0xF0,
  0x7E, 0x07, 0xFE, 0x01, 0xF8, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xF7, 0x9E,
  0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE0, 0x01, 0xF0, 0x3E, 0x03,
  0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0xF0, 0x07,
  0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80,
  0x78, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80,
  0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x01, 0x01, 0xC0, 0x4F, 0x0E, 0x1E, 0x7F, 0x77, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0x78, 0x00, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0xF8, 0x7C, 0x07,
  0xC1, 0xF0, 0x1C, 0x0F, 0x00, 0x20, 0x20, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x3F, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x70, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x73, 0xEF, 0xFF, 0xFF, 0xFF, 0x88, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x7E, 0x0F,
  0x81, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0xF0, 0xF0, 0x03, 0xE7,
  0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0x79, 0xF0, 0x01, 0xF7, 0x80,
  0x07, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00,
  0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E,
  0x3C, 0x00, 0xF8, 0xF8, 0x03, 0xC3, 0xE0, 0x1F, 0x0F, 0xC0, 0x7C, 0x1F,
  0x83, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x7E, 0x07, 0xF0, 0x7F,
  0x8F, 0xFC, 0xFD, 0xEF, 0xCF, 0xFC, 0x7B, 0xC3, 0xCC, 0x1E, 0x40, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x20, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xF0,
  0x1F, 0xC3, 0x00, 0x3F, 0x08, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x60, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE1, 0xF0, 0x0F, 0xC3, 0x00, 0x1F, 0x08, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xA0, 0x00, 0x7C, 0xE0, 0x07, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3B, 0xE0, 0x00,
  0x3D, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x87, 0xC0, 0x07, 0x83, 0xE0,
  0x03, 0xC1, 0xF0, 0x03, 0xC0, 0xF8, 0x01, 0xE0, 0x7C, 0x01, 0xE0, 0x3E,
  0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x78, 0x03,
  0xE0, 0x7C, 0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x87, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7E, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xA0, 0x01, 0xF9, 0xC0,
  0x1F, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x07, 0xFF, 0x80,
  0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0xFE, 0x07,
  0x8F, 0xFC, 0x3C, 0xFF, 0xF1, 0xEF, 0xFF, 0xCF, 0xF0, 0x7E, 0x7F, 0x01,
  0xFB, 0xF0, 0x07, 0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0x78, 0x00, 0xFB, 0xE0, 0x07, 0x9F, 0x00, 0x7C, 0x7C,
  0x07, 0xE3, 0xF0, 0x7E, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xCF, 0xF0, 0xFC, 0x07,
  0xC3, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x01, 0xE7,
  0xC0, 0x07, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0,
  0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0x87, 0xE0, 0x3F, 0xBF, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFD, 0xFC, 0x07,
  0xE1, 0xF8, 0x3F, 0x03, 0xF0, 0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0x9E, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x3E, 0x7E,
  0x01, 0xF8, 0xFF, 0x3F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFC, 0x1F, 0x83, 0xE0, 0x1F, 0x1F,
  0x00, 0x7C, 0x7C, 0x00, 0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x0F, 0xBE, 0x00,
  0x1E, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7D, 0xE0, 0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x7E,
  0x01, 0xFC, 0xFC, 0x1F, 0xF1, 0xFF, 0xF7, 0xC7, 0xFF, 0xDE, 0x0F, 0xFE,
  0x78, 0x0F, 0xE1, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x0E, 0x00, 0x00,
  0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0xFB, 0xFF, 0xFF, 0xFF, 0xE2, 0x00,
  0x3E, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF0,
  0xF0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x3F,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x3E, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x0F,
  0xFC, 0x1F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF3, 0x80, 0xFD, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x00, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x7C, 0x00,
  0x00, 0xF8, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0xF8,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0xFF, 0x81, 0xE3, 0xC0, 0x7F, 0xF8, 0x3C,
  0xF0, 0x1F, 0xFF, 0x07, 0x9E, 0x07, 0xC1, 0xE0, 0x73, 0xC0, 0xF0, 0x3C,
  0x0F, 0x70, 0x3C, 0x07, 0x81, 0xFE, 0x07, 0x80, 0xF0, 0x3F, 0xC0, 0xF0,
  0x1E, 0x07, 0xF8, 0x3C, 0x03, 0xC0, 0xFF, 0x07, 0x80, 0x78, 0x1F, 0xE0,
  0xF0, 0x1F, 0x03, 0xFC, 0x1E, 0x03, 0xC0, 0x7F, 0x83, 0xC0, 0x78, 0x0F,
  0xF0, 0x78, 0x0F, 0x01, 0xFE, 0x0F, 0x01, 0xE0, 0x3B, 0xC1, 0xE0, 0x3C,
  0x0F, 0x78, 0x1E, 0x07, 0x81, 0xEF, 0x03, 0xC1, 0xF8, 0x3D, 0xE0, 0x7C,
  0x37, 0x0F, 0x3C, 0x07, 0xFE, 0xFF, 0xE3, 0xC0, 0xFF, 0x8F, 0xF8, 0x78,
  0x0F, 0xF0, 0xFE, 0x0F, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x02, 0x00, 0x07, 0xF0,
  0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F,
  0x8F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03,
  0xE0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x7C, 0x03,
  0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x8F, 0x80, 0x7F, 0x9F, 0x00, 0x3F, 0x3E, 0x00, 0x3F,
  0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7,
  0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x3E, 0x7C,
  0x00, 0x7C, 0xF8, 0x03, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x1F, 0x00, 0xFF, 0x3E, 0x00, 0x3F, 0x7C, 0x00,
  0x3E, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x1F, 0xCF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xF0, 0x1C, 0x0F, 0xC0, 0x04, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x0C, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x02, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xF8, 0x1F, 0xF8, 0x3E, 0x00, 0x7F,
  0x0F, 0x80, 0x0F, 0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x3E, 0x00,
  0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F,
  0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8,
  0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E,
  0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0xC3, 0xE0,
  0x3F, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xE0, 0x0F, 0x83,
  0xF8, 0x00, 0x20, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xBE, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x80, 0x00, 0xF9,
  0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7E, 0x00,
  0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xFF, 0x00, 0x3E, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x30,
  0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0xFF, 0xEF, 0xFC, 0xFF,
  0xCF, 0xF0, 0x7C, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03,
  0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F,
  0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF9, 0xF0, 0x00, 0xFB, 0xF0,
  0x00, 0xFB, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x7C, 0x00, 0xFE, 0x7C,
  0x00, 0xFE, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07,
  0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x0F, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFB, 0xC0, 0x00,
  0x7F, 0xFF, 0x78, 0x00, 0x0F, 0x7F, 0xEF, 0x80, 0x01, 0xEF, 0xFC, 0xF0,
  0x00, 0x7D, 0xFF, 0x9E, 0x00, 0x0F, 0x3F, 0xF3, 0xE0, 0x01, 0xE7, 0xFE,
  0x3C, 0x00, 0x7C, 0xFF, 0xC7, 0x80, 0x0F, 0x1F, 0xF8, 0xF8, 0x01, 0xE3,
  0xFF, 0x1F, 0x00, 0x3C, 0x7F, 0xE1, 0xE0, 0x0F, 0x0F, 0xFC, 0x3C, 0x01,
  0xE1, 0xFF, 0x87, 0xC0, 0x3C, 0x3F, 0xF0, 0x78, 0x0F, 0x07, 0xFE, 0x0F,
  0x01, 0xE0, 0xFF, 0xC1, 0xF0, 0x3C, 0x1F, 0xF8, 0x1E, 0x0F, 0x83, 0xFF,
  0x03, 0xC1, 0xE0, 0x7F, 0xE0, 0x7C, 0x3C, 0x0F, 0xFC, 0x07, 0x8F, 0x81,
  0xFF, 0x80, 0xF1, 0xE0, 0x3F, 0xF0, 0x1F, 0x3C, 0x07, 0xFE, 0x01, 0xEF,
  0x80, 0xFF, 0xC0, 0x3D, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFC, 0x01, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0x80, 0x3F, 0xF0, 0x03, 0xE0, 0x07, 0xFE, 0x00, 0x7C, 0x00,
  0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0x7C, 0x00, 0x7F, 0xEF, 0x80, 0x0F, 0xFC, 0xF8, 0x01, 0xFF, 0x9F, 0x00,
  0x3F, 0xF1, 0xF0, 0x07, 0xFE, 0x3E, 0x00, 0xFF, 0xC3, 0xE0, 0x1F, 0xF8,
  0x7C, 0x03, 0xFF, 0x07, 0xC0, 0x7F, 0xE0, 0xF8, 0x0F, 0xFC, 0x0F, 0x81,
  0xFF, 0x81, 0xF0, 0x3F, 0xF0, 0x1F, 0x07, 0xFE, 0x03, 0xE0, 0xFF, 0xC0,
  0x3E, 0x1F, 0xF8, 0x07, 0xC3, 0xFF, 0x00, 0x7C, 0x7F, 0xE0, 0x0F, 0x8F,
  0xFC, 0x00, 0xF9, 0xFF, 0x80, 0x1F, 0x3F, 0xF0, 0x01, 0xF7, 0xFE, 0x00,
  0x3E, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x06, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x01,
  0xF8, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0xF8,
  0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7D, 0xF8, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x3E, 0x07,
  0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0x81, 0xFF, 0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFD, 0xF0, 0x0F, 0xEF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x1F, 0xC0,
  0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x1F, 0x1F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7C, 0x3E, 0x00,
  0x03, 0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x3F,
  0x00, 0xFE, 0x03, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xF8, 0x1F, 0xF0, 0xF8, 0x03,
  0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01,
  0xF0, 0xF8, 0x07, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07,
  0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01,
  0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x00, 0x18, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xC0, 0x79, 0xF8,
  0x00, 0x8F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7D, 0x80, 0x07, 0xEF, 0x80, 0x7E, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F,
  0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x1F, 0x87, 0xF0, 0x1F, 0xC1, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x38,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x0F,
  0xBE, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x8F, 0x80,
  0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0,
  0x7C, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x1F, 0x00,
  0x3E, 0x03, 0xE0, 0x07, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x3C, 0x07,
  0xC0, 0x07, 0xC0, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xE0, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x78, 0xF8,
  0x00, 0x0F, 0x1E, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03,
  0xDF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xEF, 0x80,
  0x03, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xBE, 0x00, 0x0F,
  0xC0, 0x01, 0xF7, 0xC0, 0x03, 0xF8, 0x00, 0x3C, 0x78, 0x00, 0x7F, 0x00,
  0x0F, 0x8F, 0x80, 0x0F, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xFE, 0x00, 0x3E,
  0x3E, 0x00, 0x3F, 0xC0, 0x07, 0xC7, 0xC0, 0x0F, 0x78, 0x00, 0xF0, 0x7C,
  0x01, 0xEF, 0x80, 0x3E, 0x0F, 0x80, 0x3C, 0xF0, 0x07, 0xC1, 0xF0, 0x07,
  0x9E, 0x00, 0xF8, 0x3E, 0x01, 0xF3, 0xC0, 0x1E, 0x03, 0xC0, 0x3C, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0x8F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0xF0, 0x1F,
  0x01, 0xF0, 0x1E, 0x1E, 0x03, 0xE0, 0x1E, 0x07, 0xC3, 0xC0, 0x78, 0x03,
  0xC0, 0xF0, 0x7C, 0x1F, 0x00, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0x0F, 0x83,
  0xC0, 0xF0, 0x7C, 0x01, 0xF0, 0xF8, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x03,
  0xE3, 0xE0, 0x03, 0xE3, 0xC0, 0x3C, 0x7C, 0x00, 0x7C, 0x78, 0x07, 0x8F,
  0x80, 0x0F, 0x9F, 0x00, 0xF1, 0xF0, 0x00, 0xF3, 0xE0, 0x1E, 0x3C, 0x00,
  0x1E, 0x78, 0x03, 0xEF, 0x80, 0x03, 0xCF, 0x00, 0x3D, 0xF0, 0x00, 0x7D,
  0xE0, 0x07, 0xBE, 0x00, 0x0F, 0xBC, 0x00, 0xF7, 0x80, 0x00, 0xFF, 0x00,
  0x1E, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xDE, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0x8F, 0x80,
  0x0F, 0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x3E,
  0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0xF8, 0x00,
  0xF8, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0x9E, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0xF9,
  0xF0, 0x00, 0x78, 0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x0F,
  0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xF1,
  0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xBE, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xC3, 0xE0, 0x03,
  0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00,
  0x78, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x01,
  0xE7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE3,
  0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x78,
  0x0F, 0x00, 0x7C, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x1E,
  0x00, 0x7C, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xC7,
  0xC0, 0x01, 0xF7, 0xC0, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1F,
  0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x81, 0xFF, 0xFC, 0x1F, 0x0F, 0xE0, 0xC0, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xC1, 0xF7,
  0xE0, 0x1F, 0x7C, 0x01, 0xF7, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0x7C, 0x07,
  0xF7, 0xE1, 0xEF, 0x3F, 0xFC, 0xF3, 0xFF, 0x8F, 0x0F, 0xF0, 0xF0, 0x10,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x18,
  0x03, 0xE3, 0xFC, 0x0F, 0x9F, 0xFC, 0x3E, 0xFF, 0xF8, 0xF7, 0xFF, 0xE3,
  0xFC, 0x0F, 0xCF, 0xE0, 0x1F, 0x3F, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xE0,
  0x03, 0xEF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xEF, 0x80,
  0x0F, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xF8, 0x07, 0xCF, 0xF0, 0x3F,
  0x3D, 0xF3, 0xF8, 0xF3, 0xFF, 0xE3, 0xC7, 0xFF, 0x0F, 0x0F, 0xF0, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x01, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF,
  0xF1, 0xF8, 0x09, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x27,
  0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFC, 0x00, 0x40, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xE0, 0x7C, 0x1F, 0xF1,
  0xF0, 0xFF, 0xE7, 0xC7, 0xFF, 0xDF, 0x3F, 0xDF, 0xFC, 0xF8, 0x0F, 0xF7,
  0xC0, 0x1F, 0xDF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0x7C, 0x00, 0xFD, 0xF0, 0x07, 0xF7, 0xE0, 0x3F, 0xCF, 0xE3, 0xFF,
  0x1F, 0xFF, 0x7C, 0x3F, 0xF8, 0xF0, 0x7F, 0xC3, 0xC0, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0x8F, 0xC3,
  0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x61, 0xFE, 0x7E, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0x03,
  0xFF, 0x07, 0xFF, 0x07, 0xC2, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3F, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00,
  0x1F, 0xF0, 0xF0, 0xFF, 0xE7, 0xC7, 0xFF, 0xDF, 0x3F, 0xDF, 0xFC, 0xF8,
  0x0F, 0xF7, 0xC0, 0x1F, 0xDF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0x7C, 0x00, 0xFD, 0xF0, 0x07, 0xF7, 0xE0, 0x3F, 0xCF,
  0xF7, 0xDF, 0x1F, 0xFF, 0x7C, 0x3F, 0xF9, 0xF0, 0x7F, 0xC7, 0xC0, 0x18,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE4, 0x00, 0x1F, 0x1C, 0x00, 0xFC, 0x7F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x18, 0x0F, 0x8F, 0xF8, 0xFB, 0xFF, 0xCF,
  0x7F, 0xFE, 0xF7, 0xFF, 0xEF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF0, 0xF7, 0xFF,
  0xFF, 0xB8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0x83, 0xEF, 0xFB, 0xFC, 0xFF, 0x3F, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3F, 0xF8, 0x07, 0xEF, 0x80, 0x7C,
  0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C,
  0x0F, 0x87, 0x80, 0xF8, 0xF8, 0x0F, 0x9F, 0x00, 0xFB, 0xE0, 0x0F, 0x3E,
  0x00, 0xF7, 0xF0, 0x0F, 0x7F, 0x00, 0xFF, 0xF8, 0x0F, 0xEF, 0x80, 0xFC,
  0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x7C,
  0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x38, 0x00, 0x30, 0x1E, 0x1F, 0xE0, 0x7F, 0xC3, 0xCF, 0xFE, 0x1F, 0xFC,
  0x7B, 0xFF, 0xE7, 0xFF, 0xCF, 0x7D, 0xFD, 0xFB, 0xFD, 0xFC, 0x0F, 0xF8,
  0x1F, 0xBF, 0x00, 0xFE, 0x01, 0xF7, 0xE0, 0x1F, 0xC0, 0x3E, 0xF8, 0x01,
  0xF0, 0x03, 0xDF, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x0F, 0xFC,
  0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xF0, 0x03, 0xE0, 0x07,
  0xFE, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0xF8, 0x01, 0xF0,
  0x03, 0xFF, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x0F, 0xFC, 0x00,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xF0, 0x03, 0xE0, 0x07, 0xFE,
  0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x03,
  0xFF, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x0F, 0xFC, 0x00, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xF0, 0x03, 0xE0, 0x07, 0xFE, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x1C, 0x0F, 0x0F, 0xF8, 0xF3, 0xFF, 0xCF, 0x3F,
  0xFE, 0xF7, 0xFF, 0xEF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xDF, 0xE0, 0xF8,
  0x0F, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x01,
  0xEF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xEF, 0x80, 0x07,
  0x9E, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x03, 0xC3, 0xFC, 0x0F, 0x1F, 0xFC, 0x3C, 0xFF, 0xF8,
  0xF7, 0xCF, 0xE3, 0xF8, 0x0F, 0xCF, 0xC0, 0x1F, 0x3F, 0x00, 0x3E, 0xF8,
  0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xEF, 0x80, 0x0F, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xF8, 0x07,
  0xCF, 0xF0, 0x3F, 0x3D, 0xFF, 0xF8, 0xF3, 0xFF, 0xE3, 0xE7, 0xFF, 0x0F,
  0x8F, 0xF0, 0x3E, 0x06, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xF0, 0xF0, 0xFF, 0xE7, 0xC7, 0xFF,
  0xDF, 0x3F, 0xDF, 0xFC, 0xF8, 0x0F, 0xF7, 0xC0, 0x1F, 0xDF, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0x7C, 0x00, 0xFD, 0xF0,
  0x07, 0xF7, 0xE0, 0x3F, 0xCF, 0xF7, 0xDF, 0x1F, 0xFF, 0x7C, 0x3F, 0xF9,
  0xF0, 0x7F, 0x87, 0xC0, 0x18, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x3B, 0xC3, 0xFF, 0x1F, 0xFC, 0xFF, 0xF7, 0xFF,
  0xDE, 0x0F, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x07, 0xFF, 0x07, 0xFF, 0xE7, 0xFF, 0xF7, 0xF1, 0xF3, 0xE0, 0x1B, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x07, 0xF8, 0x07, 0xFF, 0xDF, 0xEF, 0xFF, 0xF7,
  0xFF, 0xF0, 0xFF, 0xE0, 0x02, 0x00, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x03, 0xFC, 0x01,
  0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x7F, 0x7F, 0xFE, 0xF3, 0xFF, 0xEF, 0x1F,
  0xFC, 0xF0, 0xFF, 0x0F, 0x00, 0x80, 0x00, 0xF8, 0x00, 0x3E, 0xF0, 0x00,
  0x79, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xC7, 0x80, 0x0F,
  0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x1E, 0x00, 0xF0, 0x3E, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0xF8, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x8F, 0x80, 0x0F,
  0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x7D, 0xF0, 0x00, 0x7B,
  0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFC, 0x01, 0xF7, 0x80, 0x3F, 0x80, 0x3C, 0xF0, 0x07, 0x70, 0x0F,
  0x9F, 0x01, 0xEF, 0x01, 0xF3, 0xE0, 0x3D, 0xE0, 0x3E, 0x3C, 0x07, 0xBC,
  0x07, 0x87, 0x80, 0xF7, 0x80, 0xF0, 0xF8, 0x3C, 0xF8, 0x3E, 0x1F, 0x07,
  0x8F, 0x07, 0xC3, 0xE0, 0xF1, 0xE0, 0xF0, 0x3C, 0x1E, 0x3C, 0x1E, 0x07,
  0x87, 0x87, 0x83, 0xC0, 0xF8, 0xF0, 0x78, 0xF8, 0x1F, 0x1E, 0x0F, 0x1E,
  0x01, 0xE3, 0xC1, 0xE3, 0xC0, 0x3C, 0x78, 0x3C, 0x78, 0x07, 0x9E, 0x03,
  0xDF, 0x00, 0xFB, 0xC0, 0x7B, 0xE0, 0x0F, 0x78, 0x0F, 0x78, 0x01, 0xEF,
  0x01, 0xEF, 0x00, 0x3D, 0xC0, 0x3D, 0xE0, 0x07, 0xF8, 0x03, 0xBC, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0xF9, 0xF0, 0x07, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xE0, 0x07, 0xCF, 0x80, 0x1F,
  0x3C, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x3E, 0x3E, 0x00, 0xF8,
  0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x1F,
  0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xFB, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x3E,
  0xF0, 0x00, 0x79, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE3, 0xC0, 0x07, 0xC7,
  0xC0, 0x0F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x1E, 0x00, 0xF0, 0x3E,
  0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x1E, 0x01, 0xF0,
  0x7C, 0x01, 0xE0, 0xF8, 0x03, 0xC1, 0xE0, 0x07, 0xC3, 0xC0, 0x07, 0x8F,
  0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0xF8, 0x00, 0x3D, 0xF0,
  0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x7F, 0x80, 0xFF,
  0x00, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0xC0, 0xFF, 0x80, 0xFF, 0x00,
  0xFE, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x02, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xD0, 0x03, 0xFF, 0x20, 0x00, 0x78,
  0x00,
};

const GFXglyph NotoSans_Condensed_Regular56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 6, 41, 14, 4, -40 },
  { 32, 15, 14, 22, 3, -40 },
  { 59, 27, 40, 29, 1, -40 },
  { 194, 21, 46, 26, 3, -43 },
  { 315, 36, 42, 40, 2, -41 },
  { 504, 29, 42, 31, 2, -41 },
  { 657, 6, 14, 12, 3, -40 },
  { 668, 12, 49, 16, 3, -40 },
  { 742, 12, 49, 16, 2, -40 },
  { 816, 21, 21, 25, 2, -43 },
  { 872, 22, 26, 26, 2, -33 },
  { 944, 8, 13, 13, 2, -6 },
  { 957, 12, 4, 16, 2, -17 },
  { 963, 6, 8, 13, 4, -7 },
  { 969, 19, 40, 21, 1, -40 },
  { 1064, 22, 42, 26, 2, -41 },
  { 1180, 13, 40, 26, 4, -40 },
  { 1245, 22, 41, 26, 2, -41 },
  { 1358, 22, 42, 26, 2, -41 },
  { 1474, 25, 40, 26, 1, -40 },
  { 1599, 21, 41, 26, 3, -40 },
  { 1707, 21, 42, 26, 3, -41 },
  { 1818, 22, 40, 26, 2, -40 },
  { 1928, 22, 42, 26, 2, -41 },
  { 2044, 22, 42, 26, 2, -41 },
  { 2160, 6, 31, 13, 4, -30 },
  { 2184, 8, 37, 13, 2, -30 },
  { 2221, 22, 26, 26, 2, -33 },
  { 2293, 22, 16, 26, 2, -28 },
  { 2337, 22, 26, 26, 2, -33 },
  { 2409, 17, 42, 20, 1, -41 },
  { 2499, 35, 45, 41, 3, -40 },
  { 2696, 28, 40, 28, 0, -40 },
  { 2836, 23, 40, 30, 4, -40 },
  { 2951, 24, 42, 28, 3, -41 },
  { 3077, 26, 40, 32, 4, -40 },
  { 3207, 18, 40, 25, 4, -40 },
  { 3297, 18, 40, 24, 4, -40 },
  { 3387, 27, 42, 34, 3, -41 },
  { 3529, 25, 40, 33, 4, -40 },
  { 3654, 13, 40, 17, 2, -40 },
  { 3719, 12, 51, 13, -3, -40 },
  { 3796, 24, 40, 28, 4, -40 },
  { 3916, 18, 40, 23, 4, -40 },
  { 4006, 35, 40, 43, 4, -40 },
  { 4181, 27, 40, 35, 4, -40 },
  { 4316, 29, 42, 35, 3, -41 },
  { 4469, 21, 40, 28, 4, -40 },
  { 4574, 29, 51, 35, 3, -41 },
  { 4759, 24, 40, 29, 4, -40 },
  { 4879, 21, 42, 25, 2, -41 },
  { 4990, 23, 40, 24, 1, -40 },
  { 5105, 25, 41, 33, 4, -40 },
  { 5234, 27, 40, 27, 0, -40 },
  { 5369, 43, 40, 44, 0, -40 },
  { 5584, 25, 40, 26, 0, -40 },
  { 5709, 25, 40, 25, 0, -40 },
  { 5834, 20, 40, 24, 2, -40 },
  { 5934, 12, 49, 18, 4, -40 },
  { 6008, 19, 40, 21, 1, -40 },
  { 6103, 12, 49, 18, 2, -40 },
  { 6177, 25, 22, 27, 1, -40 },
  { 6246, 25, 3, 25, 0, 5 },
  { 6256, 11, 9, 15, 2, -43 },
  { 6269, 20, 32, 26, 2, -31 },
  { 6349, 22, 44, 28, 4, -43 },
  { 6470, 17, 32, 22, 3, -31 },
  { 6538, 22, 44, 28, 3, -43 },
  { 6659, 20, 32, 26, 3, -31 },
  { 6739, 16, 43, 16, 1, -43 },
  { 6825, 22, 44, 28, 3, -31 },
  { 6946, 20, 43, 28, 4, -43 },
  { 7054, 5, 41, 13, 4, -41 },
  { 7080, 10, 54, 13, -1, -41 },
  { 7148, 20, 43, 25, 4, -43 },
  { 7256, 5, 43, 13, 4, -43 },
  { 7283, 35, 31, 42, 4, -31 },
  { 7419, 20, 31, 28, 4, -31 },
  { 7497, 22, 32, 28, 3, -31 },
  { 7585, 22, 44, 28, 4, -31 },
  { 7706, 22, 44, 28, 3, -31 },
  { 7827, 14, 31, 19, 4, -31 },
  { 7882, 17, 32, 21, 2, -31 },
  { 7950, 14, 38, 16, 1, -37 },
  { 8017, 20, 31, 28, 4, -30 },
  { 8095, 23, 30, 23, 0, -30 },
  { 8182, 35, 30, 37, 1, -30 },
  { 8314, 22, 30, 24, 1, -30 },
  { 8397, 23, 43, 23, 0, -30 },
  { 8521, 16, 30, 20, 2, -30 },
  { 8581, 16, 49, 21, 2, -40 },
  { 8679, 5, 56, 25, 10, -43 },
  { 8714, 16, 49, 21, 2, -40 },
  { 8812, 23, 7, 26, 2, -23 },
};

const GFXfont NotoSans_Condensed_Regular56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular56pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_CONDENSED_REGULAR56PT7B_H_
