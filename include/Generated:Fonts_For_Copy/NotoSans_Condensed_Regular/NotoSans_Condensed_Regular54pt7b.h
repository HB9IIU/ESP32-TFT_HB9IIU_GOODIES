#ifndef _NOTOSANS_CONDENSED_REGULAR54PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular54pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0x79, 0xE7, 0x9E, 0x79, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0xEF, 0xBF, 0xFF, 0xEF, 0x88, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xF7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C,
  0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCE, 0x03, 0x80, 0x00, 0x78,
  0x1C, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xC0, 0xF0, 0x00,
  0x70, 0x3C, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x03, 0x80, 0x03, 0xC0, 0xE0,
  0x00, 0xF0, 0x38, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x07,
  0x01, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x70, 0x3C, 0x00, 0x1C, 0x0F, 0x00,
  0x0F, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x3C, 0x1E,
  0x00, 0x0E, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF0, 0x1E, 0x07, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xE0, 0x70, 0x00,
  0x70, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x03, 0xC0, 0xE0,
  0x00, 0xF0, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0x81,
  0xE0, 0x00, 0xE0, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x7F, 0xEF, 0xEF, 0x8E, 0x0C, 0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0xF0,
  0xE0, 0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0xF8, 0xE0, 0x0F,
  0xCE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xEF, 0xE0, 0x0E, 0x3E, 0x00, 0xE1,
  0xF0, 0x0E, 0x0F, 0x00, 0xE0, 0xF0, 0x0E, 0x0F, 0x00, 0xE0, 0xF0, 0x0E,
  0x1F, 0x80, 0xE1, 0xEE, 0x0E, 0x7E, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x03, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x07,
  0xF8, 0x00, 0x78, 0x03, 0xFF, 0x00, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x00,
  0x78, 0x78, 0x03, 0x80, 0x1E, 0x1E, 0x01, 0xE0, 0x07, 0x03, 0x80, 0x78,
  0x01, 0xC0, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x03,
  0x80, 0x0F, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0xF0, 0x78, 0x00, 0xF0, 0x3C,
  0x3C, 0x00, 0x3C, 0x0F, 0x0F, 0x00, 0x0F, 0x03, 0xC3, 0x80, 0x03, 0xC0,
  0xF1, 0xE0, 0xE0, 0x70, 0x3C, 0x70, 0xFE, 0x1C, 0x0E, 0x3C, 0x7F, 0xC7,
  0x87, 0x8F, 0x3F, 0xF9, 0xE1, 0xE7, 0x8F, 0x1E, 0x3C, 0xF1, 0xE7, 0x83,
  0x8F, 0xFC, 0x71, 0xE0, 0xF1, 0xFE, 0x3C, 0x78, 0x3C, 0x3F, 0x0F, 0x1E,
  0x0F, 0x00, 0x07, 0x87, 0x03, 0xC0, 0x01, 0xE1, 0xC0, 0xF0, 0x00, 0x70,
  0x70, 0x3C, 0x00, 0x3C, 0x1C, 0x0F, 0x00, 0x0F, 0x07, 0x03, 0xC0, 0x07,
  0x81, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x3C, 0x00, 0x70, 0x1E, 0x0F, 0x00,
  0x3C, 0x07, 0x83, 0xC0, 0x0E, 0x01, 0xE0, 0xF0, 0x07, 0x80, 0x38, 0x38,
  0x01, 0xE0, 0x0F, 0x1E, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x3C, 0x00, 0x7F,
  0xC0, 0x1E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0,
  0x01, 0xE0, 0x3C, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x03, 0xC1, 0xF7, 0xE0, 0x7C, 0x3E, 0x3E,
  0x07, 0xC7, 0xC1, 0xF0, 0x7C, 0x7C, 0x0F, 0x87, 0x8F, 0x80, 0xFC, 0x78,
  0xF8, 0x07, 0xCF, 0x8F, 0x80, 0x3E, 0xF0, 0xF8, 0x01, 0xFF, 0x0F, 0x80,
  0x1F, 0xE0, 0xF8, 0x00, 0xFE, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0xFE,
  0x07, 0xC0, 0x1F, 0xF0, 0x7E, 0x07, 0xFF, 0x07, 0xFF, 0xFE, 0xF8, 0x3F,
  0xFF, 0xCF, 0xC1, 0xFF, 0xF0, 0x7E, 0x07, 0xFE, 0x03, 0xF0, 0x06, 0x00,
  0x00, 0xFF, 0xFF, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xB8, 0x00, 0xF0,
  0x1E, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01,
  0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00,
  0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xF0,
  0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE0,
  0x78, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x1E, 0x07, 0xC0,
  0xF0, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x70, 0xF0, 0xEF, 0xEF, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xFC,
  0x00, 0x7B, 0xE0, 0x07, 0x9E, 0x00, 0xF1, 0xF0, 0x1F, 0x0F, 0x83, 0xE0,
  0xFC, 0x0E, 0x07, 0x00, 0x20, 0x40, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78,
  0x78, 0x70, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7C, 0xFB, 0xF7, 0xF7, 0xCF, 0x84, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xF8, 0x7C,
  0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x87, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0,
  0x07, 0x9F, 0x00, 0x3C, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x01,
  0xF7, 0xC0, 0x0F, 0x3E, 0x00, 0x79, 0xF0, 0x07, 0xC7, 0x80, 0x3E, 0x3E,
  0x01, 0xE1, 0xF0, 0x1F, 0x07, 0xC1, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8,
  0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x78, 0x07, 0xC0,
  0x7E, 0x07, 0xF0, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF, 0xDF, 0xFC, 0xFF, 0xC7,
  0xDC, 0x3E, 0x41, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xE0,
  0xFE, 0x1C, 0x01, 0xF0, 0x80, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xC0, 0x7E, 0x38, 0x01, 0xF0, 0x80,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF4, 0x00, 0x1F,
  0xB8, 0x01, 0xF9, 0xFC, 0x7F, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0xFF,
  0xF8, 0x00, 0x10, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1D,
  0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x79,
  0xE0, 0x00, 0xF1, 0xE0, 0x00, 0xF1, 0xE0, 0x01, 0xE1, 0xE0, 0x01, 0xE1,
  0xE0, 0x03, 0xC1, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x01,
  0xE0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x01,
  0xE0, 0x3C, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF0, 0x01,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC7, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xBE, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x83, 0x83, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE8,
  0x00, 0x7C, 0xC0, 0x0F, 0xCF, 0xEF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0x7F, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xFC, 0x0F, 0xC0, 0x41, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x0F, 0xE0, 0xF3, 0xFF, 0x0F,
  0x7F, 0xF8, 0xF7, 0xFF, 0xCF, 0xE0, 0x7E, 0xFC, 0x03, 0xEF, 0x80, 0x1E,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0x80,
  0x1F, 0x7C, 0x01, 0xE7, 0xC0, 0x3E, 0x3E, 0x07, 0xC1, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC3, 0xF0, 0x3E, 0x1F, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80,
  0x1E, 0x7C, 0x00, 0xF3, 0xE0, 0x07, 0x9F, 0x00, 0x3C, 0xF8, 0x01, 0xE3,
  0xC0, 0x1F, 0x1F, 0x00, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0xF8, 0x0F, 0xDF,
  0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x0F,
  0xCF, 0xE0, 0xFC, 0x1F, 0x87, 0xC0, 0x7E, 0x7C, 0x01, 0xF3, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x80, 0x7C,
  0x7F, 0x1F, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x04,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83,
  0xF0, 0xFC, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x78, 0x01,
  0xF7, 0xC0, 0x07, 0xBE, 0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x78, 0x00, 0xFB, 0xE0, 0x0F,
  0xDF, 0x00, 0x7E, 0xFC, 0x07, 0xF3, 0xF0, 0xFF, 0x8F, 0xFF, 0x7C, 0x7F,
  0xFB, 0xE0, 0xFF, 0x1E, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x73, 0xFE, 0x03,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x7C, 0xFB,
  0xF7, 0xF7, 0xCF, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7D, 0xFB, 0xFB, 0xE7, 0xC2,
  0x00, 0x3E, 0x3E, 0x7E, 0x7F, 0x3E, 0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0xF0, 0xF0,
  0xF0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x3F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xC7, 0x03, 0xF2,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1E, 0x00,
  0x06, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF0,
  0x1F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00,
  0xF0, 0xF0, 0x0F, 0xF8, 0x1C, 0x78, 0x0F, 0xFF, 0x07, 0x9E, 0x07, 0xFF,
  0xC1, 0xE7, 0x81, 0xE0, 0xF0, 0x79, 0xC0, 0xF0, 0x3C, 0x0E, 0xF0, 0x3C,
  0x0F, 0x03, 0xBC, 0x1E, 0x03, 0xC0, 0xEF, 0x07, 0x80, 0xF0, 0x3B, 0xC1,
  0xE0, 0x3C, 0x0F, 0xF0, 0x78, 0x0F, 0x03, 0xB8, 0x1E, 0x03, 0xC0, 0xEE,
  0x07, 0x81, 0xE0, 0x3B, 0x81, 0xE0, 0x78, 0x0E, 0xE0, 0x78, 0x1E, 0x03,
  0xB8, 0x1E, 0x07, 0x81, 0xEF, 0x07, 0x81, 0xE0, 0x7B, 0xC1, 0xE0, 0x7C,
  0x1C, 0xF0, 0x3C, 0x3F, 0x0F, 0x3C, 0x0F, 0x9D, 0xE7, 0x8F, 0x01, 0xFF,
  0x3F, 0xE1, 0xE0, 0x7F, 0x8F, 0xF0, 0x78, 0x07, 0xC0, 0xF0, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x08, 0x00,
  0x1F, 0x80, 0x0E, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x77, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x7B, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78,
  0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x78, 0x3C, 0x00,
  0x0F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x01,
  0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x00, 0xF0, 0x3E,
  0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0x87, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xF8, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF8, 0x3F, 0xF3, 0xE0,
  0x0F, 0xCF, 0x80, 0x1F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03,
  0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF,
  0x80, 0x0F, 0x3E, 0x00, 0x7C, 0xF8, 0x07, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE3, 0xE0, 0x0F, 0xCF, 0x80, 0x1F,
  0xBE, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x3F, 0xBF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0x03, 0xC1,
  0xF8, 0x01, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x30, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x03, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xC0, 0x1F, 0xC3, 0xE0,
  0x07, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x3E,
  0x00, 0x0F, 0x9F, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB,
  0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07,
  0xBE, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xF7, 0xC0, 0x00,
  0x7B, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00,
  0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xE7, 0xC0,
  0x01, 0xF3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0x7C,
  0x01, 0xFC, 0x3E, 0x03, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x07, 0xF8, 0x0F, 0x83, 0xF0, 0x00, 0xC1, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x0F, 0x7C, 0x00, 0x03,
  0xDF, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x3C, 0xFC, 0x00, 0x0F, 0x1F, 0x00,
  0x03, 0xC7, 0xF0, 0x00, 0xF0, 0xFE, 0x00, 0x3C, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x0C, 0x00,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFE, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x3E, 0x07, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0xCF, 0x80, 0x1F,
  0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0x81,
  0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F,
  0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF9, 0xF0, 0x01, 0xF7,
  0xC0, 0x03, 0xEF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0x9F, 0x00, 0x7E, 0x3F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x3E,
  0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0xF8,
  0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xF1, 0xF0, 0x03, 0xE3,
  0xE0, 0x07, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0xDF, 0x00, 0x0F, 0xBE,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x78, 0x00, 0x07, 0xFF, 0xDE, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xF7, 0xFE, 0xF0, 0x00, 0x3D, 0xFF, 0xBC, 0x00, 0x0F,
  0x7F, 0xEF, 0x00, 0x07, 0x9F, 0xF9, 0xE0, 0x01, 0xE7, 0xFE, 0x78, 0x00,
  0x79, 0xFF, 0x9E, 0x00, 0x3E, 0x7F, 0xE7, 0xC0, 0x0F, 0x1F, 0xF8, 0xF0,
  0x03, 0xC7, 0xFE, 0x3C, 0x00, 0xF1, 0xFF, 0x8F, 0x80, 0x78, 0x7F, 0xE1,
  0xE0, 0x1E, 0x1F, 0xF8, 0x78, 0x07, 0x87, 0xFE, 0x1F, 0x03, 0xC1, 0xFF,
  0x83, 0xC0, 0xF0, 0x7F, 0xE0, 0xF0, 0x3C, 0x1F, 0xF8, 0x3E, 0x1E, 0x07,
  0xFE, 0x07, 0x87, 0x81, 0xFF, 0x81, 0xE1, 0xE0, 0x7F, 0xE0, 0x78, 0xF0,
  0x1F, 0xF8, 0x0F, 0x3C, 0x07, 0xFE, 0x03, 0xCF, 0x01, 0xFF, 0x80, 0xF7,
  0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xF8, 0x07, 0xFE, 0x01,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x1F, 0xF8,
  0x03, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1E, 0x00, 0x7C,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xDE,
  0x00, 0x1F, 0xF7, 0xC0, 0x07, 0xFC, 0xF0, 0x01, 0xFF, 0xBE, 0x00, 0x7F,
  0xE7, 0x80, 0x1F, 0xF9, 0xF0, 0x07, 0xFE, 0x7C, 0x01, 0xFF, 0x8F, 0x80,
  0x7F, 0xE3, 0xE0, 0x1F, 0xF8, 0x7C, 0x07, 0xFE, 0x1F, 0x01, 0xFF, 0x83,
  0xE0, 0x7F, 0xE0, 0xF8, 0x1F, 0xF8, 0x1F, 0x07, 0xFE, 0x07, 0xC1, 0xFF,
  0x80, 0xF8, 0x7F, 0xE0, 0x3E, 0x1F, 0xF8, 0x07, 0xC7, 0xFE, 0x01, 0xF1,
  0xFF, 0x80, 0x3E, 0x7F, 0xE0, 0x0F, 0x9F, 0xF8, 0x01, 0xF7, 0xFE, 0x00,
  0x7D, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xE0, 0xFF,
  0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xF8, 0x7E,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xFC, 0x3F,
  0x00, 0x0F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x40, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x7C, 0x03, 0xF3, 0xE0, 0x0F, 0xDF, 0x00, 0x3E,
  0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xBE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7B, 0xE0, 0x03, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7,
  0xC0, 0x1F, 0xBE, 0x01, 0xF9, 0xF0, 0x3F, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xE0, 0xFF, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1E, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E,
  0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x7F,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x5F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x1F, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1,
  0xF0, 0x01, 0xE3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F,
  0x00, 0x1E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0,
  0x07, 0xC3, 0xE0, 0x3F, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x3E,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8,
  0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xF1, 0xF0, 0x03, 0xE3,
  0xE0, 0x07, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0xDF, 0x00, 0x0F, 0xBE,
  0x00, 0x1F, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xF1, 0xFF,
  0xFE, 0x3F, 0x83, 0xE7, 0xE0, 0x04, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x3E, 0xF0, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00,
  0x1E, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7E, 0x00,
  0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x9F,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x78, 0x1F, 0x00,
  0x3E, 0x03, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x01, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0x01, 0xE0,
  0x07, 0xC0, 0xF8, 0x00, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x1F, 0x1E, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0xBC, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xDE, 0x00, 0x07, 0xC0, 0x01,
  0xF7, 0xC0, 0x03, 0xF0, 0x00, 0x79, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0xC0, 0x03, 0xE3, 0xC0, 0x07,
  0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xFE, 0x00, 0x3C, 0x3E, 0x00, 0x7F, 0x80,
  0x1F, 0x0F, 0x80, 0x1F, 0xE0, 0x07, 0xC1, 0xE0, 0x07, 0xBC, 0x01, 0xF0,
  0x78, 0x03, 0xCF, 0x00, 0x78, 0x1F, 0x00, 0xF3, 0xC0, 0x1E, 0x07, 0xC0,
  0x3C, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0x87,
  0x80, 0xF8, 0x0F, 0x81, 0xE1, 0xE0, 0x3C, 0x03, 0xE0, 0x78, 0x78, 0x1F,
  0x00, 0xF8, 0x1E, 0x1E, 0x07, 0xC0, 0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0x07,
  0x83, 0xC0, 0xF0, 0x78, 0x01, 0xF0, 0xF0, 0x3C, 0x1E, 0x00, 0x7C, 0x3C,
  0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x03, 0xE3, 0xE0, 0x03, 0xC7, 0x80, 0x78,
  0xF8, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x00, 0x3E, 0x78, 0x07, 0x8F, 0x00,
  0x0F, 0x9E, 0x01, 0xE7, 0xC0, 0x01, 0xE7, 0x80, 0x3D, 0xF0, 0x00, 0x7B,
  0xC0, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00,
  0xF7, 0x80, 0x00, 0xFF, 0x00, 0x1D, 0xE0, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x1E, 0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x0F, 0x00, 0x78, 0x0F, 0x80, 0xF8,
  0x07, 0x80, 0xF8, 0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xE0,
  0x03, 0xE3, 0xE0, 0x01, 0xE3, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0xF7, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xF7, 0x80, 0x01, 0xF7, 0xC0, 0x01, 0xE7, 0xC0, 0x03, 0xE3, 0xE0,
  0x03, 0xC3, 0xE0, 0x07, 0xC1, 0xE0, 0x07, 0x81, 0xF0, 0x0F, 0x80, 0xF0,
  0x0F, 0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x1F, 0x00, 0xF8,
  0x1F, 0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0x81, 0xE0,
  0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xE7, 0xC0,
  0x01, 0xE7, 0x80, 0x01, 0xF7, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80,
  0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0x83, 0xE0, 0x07, 0x81, 0xE0,
  0x0F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0xF8, 0x1E, 0x00, 0x78,
  0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x07, 0xFE,
  0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0x87, 0xE0, 0x80, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0xCF, 0xFF, 0xF9, 0xF8, 0x0F,
  0x7C, 0x01, 0xEF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0x7C, 0x0F, 0xEF, 0xC3, 0xFD,
  0xFF, 0xF7, 0x9F, 0xFC, 0xF1, 0xFF, 0x0E, 0x02, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x0F, 0xF0, 0x79, 0xFF, 0xC3, 0xDF,
  0xFF, 0x1E, 0xFB, 0xFC, 0xFE, 0x03, 0xE7, 0xE0, 0x0F, 0xBF, 0x00, 0x7D,
  0xF0, 0x03, 0xEF, 0x80, 0x0F, 0x7C, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xF7, 0xC0, 0x0F, 0xBF, 0x00, 0x7D, 0xF8, 0x03, 0xEF, 0xE0, 0x3E, 0x7F,
  0xC7, 0xF3, 0xDF, 0xFF, 0x1E, 0x7F, 0xF0, 0xE1, 0xFF, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x01, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE3, 0xFD, 0xF1,
  0xF0, 0x09, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x8F, 0xF3, 0xC3, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x18, 0x1F, 0x03, 0xFC, 0x7C, 0x3F, 0xF9, 0xF0, 0xFF, 0xF7,
  0xC7, 0xF3, 0xFF, 0x3F, 0x03, 0xFC, 0xF8, 0x07, 0xF3, 0xC0, 0x0F, 0xDF,
  0x00, 0x3F, 0x7C, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00,
  0x1F, 0x78, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0x78, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0x7C,
  0x00, 0x7D, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xCF, 0x80, 0x7F, 0x3F, 0x01,
  0xFC, 0x7E, 0x1F, 0xF1, 0xFF, 0xF3, 0xC3, 0xFF, 0x8F, 0x03, 0xFC, 0x3C,
  0x00, 0x80, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xF0,
  0xF8, 0x3E, 0x07, 0xC7, 0xC0, 0x3C, 0x78, 0x03, 0xEF, 0x80, 0x1E, 0xF8,
  0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x43, 0xFC, 0x7C, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x03, 0xFF, 0x80, 0x06, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFE,
  0x07, 0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xF0, 0xF0, 0x7F, 0xE3,
  0xC3, 0xFF, 0xCF, 0x1F, 0xDF, 0xFC, 0xFC, 0x0F, 0xF3, 0xE0, 0x1F, 0xCF,
  0x00, 0x3F, 0x7C, 0x00, 0xFD, 0xF0, 0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00,
  0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0x78,
  0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x3E, 0x01,
  0xFC, 0xFC, 0x07, 0xF1, 0xF8, 0x7F, 0xC3, 0xFF, 0xDF, 0x0F, 0xFE, 0x7C,
  0x0F, 0xF1, 0xF0, 0x04, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x80, 0x07,
  0xC3, 0xC0, 0x7F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0xFF, 0x0F,
  0x3F, 0xF8, 0xF7, 0xFF, 0xCF, 0x7D, 0xFC, 0xFE, 0x03, 0xEF, 0xC0, 0x3E,
  0xFC, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xF0, 0x77, 0xBF,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0x03,
  0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F,
  0xBF, 0xCF, 0xF3, 0xF8, 0xF8, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x3F, 0xE0, 0x0F, 0xBC, 0x03, 0xE7, 0x80, 0xF8, 0xF0, 0x1F, 0x1E, 0x07,
  0xC3, 0xC1, 0xF0, 0x78, 0x3C, 0x0F, 0x0F, 0x81, 0xE3, 0xE0, 0x3C, 0x78,
  0x07, 0x9E, 0x00, 0xF7, 0xE0, 0x1E, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0x78,
  0x0F, 0xCF, 0x81, 0xF0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xF0, 0xF0, 0x3E,
  0x1E, 0x03, 0xE3, 0xC0, 0x7C, 0x78, 0x07, 0xCF, 0x00, 0xF9, 0xE0, 0x0F,
  0xBC, 0x01, 0xF7, 0x80, 0x1F, 0xF0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x10, 0x00, 0x40, 0x78, 0xFF, 0x03,
  0xFE, 0x3C, 0xFF, 0xC3, 0xFF, 0x9E, 0xFF, 0xF3, 0xFF, 0xEF, 0xF9, 0xFD,
  0xE7, 0xF7, 0xF0, 0x3F, 0xC0, 0xFF, 0xF0, 0x1F, 0xC0, 0x3F, 0xF0, 0x07,
  0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x07, 0xFC, 0x01, 0xF0, 0x03, 0xFE, 0x00,
  0xF8, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x7F, 0x80,
  0x1F, 0x00, 0x3F, 0xC0, 0x0F, 0x80, 0x1F, 0xE0, 0x07, 0xC0, 0x0F, 0xF0,
  0x03, 0xE0, 0x07, 0xF8, 0x01, 0xF0, 0x03, 0xFC, 0x00, 0xF8, 0x01, 0xFE,
  0x00, 0x7C, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x1F, 0x00, 0x3F,
  0xC0, 0x0F, 0x80, 0x1F, 0xE0, 0x07, 0xC0, 0x0F, 0xF0, 0x03, 0xE0, 0x07,
  0xF8, 0x01, 0xF0, 0x03, 0xFC, 0x00, 0xF8, 0x01, 0xFE, 0x00, 0x7C, 0x00,
  0xFF, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x10, 0x0F,
  0x1F, 0xF0, 0xF3, 0xFF, 0x8F, 0x7F, 0xFC, 0xFF, 0xDF, 0xCF, 0xE0, 0x7E,
  0xFC, 0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0x00, 0x30, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F,
  0xCF, 0xE0, 0xFC, 0x07, 0xC3, 0xE0, 0x0F, 0x8F, 0x00, 0x3E, 0x7C, 0x00,
  0x79, 0xF0, 0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0x7D,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xE0,
  0x00, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xF0, 0x01,
  0xE7, 0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x3E, 0x00, 0xF0, 0x7C, 0x07, 0xC1,
  0xFC, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x10, 0x07, 0x8F, 0xF8, 0x3C, 0xFF, 0xE1, 0xEF, 0xFF,
  0x8F, 0x78, 0xFE, 0x7F, 0x01, 0xF3, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xF8,
  0x01, 0xF7, 0xC0, 0x07, 0xBE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7B,
  0xE0, 0x07, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xF0, 0x1F, 0x3F, 0xF7,
  0xF9, 0xEF, 0xFF, 0x8F, 0x3F, 0xF8, 0x78, 0xFF, 0x83, 0xC0, 0xC0, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xF0,
  0xF0, 0x7F, 0xE3, 0xC3, 0xFF, 0xCF, 0x1F, 0xCF, 0xFC, 0xFC, 0x0F, 0xF3,
  0xE0, 0x1F, 0xCF, 0x00, 0x3F, 0x7C, 0x00, 0xFD, 0xF0, 0x01, 0xF7, 0x80,
  0x07, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDE,
  0x00, 0x1F, 0x78, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xDF, 0x00,
  0x3F, 0x3E, 0x01, 0xFC, 0xFC, 0x07, 0xF1, 0xFC, 0xFF, 0xC3, 0xFF, 0xDF,
  0x0F, 0xFE, 0x7C, 0x0F, 0xF1, 0xF0, 0x04, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x23, 0x83, 0xFF, 0x3F, 0xBC,
  0xFE, 0xF7, 0xFB, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00,
  0xC0, 0x07, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xE1, 0xE7, 0xC0, 0x13,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x0F, 0x60, 0x0F, 0xBF, 0x1F, 0xDF, 0xFF, 0xCF, 0xFF,
  0xC3, 0xFF, 0xC0, 0x04, 0x00, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0x87, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0xCC, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0xE0, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xEF, 0xEF, 0xFD,
  0xFF, 0xF7, 0x9F, 0xFC, 0x71, 0xFF, 0x0E, 0x02, 0x00, 0x00, 0xF8, 0x00,
  0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF8,
  0xF0, 0x03, 0xC3, 0xE0, 0x0F, 0x0F, 0x80, 0x7C, 0x1E, 0x01, 0xF0, 0x78,
  0x07, 0x81, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x0F, 0x03, 0xC0, 0x3C, 0x0F,
  0x00, 0xF8, 0x7C, 0x01, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00,
  0x3C, 0xF8, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xFC, 0x00,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xE0, 0x1F, 0xC0, 0x1E, 0x78,
  0x07, 0xF0, 0x07, 0x9E, 0x01, 0xFE, 0x03, 0xE7, 0xC0, 0x7F, 0x80, 0xF9,
  0xF0, 0x1D, 0xE0, 0x3C, 0x3C, 0x0F, 0x78, 0x0F, 0x0F, 0x03, 0xCF, 0x03,
  0xC3, 0xC0, 0xF3, 0xC1, 0xF0, 0xF8, 0x3C, 0xF0, 0x78, 0x3E, 0x1E, 0x3C,
  0x1E, 0x07, 0x87, 0x87, 0x07, 0x81, 0xE1, 0xE1, 0xE3, 0xE0, 0x78, 0x78,
  0x78, 0xF0, 0x1F, 0x3C, 0x1E, 0x3C, 0x03, 0xCF, 0x07, 0x8F, 0x00, 0xF3,
  0xC0, 0xF3, 0xC0, 0x3C, 0xF0, 0x3D, 0xE0, 0x0F, 0x38, 0x0F, 0x78, 0x01,
  0xFE, 0x03, 0xDE, 0x00, 0x7F, 0x80, 0x77, 0x80, 0x1F, 0xE0, 0x1D, 0xE0,
  0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x01,
  0xFB, 0xE0, 0x0F, 0x8F, 0x00, 0xF8, 0x7C, 0x07, 0xC1, 0xE0, 0x7C, 0x0F,
  0x83, 0xE0, 0x3C, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0x9F, 0x00, 0x3E, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xF7, 0x80,
  0x0F, 0x3E, 0x00, 0xF8, 0xF0, 0x07, 0x87, 0xC0, 0x7C, 0x1E, 0x03, 0xC0,
  0xF8, 0x3E, 0x03, 0xC1, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0xF0, 0x03, 0xEF,
  0x80, 0x0F, 0x80, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0x9F,
  0x00, 0x3E, 0x3C, 0x00, 0xF8, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x0F, 0x80,
  0x7C, 0x1E, 0x01, 0xF0, 0x7C, 0x07, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0xF8,
  0x0F, 0x03, 0xC0, 0x3E, 0x0F, 0x00, 0x78, 0x7C, 0x01, 0xE1, 0xF0, 0x07,
  0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0xF8, 0x00, 0xF3, 0xC0, 0x03, 0xEF,
  0x00, 0x07, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00,
  0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0xFF, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x04, 0xFF, 0x00, 0x17, 0xFF, 0x01, 0xFF, 0xFF, 0xDF, 0xF1,
  0xFF, 0xFF, 0x00, 0xFF, 0xE8, 0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_Condensed_Regular54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 40, 13, 4, -39 },
  { 31, 15, 14, 21, 3, -39 },
  { 58, 26, 39, 28, 1, -39 },
  { 185, 20, 44, 25, 3, -41 },
  { 295, 34, 39, 39, 2, -39 },
  { 461, 28, 40, 30, 2, -39 },
  { 601, 5, 14, 12, 3, -39 },
  { 610, 12, 48, 16, 2, -39 },
  { 682, 11, 48, 16, 2, -39 },
  { 748, 20, 20, 24, 2, -41 },
  { 798, 21, 26, 26, 2, -32 },
  { 867, 8, 13, 13, 2, -6 },
  { 880, 12, 5, 16, 2, -17 },
  { 888, 7, 7, 13, 3, -6 },
  { 895, 18, 39, 20, 1, -39 },
  { 983, 21, 40, 25, 2, -39 },
  { 1088, 13, 39, 25, 4, -39 },
  { 1152, 21, 39, 25, 2, -39 },
  { 1255, 21, 40, 25, 2, -39 },
  { 1360, 24, 39, 25, 1, -39 },
  { 1477, 20, 40, 25, 3, -39 },
  { 1577, 20, 40, 25, 3, -39 },
  { 1677, 21, 39, 25, 2, -39 },
  { 1780, 21, 40, 25, 2, -39 },
  { 1885, 21, 40, 25, 2, -39 },
  { 1990, 7, 30, 13, 3, -29 },
  { 2017, 8, 36, 13, 2, -29 },
  { 2053, 22, 25, 26, 2, -32 },
  { 2122, 21, 16, 26, 2, -27 },
  { 2164, 22, 25, 26, 2, -32 },
  { 2233, 17, 40, 19, 1, -39 },
  { 2318, 34, 44, 39, 3, -39 },
  { 2505, 27, 39, 27, 0, -39 },
  { 2637, 22, 39, 29, 4, -39 },
  { 2745, 23, 40, 27, 3, -39 },
  { 2860, 25, 39, 31, 4, -39 },
  { 2982, 18, 39, 24, 4, -39 },
  { 3070, 18, 39, 23, 4, -39 },
  { 3158, 26, 40, 32, 3, -39 },
  { 3288, 24, 39, 32, 4, -39 },
  { 3405, 12, 39, 16, 2, -39 },
  { 3464, 12, 49, 13, -3, -39 },
  { 3538, 23, 39, 27, 4, -39 },
  { 3651, 17, 39, 23, 4, -39 },
  { 3734, 34, 39, 42, 4, -39 },
  { 3900, 26, 39, 34, 4, -39 },
  { 4027, 28, 40, 33, 3, -39 },
  { 4167, 21, 39, 27, 4, -39 },
  { 4270, 28, 48, 33, 3, -39 },
  { 4438, 23, 39, 27, 4, -39 },
  { 4551, 20, 40, 25, 2, -39 },
  { 4651, 22, 39, 23, 1, -39 },
  { 4759, 24, 40, 32, 4, -39 },
  { 4879, 26, 39, 26, 0, -39 },
  { 5006, 42, 39, 42, 0, -39 },
  { 5211, 24, 39, 25, 0, -39 },
  { 5328, 24, 39, 24, 0, -39 },
  { 5445, 20, 39, 23, 2, -39 },
  { 5543, 12, 48, 17, 4, -39 },
  { 5615, 18, 39, 20, 1, -39 },
  { 5703, 11, 48, 17, 2, -39 },
  { 5769, 24, 22, 26, 1, -39 },
  { 5835, 24, 3, 24, 0, 5 },
  { 5844, 10, 8, 15, 2, -41 },
  { 5854, 19, 30, 25, 2, -29 },
  { 5926, 21, 42, 27, 4, -41 },
  { 6037, 17, 31, 21, 3, -30 },
  { 6103, 22, 42, 27, 2, -41 },
  { 6219, 20, 30, 25, 3, -29 },
  { 6294, 16, 41, 15, 1, -41 },
  { 6376, 22, 43, 27, 2, -30 },
  { 6495, 20, 41, 27, 4, -41 },
  { 6598, 5, 40, 12, 4, -40 },
  { 6623, 10, 53, 12, -1, -40 },
  { 6690, 19, 41, 24, 4, -41 },
  { 6788, 4, 41, 12, 4, -41 },
  { 6809, 33, 30, 41, 4, -30 },
  { 6933, 20, 30, 27, 4, -30 },
  { 7008, 22, 31, 27, 2, -30 },
  { 7094, 21, 43, 27, 4, -30 },
  { 7207, 22, 43, 27, 2, -30 },
  { 7326, 14, 30, 18, 4, -30 },
  { 7379, 17, 31, 21, 2, -30 },
  { 7445, 14, 37, 16, 1, -36 },
  { 7510, 19, 30, 27, 4, -29 },
  { 7582, 22, 29, 22, 0, -29 },
  { 7662, 34, 29, 36, 1, -29 },
  { 7786, 21, 29, 23, 1, -29 },
  { 7863, 22, 42, 22, 0, -29 },
  { 7979, 16, 29, 19, 2, -29 },
  { 8037, 16, 48, 20, 2, -39 },
  { 8133, 4, 54, 24, 10, -41 },
  { 8160, 16, 48, 20, 2, -39 },
  { 8256, 22, 7, 26, 2, -23 },
};

const GFXfont NotoSans_Condensed_Regular54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular54pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_CONDENSED_REGULAR54PT7B_H_
