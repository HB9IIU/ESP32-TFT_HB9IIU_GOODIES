#ifndef _NOTOSANS_CONDENSED_REGULAR18PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xD5, 0x43, 0xC0, 0xDE, 0xF7, 0xB8, 0x80, 0x19, 0x09, 0x84,
  0x82, 0x47, 0xF8, 0x90, 0xC8, 0x64, 0xFF, 0x12, 0x09, 0x04, 0x82, 0x40,
  0x10, 0x21, 0xF6, 0xA9, 0x12, 0x3C, 0x1C, 0x1C, 0x2C, 0x5C, 0xEF, 0x82,
  0x04, 0x00, 0x61, 0x92, 0x22, 0x4C, 0x49, 0x09, 0x21, 0x29, 0xA5, 0x5B,
  0x69, 0x09, 0x21, 0x24, 0x44, 0x88, 0x93, 0x1C, 0x38, 0x26, 0x13, 0x09,
  0x86, 0x81, 0xC1, 0xC1, 0xB2, 0x8D, 0x43, 0xA1, 0x99, 0xE7, 0x98, 0xFF,
  0x80, 0x36, 0x44, 0xCC, 0x88, 0x88, 0xCC, 0x44, 0x63, 0x99, 0x32, 0x49,
  0x24, 0x96, 0xB4, 0x30, 0xCB, 0x7F, 0x31, 0x6C, 0xC0, 0x10, 0x20, 0x40,
  0x8F, 0xE2, 0x04, 0x08, 0x10, 0xFE, 0xFF, 0xF0, 0x04, 0x10, 0xC2, 0x18,
  0x41, 0x0C, 0x20, 0x86, 0x10, 0xC0, 0x38, 0xDB, 0x16, 0x28, 0x70, 0xE1,
  0xC3, 0x87, 0x8B, 0x12, 0x67, 0x80, 0x19, 0xFE, 0xB1, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x80, 0x79, 0x98, 0x10, 0x20, 0x41, 0x82, 0x0C, 0x30, 0xC1,
  0x06, 0x0F, 0xE0, 0x79, 0x98, 0x10, 0x20, 0xC3, 0x1E, 0x06, 0x04, 0x0C,
  0x14, 0x6F, 0x80, 0x06, 0x0E, 0x0E, 0x1E, 0x16, 0x26, 0x26, 0x46, 0x46,
  0xFF, 0x06, 0x06, 0x06, 0x7D, 0xFB, 0x06, 0x0C, 0x1F, 0x13, 0x02, 0x06,
  0x0C, 0x14, 0x6F, 0x80, 0x3C, 0xC9, 0x06, 0x0C, 0x17, 0x33, 0x63, 0x87,
  0x0F, 0x1A, 0x67, 0x80, 0xFF, 0xFC, 0x10, 0x60, 0xC1, 0x06, 0x0C, 0x10,
  0x60, 0x83, 0x06, 0x00, 0x79, 0x9B, 0x16, 0x2C, 0x4F, 0x0E, 0x66, 0x87,
  0x0E, 0x1E, 0x27, 0xC0, 0x79, 0x9B, 0x14, 0x28, 0x70, 0xF3, 0xBF, 0x04,
  0x08, 0x30, 0xCF, 0x00, 0xF4, 0x00, 0xF0, 0xF4, 0x00, 0xFA, 0x02, 0x0C,
  0x73, 0x8C, 0x1C, 0x0E, 0x07, 0x02, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x81,
  0x81, 0xC0, 0xE0, 0x63, 0x9C, 0x60, 0x80, 0x7B, 0x30, 0xC3, 0x0C, 0x61,
  0x0C, 0x20, 0x00, 0x0C, 0x30, 0x0F, 0x06, 0x11, 0x81, 0x20, 0x3C, 0xF3,
  0x32, 0x64, 0x4C, 0x89, 0x93, 0x33, 0x6F, 0x37, 0x20, 0x06, 0x00, 0x7E,
  0x01, 0x00, 0x0C, 0x0E, 0x05, 0x02, 0x83, 0x61, 0xB0, 0x88, 0x46, 0x7F,
  0x30, 0x90, 0x58, 0x3C, 0x18, 0xFC, 0xCE, 0xC2, 0xC2, 0xC2, 0xC6, 0xFC,
  0xC2, 0xC3, 0xC3, 0xC3, 0xC6, 0xFC, 0x1F, 0x72, 0x60, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x72, 0x3E, 0xFC, 0x7F, 0x30, 0xD8, 0x6C,
  0x16, 0x0B, 0x07, 0x82, 0xC1, 0x61, 0xB0, 0xD9, 0xCF, 0xC0, 0xFF, 0xFC,
  0x30, 0xC3, 0x0F, 0xF0, 0xC3, 0x0C, 0x30, 0xFC, 0xFF, 0xFC, 0x30, 0xC3,
  0x0F, 0xFF, 0xC3, 0x0C, 0x30, 0xC0, 0x1F, 0x98, 0x98, 0x18, 0x0C, 0x06,
  0x03, 0x1F, 0x8F, 0xC1, 0xE0, 0xD8, 0x6E, 0x33, 0xF8, 0xC1, 0xC1, 0xC1,
  0xC1, 0xC1, 0xC1, 0xFF, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xF4, 0x44,
  0x44, 0x44, 0x44, 0x44, 0xF0, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x3E, 0xC3, 0xC6, 0xC4, 0xCC, 0xD8, 0xD0, 0xF0, 0xF8, 0xCC, 0xCC, 0xC6,
  0xC6, 0xC3, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFC,
  0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0xD0, 0xBD, 0x0B, 0xD9, 0xBC, 0x93,
  0xC9, 0x3C, 0xF3, 0xCE, 0x3C, 0x63, 0xC6, 0x30, 0xC1, 0xF0, 0xF8, 0x7E,
  0x3D, 0x1E, 0xCF, 0x27, 0x9B, 0xC5, 0xE3, 0xF0, 0xF8, 0x7C, 0x18, 0x3E,
  0x3B, 0x90, 0x58, 0x3C, 0x1E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xD0, 0x6C,
  0x63, 0xE0, 0xF9, 0xFF, 0x1E, 0x1C, 0x38, 0xF3, 0xFC, 0xC1, 0x83, 0x06,
  0x0C, 0x00, 0x3E, 0x3B, 0x90, 0x58, 0x3C, 0x1E, 0x07, 0x03, 0x81, 0xC1,
  0xE0, 0xD0, 0x6C, 0x63, 0xE0, 0x30, 0x0C, 0x07, 0xF8, 0xFE, 0xC6, 0xC2,
  0xC2, 0xC6, 0xFC, 0xF8, 0xCC, 0xC4, 0xC6, 0xC6, 0xC3, 0x7F, 0xBC, 0x20,
  0xC3, 0x83, 0x83, 0x04, 0x10, 0x63, 0xF8, 0xFF, 0xFF, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xC1, 0xC1, 0xC1, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0x43, 0x63, 0x3E, 0xC1, 0xE0, 0x90,
  0x4C, 0x66, 0x33, 0x10, 0x88, 0x6C, 0x34, 0x0A, 0x05, 0x03, 0x81, 0x80,
  0xC3, 0x0F, 0x0C, 0x34, 0x30, 0x90, 0xE2, 0x67, 0x99, 0x92, 0x62, 0x49,
  0x89, 0x24, 0x2C, 0xD0, 0xF1, 0xC3, 0x87, 0x06, 0x18, 0x18, 0x60, 0xC3,
  0x62, 0x26, 0x34, 0x3C, 0x18, 0x18, 0x1C, 0x34, 0x24, 0x66, 0x42, 0xC3,
  0xC3, 0x42, 0x66, 0x66, 0x24, 0x3C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0xFF, 0xF0, 0x86, 0x18, 0xC3, 0x08, 0x61, 0x0C, 0x20, 0xFC, 0xFC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xC1, 0x06, 0x08, 0x20, 0xC1,
  0x04, 0x18, 0x20, 0xC3, 0x04, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x4F, 0x08,
  0x18, 0x14, 0x34, 0x26, 0x62, 0xC3, 0xFF, 0xC8, 0x80, 0xF9, 0x30, 0xC1,
  0x3F, 0x18, 0x63, 0xCF, 0xD0, 0xC1, 0x83, 0x06, 0x0D, 0xDD, 0xF1, 0xE1,
  0xC3, 0x87, 0x0E, 0x3E, 0x7F, 0x80, 0x3D, 0xAC, 0x30, 0x82, 0x08, 0x30,
  0xC5, 0xE0, 0x06, 0x0C, 0x18, 0x33, 0x6D, 0xF1, 0xC3, 0x87, 0x0E, 0x1E,
  0x3C, 0x6F, 0x40, 0x38, 0xDB, 0x14, 0x2F, 0xF0, 0x20, 0x60, 0x44, 0xF8,
  0x1C, 0xE2, 0x08, 0x7B, 0xE2, 0x08, 0x20, 0x82, 0x08, 0x20, 0x80, 0x32,
  0xDF, 0x1C, 0x38, 0x70, 0xE1, 0xE3, 0xC6, 0xFC, 0x18, 0x38, 0x5F, 0x80,
  0xC1, 0x83, 0x06, 0x0D, 0xDF, 0xB1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xC0, 0xF3, 0xFF, 0xFF, 0xC0, 0x6C, 0x36, 0xDB, 0x6D, 0xB6, 0xDB, 0xC0,
  0xC1, 0x83, 0x06, 0x0C, 0x79, 0xB6, 0x68, 0xF1, 0xE3, 0x66, 0x6C, 0xD8,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xD9, 0xDD, 0xAF, 0x18, 0xE3, 0x1C, 0x63,
  0x8C, 0x71, 0x8E, 0x31, 0xC6, 0x38, 0xC4, 0xDD, 0xFB, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8C, 0x38, 0xDB, 0x1C, 0x38, 0x30, 0x61, 0xE3, 0x44,
  0xF8, 0xDD, 0xDF, 0x1E, 0x1C, 0x38, 0x70, 0xE3, 0xE7, 0xFB, 0x06, 0x0C,
  0x18, 0x00, 0x32, 0xDF, 0x1C, 0x38, 0x70, 0xE1, 0xE3, 0xC6, 0xFC, 0x18,
  0x30, 0x60, 0xC0, 0x9F, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x00, 0x76, 0xE1,
  0x0E, 0x18, 0x61, 0x9F, 0x80, 0x21, 0x1F, 0xF6, 0x31, 0x8C, 0x63, 0x18,
  0x70, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xCE, 0xF4, 0xC3, 0x8D,
  0x1A, 0x26, 0x45, 0x8B, 0x14, 0x38, 0x30, 0xC6, 0x3C, 0x62, 0x46, 0x24,
  0xF2, 0x6B, 0x66, 0x94, 0x29, 0x43, 0x94, 0x31, 0xC3, 0x0C, 0xC6, 0xCC,
  0xB1, 0xE1, 0x83, 0x0E, 0x16, 0x65, 0x8C, 0xC3, 0x8D, 0x1B, 0x26, 0x45,
  0x8B, 0x1C, 0x18, 0x30, 0x40, 0x83, 0x1C, 0x00, 0xFF, 0xC4, 0x62, 0x31,
  0x18, 0x87, 0xC0, 0x19, 0x88, 0x42, 0x11, 0x98, 0xC3, 0x08, 0x42, 0x10,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0x18, 0x42, 0x10, 0x87, 0x39,
  0x08, 0x42, 0x31, 0x98, 0x43, 0xFE, 0x30,
};

const GFXglyph NotoSans_Condensed_Regular18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 13, 4, 1, -13 },
  { 5, 5, 5, 7, 1, -13 },
  { 9, 9, 13, 9, 0, -13 },
  { 24, 7, 15, 9, 1, -14 },
  { 38, 11, 13, 13, 1, -13 },
  { 56, 9, 13, 10, 1, -13 },
  { 71, 2, 5, 4, 1, -13 },
  { 73, 4, 16, 5, 1, -13 },
  { 81, 3, 16, 5, 1, -13 },
  { 87, 6, 7, 8, 1, -14 },
  { 93, 7, 9, 9, 1, -11 },
  { 101, 2, 4, 4, 1, -2 },
  { 102, 4, 2, 5, 1, -6 },
  { 103, 2, 2, 4, 1, -2 },
  { 104, 6, 13, 7, 0, -13 },
  { 114, 7, 13, 9, 1, -13 },
  { 126, 5, 13, 9, 1, -13 },
  { 135, 7, 13, 9, 1, -13 },
  { 147, 7, 13, 9, 1, -13 },
  { 159, 8, 13, 9, 0, -13 },
  { 172, 7, 13, 9, 1, -13 },
  { 184, 7, 13, 9, 1, -13 },
  { 196, 7, 13, 9, 1, -13 },
  { 208, 7, 13, 9, 1, -13 },
  { 220, 7, 13, 9, 1, -13 },
  { 232, 2, 10, 4, 1, -10 },
  { 235, 2, 12, 4, 1, -10 },
  { 238, 7, 9, 9, 1, -11 },
  { 246, 7, 5, 9, 1, -9 },
  { 251, 7, 9, 9, 1, -11 },
  { 259, 6, 13, 6, 0, -13 },
  { 269, 11, 15, 13, 1, -13 },
  { 290, 9, 13, 9, 0, -13 },
  { 305, 8, 13, 10, 1, -13 },
  { 318, 8, 13, 9, 1, -13 },
  { 331, 9, 13, 10, 1, -13 },
  { 346, 6, 13, 8, 1, -13 },
  { 356, 6, 13, 8, 1, -13 },
  { 366, 9, 13, 11, 1, -13 },
  { 381, 8, 13, 11, 1, -13 },
  { 394, 4, 13, 5, 1, -13 },
  { 401, 4, 16, 4, -1, -13 },
  { 409, 8, 13, 9, 1, -13 },
  { 422, 6, 13, 8, 1, -13 },
  { 432, 12, 13, 14, 1, -13 },
  { 452, 9, 13, 11, 1, -13 },
  { 467, 9, 13, 11, 1, -13 },
  { 482, 7, 13, 9, 1, -13 },
  { 494, 9, 16, 11, 1, -13 },
  { 512, 8, 13, 9, 1, -13 },
  { 525, 6, 13, 8, 1, -13 },
  { 535, 8, 13, 8, 0, -13 },
  { 548, 8, 13, 11, 1, -13 },
  { 561, 9, 13, 9, 0, -13 },
  { 576, 14, 13, 14, 0, -13 },
  { 599, 8, 13, 8, 0, -13 },
  { 612, 8, 13, 8, 0, -13 },
  { 625, 6, 13, 8, 1, -13 },
  { 635, 4, 16, 6, 1, -13 },
  { 643, 6, 13, 7, 0, -13 },
  { 653, 3, 16, 6, 1, -13 },
  { 659, 8, 7, 9, 0, -13 },
  { 666, 8, 1, 8, 0, 2 },
  { 667, 3, 3, 5, 1, -14 },
  { 669, 6, 10, 8, 1, -10 },
  { 677, 7, 14, 9, 1, -14 },
  { 690, 6, 10, 7, 1, -10 },
  { 698, 7, 14, 9, 1, -14 },
  { 711, 7, 10, 8, 1, -10 },
  { 720, 6, 14, 5, 0, -14 },
  { 731, 7, 14, 9, 1, -10 },
  { 744, 7, 14, 9, 1, -14 },
  { 757, 2, 13, 4, 1, -13 },
  { 761, 3, 17, 4, 0, -13 },
  { 768, 7, 14, 8, 1, -14 },
  { 781, 2, 14, 4, 1, -14 },
  { 785, 11, 10, 14, 1, -10 },
  { 799, 7, 10, 9, 1, -10 },
  { 808, 7, 10, 9, 1, -10 },
  { 817, 7, 14, 9, 1, -10 },
  { 830, 7, 14, 9, 1, -10 },
  { 843, 5, 10, 6, 1, -10 },
  { 850, 5, 10, 7, 1, -10 },
  { 857, 5, 12, 5, 0, -12 },
  { 865, 7, 10, 9, 1, -10 },
  { 874, 7, 10, 7, 0, -10 },
  { 883, 12, 10, 12, 0, -10 },
  { 898, 7, 10, 8, 0, -10 },
  { 907, 7, 14, 7, 0, -10 },
  { 920, 5, 10, 6, 1, -10 },
  { 927, 5, 16, 7, 1, -13 },
  { 937, 2, 18, 8, 3, -14 },
  { 942, 5, 16, 7, 1, -13 },
  { 952, 7, 3, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_Regular18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular18pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_CONDENSED_REGULAR18PT7B_H_
