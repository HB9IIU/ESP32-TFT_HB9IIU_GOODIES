#ifndef _NOTOSANS_CONDENSED_REGULAR63PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular63pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x1F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF7, 0xC2, 0x00, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8,
  0x1F, 0x7C, 0x0F, 0x9E, 0x07, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79,
  0xE0, 0x3C, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C,
  0x07, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x78, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x7C, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xE0,
  0x3E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F,
  0x3C, 0x7C, 0x7E, 0x3C, 0x0C, 0xFC, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF8,
  0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF8,
  0x3C, 0x00, 0xFC, 0x3C, 0x00, 0x7E, 0x3C, 0x00, 0x7F, 0xBC, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3C, 0xFE, 0x00,
  0x3C, 0x3E, 0x00, 0x3C, 0x3F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x1F, 0x00,
  0x3C, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x3E, 0xC0,
  0x3C, 0x7E, 0xF8, 0x3C, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xE0,
  0x07, 0xC7, 0xC0, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x0F,
  0x80, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x78, 0x00, 0xF0, 0x1E, 0x01, 0xF0,
  0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x07, 0x80,
  0xF0, 0x1F, 0x00, 0x0F, 0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x03, 0xE0, 0xF8,
  0x00, 0x3C, 0x07, 0xC1, 0xE0, 0x00, 0x78, 0x0F, 0x83, 0xC0, 0x00, 0xF0,
  0x1F, 0x0F, 0x80, 0x01, 0xE0, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x7C,
  0x0E, 0x07, 0x80, 0xF0, 0xF0, 0x7F, 0x0F, 0x01, 0xE1, 0xE3, 0xFF, 0x1F,
  0x07, 0xC7, 0x87, 0xFF, 0x1E, 0x0F, 0x8F, 0x1F, 0x3E, 0x3C, 0x1E, 0x3E,
  0x3C, 0x3E, 0x3E, 0x7C, 0x78, 0xF8, 0x3C, 0x7F, 0xF1, 0xF1, 0xE0, 0x7C,
  0x7F, 0xC3, 0xC3, 0xC0, 0xF8, 0x7F, 0x07, 0x87, 0x80, 0xF0, 0x10, 0x1F,
  0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x1E, 0x03, 0xC0, 0x00, 0xF8, 0x7C, 0x07,
  0x80, 0x01, 0xE0, 0xF8, 0x0F, 0x00, 0x03, 0xC1, 0xF0, 0x1E, 0x00, 0x0F,
  0x83, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x7C, 0x07, 0x80,
  0xF0, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x07,
  0x80, 0x3C, 0x0F, 0x80, 0x0F, 0x00, 0x78, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0x01, 0xF3, 0xE0, 0x03,
  0xC0, 0x01, 0xFF, 0xC0, 0x07, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x7E, 0x0F, 0xEF, 0xC0, 0x3F, 0x07, 0xE3, 0xF0, 0x1F, 0x07, 0xE0,
  0xFC, 0x0F, 0x87, 0xE0, 0x7F, 0x07, 0xC3, 0xF0, 0x1F, 0x83, 0xE1, 0xF0,
  0x07, 0xE3, 0xE1, 0xF8, 0x01, 0xF9, 0xF0, 0xFC, 0x00, 0xFD, 0xF8, 0x7E,
  0x00, 0x3F, 0xF8, 0x3F, 0x00, 0x0F, 0xFC, 0x1F, 0x80, 0x03, 0xFC, 0x0F,
  0xC0, 0x01, 0xFE, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7F, 0x80,
  0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0x00, 0xFF, 0xF8, 0x1F, 0xE1, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x3F, 0x03, 0xFF, 0xFE, 0x1F, 0xC0, 0xFF, 0xFE, 0x07,
  0xF0, 0x1F, 0xFC, 0x01, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0xFB, 0xEF, 0xBE, 0xFB, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x00, 0xFC, 0x03,
  0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x3C, 0x0E, 0x7E,
  0x3C, 0x7E, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xEF, 0x80, 0x03,
  0xE7, 0xC0, 0x07, 0xE7, 0xC0, 0x07, 0xC3, 0xE0, 0x0F, 0xC3, 0xF0, 0x1F,
  0x81, 0xF8, 0x07, 0x81, 0xE0, 0x03, 0x00, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF1,
  0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x87, 0x83, 0xC3, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x10, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBE, 0x10, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xC3, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7E,
  0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0x7E,
  0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xF8, 0x1F,
  0xC3, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x01,
  0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xDF, 0x1F, 0x9F, 0x3F, 0x3F, 0xFE,
  0x3F, 0x7C, 0x3F, 0x38, 0x3F, 0x10, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x38, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0xF0, 0x03, 0xF0, 0x30, 0x00, 0xFC,
  0x10, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1C, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC3, 0xF8, 0x0F, 0xE0, 0xF0, 0x03, 0xF8, 0x60, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFD, 0x00, 0x00, 0xFC, 0x60, 0x00, 0xFE, 0x3E, 0x01, 0xFE, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x7E, 0x00, 0x00, 0xF7,
  0xE0, 0x00, 0x1E, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x7E, 0x00,
  0x07, 0xC7, 0xE0, 0x00, 0x78, 0x7E, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF0,
  0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xE0,
  0x03, 0xC0, 0x7E, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0x80, 0x7E, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0x7E,
  0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0xF8,
  0x00, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x18, 0x07,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x80, 0x00,
  0xFC, 0xE0, 0x03, 0xFC, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x07, 0xF8, 0x08, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x7F, 0xC0, 0xF8, 0xFF, 0xE0, 0xF9, 0xFF,
  0xF0, 0xFB, 0xFF, 0xF8, 0xFB, 0xC3, 0xFC, 0xFF, 0x00, 0xFC, 0xFE, 0x00,
  0x7E, 0xFE, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x1F, 0x80,
  0xFC, 0x1F, 0xC3, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xF0, 0xFE,
  0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x8F,
  0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x7E,
  0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x07, 0xF3,
  0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x1F, 0xC3, 0xF0, 0x07, 0xF3, 0xF0,
  0x01, 0xF9, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFB,
  0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x3F,
  0x1F, 0xC0, 0x7F, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0x87,
  0xF0, 0x7F, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0xFC, 0x00,
  0x7C, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0x7E, 0x00, 0xFF, 0x7E, 0x01, 0xFF, 0x3F, 0x87, 0xFF, 0x3F, 0xFF,
  0xBE, 0x1F, 0xFF, 0xBE, 0x0F, 0xFF, 0x3E, 0x03, 0xFC, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x20, 0x3F,
  0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0x00, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x9E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x43, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0xC0, 0x1F,
  0x1F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0xFC, 0x7C, 0x7E, 0x3F,
  0x1F, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC7, 0xC1, 0xFE, 0x70, 0x07, 0xE4, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x3F, 0xC0, 0x3C, 0x3E, 0x00, 0xFF, 0xF0, 0x3C, 0x3E, 0x01,
  0xFF, 0xF0, 0x3E, 0x3C, 0x03, 0xFF, 0xF0, 0x1E, 0x7C, 0x07, 0xC0, 0xF0,
  0x1E, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x78,
  0x0F, 0x00, 0xF0, 0x1E, 0x78, 0x1F, 0x00, 0xF0, 0x1F, 0x78, 0x1F, 0x00,
  0xF0, 0x1F, 0xF8, 0x1E, 0x01, 0xF0, 0x1F, 0xF8, 0x1E, 0x01, 0xF0, 0x1F,
  0xF8, 0x1E, 0x01, 0xF0, 0x1F, 0xF8, 0x1E, 0x01, 0xF0, 0x1E, 0xF8, 0x1E,
  0x01, 0xF0, 0x1E, 0xF8, 0x1E, 0x01, 0xF0, 0x1E, 0xF8, 0x1E, 0x01, 0xF0,
  0x1E, 0xF8, 0x1E, 0x01, 0xF0, 0x1E, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0xF8,
  0x1F, 0x03, 0xF0, 0x3C, 0x78, 0x0F, 0x03, 0xF0, 0x7C, 0x78, 0x0F, 0x87,
  0x78, 0x78, 0x78, 0x0F, 0xFF, 0x3F, 0xF8, 0x7C, 0x07, 0xFE, 0x3F, 0xF0,
  0x7C, 0x03, 0xFC, 0x1F, 0xE0, 0x3C, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x04, 0x00, 0x03, 0xFC, 0x00,
  0x3C, 0x00, 0x01, 0xFF, 0xC7, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7C,
  0x7E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0,
  0x0F, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xE0,
  0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x80,
  0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3F, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7C, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x3E, 0x00, 0x3F, 0x8F, 0x80, 0x07, 0xF3, 0xE0, 0x00, 0xFC,
  0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00,
  0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0,
  0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x1F, 0xC3,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0xFE, 0x3E, 0x00, 0x1F, 0xCF, 0x80,
  0x03, 0xF3, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0xBE, 0x00,
  0x07, 0xEF, 0x80, 0x03, 0xF3, 0xE0, 0x03, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFC, 0x1F, 0x81, 0xFE, 0x00,
  0x60, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x40, 0x7F, 0xC1, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x70, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0x80, 0x1F,
  0xF0, 0xF8, 0x00, 0x7F, 0x0F, 0x80, 0x03, 0xF8, 0xF8, 0x00, 0x1F, 0xCF,
  0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7E, 0xF8, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00,
  0x1F, 0x8F, 0x80, 0x03, 0xF8, 0xF8, 0x00, 0x7F, 0x0F, 0x80, 0x3F, 0xE0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xE0, 0x7F, 0x01, 0xFE, 0x00, 0x0E, 0x03, 0xF8, 0x00, 0x04, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFB, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x01, 0xF1,
  0xF8, 0x00, 0x03, 0xE3, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x0F, 0x87,
  0xF0, 0x00, 0x1F, 0x07, 0xF8, 0x00, 0x3E, 0x07, 0xFE, 0x03, 0xFC, 0x07,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xC0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0,
  0x7F, 0x00, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0xFC,
  0x7C, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x3E, 0x00,
  0x3F, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x7E, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x3F,
  0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x1F,
  0x0F, 0x80, 0x03, 0xE3, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0x9F, 0x80,
  0x01, 0xF7, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xE7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0,
  0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF8, 0x3E, 0x00,
  0x1F, 0x87, 0xC0, 0x03, 0xF8, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xF3,
  0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFE, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xDF, 0xFB, 0xC0, 0x00, 0x0F, 0xBF, 0xF7,
  0xC0, 0x00, 0x1F, 0x7F, 0xEF, 0x80, 0x00, 0x3C, 0xFF, 0xDF, 0x00, 0x00,
  0xF9, 0xFF, 0x9F, 0x00, 0x01, 0xF3, 0xFF, 0x3E, 0x00, 0x03, 0xE7, 0xFE,
  0x7C, 0x00, 0x0F, 0x8F, 0xFC, 0x7C, 0x00, 0x1F, 0x1F, 0xF8, 0xF8, 0x00,
  0x3E, 0x3F, 0xF1, 0xF0, 0x00, 0x78, 0x7F, 0xE1, 0xF0, 0x01, 0xF0, 0xFF,
  0xC3, 0xE0, 0x03, 0xE1, 0xFF, 0x87, 0xC0, 0x07, 0x83, 0xFF, 0x07, 0xC0,
  0x1F, 0x07, 0xFE, 0x0F, 0x80, 0x3E, 0x0F, 0xFC, 0x1F, 0x00, 0x78, 0x1F,
  0xF8, 0x1E, 0x01, 0xF0, 0x3F, 0xF0, 0x3E, 0x03, 0xE0, 0x7F, 0xE0, 0x7C,
  0x07, 0x80, 0xFF, 0xC0, 0xF8, 0x1F, 0x01, 0xFF, 0x80, 0xF8, 0x3E, 0x03,
  0xFF, 0x01, 0xF0, 0x7C, 0x07, 0xFE, 0x03, 0xE1, 0xF0, 0x0F, 0xFC, 0x03,
  0xE3, 0xE0, 0x1F, 0xF8, 0x07, 0xC7, 0xC0, 0x3F, 0xF0, 0x0F, 0x8F, 0x00,
  0x7F, 0xE0, 0x0F, 0xBE, 0x00, 0xFF, 0xC0, 0x1F, 0x7C, 0x01, 0xFF, 0x80,
  0x3E, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xDF, 0x00, 0x07, 0xFE, 0xFC, 0x00, 0x3F, 0xF3,
  0xE0, 0x01, 0xFF, 0x9F, 0x80, 0x0F, 0xFC, 0x7C, 0x00, 0x7F, 0xE3, 0xF0,
  0x03, 0xFF, 0x0F, 0x80, 0x1F, 0xF8, 0x7E, 0x00, 0xFF, 0xC1, 0xF0, 0x07,
  0xFE, 0x0F, 0xC0, 0x3F, 0xF0, 0x7E, 0x01, 0xFF, 0x81, 0xF8, 0x0F, 0xFC,
  0x0F, 0xC0, 0x7F, 0xE0, 0x3F, 0x03, 0xFF, 0x01, 0xF8, 0x1F, 0xF8, 0x07,
  0xE0, 0xFF, 0xC0, 0x3F, 0x07, 0xFE, 0x00, 0xFC, 0x3F, 0xF0, 0x07, 0xE1,
  0xFF, 0x80, 0x1F, 0x8F, 0xFC, 0x00, 0xFC, 0x7F, 0xE0, 0x03, 0xF3, 0xFF,
  0x00, 0x1F, 0x9F, 0xF8, 0x00, 0x7E, 0xFF, 0xC0, 0x03, 0xF3, 0xFE, 0x00,
  0x0F, 0xDF, 0xF0, 0x00, 0x7E, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0x80, 0x03, 0xF0,
  0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00,
  0x3F, 0x3E, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x8F,
  0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xF8, 0x03, 0xFC, 0xF8,
  0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xFC, 0xF8,
  0x0F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0x03, 0xE3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0x7E, 0x7C, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x07, 0xDF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xF9,
  0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x07,
  0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3E, 0x00, 0xFF, 0x0F,
  0x80, 0x0F, 0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x0F,
  0x8F, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x3E, 0x00,
  0x0F, 0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E,
  0x00, 0x1F, 0x8F, 0x80, 0x07, 0xE3, 0xE0, 0x03, 0xF0, 0xF8, 0x01, 0xFC,
  0x3E, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0x81, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0xF8,
  0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x0F, 0xC0,
  0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x03,
  0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xE3, 0xE0,
  0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xEF, 0x80, 0x01, 0xFB,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFC, 0x7F,
  0x1F, 0xC0, 0x0E, 0x3F, 0x00, 0x04, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x40,
  0x00, 0x7E, 0xE0, 0x03, 0xF9, 0xFC, 0x3F, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x9F, 0x80,
  0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF8,
  0x07, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x01,
  0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3F,
  0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF9,
  0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0xBE, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0xF0, 0x00, 0x7C, 0x3F, 0x00,
  0x0F, 0x78, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xBC, 0x00, 0x3F, 0x07, 0xC0,
  0x03, 0xDF, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0x81, 0xF8,
  0x01, 0xF7, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0xF9, 0xE0, 0x07, 0xE0, 0x3E,
  0x00, 0x78, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0x0F,
  0x80, 0x3E, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x0F, 0x87, 0x80, 0x7E, 0x00, 0xF8, 0x07, 0x83, 0xE0, 0x3F, 0x00,
  0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0x80,
  0x1F, 0x81, 0xF0, 0x3C, 0x07, 0xC0, 0x07, 0xC0, 0xF0, 0x1F, 0x07, 0xE0,
  0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0,
  0x00, 0xFC, 0x3E, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0xF8, 0xFC,
  0x00, 0x1F, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x8F, 0x80, 0x3E, 0x3E,
  0x00, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x03, 0xF3, 0xE0, 0x07, 0x8F,
  0x80, 0x00, 0xF9, 0xE0, 0x03, 0xEF, 0xC0, 0x00, 0x7D, 0xF0, 0x01, 0xF7,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x3D,
  0xF0, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0x7C, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7C, 0x0F,
  0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x7C, 0x01,
  0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xF0, 0x7E, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8,
  0xF8, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0xF9, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x07,
  0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xE0, 0x3F, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0xF8, 0x01, 0xF8, 0x1F, 0x80,
  0x0F, 0x81, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7E,
  0x3E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x7E, 0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x81,
  0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xC0,
  0x03, 0xE0, 0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x8F, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F,
  0x9F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0x7C,
  0x00, 0x3E, 0x07, 0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0xF8, 0x1E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC1,
  0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1C, 0x01,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xF0,
  0x1F, 0x80, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x3F, 0xF8, 0xFC, 0xFE, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xEF,
  0x80, 0x0F, 0xDF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x03, 0xFB, 0xE0, 0x07, 0xF7, 0xE0, 0x1F, 0xEF, 0xE0,
  0x7F, 0xCF, 0xFF, 0xEF, 0x9F, 0xFF, 0x9F, 0x1F, 0xFE, 0x3E, 0x1F, 0xF8,
  0x3C, 0x03, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0xFF, 0x01, 0xF9, 0xFF, 0xE0, 0xFD, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE,
  0x3E, 0xF8, 0x7F, 0x9F, 0xF0, 0x0F, 0xCF, 0xF0, 0x03, 0xF7, 0xF0, 0x01,
  0xFB, 0xF8, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7D, 0xFC, 0x00, 0x3E, 0xFE, 0x00, 0x3F,
  0x7F, 0x80, 0x1F, 0xBF, 0xE0, 0x1F, 0x9F, 0xF8, 0x1F, 0xCF, 0xBF, 0xFF,
  0xC7, 0xCF, 0xFF, 0xC3, 0xE3, 0xFF, 0xC1, 0xF0, 0xFF, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x1F, 0xE1, 0xE3, 0xF8, 0x02, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x11, 0xFC, 0x06, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x07, 0xF8, 0x7E, 0x0F, 0xFF, 0x3F, 0x0F, 0xFF, 0xDF, 0x8F,
  0xFF, 0xFF, 0xC7, 0xF0, 0xFB, 0xE7, 0xE0, 0x1F, 0xF3, 0xE0, 0x07, 0xFB,
  0xF0, 0x01, 0xFD, 0xF8, 0x00, 0xFE, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x7F, 0x7E,
  0x00, 0x3F, 0xBF, 0x00, 0x3F, 0xCF, 0xC0, 0x1F, 0xE7, 0xF0, 0x3F, 0xF1,
  0xFF, 0xFE, 0xF8, 0x7F, 0xFE, 0x7C, 0x1F, 0xFE, 0x3E, 0x07, 0xFE, 0x1F,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x81, 0xF8, 0x3F, 0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x1F,
  0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x43, 0xF8, 0x07, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x7F, 0x80,
  0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xF9, 0x81, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F,
  0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x0F,
  0x83, 0xFF, 0xC7, 0xC3, 0xFF, 0xF3, 0xE3, 0xFF, 0xFD, 0xF1, 0xFC, 0x3E,
  0xF9, 0xF8, 0x07, 0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0x7F, 0x7C, 0x00,
  0x3F, 0xBE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x0F,
  0xF3, 0xF0, 0x07, 0xF9, 0xFC, 0x0F, 0x7C, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xBF, 0x07, 0xFF, 0x9F, 0x81, 0xFF, 0x0F, 0xC0, 0x0C, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x88, 0x00, 0x1F, 0x87,
  0x00, 0x1F, 0xC3, 0xFC, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x0F, 0xF8, 0x7E, 0x7F, 0xF8, 0xFD, 0xFF, 0xF9, 0xFF, 0xFF, 0xFB, 0xEF,
  0x87, 0xF7, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0x11, 0xEF, 0xFF, 0xFF, 0xF7, 0xCC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x40, 0x1E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xF0,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3E, 0x07, 0xEF, 0xFE, 0xFF, 0xCF, 0xFC, 0xFF, 0x8F, 0xE0, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x1F, 0xFE, 0x00, 0x7E, 0xFC, 0x01, 0xF9, 0xF8,
  0x03, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x81,
  0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x3E, 0x01, 0xF8, 0xF8,
  0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0x7F, 0x80,
  0x3E, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x3E, 0x01, 0xFE, 0x7E, 0x03,
  0xF8, 0x7C, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF8, 0x3F,
  0x01, 0xF0, 0x7E, 0x03, 0xF0, 0xFC, 0x03, 0xE1, 0xF8, 0x07, 0xE3, 0xF0,
  0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0x3F, 0xE1, 0xF1, 0xFF, 0xC0,
  0xFF, 0xE3, 0xE7, 0xFF, 0xC3, 0xFF, 0xE7, 0xDF, 0xFF, 0xCF, 0xFF, 0xEF,
  0xBC, 0x3F, 0xBE, 0x1F, 0xDF, 0xE0, 0x1F, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0xF8, 0x3F, 0xE1, 0xF1, 0xFF, 0xE3, 0xE7, 0xFF, 0xE7, 0xDF,
  0xFF, 0xEF, 0xBE, 0x1F, 0xDF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xBF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0x9F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xF0, 0x07, 0xE0, 0xFE,
  0x0F, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x3F, 0xC0, 0x7C, 0x7F, 0xF8,
  0x3E, 0x7F, 0xFE, 0x1F, 0x7F, 0xFF, 0x8F, 0xBC, 0x1F, 0xE7, 0xFC, 0x03,
  0xF3, 0xFC, 0x00, 0xFD, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0x7E, 0x00,
  0x0F, 0xBF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0x7F, 0x00, 0x0F, 0xBF, 0x80, 0x0F, 0xDF, 0xE0, 0x07, 0xEF, 0xF8, 0x07,
  0xE7, 0xFE, 0x07, 0xF3, 0xEF, 0xFF, 0xF1, 0xFB, 0xFF, 0xF0, 0xFC, 0xFF,
  0xF0, 0x7E, 0x1F, 0xF0, 0x3F, 0x03, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0x83, 0xFF, 0xC7, 0xC3, 0xFF,
  0xF3, 0xE3, 0xFF, 0xFD, 0xF1, 0xFC, 0x3E, 0xF9, 0xF8, 0x07, 0xFC, 0xF8,
  0x01, 0xFE, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xBE, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBE, 0x00,
  0x1F, 0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x0F, 0xF3, 0xF0, 0x07, 0xF9, 0xFC,
  0x0F, 0x7C, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xBF, 0x07, 0xFF, 0x9F, 0x81,
  0xFF, 0x0F, 0xC0, 0x0E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0xF8, 0x3F, 0xFC, 0x3F, 0xBE, 0x3F, 0xDF, 0x3F, 0xEF, 0xBF,
  0xF7, 0xDE, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x7F, 0x03, 0xC7, 0xC0, 0x04, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00,
  0x3E, 0xC0, 0x07, 0xEF, 0x80, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x03, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xE1, 0x07, 0xFF, 0x07,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x70, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF0, 0x01,
  0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x1F, 0xEF, 0xE0, 0x7F, 0xCF, 0xFF, 0xF7,
  0x8F, 0xFF, 0xCF, 0x0F, 0xFF, 0x1E, 0x0F, 0xF8, 0x3C, 0x01, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF8, 0x00,
  0x7E, 0x7E, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xFC,
  0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0,
  0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7E,
  0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3C, 0xF0,
  0x00, 0x0F, 0x7C, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x3E, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x7C,
  0x00, 0xFF, 0x00, 0x3E, 0x7C, 0x00, 0xFF, 0x00, 0x3E, 0x7C, 0x01, 0xFF,
  0x00, 0x7C, 0x7E, 0x01, 0xEF, 0x00, 0x7C, 0x3E, 0x01, 0xEF, 0x80, 0x7C,
  0x3E, 0x01, 0xEF, 0x80, 0x7C, 0x3E, 0x03, 0xE7, 0x80, 0xFC, 0x3E, 0x03,
  0xE7, 0x80, 0xF8, 0x3F, 0x03, 0xC7, 0xC0, 0xF8, 0x1F, 0x03, 0xC7, 0xC0,
  0xF8, 0x1F, 0x07, 0xC7, 0xC0, 0xF8, 0x1F, 0x07, 0xC3, 0xC1, 0xF0, 0x1F,
  0x87, 0xC3, 0xE1, 0xF0, 0x0F, 0x87, 0x83, 0xE1, 0xF0, 0x0F, 0x87, 0x83,
  0xE1, 0xF0, 0x0F, 0x8F, 0x81, 0xE3, 0xE0, 0x0F, 0x8F, 0x81, 0xE3, 0xE0,
  0x07, 0x8F, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x01, 0xF3, 0xE0, 0x07, 0xDF,
  0x01, 0xF3, 0xC0, 0x07, 0xDF, 0x00, 0xF7, 0xC0, 0x07, 0xDE, 0x00, 0xF7,
  0xC0, 0x03, 0xDE, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x0F,
  0x80, 0x1F, 0x87, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xC0,
  0x3E, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xF1, 0xF0,
  0x00, 0xF9, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xBE, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x07,
  0xE0, 0xF8, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0xC1,
  0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0x7C, 0x00, 0x3F,
  0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0xF9, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xC3,
  0xE0, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F,
  0x81, 0xF8, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x00,
  0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0,
  0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF3,
  0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x6F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0x80, 0x03, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x4F, 0xFE,
  0x00, 0x37, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xEC, 0x00, 0x3F, 0xE2, 0x00, 0x01, 0xE0,
};

const GFXglyph NotoSans_Condensed_Regular63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 7, 46, 15, 4, -45 },
  { 42, 17, 16, 24, 4, -45 },
  { 76, 30, 45, 33, 1, -45 },
  { 245, 24, 52, 30, 3, -48 },
  { 401, 39, 47, 45, 3, -46 },
  { 631, 33, 47, 35, 2, -46 },
  { 825, 6, 16, 13, 4, -45 },
  { 837, 14, 55, 19, 3, -45 },
  { 934, 14, 55, 19, 2, -45 },
  { 1031, 24, 23, 28, 2, -48 },
  { 1100, 25, 30, 30, 2, -37 },
  { 1194, 9, 15, 15, 2, -7 },
  { 1211, 14, 5, 18, 2, -19 },
  { 1220, 7, 9, 15, 4, -8 },
  { 1228, 22, 45, 23, 1, -45 },
  { 1352, 24, 47, 30, 3, -46 },
  { 1493, 16, 45, 30, 4, -45 },
  { 1583, 25, 46, 30, 2, -46 },
  { 1727, 25, 47, 30, 2, -46 },
  { 1874, 28, 45, 30, 1, -45 },
  { 2032, 24, 46, 30, 3, -45 },
  { 2170, 24, 47, 30, 3, -46 },
  { 2311, 25, 45, 30, 2, -45 },
  { 2452, 25, 47, 30, 2, -46 },
  { 2599, 24, 47, 30, 3, -46 },
  { 2740, 7, 35, 15, 4, -34 },
  { 2771, 9, 42, 15, 2, -34 },
  { 2819, 25, 29, 30, 2, -37 },
  { 2910, 25, 18, 30, 2, -31 },
  { 2967, 26, 29, 30, 2, -37 },
  { 3062, 20, 47, 22, 1, -46 },
  { 3180, 40, 50, 46, 3, -45 },
  { 3430, 32, 45, 32, 0, -45 },
  { 3610, 26, 45, 33, 5, -45 },
  { 3757, 27, 47, 32, 3, -46 },
  { 3916, 28, 45, 37, 5, -45 },
  { 4074, 20, 45, 28, 5, -45 },
  { 4187, 20, 45, 27, 5, -45 },
  { 4300, 31, 47, 38, 3, -46 },
  { 4483, 28, 45, 37, 5, -45 },
  { 4641, 15, 45, 19, 2, -45 },
  { 4726, 14, 57, 15, -4, -45 },
  { 4826, 27, 45, 31, 5, -45 },
  { 4978, 20, 45, 26, 5, -45 },
  { 5091, 39, 45, 49, 5, -45 },
  { 5311, 29, 45, 39, 5, -45 },
  { 5475, 33, 47, 39, 3, -46 },
  { 5669, 24, 45, 31, 5, -45 },
  { 5804, 33, 57, 39, 3, -46 },
  { 6040, 26, 45, 32, 5, -45 },
  { 6187, 23, 47, 29, 3, -46 },
  { 6323, 26, 45, 27, 1, -45 },
  { 6470, 27, 46, 37, 5, -45 },
  { 6626, 31, 45, 31, 0, -45 },
  { 6801, 49, 45, 49, 0, -45 },
  { 7077, 28, 45, 29, 0, -45 },
  { 7235, 28, 45, 28, 0, -45 },
  { 7393, 23, 45, 27, 2, -45 },
  { 7523, 13, 55, 20, 5, -45 },
  { 7613, 22, 45, 23, 1, -45 },
  { 7737, 13, 55, 20, 2, -45 },
  { 7827, 28, 25, 30, 1, -45 },
  { 7915, 28, 4, 28, 0, 5 },
  { 7929, 11, 10, 17, 3, -48 },
  { 7943, 23, 35, 29, 2, -34 },
  { 8044, 25, 49, 32, 4, -48 },
  { 8198, 20, 35, 24, 3, -34 },
  { 8286, 25, 49, 32, 3, -48 },
  { 8440, 23, 35, 29, 3, -34 },
  { 8541, 18, 48, 18, 1, -48 },
  { 8649, 25, 49, 32, 3, -34 },
  { 8803, 23, 48, 32, 4, -48 },
  { 8941, 6, 47, 14, 4, -47 },
  { 8977, 12, 62, 14, -2, -47 },
  { 9070, 23, 48, 28, 4, -48 },
  { 9208, 6, 48, 14, 4, -48 },
  { 9244, 39, 34, 48, 4, -34 },
  { 9410, 23, 34, 32, 4, -34 },
  { 9508, 25, 35, 31, 3, -34 },
  { 9618, 25, 49, 32, 4, -34 },
  { 9772, 25, 49, 32, 3, -34 },
  { 9926, 17, 34, 21, 4, -34 },
  { 9999, 20, 35, 24, 2, -34 },
  { 10087, 16, 42, 18, 1, -41 },
  { 10171, 23, 35, 32, 4, -34 },
  { 10272, 26, 34, 26, 0, -34 },
  { 10383, 40, 34, 42, 1, -34 },
  { 10553, 25, 34, 26, 1, -34 },
  { 10660, 26, 49, 26, 0, -34 },
  { 10820, 19, 34, 22, 2, -34 },
  { 10901, 19, 55, 23, 2, -45 },
  { 11032, 5, 63, 28, 12, -48 },
  { 11072, 19, 55, 23, 2, -45 },
  { 11203, 26, 8, 30, 2, -26 },
};

const GFXfont NotoSans_Condensed_Regular63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular63pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_CONDENSED_REGULAR63PT7B_H_
