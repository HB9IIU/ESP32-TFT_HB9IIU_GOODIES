#ifndef _NOTOSANS_CONDENSED_REGULAR7PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xF0, 0x7D, 0xFA, 0x79, 0x3C, 0xD7, 0x3E, 0x55, 0x80, 0x66,
  0x5A, 0xF0, 0xC0, 0x6A, 0x90, 0x95, 0x60, 0xEC, 0x5D, 0x00, 0xC0, 0xC0,
  0x80, 0x29, 0x48, 0x76, 0xD6, 0x75, 0x40, 0xE4, 0xAE, 0xE5, 0x1E, 0x2E,
  0xF2, 0x73, 0x9E, 0x73, 0xD6, 0xE5, 0x24, 0xF5, 0x5E, 0xF7, 0x94, 0x90,
  0x98, 0x71, 0x80, 0xFC, 0xC7, 0x00, 0xD5, 0x40, 0x75, 0x77, 0xBA, 0x38,
  0x46, 0xAE, 0x90, 0xFF, 0xC0, 0x72, 0x46, 0xD6, 0xDC, 0xEE, 0xC0, 0xEE,
  0x80, 0x78, 0xB9, 0x70, 0xB7, 0xDA, 0xD5, 0xC0, 0xFC, 0xD2, 0x6E, 0xAA,
  0xC0, 0x99, 0xBD, 0xD0, 0xB7, 0xFA, 0x69, 0x99, 0x60, 0xFE, 0x80, 0x69,
  0x99, 0x63, 0xFF, 0xC0, 0x71, 0x1E, 0xE9, 0x24, 0xB6, 0xDC, 0xB6, 0xA4,
  0xAD, 0x6E, 0xB5, 0x00, 0xA9, 0x2A, 0xB5, 0x24, 0xE9, 0x4E, 0xFC, 0x91,
  0x22, 0xD5, 0x70, 0x4E, 0x80, 0xE0, 0xC0, 0x4E, 0xF0, 0x9E, 0xDE, 0x72,
  0x20, 0x2E, 0xDE, 0x57, 0x30, 0xFA, 0x80, 0x76, 0xF2, 0x80, 0x9E, 0xDA,
  0xF8, 0xFE, 0x97, 0x6A, 0xF8, 0xFD, 0x6B, 0x50, 0xF6, 0xD0, 0x76, 0xB0,
  0xF6, 0xF9, 0x00, 0x76, 0xF2, 0x40, 0xEA, 0x67, 0xBA, 0xC0, 0xB6, 0xF0,
  0xB7, 0x20, 0xAD, 0x94, 0xA0, 0xA9, 0x50, 0xB7, 0x25, 0x00, 0xD7, 0x57,
  0x50, 0xFE, 0x95, 0x70, 0xE0,
};

const GFXglyph NotoSans_Condensed_Regular7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 5, 2, 0, -5 },
  { 2, 2, 2, 3, 0, -5 },
  { 3, 3, 5, 4, 0, -5 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 5, 5, 5, 0, -5 },
  { 11, 4, 5, 4, 0, -5 },
  { 14, 1, 2, 1, 0, -5 },
  { 15, 2, 6, 2, 0, -5 },
  { 17, 2, 6, 2, 0, -5 },
  { 19, 3, 2, 3, 0, -5 },
  { 20, 3, 3, 3, 0, -4 },
  { 22, 1, 2, 2, 0, -1 },
  { 23, 2, 1, 2, 0, -2 },
  { 24, 1, 1, 2, 0, -1 },
  { 25, 3, 5, 3, 0, -5 },
  { 27, 3, 5, 3, 0, -5 },
  { 29, 2, 5, 3, 0, -5 },
  { 31, 3, 5, 3, 0, -5 },
  { 33, 3, 5, 3, 0, -5 },
  { 35, 3, 5, 3, 0, -5 },
  { 37, 3, 5, 3, 0, -5 },
  { 39, 3, 5, 3, 0, -5 },
  { 41, 3, 5, 3, 0, -5 },
  { 43, 3, 5, 3, 0, -5 },
  { 45, 3, 5, 3, 0, -5 },
  { 47, 1, 4, 2, 0, -4 },
  { 48, 1, 5, 2, 0, -4 },
  { 49, 3, 3, 3, 0, -4 },
  { 51, 3, 2, 3, 0, -3 },
  { 52, 3, 3, 3, 0, -4 },
  { 54, 2, 5, 2, 0, -5 },
  { 56, 5, 6, 5, 0, -5 },
  { 60, 4, 5, 4, 0, -5 },
  { 63, 2, 5, 4, 1, -5 },
  { 65, 3, 5, 4, 0, -5 },
  { 67, 3, 5, 4, 1, -5 },
  { 69, 2, 5, 3, 1, -5 },
  { 71, 2, 5, 3, 1, -5 },
  { 73, 4, 5, 4, 0, -5 },
  { 76, 3, 5, 4, 1, -5 },
  { 78, 2, 5, 2, 0, -5 },
  { 80, 1, 6, 2, 0, -5 },
  { 81, 3, 5, 4, 1, -5 },
  { 83, 2, 5, 3, 1, -5 },
  { 85, 4, 5, 5, 1, -5 },
  { 88, 3, 5, 4, 1, -5 },
  { 90, 4, 5, 4, 0, -5 },
  { 93, 2, 5, 3, 1, -5 },
  { 95, 4, 6, 4, 0, -5 },
  { 98, 2, 5, 4, 1, -5 },
  { 100, 3, 5, 3, 0, -5 },
  { 102, 3, 5, 3, 0, -5 },
  { 104, 3, 5, 4, 1, -5 },
  { 106, 3, 5, 3, 0, -5 },
  { 108, 5, 5, 5, 0, -5 },
  { 112, 3, 5, 3, 0, -5 },
  { 114, 3, 5, 3, 0, -5 },
  { 116, 3, 5, 3, 0, -5 },
  { 118, 1, 6, 2, 1, -5 },
  { 119, 3, 5, 3, 0, -5 },
  { 121, 2, 6, 2, 0, -5 },
  { 123, 3, 3, 3, 0, -5 },
  { 125, 3, 1, 3, 0, 0 },
  { 126, 2, 1, 2, 0, -5 },
  { 127, 3, 4, 3, 0, -4 },
  { 129, 3, 5, 4, 0, -5 },
  { 131, 3, 4, 3, 0, -4 },
  { 133, 3, 5, 4, 0, -5 },
  { 135, 3, 4, 3, 0, -4 },
  { 137, 2, 5, 2, 0, -5 },
  { 139, 3, 6, 4, 0, -4 },
  { 142, 3, 5, 4, 0, -5 },
  { 144, 1, 5, 2, 0, -5 },
  { 145, 1, 7, 2, 0, -5 },
  { 146, 3, 5, 3, 0, -5 },
  { 148, 1, 5, 2, 0, -5 },
  { 149, 5, 4, 5, 0, -4 },
  { 152, 3, 4, 4, 0, -4 },
  { 154, 3, 4, 3, 0, -4 },
  { 156, 3, 6, 4, 0, -4 },
  { 159, 3, 6, 4, 0, -4 },
  { 162, 2, 4, 2, 0, -4 },
  { 163, 2, 4, 3, 0, -4 },
  { 164, 2, 5, 2, 0, -5 },
  { 166, 3, 4, 4, 0, -4 },
  { 168, 3, 4, 3, 0, -4 },
  { 170, 5, 4, 5, 0, -4 },
  { 173, 3, 4, 3, 0, -4 },
  { 175, 3, 6, 3, 0, -4 },
  { 178, 2, 4, 2, 0, -4 },
  { 179, 2, 6, 3, 0, -5 },
  { 181, 1, 7, 3, 1, -5 },
  { 182, 2, 6, 3, 0, -5 },
  { 184, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Condensed_Regular7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular7pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_CONDENSED_REGULAR7PT7B_H_
