#ifndef _NOTOSANS_CONDENSED_REGULAR53PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular53pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7C, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x80, 0x00, 0x00,
  0x00, 0x7D, 0xF7, 0xFF, 0x7D, 0xF1, 0x00, 0xF8, 0x7F, 0xE1, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x3D, 0xE0,
  0xF7, 0x83, 0xDC, 0x0F, 0x70, 0x3D, 0xC0, 0xF0, 0x00, 0x70, 0x3C, 0x00,
  0x38, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x03, 0x80,
  0x07, 0x81, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xC0, 0xF0, 0x00, 0xE0, 0x78,
  0x00, 0x70, 0x38, 0x00, 0x78, 0x1C, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFC, 0x07, 0x03, 0xC0, 0x03, 0x81, 0xE0, 0x01, 0xC0,
  0xE0, 0x01, 0xE0, 0x70, 0x00, 0xF0, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x3C,
  0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x0E, 0x07, 0x81, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0xE0, 0x78, 0x00,
  0x70, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x07, 0x00,
  0x0F, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xC0, 0xF0,
  0x00, 0xE0, 0x78, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFC, 0x3E, 0x71, 0xE3, 0xE3, 0x81, 0x1E, 0x1C, 0x00,
  0xF0, 0xE0, 0x0F, 0x87, 0x00, 0x7C, 0x38, 0x01, 0xE1, 0xC0, 0x0F, 0x0E,
  0x00, 0x7C, 0x70, 0x01, 0xFB, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x73,
  0xF0, 0x03, 0x87, 0x80, 0x1C, 0x3E, 0x00, 0xE0, 0xF0, 0x07, 0x07, 0x80,
  0x38, 0x3C, 0x01, 0xC3, 0xD0, 0x0E, 0x1E, 0xE0, 0x73, 0xF7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x0F, 0xC0, 0x01, 0xE0, 0x07, 0xF8, 0x00, 0xF0, 0x03, 0xFF, 0x00, 0x3C,
  0x00, 0xE3, 0xC0, 0x1E, 0x00, 0x78, 0x78, 0x07, 0x80, 0x1C, 0x1E, 0x01,
  0xC0, 0x07, 0x03, 0x80, 0xF0, 0x03, 0xC0, 0xE0, 0x3C, 0x00, 0xF0, 0x38,
  0x1E, 0x00, 0x3C, 0x0F, 0x07, 0x80, 0x0F, 0x03, 0xC1, 0xC0, 0x03, 0xC0,
  0xF0, 0xF0, 0x00, 0xF0, 0x3C, 0x38, 0x00, 0x3C, 0x0F, 0x1E, 0x00, 0x0F,
  0x03, 0x87, 0x80, 0x01, 0xC0, 0xE1, 0xC3, 0xF0, 0x70, 0x38, 0xF1, 0xFE,
  0x1C, 0x1E, 0x38, 0xFF, 0xC7, 0x87, 0x9E, 0x3C, 0xF0, 0xE3, 0xC7, 0x9E,
  0x1E, 0x3F, 0xF3, 0xC7, 0x87, 0x87, 0xF8, 0xF1, 0xC0, 0xE0, 0xFC, 0x38,
  0xF0, 0x38, 0x00, 0x1E, 0x3C, 0x0E, 0x00, 0x07, 0x8F, 0x03, 0xC0, 0x03,
  0xC3, 0xC0, 0xF0, 0x00, 0xF0, 0xF0, 0x3C, 0x00, 0x38, 0x3C, 0x0F, 0x00,
  0x1E, 0x0F, 0x03, 0xC0, 0x07, 0x03, 0xC0, 0xE0, 0x03, 0xC0, 0xF0, 0x38,
  0x00, 0xF0, 0x1C, 0x0E, 0x00, 0x38, 0x07, 0x07, 0x80, 0x1E, 0x01, 0xE1,
  0xE0, 0x07, 0x00, 0x38, 0xF0, 0x03, 0xC0, 0x0F, 0xFC, 0x00, 0xF0, 0x01,
  0xFE, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3C,
  0x0F, 0x80, 0x07, 0x81, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x07, 0xC0,
  0x03, 0xC0, 0xF8, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF0,
  0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xEF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xF7, 0xC0, 0x7C, 0x7C, 0x7C, 0x0F, 0x1F, 0x0F, 0xC1, 0xE3,
  0xE0, 0xF8, 0x7C, 0xF8, 0x0F, 0x8F, 0x9F, 0x00, 0xF9, 0xE3, 0xE0, 0x1F,
  0x7C, 0x78, 0x01, 0xFF, 0x8F, 0x00, 0x1F, 0xE1, 0xF0, 0x01, 0xFC, 0x3E,
  0x00, 0x3F, 0x07, 0xC0, 0x07, 0xE0, 0xFC, 0x01, 0xFE, 0x0F, 0xC0, 0xFF,
  0xE1, 0xFF, 0xFF, 0x7E, 0x1F, 0xFF, 0xC7, 0xC1, 0xFF, 0xF0, 0x7C, 0x1F,
  0xF8, 0x0F, 0xC0, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xBD, 0xEF, 0x7B,
  0xDE, 0xE7, 0x38, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF8,
  0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F,
  0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F,
  0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F,
  0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3E,
  0x07, 0x81, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x01, 0x01, 0xC0, 0x5E, 0x38, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3B, 0xC0, 0x0F,
  0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF8, 0x3F, 0x0F, 0x83, 0xC1, 0xE0, 0x18,
  0x10, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x3E, 0x7C, 0xF9, 0xF3,
  0xC7, 0x9F, 0x3C, 0x78, 0xF1, 0xC7, 0x8E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7D, 0xFF, 0xFF, 0x7D, 0xF1, 0x00, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xF0, 0x7C, 0x1F,
  0x01, 0xF0, 0xF8, 0x0F, 0x87, 0x80, 0x3C, 0x7C, 0x01, 0xF3, 0xE0, 0x0F,
  0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x7C, 0x00, 0x7B, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7,
  0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0x87, 0x80, 0x7C, 0x3E, 0x03,
  0xE0, 0xF8, 0x3E, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0,
  0xFF, 0x8F, 0xFC, 0xFB, 0xEF, 0x9F, 0xF8, 0xFB, 0x87, 0xC8, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xFC, 0x01, 0xFF, 0xF0,
  0x7F, 0xFF, 0x8F, 0xFF, 0xFC, 0x7C, 0x07, 0xC3, 0x00, 0x3E, 0x20, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0xF0, 0x7F,
  0xFF, 0x8F, 0xFF, 0xFC, 0x78, 0x07, 0xE2, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x03, 0xEC, 0x00, 0x7E, 0xFC, 0x3F, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF7,
  0xC0, 0x03, 0xCF, 0x80, 0x07, 0x9F, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x7C,
  0x00, 0xF0, 0xF8, 0x01, 0xE1, 0xF0, 0x07, 0x83, 0xE0, 0x1E, 0x07, 0xC0,
  0x3C, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x07, 0x80, 0x7C, 0x0F,
  0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x78, 0x03, 0xE1, 0xE0, 0x07, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xC0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xD8, 0x01, 0xFB, 0xF3, 0xFE, 0x7F, 0xFF, 0x8F,
  0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE1, 0xF8, 0x0F, 0x3F,
  0xF0, 0x7B, 0xFF, 0xC3, 0xDF, 0xFE, 0x1F, 0xC1, 0xF8, 0xFC, 0x07, 0xEF,
  0xC0, 0x1F, 0x7E, 0x00, 0x7B, 0xE0, 0x03, 0xCF, 0x00, 0x1F, 0x78, 0x00,
  0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0xBE,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF0, 0xF8, 0x1F,
  0x07, 0xF7, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x00, 0x00,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF0, 0x7F, 0xBF, 0xC3, 0xE0, 0x3E, 0x3E, 0x00, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x3E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9F, 0x00, 0x7C, 0xF8,
  0x03, 0xE3, 0xC0, 0x1E, 0x1F, 0x01, 0xF0, 0x7C, 0x1F, 0x01, 0xF9, 0xF0,
  0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF,
  0xF8, 0x0F, 0x87, 0xE0, 0xF8, 0x1F, 0x8F, 0x80, 0x7E, 0x78, 0x01, 0xF7,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x8F,
  0xE3, 0xF8, 0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x3E,
  0x07, 0xC7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x78, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03,
  0xF3, 0xE0, 0x7F, 0x3F, 0xFE, 0xF1, 0xFF, 0xEF, 0x0F, 0xFC, 0xF0, 0x3F,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x30, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00,
  0x03, 0x00, 0x00, 0x39, 0xFF, 0xFF, 0xFD, 0xF7, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x7F, 0xFF, 0xDF,
  0x7C, 0x40, 0x1C, 0x7D, 0xFB, 0xF7, 0xE7, 0xCF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x3E,
  0x7C, 0xF9, 0xE7, 0xCF, 0x9E, 0x3C, 0x79, 0xE3, 0xC7, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x7C, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xFC,
  0xFF, 0xFE, 0xFF, 0xFE, 0x60, 0x3F, 0x40, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x02, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x3E, 0x03, 0x87,
  0x00, 0xFF, 0xC1, 0xE7, 0x80, 0xFF, 0xE0, 0xF3, 0xC0, 0xF8, 0xF0, 0x39,
  0xC0, 0xF0, 0x38, 0x1D, 0xE0, 0x78, 0x3C, 0x0F, 0xF0, 0x78, 0x1E, 0x07,
  0xF8, 0x3C, 0x0F, 0x03, 0xFC, 0x1E, 0x07, 0x81, 0xFC, 0x0E, 0x03, 0xC0,
  0xFE, 0x07, 0x01, 0xE0, 0x7F, 0x07, 0x80, 0xF0, 0x3F, 0x83, 0xC0, 0x78,
  0x1F, 0xC0, 0xE0, 0x3C, 0x0E, 0xE0, 0x70, 0x1E, 0x07, 0x70, 0x3C, 0x0F,
  0x03, 0xBC, 0x1E, 0x0F, 0x83, 0xDE, 0x0F, 0x06, 0xC1, 0xCF, 0x03, 0xC7,
  0x71, 0xE7, 0x81, 0xFF, 0x3F, 0xE1, 0xC0, 0x7F, 0x8F, 0xE0, 0xF0, 0x1F,
  0x03, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x04, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x78, 0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x78, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x78, 0x0F,
  0x00, 0x0F, 0x01, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x78, 0x07, 0xC0, 0x0F,
  0x00, 0x78, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x81, 0xE0,
  0x01, 0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C,
  0x3C, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3C, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xC0, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF8, 0x07, 0xF3, 0xE0,
  0x0F, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03,
  0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xF3, 0xE0, 0x07, 0xCF,
  0x80, 0x1F, 0x3E, 0x00, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0xF8, 0x07, 0xE3, 0xE0, 0x07, 0xCF, 0x80, 0x0F,
  0xBE, 0x00, 0x3E, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xBE, 0x00,
  0x3E, 0xF8, 0x01, 0xFB, 0xE0, 0x0F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xE0, 0x18, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x20, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xF8, 0x1F, 0xF0, 0xF8, 0x03, 0xF8,
  0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF0, 0xF8, 0x0F, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xE0, 0x0F, 0x07, 0xF0,
  0x00, 0x41, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00,
  0x1F, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0x7C,
  0x00, 0x1F, 0x1F, 0x80, 0x07, 0xC3, 0xF8, 0x01, 0xF0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x28,
  0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x7E, 0xFF, 0xCF, 0xFC, 0xFF, 0x8F, 0xE0,
  0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x8F,
  0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xF8,
  0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x87,
  0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xE0,
  0x01, 0xF7, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x1F, 0xCF, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01,
  0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F,
  0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xF1, 0xF0,
  0x03, 0xE3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x07, 0xDF, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xDE, 0x00, 0x03, 0xDF, 0xEF, 0x00, 0x01, 0xEF, 0xF7, 0x80, 0x00, 0xF7,
  0xF9, 0xE0, 0x00, 0xF3, 0xFC, 0xF0, 0x00, 0x7B, 0xFE, 0x78, 0x00, 0x3D,
  0xFF, 0xBE, 0x00, 0x3C, 0xFF, 0xCF, 0x00, 0x1E, 0x7F, 0xE7, 0x80, 0x0F,
  0x3F, 0xF3, 0xE0, 0x0F, 0x1F, 0xF8, 0xF0, 0x07, 0x8F, 0xFC, 0x78, 0x03,
  0xC7, 0xFE, 0x3E, 0x01, 0xE3, 0xFF, 0x0F, 0x01, 0xE1, 0xFF, 0x87, 0x80,
  0xF0, 0xFF, 0xC3, 0xC0, 0x78, 0x7F, 0xE0, 0xF0, 0x78, 0x3F, 0xF0, 0x78,
  0x3C, 0x1F, 0xF8, 0x3C, 0x1E, 0x0F, 0xFC, 0x0F, 0x1E, 0x07, 0xFE, 0x07,
  0x8F, 0x03, 0xFF, 0x03, 0xC7, 0x81, 0xFF, 0x81, 0xF7, 0x80, 0xFF, 0xC0,
  0x7B, 0xC0, 0x7F, 0xE0, 0x3D, 0xE0, 0x3F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF8,
  0x07, 0xF0, 0x0F, 0xFC, 0x03, 0xF8, 0x07, 0xFE, 0x01, 0xFC, 0x03, 0xFF,
  0x00, 0x7C, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x7C,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xEF, 0x00,
  0x0F, 0xF7, 0xC0, 0x07, 0xF9, 0xE0, 0x03, 0xFC, 0xF8, 0x01, 0xFE, 0x3C,
  0x00, 0xFF, 0x1F, 0x00, 0x7F, 0x87, 0x80, 0x3F, 0xE3, 0xE0, 0x1F, 0xF0,
  0xF0, 0x0F, 0xF8, 0x7C, 0x07, 0xFC, 0x1E, 0x03, 0xFE, 0x0F, 0x81, 0xFF,
  0x07, 0xC0, 0xFF, 0x81, 0xF0, 0x7F, 0xC0, 0xF8, 0x3F, 0xE0, 0x3E, 0x1F,
  0xF0, 0x1F, 0x0F, 0xF8, 0x07, 0xC7, 0xFC, 0x03, 0xE3, 0xFE, 0x00, 0xF9,
  0xFF, 0x00, 0x7C, 0xFF, 0x80, 0x1F, 0x7F, 0xC0, 0x0F, 0xBF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x01, 0xFC, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE1, 0xF0,
  0x00, 0x7C, 0x7C, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F,
  0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x7C, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xFC, 0x1F,
  0x00, 0x1F, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x1F, 0xCF,
  0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x0F, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01,
  0xFC, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x7C,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C,
  0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xFC, 0x1F, 0x00,
  0x1F, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0xF8, 0x1F, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0xF8,
  0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01,
  0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3,
  0xE0, 0x3F, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F,
  0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80,
  0x1F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xF0, 0x03, 0xFF,
  0x80, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0x01, 0xC7, 0xE0,
  0x04, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x80, 0x03, 0xEE, 0x00, 0xFC, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xBE, 0x00, 0x3E,
  0x7C, 0x00, 0x7C, 0x7E, 0x03, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x3E, 0x7C, 0x00,
  0x0F, 0x9F, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E,
  0x00, 0x1F, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xF8,
  0x1F, 0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x7C, 0x0F, 0x80, 0x1F,
  0x03, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x3E, 0x1F, 0x00,
  0x0F, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x1F, 0x3E,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x0F,
  0x7C, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0x00, 0x07, 0xDE,
  0x00, 0x0F, 0x80, 0x03, 0xEF, 0x80, 0x07, 0xE0, 0x01, 0xE7, 0xC0, 0x07,
  0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xF8, 0x00, 0xF8, 0xF0, 0x01, 0xFC, 0x00,
  0x7C, 0x7C, 0x00, 0xFF, 0x00, 0x3E, 0x3E, 0x00, 0x77, 0x80, 0x1E, 0x1F,
  0x00, 0x7B, 0xC0, 0x1F, 0x07, 0x80, 0x3D, 0xE0, 0x0F, 0x83, 0xC0, 0x1E,
  0x78, 0x07, 0xC1, 0xF0, 0x0F, 0x3C, 0x03, 0xC0, 0xF8, 0x0F, 0x1E, 0x01,
  0xE0, 0x3C, 0x07, 0x8F, 0x01, 0xF0, 0x1E, 0x03, 0xC7, 0x80, 0xF8, 0x0F,
  0x81, 0xE1, 0xE0, 0x7C, 0x07, 0xC0, 0xF0, 0xF0, 0x3C, 0x03, 0xE0, 0xF0,
  0x78, 0x1E, 0x00, 0xF0, 0x78, 0x3C, 0x1F, 0x00, 0x78, 0x3C, 0x0F, 0x0F,
  0x80, 0x3E, 0x1E, 0x07, 0x87, 0x80, 0x1F, 0x1E, 0x03, 0xC3, 0xC0, 0x07,
  0x8F, 0x01, 0xE3, 0xE0, 0x03, 0xC7, 0x80, 0xF1, 0xF0, 0x01, 0xE3, 0xC0,
  0x3C, 0xF0, 0x00, 0xF9, 0xE0, 0x1E, 0x78, 0x00, 0x7D, 0xE0, 0x0F, 0x3C,
  0x00, 0x1E, 0xF0, 0x07, 0xBE, 0x00, 0x0F, 0x78, 0x01, 0xDF, 0x00, 0x07,
  0xBC, 0x00, 0xFF, 0x00, 0x03, 0xDC, 0x00, 0x7F, 0x80, 0x00, 0xEE, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x3C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x78, 0x0F, 0x00, 0xF8, 0x0F, 0x80,
  0xF0, 0x07, 0x81, 0xF0, 0x07, 0xC1, 0xE0, 0x03, 0xC3, 0xE0, 0x03, 0xE3,
  0xE0, 0x01, 0xE3, 0xC0, 0x01, 0xE7, 0xC0, 0x01, 0xF7, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xF7, 0x80, 0x01, 0xE7, 0xC0, 0x03, 0xE3, 0xC0, 0x03, 0xC3,
  0xE0, 0x07, 0xC3, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x00,
  0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x01,
  0xF0, 0x0F, 0x01, 0xF0, 0x0F, 0x81, 0xE0, 0x07, 0x83, 0xE0, 0x07, 0xC3,
  0xC0, 0x07, 0xC3, 0xC0, 0x03, 0xC7, 0xC0, 0x03, 0xE7, 0x80, 0x01, 0xEF,
  0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF3, 0x80, 0x03, 0xC7, 0x80, 0x07,
  0x8F, 0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x1E, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x3E, 0x00, 0x78, 0x78, 0x00,
  0xF0, 0xF0, 0x00, 0xF3, 0xC0, 0x01, 0xEF, 0x80, 0x01, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x01, 0xFC,
  0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC1, 0xC0, 0x7C, 0x20, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF9, 0xFC, 0x1F,
  0x7C, 0x03, 0xEF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xEF, 0xC3, 0xBD,
  0xFF, 0xF7, 0x9F, 0xFC, 0xF1, 0xFE, 0x1E, 0x02, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE1, 0xF8, 0x0F, 0x1F, 0xF0, 0x7B, 0xFF, 0xC3, 0xDF,
  0xFF, 0x1F, 0xC0, 0xF8, 0xFC, 0x03, 0xE7, 0xE0, 0x0F, 0x3E, 0x00, 0x7D,
  0xF0, 0x03, 0xEF, 0x80, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00,
  0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xEF,
  0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDF, 0x00, 0x3E, 0xF8, 0x01,
  0xF7, 0xC0, 0x0F, 0xBF, 0x00, 0xF9, 0xFC, 0x07, 0xCF, 0xF8, 0xFC, 0x7B,
  0xFF, 0xE3, 0xCF, 0xFE, 0x1C, 0x3F, 0xC0, 0x00, 0x10, 0x00, 0x00, 0xFE,
  0x01, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE1, 0xF8, 0x31, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x8F, 0xE3, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0,
  0x01, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xF0, 0xF0, 0x7F, 0xC7,
  0x87, 0xFF, 0xBC, 0x7F, 0xFD, 0xE7, 0xE0, 0xFF, 0x3E, 0x01, 0xF9, 0xE0,
  0x0F, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x7D,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF,
  0x00, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x07,
  0xF1, 0xF8, 0x7F, 0x8F, 0xFF, 0xBC, 0x3F, 0xF9, 0xE0, 0x7F, 0x87, 0x00,
  0x60, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC,
  0x1F, 0x07, 0xC3, 0xE0, 0x3E, 0x3C, 0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x00,
  0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x21, 0xFC, 0x3E, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x01, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x20, 0x03, 0xFC, 0x0F, 0xF8, 0x3F,
  0xF0, 0xFC, 0x41, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0xE3, 0xC3, 0xFF, 0x9E, 0x3F, 0xFE, 0xF1, 0xF0, 0x7F, 0x9F,
  0x00, 0xFC, 0xF0, 0x07, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xC0, 0x07,
  0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E,
  0xF0, 0x00, 0xF7, 0x80, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xE7, 0xC0,
  0x3F, 0x3E, 0x03, 0xF8, 0xFC, 0x7F, 0xC7, 0xFF, 0xDE, 0x1F, 0xFC, 0xF0,
  0x3F, 0xC7, 0x80, 0x30, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE2, 0x00, 0x1F, 0x1E,
  0x03, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x7E, 0x0F, 0x1F, 0xF1, 0xEF, 0xFF, 0x3D, 0xFF,
  0xF7, 0xF8, 0x3E, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0x79, 0xEF, 0xFF, 0x78, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x79, 0xE7, 0x9E,
  0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x80, 0x07, 0x81, 0xE0, 0xFC, 0x3F, 0x07,
  0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0xFA, 0x7E, 0xFF, 0x3F, 0xCF, 0xE1, 0xE0, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x7D, 0xE0, 0x1F, 0x3C, 0x07, 0xC7, 0x80,
  0xF8, 0xF0, 0x3E, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0x78, 0x7C, 0x0F, 0x1F,
  0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0xE0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7E, 0x7C, 0x0F, 0x8F, 0x81, 0xE0, 0xF8, 0x3C, 0x1F,
  0x07, 0x81, 0xF0, 0xF0, 0x3E, 0x1E, 0x03, 0xE3, 0xC0, 0x7C, 0x78, 0x07,
  0xCF, 0x00, 0xF9, 0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x03, 0xF0, 0x71, 0xFF,
  0x87, 0xFE, 0x3D, 0xFF, 0xC7, 0xFF, 0x9E, 0xFF, 0xF7, 0xFF, 0xCF, 0xE0,
  0xFB, 0x83, 0xF7, 0xE0, 0x3F, 0x80, 0xFB, 0xE0, 0x1F, 0x80, 0x3D, 0xF0,
  0x07, 0xC0, 0x1E, 0xF8, 0x03, 0xE0, 0x0F, 0x78, 0x01, 0xF0, 0x07, 0xFC,
  0x00, 0xF0, 0x03, 0xFE, 0x00, 0x78, 0x01, 0xFF, 0x00, 0x3C, 0x00, 0xFF,
  0x80, 0x1E, 0x00, 0x7F, 0xC0, 0x0F, 0x00, 0x3F, 0xE0, 0x07, 0x80, 0x1F,
  0xF0, 0x03, 0xC0, 0x0F, 0xF8, 0x01, 0xE0, 0x07, 0xFC, 0x00, 0xF0, 0x03,
  0xFE, 0x00, 0x78, 0x01, 0xFF, 0x00, 0x3C, 0x00, 0xFF, 0x80, 0x1E, 0x00,
  0x7F, 0xC0, 0x0F, 0x00, 0x3F, 0xE0, 0x07, 0x80, 0x1F, 0xF0, 0x03, 0xC0,
  0x0F, 0xF8, 0x01, 0xE0, 0x07, 0xFC, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0x78,
  0x01, 0xFF, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xFC, 0x1C, 0x3F, 0xE3, 0xDF,
  0xFE, 0x7B, 0xFF, 0xEF, 0xE0, 0x7D, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1E, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xC0, 0x0F, 0x1F, 0x00,
  0x3E, 0x7C, 0x00, 0xF9, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x7C, 0x00,
  0x79, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF0,
  0x7F, 0x3F, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xFC, 0x07, 0x8F, 0xF8, 0x3D, 0xFF, 0xE1, 0xEF, 0xFF,
  0x8F, 0xE0, 0x7E, 0x7E, 0x01, 0xF3, 0xE0, 0x07, 0x9F, 0x00, 0x3E, 0xF8,
  0x01, 0xF7, 0xC0, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F,
  0x78, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xF7, 0x80,
  0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB,
  0xE0, 0x07, 0xDF, 0x80, 0x7C, 0xFE, 0x07, 0xE7, 0xFC, 0x7E, 0x3D, 0xFF,
  0xE1, 0xE7, 0xFF, 0x0F, 0x1F, 0xE0, 0x78, 0x18, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xE3, 0xC3, 0xFF,
  0x9E, 0x3F, 0xFE, 0xF1, 0xF0, 0x7F, 0x9F, 0x00, 0xFC, 0xF0, 0x07, 0xEF,
  0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x1E, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x01, 0xF7, 0x80, 0x0F,
  0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xE7, 0xC0, 0x3F, 0x3E, 0x03, 0xF8, 0xFC,
  0x7F, 0xC7, 0xFF, 0xDE, 0x1F, 0xFC, 0xF0, 0x3F, 0xC7, 0x80, 0x30, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x0F, 0xF8,
  0xFF, 0xEF, 0xFF, 0x7C, 0xFF, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xFE,
  0x3F, 0xFF, 0x7F, 0xFE, 0x7C, 0x0E, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0xF8, 0x7E,
  0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x01, 0x00, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC7, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xF1,
  0x0F, 0xF8, 0x7F, 0xC0, 0xFE, 0x01, 0x80, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x01, 0xFF, 0xE0, 0x7F, 0x7F, 0x3D, 0xEF, 0xFF, 0xBC, 0xFF, 0xE7, 0x8F,
  0xF8, 0xF0, 0x18, 0x00, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xE7, 0xC0, 0x0F,
  0x9F, 0x00, 0x3E, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x0F,
  0x80, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x0F, 0x81, 0xF0, 0x3C, 0x03, 0xC0,
  0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x1F, 0x00, 0xF8, 0x78, 0x01, 0xE1, 0xE0,
  0x07, 0x87, 0x80, 0x1F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03,
  0xCF, 0x00, 0x07, 0x78, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xF8, 0x01, 0xF0, 0x03, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0x00, 0xFE,
  0x01, 0xF7, 0x80, 0x77, 0x00, 0xF3, 0xC0, 0x3B, 0x80, 0x79, 0xF0, 0x3D,
  0xE0, 0x7C, 0xF8, 0x1E, 0xF0, 0x3E, 0x3C, 0x0F, 0x78, 0x1E, 0x1E, 0x07,
  0x3C, 0x0F, 0x0F, 0x07, 0x8E, 0x07, 0x87, 0xC3, 0xC7, 0x87, 0xC1, 0xE1,
  0xE3, 0xC3, 0xC0, 0xF0, 0xF1, 0xE1, 0xE0, 0x78, 0xF0, 0x70, 0xF0, 0x3C,
  0x78, 0x3C, 0x78, 0x1F, 0x3C, 0x1E, 0x78, 0x07, 0x9E, 0x0F, 0x3C, 0x03,
  0xCE, 0x07, 0x9E, 0x01, 0xEF, 0x01, 0xCF, 0x00, 0xF7, 0x80, 0xF7, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF7, 0xC0, 0x3E, 0x3C, 0x03,
  0xE3, 0xE0, 0x7C, 0x1E, 0x07, 0xC1, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF9,
  0xF0, 0x07, 0x9E, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0x9E, 0x00, 0xF9, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF8,
  0x1E, 0x07, 0xC3, 0xE0, 0x7C, 0x3C, 0x03, 0xE7, 0xC0, 0x3E, 0x78, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xE7, 0xC0, 0x0F, 0x9F,
  0x00, 0x3E, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x07, 0x80,
  0x78, 0x1E, 0x01, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x3C, 0x03, 0xC0, 0xF0,
  0x0F, 0x03, 0xC0, 0x3E, 0x1F, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07,
  0xCF, 0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x01, 0xDF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x7C, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x01, 0xF8, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3F,
  0xC0, 0x1F, 0x80, 0x1F, 0x00, 0xFE, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x0B, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xC0,
  0x0F, 0xF2, 0x00, 0x06, 0x00,
};

const GFXglyph NotoSans_Condensed_Regular53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 39, 13, 3, -38 },
  { 31, 14, 14, 21, 3, -38 },
  { 56, 25, 38, 27, 1, -38 },
  { 175, 21, 43, 25, 2, -40 },
  { 288, 34, 38, 38, 2, -38 },
  { 450, 27, 39, 29, 2, -38 },
  { 582, 5, 14, 11, 3, -38 },
  { 591, 12, 46, 16, 2, -38 },
  { 660, 11, 46, 16, 2, -38 },
  { 724, 19, 19, 23, 2, -40 },
  { 770, 21, 25, 25, 2, -31 },
  { 836, 7, 13, 13, 2, -6 },
  { 848, 12, 4, 15, 2, -16 },
  { 854, 6, 7, 13, 3, -6 },
  { 860, 18, 38, 20, 1, -38 },
  { 946, 21, 39, 25, 2, -38 },
  { 1049, 13, 38, 25, 4, -38 },
  { 1111, 20, 38, 25, 2, -38 },
  { 1206, 20, 39, 25, 2, -38 },
  { 1304, 23, 38, 25, 1, -38 },
  { 1414, 19, 39, 25, 3, -38 },
  { 1507, 21, 39, 25, 2, -38 },
  { 1610, 21, 38, 25, 2, -38 },
  { 1710, 21, 39, 25, 2, -38 },
  { 1813, 20, 39, 25, 2, -38 },
  { 1911, 6, 30, 13, 3, -29 },
  { 1934, 7, 36, 13, 2, -29 },
  { 1966, 21, 24, 25, 2, -31 },
  { 2029, 21, 15, 25, 2, -26 },
  { 2069, 21, 24, 25, 2, -31 },
  { 2132, 16, 39, 19, 1, -38 },
  { 2210, 33, 43, 38, 3, -38 },
  { 2388, 27, 38, 27, 0, -38 },
  { 2517, 22, 38, 28, 4, -38 },
  { 2622, 22, 39, 27, 3, -38 },
  { 2730, 24, 38, 31, 4, -38 },
  { 2844, 17, 38, 24, 4, -38 },
  { 2925, 17, 38, 22, 4, -38 },
  { 3006, 26, 39, 32, 3, -38 },
  { 3133, 23, 38, 32, 4, -38 },
  { 3243, 12, 38, 16, 2, -38 },
  { 3300, 12, 48, 13, -3, -38 },
  { 3372, 23, 38, 26, 4, -38 },
  { 3482, 17, 38, 22, 4, -38 },
  { 3563, 33, 38, 41, 4, -38 },
  { 3720, 25, 38, 33, 4, -38 },
  { 3839, 27, 39, 33, 3, -38 },
  { 3971, 20, 38, 26, 4, -38 },
  { 4066, 27, 47, 33, 3, -38 },
  { 4225, 22, 38, 27, 4, -38 },
  { 4330, 20, 39, 24, 2, -38 },
  { 4428, 21, 38, 23, 1, -38 },
  { 4528, 23, 39, 31, 4, -38 },
  { 4641, 26, 38, 26, 0, -38 },
  { 4765, 41, 38, 41, 0, -38 },
  { 4960, 24, 38, 24, 0, -38 },
  { 5074, 24, 38, 24, 0, -38 },
  { 5188, 19, 38, 22, 2, -38 },
  { 5279, 11, 46, 17, 4, -38 },
  { 5343, 18, 38, 20, 1, -38 },
  { 5429, 11, 46, 17, 2, -38 },
  { 5493, 23, 21, 26, 1, -38 },
  { 5554, 23, 4, 23, 0, 4 },
  { 5566, 10, 9, 14, 2, -41 },
  { 5578, 19, 30, 24, 2, -29 },
  { 5650, 21, 41, 27, 4, -40 },
  { 5758, 17, 30, 21, 2, -29 },
  { 5822, 21, 41, 27, 2, -40 },
  { 5930, 20, 30, 24, 2, -29 },
  { 6005, 15, 41, 15, 1, -41 },
  { 6082, 21, 42, 27, 2, -29 },
  { 6193, 19, 40, 27, 4, -40 },
  { 6288, 6, 39, 12, 3, -39 },
  { 6318, 10, 52, 12, -1, -39 },
  { 6383, 19, 40, 23, 4, -40 },
  { 6478, 4, 40, 12, 4, -40 },
  { 6498, 33, 29, 40, 4, -29 },
  { 6618, 19, 29, 27, 4, -29 },
  { 6687, 22, 30, 26, 2, -29 },
  { 6770, 21, 42, 27, 4, -29 },
  { 6881, 21, 42, 27, 2, -29 },
  { 6992, 13, 29, 18, 4, -29 },
  { 7040, 16, 30, 20, 2, -29 },
  { 7100, 13, 36, 15, 1, -35 },
  { 7159, 19, 29, 27, 4, -28 },
  { 7228, 22, 28, 22, 0, -28 },
  { 7305, 33, 28, 35, 1, -28 },
  { 7421, 20, 28, 22, 1, -28 },
  { 7491, 22, 41, 22, 0, -28 },
  { 7604, 15, 28, 19, 2, -28 },
  { 7657, 15, 46, 19, 2, -38 },
  { 7744, 4, 53, 24, 10, -40 },
  { 7771, 15, 46, 19, 2, -38 },
  { 7858, 21, 7, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_Regular53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular53pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_CONDENSED_REGULAR53PT7B_H_
