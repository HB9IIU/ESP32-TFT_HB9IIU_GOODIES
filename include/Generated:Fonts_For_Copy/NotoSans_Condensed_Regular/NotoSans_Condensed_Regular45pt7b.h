#ifndef _NOTOSANS_CONDENSED_REGULAR45PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xEE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xEF, 0x0E, 0xF0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E,
  0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83,
  0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x06, 0x0E, 0x00, 0x70, 0x70, 0x03,
  0x83, 0x83, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x38, 0x38,
  0x01, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38,
  0x38, 0x01, 0xC1, 0xC1, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8,
  0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83,
  0x80, 0x18, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03,
  0x83, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0xFF,
  0xE0, 0xFF, 0xFC, 0xFF, 0xFC, 0xF3, 0x8E, 0xF1, 0xC0, 0x78, 0xE0, 0x3C,
  0x70, 0x1E, 0x38, 0x0F, 0x1C, 0x07, 0x8E, 0x01, 0xF7, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1D, 0xF0, 0x0E,
  0x3C, 0x07, 0x1E, 0x03, 0x87, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x71, 0xF8,
  0x39, 0xEF, 0xFF, 0xF7, 0xFF, 0xF1, 0xFF, 0xE0, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x04, 0x00, 0x00,
  0x01, 0xF8, 0x01, 0xC0, 0x3F, 0x80, 0x3C, 0x07, 0xBC, 0x03, 0x80, 0x71,
  0xC0, 0x38, 0x0E, 0x0E, 0x07, 0x00, 0xE0, 0xE0, 0x70, 0x0E, 0x0E, 0x0E,
  0x00, 0xE0, 0xE0, 0xE0, 0x0E, 0x0E, 0x0E, 0x00, 0xE0, 0xE1, 0xC0, 0x0E,
  0x0E, 0x1C, 0x00, 0xE0, 0xE3, 0x80, 0x0E, 0x0E, 0x38, 0x70, 0xE0, 0xE7,
  0x9F, 0xCE, 0x0E, 0x73, 0xFE, 0x71, 0xC7, 0x38, 0xE7, 0xBC, 0xE3, 0x8E,
  0x3F, 0x8E, 0x70, 0x71, 0xF9, 0xE7, 0x07, 0x06, 0x1C, 0x70, 0x70, 0x01,
  0xC7, 0x07, 0x00, 0x38, 0x70, 0x70, 0x03, 0x87, 0x07, 0x00, 0x78, 0x70,
  0x70, 0x07, 0x07, 0x07, 0x00, 0x70, 0x70, 0x70, 0x0E, 0x07, 0x07, 0x00,
  0xE0, 0x70, 0x70, 0x1C, 0x03, 0x8E, 0x01, 0xC0, 0x3D, 0xE0, 0x3C, 0x01,
  0xFC, 0x03, 0x80, 0x0F, 0x80, 0x00, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0xFB, 0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x83, 0xC0, 0x0F, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x38, 0x00, 0x70, 0x70,
  0x00, 0xF1, 0xE0, 0x01, 0xE7, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x70, 0xF3, 0xC0, 0xE3,
  0xC7, 0xC3, 0xCF, 0x87, 0x87, 0x9E, 0x07, 0x8F, 0x3C, 0x0F, 0xBC, 0x78,
  0x0F, 0xF8, 0xE0, 0x0F, 0xF1, 0xE0, 0x0F, 0xC3, 0xC0, 0x1F, 0x07, 0x80,
  0x3F, 0x0F, 0x80, 0xFE, 0x0F, 0x87, 0xFE, 0x1F, 0xFF, 0xBE, 0x1F, 0xFE,
  0x3E, 0x1F, 0xF0, 0x3E, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0xE0, 0x03, 0xC1,
  0xE0, 0x70, 0x3C, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03,
  0xC0, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0xF0,
  0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x01, 0xE0,
  0x78, 0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81,
  0xE0, 0x70, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0xE1, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0x70,
  0x1E, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x08, 0x10, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0xF7,
  0xDE, 0x79, 0xE7, 0x3C, 0xF3, 0x8E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x01, 0x80, 0x03, 0xF8, 0x07, 0xFF, 0x03,
  0xFF, 0x83, 0xE1, 0xE1, 0xE0, 0xF9, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x07,
  0x78, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xBC, 0x03,
  0x9E, 0x03, 0xCF, 0x01, 0xE3, 0xC1, 0xF1, 0xF1, 0xF0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x07, 0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x1F, 0x87, 0xF1, 0xFE, 0x7B,
  0xFE, 0x7B, 0x8F, 0x21, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0x80, 0x0F, 0xF8, 0x1F, 0xFF, 0x1F, 0xFF, 0xC7, 0x83, 0xE3, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0x80, 0x0F, 0xFC, 0x1F, 0xFF, 0x1F, 0xFF, 0xCF, 0x01, 0xE2, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07,
  0xFE, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE8, 0x01,
  0xF7, 0x01, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xCF, 0x00, 0x3C, 0xF0, 0x03,
  0x8F, 0x00, 0x78, 0xF0, 0x07, 0x0F, 0x00, 0xF0, 0xF0, 0x0E, 0x0F, 0x01,
  0xE0, 0xF0, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0F, 0x07, 0x00, 0xF0,
  0xF0, 0x0F, 0x0E, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF,
  0x87, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x7E, 0x03, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xD0, 0x03, 0xEE, 0x03, 0xE7, 0xFF, 0xE3, 0xFF, 0xE0,
  0xFF, 0xE0, 0x00, 0x3C, 0x00, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x8F, 0xC3, 0xDF, 0xF1, 0xEF, 0xFC,
  0xFE, 0x1F, 0x7C, 0x07, 0xBE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0x70, 0x07, 0xB8, 0x03, 0xDE, 0x01, 0xEF,
  0x00, 0xF3, 0xC0, 0xF1, 0xF0, 0xF8, 0x7F, 0xF8, 0x1F, 0xF8, 0x07, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x80, 0x03,
  0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x7C, 0x1F, 0x1E, 0x03, 0xC7, 0x80,
  0x79, 0xC0, 0x1E, 0x70, 0x07, 0x9C, 0x01, 0xE7, 0x80, 0x71, 0xE0, 0x3C,
  0x3C, 0x1E, 0x0F, 0x8F, 0x81, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0xF0, 0x03,
  0xFE, 0x03, 0xE7, 0xE0, 0xF0, 0x7C, 0x78, 0x0F, 0x3C, 0x01, 0xEF, 0x00,
  0x7B, 0xC0, 0x0E, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x7B, 0xC0, 0x1E,
  0xF8, 0x07, 0x9F, 0x03, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xF8, 0x00,
  0x00, 0x80, 0x07, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x87, 0xC3, 0xE3, 0xC0,
  0xF3, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x07, 0x78, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0x78, 0x1F,
  0xBE, 0x1F, 0xCF, 0xFD, 0xE3, 0xFE, 0xF0, 0xFC, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0xF7,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF,
  0xFF, 0xFE, 0x79, 0xF7, 0xDF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x7D, 0xE7, 0x9E, 0x71, 0xCF, 0x38, 0xE3,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x06, 0x01, 0xFF,
  0x8F, 0xFF, 0x3F, 0xFE, 0xE0, 0x7A, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00,
  0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x07,
  0x80, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x3C,
  0x01, 0x00, 0xE3, 0x81, 0xFF, 0x0F, 0x38, 0x3F, 0xF0, 0x77, 0x03, 0xC7,
  0x07, 0x70, 0x70, 0x70, 0x77, 0x07, 0x07, 0x07, 0x70, 0xE0, 0x70, 0x7F,
  0x0E, 0x07, 0x07, 0xE0, 0xE0, 0x70, 0x7E, 0x0E, 0x07, 0x07, 0xE0, 0xE0,
  0x70, 0x7E, 0x0E, 0x07, 0x07, 0xE0, 0xE0, 0xF0, 0x7E, 0x0E, 0x0F, 0x07,
  0xF0, 0xE0, 0xF0, 0xE7, 0x07, 0x1F, 0x8E, 0x70, 0x7F, 0xBF, 0xC7, 0x03,
  0xF9, 0xFC, 0x78, 0x1E, 0x0F, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x40, 0x07,
  0xC0, 0x38, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xF7, 0x80,
  0x01, 0xCF, 0x00, 0x07, 0x8E, 0x00, 0x0F, 0x1E, 0x00, 0x1C, 0x3C, 0x00,
  0x38, 0x78, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0xF0, 0x03, 0x81, 0xE0, 0x0F,
  0x01, 0xC0, 0x1E, 0x03, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00,
  0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x03,
  0xCF, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE3, 0x80, 0xFC, 0xE0, 0x0F, 0xB8, 0x01, 0xEE, 0x00,
  0x7B, 0x80, 0x1E, 0xE0, 0x07, 0xB8, 0x01, 0xEE, 0x00, 0x7B, 0x80, 0x3C,
  0xE0, 0x0F, 0x38, 0x3F, 0x8F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFE, 0x38,
  0x07, 0xCE, 0x00, 0xFB, 0x80, 0x1E, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7B, 0x80, 0x3E,
  0xE0, 0x7F, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x1E, 0x00,
  0x1F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFC, 0x0C, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x81, 0x81, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0E,
  0x07, 0xF0, 0xE0, 0x1F, 0x8E, 0x00, 0x7C, 0xE0, 0x03, 0xCE, 0x00, 0x3E,
  0xE0, 0x01, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xEE, 0x00, 0x1E, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xEE, 0x00, 0x1E, 0xE0,
  0x01, 0xEE, 0x00, 0x3E, 0xE0, 0x03, 0xCE, 0x00, 0x7C, 0xE0, 0x0F, 0x8E,
  0x01, 0xF8, 0xE1, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF,
  0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0xFE,
  0xFF, 0xFB, 0xFF, 0xEE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xC0, 0x38, 0x7E, 0x00, 0x21, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0x78,
  0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x7C, 0x00,
  0x3C, 0xF0, 0x00, 0xF3, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1F, 0x80, 0x3C,
  0x3F, 0x00, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xF7, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x1F, 0xEF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xFF, 0xEF, 0xFB, 0xFC, 0x78, 0x00, 0xE0,
  0x07, 0xDC, 0x00, 0xF3, 0x80, 0x3C, 0x70, 0x07, 0x8E, 0x01, 0xE1, 0xC0,
  0x78, 0x38, 0x0F, 0x07, 0x03, 0xC0, 0xE0, 0xF0, 0x1C, 0x1E, 0x03, 0x87,
  0x80, 0x71, 0xE0, 0x0E, 0x3C, 0x01, 0xCF, 0x00, 0x3B, 0xE0, 0x07, 0x7E,
  0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xE7, 0x80, 0x78, 0xF8, 0x0E, 0x0F,
  0x01, 0xC1, 0xF0, 0x38, 0x1E, 0x07, 0x01, 0xE0, 0xE0, 0x3C, 0x1C, 0x03,
  0xC3, 0x80, 0x7C, 0x70, 0x07, 0x8E, 0x00, 0xF9, 0xC0, 0x0F, 0x38, 0x01,
  0xF7, 0x00, 0x1F, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1D, 0xFB, 0x80, 0x03, 0xBF, 0x78,
  0x00, 0xF7, 0xEF, 0x00, 0x1C, 0xFC, 0xE0, 0x03, 0x9F, 0x9C, 0x00, 0xF3,
  0xF3, 0xC0, 0x1C, 0x7E, 0x38, 0x03, 0x8F, 0xC7, 0x00, 0xF1, 0xF8, 0xF0,
  0x1E, 0x3F, 0x0E, 0x03, 0x87, 0xE1, 0xC0, 0x70, 0xFC, 0x3C, 0x1E, 0x1F,
  0x87, 0x83, 0x83, 0xF0, 0x70, 0x70, 0x7E, 0x0F, 0x1E, 0x0F, 0xC1, 0xE3,
  0x81, 0xF8, 0x1C, 0x70, 0x3F, 0x03, 0xDE, 0x07, 0xE0, 0x7B, 0x80, 0xFC,
  0x07, 0x70, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF0, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xBC, 0x01, 0xFD, 0xE0, 0x0F, 0xEF, 0x80, 0x7F, 0x3C,
  0x03, 0xF9, 0xE0, 0x1F, 0xC7, 0x80, 0xFE, 0x3C, 0x07, 0xF0, 0xF0, 0x3F,
  0x87, 0x81, 0xFC, 0x1E, 0x0F, 0xE0, 0xF0, 0x7F, 0x03, 0xC3, 0xF8, 0x1E,
  0x1F, 0xC0, 0x78, 0xFE, 0x03, 0xC7, 0xF0, 0x0F, 0x3F, 0x80, 0x79, 0xFC,
  0x01, 0xEF, 0xE0, 0x0F, 0x7F, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0x00,
  0x18, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F,
  0x81, 0xF0, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x7C,
  0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x1F,
  0x00, 0xF8, 0x0F, 0x83, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xE0, 0xFE, 0xE0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7E, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0x00, 0xF8,
  0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x0F, 0x83, 0xF0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0xFF, 0xE0, 0x3F,
  0xFE, 0x0F, 0xFF, 0xC3, 0x83, 0xF8, 0xE0, 0x1F, 0x38, 0x03, 0xCE, 0x00,
  0xF3, 0x80, 0x3C, 0xE0, 0x0F, 0x38, 0x03, 0xCE, 0x00, 0xF3, 0x80, 0x3C,
  0xE0, 0x0F, 0x38, 0x07, 0xCE, 0x03, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xF8, 0x0F, 0xFF, 0x03, 0x83, 0xC0, 0xE0, 0x78, 0x38, 0x1E, 0x0E, 0x07,
  0xC3, 0x80, 0xF0, 0xE0, 0x3E, 0x38, 0x07, 0x8E, 0x01, 0xF3, 0x80, 0x3C,
  0xE0, 0x0F, 0xB8, 0x01, 0xEE, 0x00, 0x7F, 0x80, 0x0F, 0x00, 0xC0, 0x07,
  0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xE0, 0xE3, 0xC0, 0x13, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE8, 0x01, 0xF7, 0x81,
  0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0x70, 0x00, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x3F, 0x07,
  0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xF7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xF0, 0x03,
  0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x78, 0x07, 0x81,
  0xE0, 0x1E, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0xF0,
  0x3C, 0x03, 0xC0, 0xF0, 0x07, 0x03, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78,
  0x01, 0xE1, 0xE0, 0x03, 0x87, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00,
  0xF3, 0x80, 0x01, 0xCE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0x00, 0x3D, 0xE0, 0x07, 0xC0,
  0x0F, 0x3C, 0x00, 0xF8, 0x01, 0xE7, 0x80, 0x1F, 0x80, 0x3C, 0x70, 0x07,
  0xF0, 0x07, 0x8F, 0x00, 0xEE, 0x00, 0xE1, 0xE0, 0x1D, 0xC0, 0x3C, 0x3C,
  0x03, 0xB8, 0x07, 0x87, 0x80, 0xF7, 0x80, 0xF0, 0x78, 0x1E, 0xF0, 0x1E,
  0x0F, 0x03, 0x8E, 0x07, 0x81, 0xE0, 0x71, 0xC0, 0xF0, 0x3C, 0x0E, 0x3C,
  0x1E, 0x03, 0x83, 0xC7, 0x83, 0xC0, 0x78, 0x78, 0x70, 0x70, 0x0F, 0x0E,
  0x0E, 0x1E, 0x01, 0xE1, 0xC1, 0xE3, 0xC0, 0x3C, 0x78, 0x3C, 0x78, 0x03,
  0x8F, 0x03, 0x8F, 0x00, 0x79, 0xC0, 0x73, 0xC0, 0x0F, 0x38, 0x0E, 0x78,
  0x01, 0xE7, 0x01, 0xEF, 0x00, 0x1D, 0xE0, 0x3D, 0xE0, 0x03, 0xBC, 0x03,
  0xB8, 0x00, 0x7F, 0x00, 0x77, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x78, 0x01, 0xF3, 0xC0,
  0x1E, 0x3C, 0x01, 0xE1, 0xE0, 0x3C, 0x1E, 0x03, 0xC0, 0xF0, 0x78, 0x0F,
  0x07, 0x80, 0x70, 0xF0, 0x07, 0x8F, 0x00, 0x38, 0xE0, 0x03, 0xDE, 0x00,
  0x3D, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3D, 0xC0, 0x03, 0xDE,
  0x00, 0x78, 0xE0, 0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x01, 0xE7, 0x80, 0x1E, 0x78,
  0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xF7, 0x80, 0x1E, 0x78, 0x01, 0xE7,
  0xC0, 0x3E, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x0E, 0x07, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0x79, 0xE0, 0x07, 0x9E,
  0x00, 0x39, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3B,
  0xC0, 0x07, 0x9C, 0x00, 0x71, 0xE0, 0x0F, 0x0E, 0x00, 0xE0, 0xF0, 0x1E,
  0x07, 0x01, 0xC0, 0x78, 0x1C, 0x03, 0x83, 0xC0, 0x3C, 0x38, 0x01, 0xC7,
  0x80, 0x1E, 0x70, 0x01, 0xEF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x00, 0x80,
  0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x10, 0x1E, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3F, 0x0F, 0xFF, 0x3F, 0xFF,
  0x7E, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0x7F, 0xEF, 0x7F, 0xEF, 0x3F, 0x87,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x10, 0x0F, 0x3F,
  0xC3, 0xDF, 0xF8, 0xFF, 0xFF, 0x3F, 0x03, 0xCF, 0x80, 0xFB, 0xE0, 0x1E,
  0xF0, 0x07, 0xBC, 0x00, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3B, 0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x03, 0xEF, 0xC1, 0xF3, 0xFF, 0xFC,
  0xE7, 0xFE, 0x38, 0xFF, 0x00, 0x00, 0xC0, 0x1F, 0xF1, 0xFF, 0xC7, 0xFF,
  0x3E, 0x09, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x13, 0xFF, 0xC7, 0xFF, 0x07,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x60, 0xF0,
  0xFF, 0x3C, 0x7F, 0xEF, 0x3F, 0xFF, 0xCF, 0x03, 0xF7, 0x80, 0xFD, 0xE0,
  0x1F, 0x78, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3D, 0xE0, 0x1F, 0x78, 0x07, 0xDE, 0x03, 0xF3, 0xC0, 0xFC, 0xFF,
  0xFF, 0x1F, 0xFB, 0xC3, 0xFC, 0x70, 0x00, 0x80, 0x03, 0xFC, 0x07, 0xFF,
  0x03, 0xFF, 0xC3, 0xC1, 0xE3, 0xC0, 0x79, 0xE0, 0x1C, 0xE0, 0x0E, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x18, 0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFE, 0x00,
  0x01, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x03, 0xFF, 0x3F, 0xFC, 0xFF, 0xF0, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x01, 0x80, 0x03, 0xFC, 0x71, 0xFF, 0xBC, 0xFF, 0xFF, 0x3C, 0x1F, 0xDE,
  0x03, 0xF7, 0x80, 0x7D, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x00, 0x7D, 0xE0, 0x1F, 0x78, 0x0F, 0xCF,
  0x07, 0xF3, 0xFF, 0xBC, 0x7F, 0xEF, 0x0F, 0xE3, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x79, 0x80, 0x3C,
  0x7F, 0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0x80, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x20, 0x3C, 0xFF, 0x1E, 0xFF, 0xCF, 0xFF,
  0xF7, 0xE0, 0xFB, 0xE0, 0x3D, 0xF0, 0x0E, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xC0, 0xFF, 0xFF,
  0x60, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x0F, 0x0F, 0x0F, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFE, 0xFE, 0xFC, 0xF0, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x07, 0xDE, 0x03,
  0xCF, 0x03, 0xC7, 0x83, 0xC3, 0xC1, 0xE1, 0xE1, 0xE0, 0xF1, 0xE0, 0x78,
  0xE0, 0x3C, 0xF0, 0x1E, 0xF0, 0x0F, 0x7C, 0x07, 0xFE, 0x03, 0xF7, 0x81,
  0xF3, 0xC0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x03,
  0xC7, 0x81, 0xE3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x0F, 0x78, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x06, 0x0E, 0x3F, 0x83, 0xF8,
  0xE7, 0xFC, 0x7F, 0xCF, 0xFF, 0xEF, 0xFE, 0xFC, 0x1F, 0xC1, 0xEF, 0x80,
  0xF8, 0x0F, 0xF8, 0x0F, 0x80, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00,
  0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0,
  0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0,
  0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF,
  0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F,
  0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x60, 0x71,
  0xFE, 0x39, 0xFF, 0x9F, 0xFF, 0xEF, 0xC1, 0xF7, 0xC0, 0x7B, 0xE0, 0x1D,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0x80, 0x00, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x3C, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x0E, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x39, 0xE0, 0x1E,
  0x7C, 0x07, 0x8F, 0x83, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xF8, 0x00,
  0x00, 0x60, 0x38, 0xFF, 0x0E, 0x7F, 0xE3, 0xFF, 0xFC, 0xFC, 0x0F, 0x3E,
  0x01, 0xEF, 0x80, 0x7B, 0xC0, 0x1E, 0xF0, 0x03, 0xBC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0xFC, 0x0F, 0xBF,
  0x87, 0xCF, 0xFF, 0xF3, 0xDF, 0xF8, 0xF3, 0xF8, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x03,
  0xFC, 0xF1, 0xFF, 0xBC, 0xFF, 0xFF, 0x3C, 0x0F, 0xDE, 0x03, 0xF7, 0x80,
  0x7D, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xF7, 0x80, 0x7D, 0xE0, 0x1F, 0x78, 0x0F, 0xCF, 0x07, 0xF3, 0xFF,
  0xBC, 0x7F, 0xEF, 0x0F, 0xE3, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x6E, 0x3F, 0xE7, 0xEE, 0x7E,
  0xFF, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x7F, 0xC7,
  0xFF, 0x9F, 0xFE, 0xF0, 0x13, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0E, 0x80, 0x7B, 0x01, 0xEF, 0xFF,
  0x3F, 0xFC, 0x7F, 0xC0, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE7, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0xF1, 0xFE, 0x1F, 0xC0, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFF, 0x03, 0xF7, 0x83, 0xFB, 0xFF, 0xBC, 0xFF, 0xDE, 0x3F,
  0x8F, 0xF0, 0x03, 0xDC, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x1E, 0x78, 0x07,
  0x8F, 0x01, 0xE3, 0xC0, 0x70, 0xF0, 0x3C, 0x1C, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xE0, 0x78, 0x78, 0x0E, 0x1E, 0x03, 0xC7, 0x00, 0xF1, 0xC0, 0x1C,
  0xF0, 0x07, 0x3C, 0x01, 0xEE, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x7B, 0xC0,
  0x7C, 0x03, 0xDE, 0x03, 0xF0, 0x1E, 0xF0, 0x1F, 0x80, 0xE3, 0x80, 0xFC,
  0x0F, 0x1C, 0x0F, 0xE0, 0x78, 0xF0, 0x77, 0x03, 0xC7, 0x83, 0xBC, 0x1C,
  0x3C, 0x1C, 0xE0, 0xE0, 0xE1, 0xE7, 0x0F, 0x07, 0x8F, 0x38, 0x78, 0x3C,
  0x71, 0xE3, 0x81, 0xE3, 0x87, 0x1C, 0x07, 0x1C, 0x39, 0xE0, 0x39, 0xE1,
  0xCF, 0x01, 0xEE, 0x0F, 0x78, 0x0F, 0x70, 0x7B, 0x80, 0x3B, 0x81, 0xDC,
  0x01, 0xDC, 0x0E, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x03,
  0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x78, 0x03, 0xE0, 0xF0, 0x07,
  0xBC, 0x07, 0x9E, 0x03, 0xC7, 0x83, 0xC1, 0xC1, 0xC0, 0xF1, 0xE0, 0x38,
  0xE0, 0x1E, 0xF0, 0x07, 0x70, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0x1E,
  0x07, 0x0F, 0x07, 0x83, 0xC3, 0x81, 0xE3, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0,
  0x0F, 0xF0, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0E, 0x38, 0x07,
  0x8F, 0x01, 0xE3, 0xC0, 0x70, 0xF0, 0x3C, 0x1C, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xE0, 0x38, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x00, 0x71, 0xC0, 0x1C,
  0xF0, 0x07, 0xBC, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x01, 0x7E,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x00, 0x7F, 0xF9, 0xFF, 0xE7,
  0xFF, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x78, 0x0F, 0xC0, 0xFE, 0x0F, 0x80, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x3F, 0x01, 0xE0, 0x0F, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F,
  0x80, 0x3F, 0x80, 0xFC, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xFE,
  0x00, 0xF0, 0x3F, 0x83, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x3C, 0x0F, 0xE0, 0x7E, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x5F,
  0xE0, 0x3F, 0xFE, 0x1F, 0x9F, 0xFF, 0x80, 0xFF, 0xA0, 0x0F, 0x80,
};

const GFXglyph NotoSans_Condensed_Regular45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 32, 11, 3, -32 },
  { 21, 12, 11, 17, 3, -32 },
  { 38, 21, 32, 23, 1, -32 },
  { 122, 17, 37, 21, 2, -34 },
  { 201, 28, 33, 32, 2, -33 },
  { 317, 23, 33, 25, 2, -33 },
  { 412, 4, 11, 10, 3, -32 },
  { 418, 10, 39, 13, 2, -32 },
  { 467, 10, 39, 13, 1, -32 },
  { 516, 16, 16, 20, 2, -34 },
  { 548, 18, 22, 21, 2, -27 },
  { 598, 6, 11, 11, 2, -5 },
  { 607, 11, 4, 13, 1, -14 },
  { 613, 5, 5, 11, 3, -5 },
  { 617, 15, 32, 17, 1, -32 },
  { 677, 17, 33, 21, 2, -33 },
  { 748, 11, 32, 21, 3, -32 },
  { 792, 17, 33, 21, 2, -33 },
  { 863, 17, 33, 21, 2, -33 },
  { 934, 20, 32, 21, 1, -32 },
  { 1014, 17, 32, 21, 2, -32 },
  { 1082, 17, 33, 21, 2, -33 },
  { 1153, 17, 32, 21, 2, -32 },
  { 1221, 18, 33, 21, 2, -33 },
  { 1296, 17, 33, 21, 2, -33 },
  { 1367, 5, 24, 11, 3, -24 },
  { 1382, 6, 30, 11, 2, -24 },
  { 1405, 18, 20, 21, 2, -26 },
  { 1450, 17, 12, 21, 2, -22 },
  { 1476, 18, 20, 21, 2, -26 },
  { 1521, 14, 33, 16, 1, -33 },
  { 1579, 28, 36, 33, 2, -32 },
  { 1705, 23, 32, 23, 0, -32 },
  { 1797, 18, 32, 24, 4, -32 },
  { 1869, 19, 33, 23, 2, -33 },
  { 1948, 20, 32, 26, 4, -32 },
  { 2028, 14, 32, 20, 4, -32 },
  { 2084, 14, 32, 19, 4, -32 },
  { 2140, 22, 33, 27, 2, -33 },
  { 2231, 19, 32, 27, 4, -32 },
  { 2307, 10, 32, 14, 2, -32 },
  { 2347, 10, 41, 11, -3, -32 },
  { 2399, 19, 32, 22, 4, -32 },
  { 2475, 14, 32, 19, 4, -32 },
  { 2531, 27, 32, 35, 4, -32 },
  { 2639, 21, 32, 28, 4, -32 },
  { 2723, 24, 33, 28, 2, -33 },
  { 2822, 16, 32, 22, 4, -32 },
  { 2886, 24, 41, 28, 2, -33 },
  { 3009, 18, 32, 23, 4, -32 },
  { 3081, 17, 33, 20, 2, -33 },
  { 3152, 19, 32, 19, 0, -32 },
  { 3228, 20, 32, 26, 3, -32 },
  { 3308, 22, 32, 22, 0, -32 },
  { 3396, 35, 32, 35, 0, -32 },
  { 3536, 20, 32, 21, 0, -32 },
  { 3616, 20, 32, 20, 0, -32 },
  { 3696, 17, 32, 19, 1, -32 },
  { 3764, 10, 39, 14, 3, -32 },
  { 3813, 15, 32, 17, 1, -32 },
  { 3873, 10, 39, 14, 1, -32 },
  { 3922, 20, 18, 22, 1, -32 },
  { 3967, 20, 3, 20, 0, 4 },
  { 3975, 8, 7, 12, 2, -34 },
  { 3982, 16, 25, 21, 2, -25 },
  { 4032, 18, 34, 23, 3, -34 },
  { 4109, 14, 25, 17, 2, -25 },
  { 4153, 18, 34, 23, 2, -34 },
  { 4230, 17, 25, 21, 2, -25 },
  { 4284, 14, 34, 13, 0, -34 },
  { 4344, 18, 36, 23, 2, -25 },
  { 4425, 17, 34, 23, 3, -34 },
  { 4498, 4, 33, 10, 3, -33 },
  { 4515, 8, 44, 10, -1, -33 },
  { 4559, 17, 34, 20, 3, -34 },
  { 4632, 4, 34, 10, 3, -34 },
  { 4649, 28, 25, 34, 3, -25 },
  { 4737, 17, 25, 23, 3, -25 },
  { 4791, 18, 25, 22, 2, -25 },
  { 4848, 18, 36, 23, 3, -25 },
  { 4929, 18, 36, 23, 2, -25 },
  { 5010, 12, 25, 15, 3, -25 },
  { 5048, 14, 25, 17, 2, -25 },
  { 5092, 11, 30, 13, 1, -30 },
  { 5134, 17, 24, 23, 3, -24 },
  { 5185, 18, 24, 19, 0, -24 },
  { 5239, 29, 24, 30, 0, -24 },
  { 5326, 17, 24, 19, 1, -24 },
  { 5377, 18, 35, 19, 0, -24 },
  { 5456, 14, 24, 16, 1, -24 },
  { 5498, 13, 39, 17, 2, -32 },
  { 5562, 4, 45, 20, 8, -34 },
  { 5585, 13, 39, 17, 2, -32 },
  { 5649, 18, 6, 21, 2, -19 },
};

const GFXfont NotoSans_Condensed_Regular45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular45pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_CONDENSED_REGULAR45PT7B_H_
