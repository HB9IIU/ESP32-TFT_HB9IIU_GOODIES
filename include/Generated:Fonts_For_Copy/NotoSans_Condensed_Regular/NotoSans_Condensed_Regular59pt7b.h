#ifndef _NOTOSANS_CONDENSED_REGULAR59PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular59pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xCF, 0xDF, 0xBF, 0xFF,
  0xFC, 0xF8, 0x40, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0x9C, 0x07, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x78,
  0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x0E, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x70, 0x1E, 0x00, 0x0F,
  0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x03, 0xC0, 0x01,
  0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x1E, 0x07,
  0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xC0, 0x78, 0x0F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x38, 0x0F, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x78,
  0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9,
  0xFF, 0xCF, 0xE7, 0xC7, 0x03, 0x3E, 0x1C, 0x00, 0xF8, 0x70, 0x03, 0xC1,
  0xC0, 0x0F, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x70, 0x03, 0xE1, 0xC0,
  0x0F, 0xC7, 0x00, 0x1F, 0x9C, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x1C, 0x7E, 0x00, 0x70, 0xFC, 0x01, 0xC1, 0xF0, 0x07, 0x07,
  0xC0, 0x1C, 0x0F, 0x00, 0x70, 0x3C, 0x01, 0xC0, 0xF0, 0x07, 0x07, 0xE0,
  0x1C, 0x1F, 0xC0, 0x70, 0xFB, 0xF1, 0xDF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x0F, 0xFC, 0x00, 0x3C,
  0x00, 0xFF, 0xE0, 0x01, 0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0xF0, 0x03, 0xC1, 0xF0, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x78, 0x00,
  0xF0, 0x3C, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x3C, 0x00, 0x3C, 0x0F, 0x01,
  0xE0, 0x01, 0xE0, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x78,
  0x1E, 0x0F, 0x80, 0x03, 0xC0, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x83, 0xC0,
  0x00, 0xF0, 0x3C, 0x3C, 0x00, 0x07, 0x81, 0xE1, 0xE0, 0xF0, 0x3C, 0x0F,
  0x1F, 0x1F, 0xE1, 0xE0, 0x78, 0xF1, 0xFF, 0x8F, 0x03, 0xC7, 0x8F, 0xFE,
  0x3C, 0x3C, 0x78, 0xF0, 0xF1, 0xE3, 0xE3, 0xC7, 0x87, 0xC7, 0xFE, 0x3C,
  0x78, 0x1E, 0x3F, 0xF1, 0xE3, 0xC0, 0xF0, 0xFF, 0x0F, 0x1E, 0x07, 0x81,
  0xE0, 0xF0, 0xF0, 0x3C, 0x00, 0x07, 0x87, 0x81, 0xF0, 0x00, 0x78, 0x3C,
  0x0F, 0x80, 0x03, 0xC1, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0x03, 0xE0, 0x01,
  0xE0, 0x78, 0x1F, 0x00, 0x0F, 0x03, 0xC0, 0xF8, 0x00, 0xF0, 0x1E, 0x07,
  0x80, 0x07, 0x80, 0xF0, 0x3C, 0x00, 0x7C, 0x07, 0x81, 0xE0, 0x03, 0xC0,
  0x3C, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x87, 0x80,
  0x0F, 0x00, 0x3E, 0x7C, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0x80, 0x03,
  0xFE, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x7C, 0x1F, 0x1F, 0x80, 0xF0,
  0x7E, 0x1F, 0x03, 0xE1, 0xF8, 0x3F, 0x07, 0xC3, 0xE0, 0x3F, 0x0F, 0x87,
  0xC0, 0x3F, 0x1E, 0x1F, 0x00, 0x3E, 0x7C, 0x3E, 0x00, 0x7E, 0xF8, 0x7C,
  0x00, 0x7F, 0xE0, 0xF8, 0x00, 0x7F, 0xC1, 0xF0, 0x00, 0xFF, 0x03, 0xE0,
  0x00, 0xFE, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xC0, 0x07, 0xFC, 0x0F, 0xC0,
  0x1F, 0xF8, 0x1F, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0xF9, 0xF8, 0x1F, 0xFF,
  0xE1, 0xF8, 0x1F, 0xFF, 0x83, 0xF8, 0x1F, 0xFC, 0x03, 0xF8, 0x05, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBD, 0xEF, 0x79, 0xC0,
  0x00, 0xF8, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3E, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x04, 0x07, 0x80, 0x9E, 0x1E, 0x1E, 0x7F, 0x7B, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0xCF, 0x80, 0x3E, 0x1F, 0x01,
  0xF8, 0x7E, 0x07, 0xC0, 0xF8, 0x07, 0x03, 0x80, 0x08, 0x04, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x1F,
  0x8F, 0x87, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x3C, 0x3E, 0x1F, 0x0F,
  0x07, 0x87, 0x83, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCC, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x3F, 0x1F, 0x80, 0x7C,
  0x7C, 0x01, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xBE, 0x00, 0x3E, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xE7,
  0xC0, 0x0F, 0x9F, 0x00, 0x7E, 0x7E, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xF8,
  0x7E, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x0C, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xFC,
  0x3F, 0xF1, 0xFB, 0xCF, 0xCF, 0x7E, 0x3F, 0xF1, 0xF7, 0x87, 0xCC, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x7F,
  0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xC0, 0x7F, 0x0E, 0x00,
  0x7E, 0x08, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x00,
  0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0x80, 0x7F, 0x0E, 0x00, 0x7E, 0x10, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xD8, 0x00, 0x3F, 0x3C, 0x00,
  0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0xFF, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF8, 0x00,
  0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1E, 0x03, 0xE0, 0x0F, 0x80, 0xF8,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xE0, 0x3E, 0x00,
  0xF8, 0x0F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x03, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x7B, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3E, 0x1F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x80, 0x03, 0xF3, 0xC0, 0x3F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x01,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x18, 0x03, 0xE3, 0xFE, 0x0F, 0x9F, 0xFC,
  0x3E, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFC, 0x0F, 0xEF, 0xE0, 0x1F, 0xBF,
  0x00, 0x3E, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x3E, 0x3E,
  0x00, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xEF,
  0xF8, 0x3F, 0x01, 0xFC, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x3C, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x81,
  0xF8, 0x0F, 0xC3, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0, 0x1F, 0x87,
  0xF0, 0x3F, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF,
  0x07, 0xF0, 0x7E, 0x0F, 0x80, 0x7E, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xEF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8,
  0x00, 0x7D, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xE0, 0x0F, 0xE7, 0xC0,
  0x1F, 0xCF, 0xE0, 0xFF, 0x8F, 0xFF, 0xDF, 0x0F, 0xFF, 0xBE, 0x0F, 0xFE,
  0x7C, 0x0F, 0xF0, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x3A, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xFF, 0xCC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0x10, 0x1E, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x3F, 0x3E,
  0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x07, 0xFF, 0x07, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9C, 0x07, 0xF4,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x06,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x3C, 0x00, 0xFE, 0x03, 0xC3, 0xC0, 0x1F, 0xFC,
  0x0F, 0x1E, 0x03, 0xFF, 0xE0, 0x79, 0xF0, 0x1F, 0xFF, 0x03, 0xCF, 0x01,
  0xF0, 0x78, 0x1E, 0x78, 0x1F, 0x03, 0xC0, 0x7B, 0xC0, 0xF0, 0x1E, 0x03,
  0xDE, 0x07, 0x80, 0xF0, 0x1F, 0xE0, 0x7C, 0x07, 0x80, 0xFF, 0x03, 0xC0,
  0x3C, 0x07, 0xF8, 0x1E, 0x01, 0xE0, 0x3F, 0xC0, 0xF0, 0x0F, 0x01, 0xFE,
  0x07, 0x80, 0x78, 0x0F, 0xF0, 0x3C, 0x03, 0xC0, 0x7F, 0x81, 0xE0, 0x3E,
  0x03, 0xFC, 0x0F, 0x01, 0xF0, 0x3D, 0xE0, 0x78, 0x0F, 0x81, 0xEF, 0x03,
  0xC0, 0x7C, 0x0F, 0x78, 0x1F, 0x03, 0xE0, 0x7B, 0xC0, 0x78, 0x3F, 0x07,
  0x8F, 0x03, 0xF3, 0x9C, 0x7C, 0x78, 0x0F, 0xFC, 0xFF, 0xC3, 0xC0, 0x7F,
  0xC3, 0xFC, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x80, 0x00, 0xFE, 0x00, 0x38, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1E, 0x3E, 0x00,
  0x00, 0xF8, 0x78, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x3C, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x3C, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x03, 0xF0, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xF8, 0x0F, 0xF8, 0xF8, 0x01, 0xFC, 0xF8,
  0x00, 0xFC, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x07, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xF8,
  0x07, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0xF8, 0x07, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xC0, 0x78, 0x3F, 0x80, 0x04, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x08, 0x1F, 0xE0,
  0x1C, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xF8, 0x1F, 0xF8, 0x3E, 0x00, 0x7F,
  0x0F, 0x80, 0x0F, 0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x3E, 0x00,
  0x07, 0xCF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00,
  0x7C, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xE3, 0xE0,
  0x03, 0xF0, 0xF8, 0x03, 0xFC, 0x3E, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xBE, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFE, 0x00, 0xF0, 0x3F, 0xC0, 0x01, 0x81, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x3E, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xF0, 0x00, 0x7C,
  0x1F, 0xF0, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC7, 0xF8, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x87, 0xF7, 0xFF, 0x3F, 0xF1, 0xFF,
  0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x0F,
  0xC1, 0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03,
  0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE1,
  0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E,
  0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x01, 0xFC, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x1F, 0x80,
  0x3E, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7E,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01,
  0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC7, 0xC0,
  0x07, 0xE3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x7C,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x78, 0x00,
  0x03, 0xFF, 0xF7, 0xC0, 0x00, 0x3D, 0xFF, 0x7C, 0x00, 0x03, 0xDF, 0xF3,
  0xC0, 0x00, 0x7D, 0xFF, 0x3E, 0x00, 0x07, 0xDF, 0xF3, 0xE0, 0x00, 0x79,
  0xFF, 0x1E, 0x00, 0x0F, 0x9F, 0xF1, 0xF0, 0x00, 0xF9, 0xFF, 0x9F, 0x00,
  0x0F, 0x1F, 0xF8, 0xF0, 0x00, 0xF1, 0xFF, 0x8F, 0x80, 0x1F, 0x1F, 0xF8,
  0xF8, 0x01, 0xE1, 0xFF, 0x87, 0x80, 0x1E, 0x1F, 0xF8, 0x78, 0x03, 0xE1,
  0xFF, 0x87, 0xC0, 0x3C, 0x1F, 0xF8, 0x7C, 0x03, 0xC1, 0xFF, 0x83, 0xC0,
  0x7C, 0x1F, 0xF8, 0x3E, 0x07, 0x81, 0xFF, 0x83, 0xE0, 0x78, 0x1F, 0xF8,
  0x1E, 0x0F, 0x81, 0xFF, 0x81, 0xF0, 0xF8, 0x1F, 0xF8, 0x1F, 0x0F, 0x01,
  0xFF, 0x80, 0xF1, 0xF0, 0x1F, 0xF8, 0x0F, 0x9F, 0x01, 0xFF, 0x80, 0xF9,
  0xE0, 0x1F, 0xF8, 0x07, 0x9E, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xF7, 0xC0, 0x03, 0xFE, 0xFC, 0x00, 0x7F, 0xCF, 0x80, 0x0F,
  0xF9, 0xF8, 0x01, 0xFF, 0x1F, 0x00, 0x3F, 0xE3, 0xF0, 0x07, 0xFC, 0x3E,
  0x00, 0xFF, 0x87, 0xE0, 0x1F, 0xF0, 0x7C, 0x03, 0xFF, 0x0F, 0x80, 0x7F,
  0xE0, 0xF8, 0x0F, 0xFC, 0x1F, 0x01, 0xFF, 0x81, 0xF0, 0x3F, 0xF0, 0x3E,
  0x07, 0xFE, 0x03, 0xE0, 0xFF, 0xC0, 0x7C, 0x1F, 0xF8, 0x07, 0xC3, 0xFF,
  0x00, 0xF8, 0x7F, 0xE0, 0x0F, 0x8F, 0xFC, 0x01, 0xF0, 0xFF, 0x80, 0x1F,
  0x1F, 0xF0, 0x03, 0xE3, 0xFE, 0x00, 0x3E, 0x7F, 0xC0, 0x07, 0xCF, 0xF8,
  0x00, 0x7D, 0xFF, 0x00, 0x0F, 0xBF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC,
  0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF8, 0x3F, 0xF3, 0xE0, 0x0F, 0xCF, 0x80,
  0x1F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0xBE, 0x00,
  0xFC, 0xF8, 0x0F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F,
  0x01, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3E, 0x7E,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x3F,
  0x80, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xF8, 0x7F, 0xF0,
  0xF8, 0x03, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xFC,
  0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xF8, 0x3F, 0x00,
  0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0,
  0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xF0,
  0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC,
  0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFE, 0x03, 0xE3, 0xF0, 0x01, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xEF,
  0xC0, 0x7F, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x07, 0xF0,
  0x1F, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3F,
  0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3F,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3E,
  0x01, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0,
  0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x7C,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F,
  0x3E, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xE3, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x1F, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0xFF, 0xC0, 0x07,
  0xC1, 0xF0, 0x03, 0xCF, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x3C, 0x00, 0xF8,
  0x1F, 0x00, 0x3C, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x80,
  0xF8, 0x07, 0xCF, 0x80, 0x7E, 0x03, 0xE0, 0x1E, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE1, 0xF0, 0x1F, 0x00, 0x7C,
  0x0F, 0x87, 0xC0, 0x7C, 0x01, 0xF0, 0x3E, 0x1F, 0x03, 0xE0, 0x07, 0xC0,
  0xF0, 0x3C, 0x0F, 0x80, 0x1F, 0x03, 0xC0, 0xF0, 0x3E, 0x00, 0x7C, 0x1F,
  0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xE0,
  0x1E, 0x1F, 0x00, 0x0F, 0x87, 0x80, 0x78, 0x7C, 0x00, 0x3E, 0x3E, 0x01,
  0xF1, 0xF0, 0x00, 0x78, 0xF8, 0x07, 0xC7, 0xC0, 0x01, 0xF3, 0xE0, 0x0F,
  0x3E, 0x00, 0x07, 0xCF, 0x00, 0x3C, 0xF8, 0x00, 0x1F, 0x3C, 0x00, 0xF3,
  0xE0, 0x00, 0x7C, 0xF0, 0x03, 0xEF, 0x80, 0x00, 0xF7, 0xC0, 0x0F, 0xBE,
  0x00, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00,
  0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x1F,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xF8,
  0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x01, 0xF0, 0x7E, 0x00,
  0x3E, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0xF9, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC1, 0xF0,
  0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x1F, 0x00,
  0xFC, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x7C,
  0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x78,
  0x78, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF8, 0x01,
  0xE0, 0x1E, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x0F, 0x00, 0x3E,
  0x07, 0xC0, 0x07, 0x81, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x3C, 0x00,
  0x0F, 0x9F, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E,
  0x00, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xE0, 0x3F, 0x04, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFC, 0xF9, 0xF8,
  0x07, 0xDF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xDF, 0x00,
  0xFE, 0xFC, 0x0F, 0xF7, 0xF9, 0xF7, 0x9F, 0xFF, 0x3C, 0x7F, 0xF1, 0xE1,
  0xFF, 0x0F, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0xF0, 0x3E, 0x3F, 0xF0,
  0x7C, 0xFF, 0xF0, 0xFB, 0xFF, 0xF1, 0xFF, 0x07, 0xF3, 0xFC, 0x03, 0xE7,
  0xF0, 0x07, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xBF, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xBF, 0x80, 0x1F, 0x7F, 0x00, 0x7E,
  0xFF, 0x81, 0xF9, 0xFF, 0xFF, 0xE3, 0xEF, 0xFF, 0xC7, 0x8F, 0xFF, 0x0F,
  0x07, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0xFF,
  0xFC, 0x7F, 0xFF, 0x1F, 0xC3, 0x8F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFE, 0x03, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x7F,
  0x87, 0xC1, 0xFF, 0x8F, 0x87, 0xFF, 0xDF, 0x1F, 0xFF, 0xBE, 0x7F, 0x07,
  0xFC, 0xF8, 0x07, 0xFB, 0xF0, 0x07, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xDF, 0x00,
  0x3F, 0xBF, 0x00, 0x7F, 0x3F, 0x01, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFE,
  0xF8, 0x7F, 0xF8, 0xF0, 0x3F, 0xC1, 0xE0, 0x0C, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x03, 0xE0,
  0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0xFB, 0xE0,
  0x01, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x8F, 0xE0, 0x0C, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xE0, 0x7E, 0x10, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFF, 0xF1, 0xFF,
  0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x03, 0xFC, 0x1E, 0x0F, 0xFC, 0x3C, 0x3F,
  0xFC, 0xF8, 0xFF, 0xFD, 0xF3, 0xF8, 0x7F, 0xE7, 0xC0, 0x3F, 0xDF, 0x80,
  0x3F, 0xBE, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0x7C, 0x00, 0x7E, 0xF8, 0x01, 0xFD, 0xF8, 0x03, 0xF9, 0xF8,
  0x1F, 0xF3, 0xFF, 0xFB, 0xE3, 0xFF, 0xF7, 0xC3, 0xFF, 0xCF, 0x81, 0xFE,
  0x1F, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x20, 0x01, 0xF8, 0x7C, 0x0F, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE1, 0xFE, 0x0F, 0x8F, 0xFE, 0x3E,
  0xFF, 0xFC, 0xFB, 0xFF, 0xF3, 0xFE, 0x0F, 0xEF, 0xF0, 0x1F, 0xBF, 0x80,
  0x3E, 0xFC, 0x00, 0xFB, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x23, 0xEF,
  0xBF, 0xFB, 0xE7, 0x80, 0x00, 0x00, 0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x00, 0x80, 0x3E, 0x03, 0xE0,
  0x3F, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x07, 0xE8, 0x7C, 0xFF, 0xCF, 0xFC, 0xFF, 0x8F, 0xE0, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x07,
  0xEF, 0x80, 0x1F, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x0F,
  0x80, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x0F, 0x87,
  0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0xBF, 0x00,
  0x3E, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xF7, 0xC0, 0x3F,
  0x9F, 0x80, 0xFC, 0x3E, 0x03, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF8,
  0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7E, 0xF8,
  0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x7F, 0x00, 0xFF, 0x07,
  0x8F, 0xFE, 0x0F, 0xFE, 0x3C, 0xFF, 0xF8, 0xFF, 0xF9, 0xF7, 0xFF, 0xCF,
  0xFF, 0xCF, 0xF8, 0x7F, 0xF8, 0x7F, 0x7F, 0x00, 0xFF, 0x01, 0xFB, 0xF8,
  0x07, 0xF0, 0x07, 0xDF, 0x80, 0x1F, 0x80, 0x3E, 0xFC, 0x00, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0xF0, 0x01,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xFC, 0x00, 0x7C, 0x00, 0x7F,
  0xE0, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x00, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0xF0,
  0x01, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xFC, 0x00, 0x7C, 0x00,
  0x7F, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x00,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x3F,
  0xF0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xFC, 0x00, 0x7C,
  0x00, 0x7F, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xF0,
  0x7F, 0x83, 0xC3, 0xFF, 0x8F, 0x3F, 0xFF, 0x3E, 0xFF, 0xFC, 0xFF, 0x83,
  0xFB, 0xFC, 0x07, 0xEF, 0xE0, 0x0F, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0x87, 0xC0, 0x1F, 0x1F, 0x80, 0x3F, 0x3E,
  0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xBE, 0x00, 0x3E,
  0x7C, 0x00, 0x7C, 0xFC, 0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xF8, 0x0F, 0xC1,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0x10, 0x00, 0xF0, 0x7F, 0x81, 0xE1, 0xFF, 0x83, 0xE7, 0xFF, 0xC7, 0xDF,
  0xFF, 0x8F, 0xF8, 0x3F, 0x9F, 0xE0, 0x1F, 0x3F, 0x80, 0x3F, 0x7E, 0x00,
  0x3E, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7D, 0xFC, 0x00, 0xFB, 0xF8, 0x03, 0xF7, 0xFC, 0x0F, 0xCF, 0xFF,
  0xFF, 0x1F, 0x7F, 0xFE, 0x3E, 0x7F, 0xF8, 0x7C, 0x3F, 0xC0, 0xF8, 0x0E,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x1E, 0x0F, 0xFC, 0x3C, 0x3F, 0xFC, 0xF8,
  0xFF, 0xFD, 0xF3, 0xF8, 0x3F, 0xE7, 0xC0, 0x3F, 0xDF, 0x80, 0x3F, 0xBE,
  0x00, 0x3F, 0x7C, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0x7C, 0x00, 0x7E, 0xF8, 0x01, 0xFD, 0xF8, 0x03, 0xF9, 0xF8, 0x1F, 0xF3,
  0xFF, 0xFB, 0xE3, 0xFF, 0xF7, 0xC3, 0xFF, 0xCF, 0x81, 0xFE, 0x1F, 0x00,
  0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF,
  0xBF, 0xFF, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF,
  0xFE, 0x7E, 0x03, 0x9F, 0x00, 0x2F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF,
  0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x10, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xF7, 0xC0, 0x3F,
  0xDF, 0x81, 0xFF, 0x7F, 0xFF, 0x7C, 0xFF, 0xFD, 0xF1, 0xFF, 0xE7, 0xC3,
  0xFE, 0x0F, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x78, 0x1F,
  0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x0F,
  0x81, 0xF0, 0x07, 0x81, 0xF0, 0x07, 0xC1, 0xE0, 0x07, 0xC3, 0xE0, 0x07,
  0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xE3, 0xC0, 0x03, 0xE7, 0xC0, 0x01,
  0xE7, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xF7, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x03, 0xF8, 0x01, 0xF7,
  0x80, 0x1F, 0xC0, 0x0F, 0x3E, 0x01, 0xFE, 0x00, 0xF9, 0xF0, 0x0F, 0x78,
  0x07, 0xCF, 0x80, 0x7B, 0xC0, 0x3E, 0x7C, 0x03, 0xDE, 0x01, 0xE1, 0xF0,
  0x1E, 0xF0, 0x1F, 0x0F, 0x81, 0xF7, 0xC0, 0xF8, 0x7C, 0x0F, 0x1E, 0x07,
  0xC3, 0xE0, 0x78, 0xF0, 0x3C, 0x0F, 0x03, 0xC7, 0x81, 0xE0, 0x7C, 0x3E,
  0x3E, 0x1F, 0x03, 0xE1, 0xE1, 0xF0, 0xF8, 0x1F, 0x0F, 0x07, 0x87, 0xC0,
  0x78, 0x78, 0x3C, 0x3C, 0x03, 0xC7, 0xC1, 0xE3, 0xE0, 0x1F, 0x3C, 0x0F,
  0x9F, 0x00, 0xF9, 0xE0, 0x3C, 0xF8, 0x07, 0xCF, 0x01, 0xE7, 0x80, 0x1E,
  0x78, 0x0F, 0x3C, 0x00, 0xF7, 0xC0, 0x7B, 0xE0, 0x07, 0xFC, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E,
  0xF8, 0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC1, 0xF0, 0x1F, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F,
  0x8F, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0xF9, 0xF0,
  0x01, 0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x83, 0xE0, 0x3E, 0x07, 0xC0,
  0x7C, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x9F,
  0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x78, 0x1F,
  0x00, 0xF8, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x07,
  0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xE0, 0x07, 0xC3, 0xE0, 0x03,
  0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xC0, 0x01, 0xE7, 0xC0, 0x01,
  0xE7, 0xC0, 0x01, 0xF7, 0x80, 0x00, 0xF7, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x87, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0x0F, 0xE0,
  0x1F, 0xF0, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80,
  0x3F, 0x00, 0x00, 0x06, 0x00, 0x01, 0x3F, 0xE0, 0x01, 0x7F, 0xF8, 0x07,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0xC0, 0x0F, 0xFC,
  0x80, 0x01, 0xF0,
};

const GFXglyph NotoSans_Condensed_Regular59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 43, 14, 4, -42 },
  { 39, 15, 15, 23, 4, -42 },
  { 68, 28, 42, 30, 1, -42 },
  { 215, 22, 48, 28, 3, -45 },
  { 347, 37, 44, 42, 3, -43 },
  { 551, 31, 44, 33, 2, -43 },
  { 722, 5, 15, 13, 4, -42 },
  { 732, 13, 51, 17, 3, -42 },
  { 815, 13, 51, 17, 2, -42 },
  { 898, 22, 22, 26, 2, -45 },
  { 959, 24, 28, 28, 2, -35 },
  { 1043, 9, 15, 14, 2, -7 },
  { 1060, 13, 4, 17, 2, -18 },
  { 1067, 6, 8, 14, 4, -7 },
  { 1073, 20, 42, 22, 1, -42 },
  { 1178, 22, 44, 28, 3, -43 },
  { 1299, 14, 42, 28, 4, -42 },
  { 1373, 23, 43, 28, 2, -43 },
  { 1497, 23, 44, 28, 2, -43 },
  { 1624, 26, 42, 28, 1, -42 },
  { 1761, 22, 43, 28, 3, -42 },
  { 1880, 22, 44, 28, 3, -43 },
  { 2001, 23, 42, 28, 2, -42 },
  { 2122, 24, 44, 28, 2, -43 },
  { 2254, 23, 44, 28, 2, -43 },
  { 2381, 6, 33, 14, 4, -32 },
  { 2406, 8, 40, 14, 2, -32 },
  { 2446, 24, 28, 28, 2, -35 },
  { 2530, 24, 16, 28, 2, -29 },
  { 2578, 24, 28, 28, 2, -35 },
  { 2662, 18, 44, 21, 1, -43 },
  { 2761, 37, 47, 43, 3, -42 },
  { 2979, 30, 42, 30, 0, -42 },
  { 3137, 24, 42, 31, 5, -42 },
  { 3263, 25, 44, 30, 3, -43 },
  { 3401, 26, 42, 34, 5, -42 },
  { 3538, 19, 42, 26, 5, -42 },
  { 3638, 19, 42, 25, 5, -42 },
  { 3738, 29, 44, 35, 3, -43 },
  { 3898, 25, 42, 35, 5, -42 },
  { 4030, 14, 42, 18, 2, -42 },
  { 4104, 13, 53, 14, -3, -42 },
  { 4191, 25, 42, 29, 5, -42 },
  { 4323, 18, 42, 25, 5, -42 },
  { 4418, 36, 42, 46, 5, -42 },
  { 4607, 27, 42, 37, 5, -42 },
  { 4749, 30, 44, 37, 3, -43 },
  { 4914, 22, 42, 29, 5, -42 },
  { 5030, 30, 53, 37, 3, -43 },
  { 5229, 24, 42, 30, 5, -42 },
  { 5355, 22, 44, 27, 2, -43 },
  { 5476, 24, 42, 26, 1, -42 },
  { 5602, 26, 43, 35, 4, -42 },
  { 5742, 29, 42, 29, 0, -42 },
  { 5895, 46, 42, 46, 0, -42 },
  { 6137, 27, 42, 27, 0, -42 },
  { 6279, 26, 42, 26, 0, -42 },
  { 6416, 22, 42, 25, 2, -42 },
  { 6532, 13, 51, 19, 4, -42 },
  { 6615, 20, 42, 22, 1, -42 },
  { 6720, 12, 51, 19, 2, -42 },
  { 6797, 26, 24, 28, 1, -42 },
  { 6875, 26, 4, 26, 0, 5 },
  { 6888, 12, 9, 16, 2, -45 },
  { 6902, 21, 33, 27, 2, -32 },
  { 6989, 23, 46, 30, 4, -45 },
  { 7122, 18, 33, 23, 3, -32 },
  { 7197, 23, 46, 30, 3, -45 },
  { 7330, 22, 33, 27, 3, -32 },
  { 7421, 17, 45, 17, 1, -45 },
  { 7517, 23, 46, 30, 3, -32 },
  { 7650, 22, 45, 30, 4, -45 },
  { 7774, 6, 44, 13, 4, -44 },
  { 7807, 12, 58, 13, -2, -44 },
  { 7894, 22, 45, 26, 4, -45 },
  { 8018, 5, 45, 13, 4, -45 },
  { 8047, 37, 32, 45, 4, -32 },
  { 8195, 22, 32, 30, 4, -32 },
  { 8283, 23, 33, 29, 3, -32 },
  { 8378, 23, 46, 30, 4, -32 },
  { 8511, 23, 46, 30, 3, -32 },
  { 8644, 15, 32, 20, 4, -32 },
  { 8704, 18, 33, 22, 2, -32 },
  { 8779, 15, 40, 17, 1, -39 },
  { 8854, 22, 33, 30, 4, -32 },
  { 8945, 24, 32, 24, 0, -32 },
  { 9041, 37, 32, 39, 1, -32 },
  { 9189, 23, 32, 25, 1, -32 },
  { 9281, 24, 46, 24, 0, -32 },
  { 9419, 17, 32, 21, 2, -32 },
  { 9487, 17, 51, 22, 2, -42 },
  { 9596, 4, 59, 26, 11, -45 },
  { 9626, 17, 51, 22, 2, -42 },
  { 9735, 24, 8, 28, 2, -25 },
};

const GFXfont NotoSans_Condensed_Regular59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular59pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_CONDENSED_REGULAR59PT7B_H_
