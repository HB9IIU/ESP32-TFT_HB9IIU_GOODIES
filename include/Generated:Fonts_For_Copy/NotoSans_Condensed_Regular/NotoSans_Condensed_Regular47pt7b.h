#ifndef _NOTOSANS_CONDENSED_REGULAR47PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x70, 0x00, 0x03, 0x3F, 0xFF, 0xFB, 0xC0, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0x7F, 0x07, 0x70, 0x77, 0x07, 0x60, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0x83,
  0x80, 0x0E, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x00,
  0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x07, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x0E, 0x0E, 0x00, 0x38, 0x38,
  0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x01,
  0xC1, 0xC0, 0x07, 0x07, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80,
  0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x07, 0x03, 0x80, 0x1C,
  0x0E, 0x00, 0x70, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFE, 0x78,
  0xC1, 0x1C, 0x30, 0x0F, 0x0C, 0x03, 0xC3, 0x00, 0xF0, 0xC0, 0x3C, 0x30,
  0x07, 0x8C, 0x01, 0xF3, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x37, 0xE0, 0x0C, 0x78, 0x03, 0x0F, 0x00,
  0xC3, 0xC0, 0x30, 0x70, 0x0C, 0x3C, 0x03, 0x0F, 0x80, 0xC3, 0xF8, 0x33,
  0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0xFE, 0x00, 0x38, 0x03, 0xFC, 0x01, 0xC0, 0x1E, 0x78, 0x07, 0x00,
  0x70, 0xE0, 0x3C, 0x03, 0xC3, 0x80, 0xE0, 0x0E, 0x0F, 0x03, 0x80, 0x38,
  0x3C, 0x1C, 0x00, 0xE0, 0x70, 0x70, 0x03, 0x81, 0xC3, 0xC0, 0x0E, 0x07,
  0x0E, 0x00, 0x38, 0x1C, 0x78, 0x00, 0xE0, 0xF1, 0xC0, 0x03, 0x83, 0xC7,
  0x0E, 0x0F, 0x0F, 0x3C, 0xFE, 0x1C, 0x38, 0xE3, 0xFC, 0x70, 0xE7, 0x9E,
  0xF1, 0xE7, 0x9C, 0x71, 0xE3, 0xFC, 0x73, 0x83, 0x8F, 0xE3, 0x8E, 0x0E,
  0x0F, 0x0E, 0x38, 0x38, 0x00, 0x78, 0xE0, 0xE0, 0x01, 0xC3, 0x83, 0xC0,
  0x07, 0x0E, 0x0F, 0x00, 0x38, 0x38, 0x3C, 0x00, 0xE0, 0xE0, 0xF0, 0x07,
  0x83, 0x83, 0x80, 0x1C, 0x0E, 0x0E, 0x00, 0xF0, 0x38, 0x38, 0x03, 0x80,
  0xF0, 0xE0, 0x0E, 0x01, 0xC7, 0x80, 0x78, 0x07, 0xBC, 0x01, 0xC0, 0x0F,
  0xE0, 0x0F, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x0E, 0x00, 0x3C,
  0x0E, 0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3E,
  0xF0, 0x3C, 0x7C, 0xF8, 0x3C, 0x78, 0x7C, 0x3C, 0xF8, 0x3C, 0x3C, 0xF0,
  0x1E, 0x78, 0xF0, 0x1F, 0x78, 0xF0, 0x0F, 0xF8, 0xF0, 0x07, 0xF0, 0xF0,
  0x03, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xF0, 0xF8, 0x0F, 0xF8, 0x7C,
  0x1F, 0x78, 0x7F, 0xFE, 0x7C, 0x3F, 0xFC, 0x3E, 0x0F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0x60, 0x01, 0xC0, 0xF0, 0x78, 0x1C, 0x0F,
  0x03, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F,
  0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x0F,
  0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xF0,
  0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x81,
  0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0xF8, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x04, 0x0E, 0x0B, 0xE7, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0xFC, 0x00, 0xF8, 0x00, 0xEE, 0x00, 0xF7, 0x80, 0xF1,
  0xC0, 0x78, 0xF0, 0x78, 0x3C, 0x1C, 0x18, 0x02, 0x08, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x3C, 0xF3, 0xDF, 0x79, 0xE7, 0x9C, 0xF3, 0x8E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x37, 0xFF, 0xFF, 0xBC, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0x7F, 0xF8, 0x3E, 0x1F, 0x0F, 0x03, 0xC7, 0x80, 0x79, 0xE0, 0x1E, 0x78,
  0x07, 0x9E, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x03, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x7C, 0x0F, 0x8F, 0x03,
  0xC3, 0xE1, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xF0,
  0x1F, 0x03, 0xF0, 0x7F, 0x0F, 0xF1, 0xEF, 0x3E, 0xFF, 0x8F, 0x70, 0xF2,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x07, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0xE3, 0xFF, 0xFC, 0x70, 0x1F,
  0x08, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x0F, 0xFF, 0x07, 0xFF,
  0xE3, 0xF9, 0xFC, 0x70, 0x0F, 0x10, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0xA0,
  0x03, 0xEE, 0x03, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0x78, 0x00, 0x77, 0x80, 0x0F, 0x78, 0x00, 0xE7, 0x80, 0x1E, 0x78,
  0x01, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0x87, 0x80, 0x78, 0x78, 0x07, 0x07,
  0x80, 0xF0, 0x78, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x07, 0x83, 0x80,
  0x78, 0x78, 0x07, 0x87, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x78, 0x07, 0xFF, 0xC1, 0xFF, 0xF8,
  0x7F, 0xFF, 0x08, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0xA0, 0x03, 0xEF, 0x03, 0xF3, 0xFF, 0xF8,
  0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xF0,
  0x3F, 0xCC, 0x1F, 0x80, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x7F,
  0x0F, 0x3F, 0xE3, 0xDF, 0xFC, 0xFF, 0x1F, 0xBF, 0x01, 0xEF, 0x80, 0x7B,
  0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x70,
  0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x3C, 0x07, 0x8F, 0x01,
  0xE1, 0xF1, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFC, 0xFC,
  0x7C, 0x0F, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x0F, 0x78, 0x03, 0xDE,
  0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x3C, 0x0F, 0x07, 0x87, 0xC1, 0xFF,
  0xE0, 0x3F, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xF7, 0xE0, 0xF8, 0x7C,
  0x7C, 0x0F, 0x9E, 0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xF7, 0xC0,
  0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xF0, 0x03, 0xFE,
  0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x7C, 0x1F, 0x1E, 0x03, 0xC7, 0x80, 0x7B,
  0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x00, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0x78, 0x0F, 0xDF, 0x07,
  0xF3, 0xFF, 0xBC, 0x7F, 0xEF, 0x0F, 0xF3, 0xC0, 0x40, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x84, 0x0F, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0,
  0x00, 0x27, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x7F, 0xFF, 0xFB, 0xC0, 0x11, 0xF7, 0xDF, 0x7D, 0xF1, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xDF,
  0x79, 0xE7, 0x9C, 0xF3, 0xCE, 0x38, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7C,
  0x00, 0x0E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0xE3, 0xFF,
  0xE7, 0xFF, 0xE4, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7E,
  0x07, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x70, 0xF0, 0x06, 0x01,
  0xE3, 0xC0, 0xFF, 0x83, 0x8E, 0x07, 0xFE, 0x0E, 0x78, 0x3C, 0x38, 0x39,
  0xC0, 0xE0, 0xE0, 0xF7, 0x07, 0x83, 0x83, 0xDC, 0x1C, 0x0E, 0x07, 0x70,
  0x70, 0x38, 0x1F, 0xC3, 0xC0, 0xE0, 0x7F, 0x0F, 0x03, 0x81, 0xFC, 0x3C,
  0x0E, 0x07, 0xF0, 0xF0, 0x78, 0x3F, 0xC3, 0xC1, 0xE0, 0xEF, 0x0F, 0x07,
  0x83, 0xBC, 0x1C, 0x1E, 0x0E, 0x70, 0x70, 0x78, 0x79, 0xC1, 0xE3, 0x73,
  0xC7, 0x03, 0xFC, 0xFE, 0x1E, 0x07, 0xE3, 0xF8, 0x78, 0x0F, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x08, 0x00, 0x7E, 0x01, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xEF, 0x00, 0x00, 0xEF, 0x00, 0x01, 0xE7,
  0x00, 0x01, 0xE7, 0x80, 0x01, 0xC7, 0x80, 0x03, 0xC3, 0x80, 0x03, 0xC3,
  0xC0, 0x03, 0xC3, 0xC0, 0x03, 0x83, 0xC0, 0x07, 0x81, 0xC0, 0x07, 0x81,
  0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1E, 0x00,
  0x78, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00,
  0x1E, 0xF0, 0x00, 0x1F, 0xFF, 0x40, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F,
  0xFF, 0xCF, 0x01, 0xF9, 0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0x80, 0x1E, 0xF0,
  0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x79, 0xE0,
  0x1F, 0x3C, 0x0F, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFF, 0xE3, 0xC0,
  0x7E, 0x78, 0x03, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xEF, 0x00,
  0x7D, 0xE0, 0x0F, 0xBC, 0x1F, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F,
  0xC0, 0x21, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x60, 0x7F, 0xFE, 0x03, 0xFF, 0xE0,
  0x0F, 0xFE, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE,
  0x0F, 0x01, 0xF8, 0x78, 0x03, 0xE3, 0xC0, 0x0F, 0x9E, 0x00, 0x7C, 0xF0,
  0x01, 0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7B,
  0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0xBC, 0x00,
  0x79, 0xE0, 0x07, 0xCF, 0x00, 0x7C, 0x78, 0x0F, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7,
  0xFF, 0xEF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFC, 0x01, 0xC1, 0xF0, 0x00, 0x87, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFB, 0xC0,
  0x1F, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00,
  0x0F, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF8, 0x00, 0x78, 0xF0, 0x00,
  0xF1, 0xF0, 0x01, 0xE1, 0xF0, 0x03, 0xC3, 0xFC, 0x0F, 0x83, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE3, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xF7, 0xFE, 0xFF, 0x9F, 0xE3,
  0xF0, 0x00, 0xF0, 0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x07, 0xCF, 0x00, 0x78,
  0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x7C,
  0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x3C,
  0x00, 0xF3, 0xC0, 0x0F, 0x78, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFD,
  0xE0, 0x0F, 0x9F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x80, 0xF0, 0x78, 0x0F,
  0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xF0,
  0xF0, 0x0F, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0xCF, 0x00, 0x3C, 0xF0, 0x03,
  0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xB8, 0x00, 0x1D, 0xFD, 0xE0, 0x00, 0xEF,
  0xEF, 0x00, 0x0F, 0x7F, 0xB8, 0x00, 0x7B, 0xFD, 0xE0, 0x03, 0x9F, 0xEF,
  0x00, 0x3C, 0xFF, 0x38, 0x01, 0xE7, 0xF9, 0xE0, 0x0E, 0x3F, 0xCF, 0x00,
  0xF1, 0xFE, 0x38, 0x07, 0x8F, 0xF1, 0xE0, 0x38, 0x7F, 0x8F, 0x01, 0xC3,
  0xFC, 0x38, 0x1E, 0x1F, 0xE1, 0xE0, 0xE0, 0xFF, 0x0F, 0x07, 0x07, 0xF8,
  0x78, 0x78, 0x3F, 0xC1, 0xC3, 0x81, 0xFE, 0x0F, 0x1C, 0x0F, 0xF0, 0x79,
  0xE0, 0x7F, 0x81, 0xCF, 0x03, 0xFC, 0x0F, 0x70, 0x1F, 0xE0, 0x7F, 0x80,
  0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0xC0, 0x7E, 0x01, 0xFE,
  0x01, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0x7F, 0x80, 0x78, 0x03, 0xC0, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFB, 0xC0, 0x0F, 0xEF, 0x80, 0x3F,
  0x9E, 0x00, 0xFE, 0x7C, 0x03, 0xFC, 0xF0, 0x0F, 0xF3, 0xE0, 0x3F, 0xC7,
  0x80, 0xFF, 0x1F, 0x03, 0xFC, 0x3C, 0x0F, 0xF0, 0xF8, 0x3F, 0xC1, 0xE0,
  0xFF, 0x07, 0xC3, 0xFC, 0x0F, 0x0F, 0xF0, 0x3C, 0x3F, 0xC0, 0x78, 0xFF,
  0x01, 0xE3, 0xFC, 0x03, 0xCF, 0xF0, 0x0F, 0x3F, 0xC0, 0x1E, 0xFF, 0x00,
  0x7B, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xF8, 0x0F,
  0x80, 0xF8, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0x3C, 0x3C, 0x00,
  0x1E, 0x3E, 0x00, 0x0F, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0xFB, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E,
  0x7C, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0x87, 0xC0, 0x07,
  0xC1, 0xE0, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0x3F, 0x07, 0xE0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xFC,
  0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x03, 0xF7, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1E, 0xF0, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF,
  0x1F, 0xFF, 0x0F, 0xFE, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xF8, 0x0F,
  0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0x3C, 0x3C, 0x00,
  0x1F, 0x3E, 0x00, 0x0F, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0xFB, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E,
  0x7C, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0x87, 0xC0, 0x07,
  0xC1, 0xE0, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0x3F, 0x07, 0xE0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0x1F,
  0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0x03, 0xF1, 0xE0, 0x1F, 0x3C,
  0x03, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78,
  0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xE7, 0x80, 0xF8, 0xF0,
  0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0x0F, 0x81, 0xE0,
  0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0xF0, 0x3E, 0x1E, 0x03, 0xC3, 0xC0,
  0x7C, 0x78, 0x07, 0x8F, 0x00, 0xF9, 0xE0, 0x0F, 0x3C, 0x01, 0xF7, 0x80,
  0x1E, 0xF0, 0x03, 0xFE, 0x00, 0x3C, 0x03, 0xFC, 0x07, 0xFF, 0xC7, 0xFF,
  0xE7, 0xFF, 0xE7, 0xC0, 0x33, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFB, 0xF0, 0xFD,
  0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0x78,
  0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x01, 0xE7, 0xC0, 0x0F,
  0x1F, 0x00, 0xF8, 0xFE, 0x1F, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xF3, 0xC0,
  0x01, 0xE7, 0x80, 0x03, 0xCF, 0x80, 0x0F, 0x8F, 0x00, 0x1E, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x7C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07,
  0x81, 0xE0, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0,
  0x0F, 0x01, 0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00,
  0x38, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x01,
  0xCF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x70, 0x00, 0x0E,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x80,
  0x0F, 0x78, 0x00, 0xF8, 0x00, 0xF7, 0x80, 0x0F, 0x80, 0x0F, 0x78, 0x01,
  0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x80, 0x1E, 0x3C, 0x01, 0xFC, 0x01, 0xE3,
  0xC0, 0x1D, 0xC0, 0x1E, 0x3C, 0x01, 0xDC, 0x01, 0xE3, 0xC0, 0x3D, 0xC0,
  0x3C, 0x1E, 0x03, 0xDE, 0x03, 0xC1, 0xE0, 0x39, 0xE0, 0x3C, 0x1E, 0x03,
  0x9E, 0x03, 0xC1, 0xE0, 0x78, 0xE0, 0x3C, 0x1E, 0x07, 0x8F, 0x07, 0x80,
  0xF0, 0x78, 0xF0, 0x78, 0x0F, 0x07, 0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x70,
  0x78, 0x0F, 0x0F, 0x07, 0x0F, 0x00, 0x78, 0xF0, 0x78, 0xF0, 0x07, 0x8E,
  0x07, 0x8F, 0x00, 0x78, 0xE0, 0x38, 0xF0, 0x07, 0x9E, 0x03, 0x8F, 0x00,
  0x79, 0xE0, 0x3D, 0xE0, 0x03, 0x9E, 0x03, 0xDE, 0x00, 0x3D, 0xC0, 0x3D,
  0xE0, 0x03, 0xDC, 0x01, 0xDE, 0x00, 0x3F, 0xC0, 0x1D, 0xC0, 0x01, 0xFC,
  0x01, 0xDC, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0xF9, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x3C, 0x03, 0xC1,
  0xE0, 0x1E, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0xF0, 0x07, 0x87,
  0x80, 0x3C, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xEF, 0x00, 0x0F,
  0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x78, 0x3C, 0x03, 0xC0, 0xF0,
  0x3C, 0x07, 0x81, 0xE0, 0x3E, 0x1F, 0x00, 0xF0, 0xF0, 0x07, 0xCF, 0x80,
  0x1E, 0x78, 0x00, 0xF7, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x7F, 0xC0, 0x07,
  0x9E, 0x00, 0x3C, 0xF0, 0x03, 0xE3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF8,
  0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x3C, 0x03, 0xC1, 0xE0,
  0x1F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x78, 0x00, 0x7B,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0x70, 0x00,
  0x73, 0xC0, 0x07, 0x8E, 0x00, 0x38, 0x78, 0x03, 0xC1, 0xC0, 0x1C, 0x0F,
  0x01, 0xE0, 0x38, 0x0E, 0x01, 0xE0, 0xF0, 0x07, 0x07, 0x00, 0x3C, 0x78,
  0x00, 0xE3, 0xC0, 0x07, 0xBC, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF8, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07,
  0x01, 0xE0, 0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x10, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x07, 0xFF,
  0x1F, 0xFF, 0x3F, 0xFF, 0x7C, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0x7F, 0xF7,
  0x3F, 0xE7, 0x1F, 0xC7, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC1, 0xC0, 0x78, 0xFE, 0x0F, 0x7F, 0xF1, 0xEF,
  0xFE, 0x3F, 0x83, 0xE7, 0xE0, 0x3E, 0xF8, 0x03, 0xDF, 0x00, 0x7B, 0xE0,
  0x0F, 0x78, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xEF, 0x80,
  0x3D, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0xE0, 0x3C, 0xFE, 0x0F, 0x9E, 0xFF,
  0xE3, 0xCF, 0xF8, 0x70, 0xFE, 0x00, 0x00, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8,
  0xFF, 0xE3, 0xE0, 0x47, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x81, 0x8F, 0xFF, 0x0F, 0xFE, 0x0F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x06, 0x07, 0x87, 0xF8, 0xF1,
  0xFF, 0xDE, 0x7F, 0xFB, 0xCF, 0x83, 0xFB, 0xE0, 0x3F, 0x78, 0x03, 0xEF,
  0x00, 0x7D, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x01, 0xF7, 0x80, 0x3E, 0xF0, 0x07, 0xDE, 0x00, 0xFB, 0xE0, 0x3F, 0x3E,
  0x0F, 0xE3, 0xFF, 0xBC, 0x7F, 0xE7, 0x83, 0xF8, 0xF0, 0x00, 0xC0, 0x01,
  0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x3C, 0x0F, 0x0F, 0x01, 0xE7, 0x80,
  0x79, 0xE0, 0x1E, 0x70, 0x03, 0xBC, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x23, 0xF0,
  0x38, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFC, 0x1F, 0xE0,
  0xFF, 0x83, 0xE6, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC1, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x01,
  0xC0, 0x01, 0xFE, 0x3C, 0x7F, 0xF7, 0x9F, 0xFE, 0xF3, 0xE0, 0xFE, 0xF8,
  0x0F, 0xDE, 0x00, 0xFB, 0xC0, 0x1F, 0x78, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7D, 0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0x80,
  0x3E, 0xF8, 0x0F, 0xCF, 0x83, 0xF8, 0xFF, 0xEF, 0x1F, 0xF9, 0xE0, 0xFE,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x20, 0x07, 0x87, 0x03, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x01, 0xFF, 0x80, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x0C, 0x1E, 0x3F, 0xCF, 0x7F, 0xF7, 0xBF, 0xFB, 0xF8, 0x3F, 0xF8,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x70, 0x67, 0xBF, 0xFF, 0x30,
  0x00, 0x00, 0x3D, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0x06, 0x07, 0x83, 0xE1, 0xF0, 0xF0,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xA7, 0xDF, 0xCF, 0xE7, 0xE0, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x01, 0xFF,
  0x01, 0xF7, 0x80, 0xF3, 0xC0, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x78,
  0x3C, 0x78, 0x1E, 0x7C, 0x0F, 0x3C, 0x07, 0xBE, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0xFD, 0xE0, 0x7C, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0xC7,
  0x81, 0xE3, 0xC0, 0xF9, 0xE0, 0x3C, 0xF0, 0x1F, 0x78, 0x07, 0xBC, 0x03,
  0xFE, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x07,
  0x87, 0x9F, 0xE0, 0xFF, 0x3D, 0xFF, 0x8F, 0xFD, 0xEF, 0xFE, 0xFF, 0xEF,
  0xE1, 0xFE, 0x0F, 0xFE, 0x07, 0xE0, 0x3F, 0xE0, 0x1F, 0x01, 0xFF, 0x00,
  0xF0, 0x0F, 0xF8, 0x07, 0x80, 0x7F, 0x80, 0x3C, 0x01, 0xFC, 0x01, 0xE0,
  0x0F, 0xE0, 0x0F, 0x00, 0x7F, 0x00, 0x78, 0x03, 0xF8, 0x03, 0xC0, 0x1F,
  0xC0, 0x1E, 0x00, 0xFE, 0x00, 0xF0, 0x07, 0xF0, 0x07, 0x80, 0x3F, 0x80,
  0x3C, 0x01, 0xFC, 0x01, 0xE0, 0x0F, 0xE0, 0x0F, 0x00, 0x7F, 0x00, 0x78,
  0x03, 0xF8, 0x03, 0xC0, 0x1F, 0xC0, 0x1E, 0x00, 0xFE, 0x00, 0xF0, 0x07,
  0xF0, 0x07, 0x80, 0x3F, 0x80, 0x3C, 0x01, 0xC0, 0x00, 0x70, 0x79, 0xFF,
  0x3D, 0xFF, 0xDE, 0xFF, 0xEF, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F,
  0xFF, 0x83, 0xE0, 0xF8, 0x78, 0x0F, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3D, 0xE0,
  0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0x78, 0x0F, 0x0F, 0x83, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x70, 0x1E, 0x3F, 0xC3, 0xDF,
  0xFC, 0x7B, 0xFF, 0xCF, 0xE0, 0xF9, 0xF8, 0x0F, 0xBE, 0x00, 0xF7, 0xC0,
  0x1E, 0xF8, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x7B, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x80, 0x3D, 0xF8, 0x0F, 0x3F, 0x83,
  0xE7, 0xBF, 0xF8, 0xF3, 0xFE, 0x1E, 0x3F, 0x83, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x01, 0xFE, 0x3C, 0x7F, 0xE7, 0x9F, 0xFE, 0xF3, 0xE0, 0xFE, 0xF8, 0x0F,
  0xDE, 0x00, 0xFB, 0xC0, 0x1F, 0x78, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x7D, 0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0x80, 0x3E,
  0xF8, 0x0F, 0xCF, 0x83, 0xF8, 0xFF, 0xEF, 0x1F, 0xF9, 0xE0, 0xFE, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x7F, 0x1F, 0xF3, 0xFF, 0x7F, 0xFF, 0x1F, 0xE0, 0xFC,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0x80, 0x7F, 0xE7, 0xFF, 0xDF, 0xFE,
  0xF8, 0x1B, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xFE, 0x07, 0xFF, 0xFE, 0xFF,
  0xF1, 0xFF, 0x80, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0xF0, 0xFF,
  0x07, 0xF0, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xF7, 0x80, 0xFB, 0xE1,
  0xFC, 0xFF, 0xEE, 0x7F, 0xE7, 0x1F, 0xE3, 0x80, 0xF0, 0x01, 0xEF, 0x00,
  0x3D, 0xE0, 0x0F, 0x3C, 0x01, 0xE3, 0x80, 0x3C, 0x78, 0x07, 0x8F, 0x01,
  0xE1, 0xE0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x3C, 0x07, 0x07,
  0x80, 0xF0, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x38, 0xF0, 0x07, 0x9C,
  0x00, 0xF7, 0x80, 0x0E, 0xF0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0xF0, 0x0F, 0x80, 0x79, 0xE0, 0x1F, 0x00, 0xF3, 0xC0, 0x7F, 0x01, 0xE3,
  0x80, 0xEE, 0x03, 0x87, 0x81, 0xDC, 0x0F, 0x0F, 0x03, 0xB8, 0x1E, 0x1E,
  0x0F, 0x70, 0x3C, 0x3C, 0x1E, 0xF0, 0x70, 0x3C, 0x38, 0xE1, 0xE0, 0x78,
  0x71, 0xC3, 0xC0, 0xF0, 0xE3, 0x87, 0x81, 0xE3, 0xC7, 0x8F, 0x01, 0xC7,
  0x0F, 0x1C, 0x03, 0xCE, 0x0E, 0x78, 0x07, 0x9C, 0x1C, 0xF0, 0x0F, 0x78,
  0x3D, 0xE0, 0x0E, 0xF0, 0x7B, 0x80, 0x1D, 0xC0, 0x77, 0x00, 0x3B, 0x80,
  0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xF8, 0x07,
  0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x07, 0xDE,
  0x01, 0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x1E, 0x1E, 0x07, 0x87, 0x80, 0xF3,
  0xC0, 0x3C, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0x38, 0x03,
  0xCF, 0x01, 0xE1, 0xE0, 0x78, 0x78, 0x3C, 0x0F, 0x0F, 0x03, 0xC7, 0x80,
  0x7B, 0xE0, 0x1E, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xEF, 0x00, 0x3D, 0xE0,
  0x0F, 0x3C, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xE0, 0xE0,
  0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x3C, 0x07, 0x87, 0x80, 0xF0,
  0xF0, 0x1E, 0x3C, 0x01, 0xC7, 0x80, 0x3C, 0xF0, 0x07, 0x9C, 0x00, 0x77,
  0x80, 0x0E, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xF7,
  0xFF, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x07, 0xC0, 0x7E, 0x07, 0xF0, 0x7C,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0xC1, 0xFC,
  0x0F, 0x80, 0x7E, 0x03, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x03, 0xE0, 0x0F, 0xE0,
  0x3F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0xFC, 0x03, 0xF0, 0x3F, 0x81,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x02, 0x00, 0x00, 0x08, 0x00, 0x2F,
  0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFD, 0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_Condensed_Regular47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 34, 12, 3, -34 },
  { 23, 12, 13, 18, 3, -34 },
  { 43, 22, 34, 24, 1, -34 },
  { 137, 18, 39, 22, 2, -36 },
  { 225, 30, 34, 34, 2, -34 },
  { 353, 24, 34, 26, 2, -34 },
  { 455, 4, 13, 10, 3, -34 },
  { 462, 10, 41, 14, 2, -34 },
  { 514, 11, 41, 14, 1, -34 },
  { 571, 17, 18, 21, 2, -36 },
  { 610, 18, 23, 22, 2, -28 },
  { 662, 6, 11, 11, 2, -5 },
  { 671, 11, 4, 14, 1, -15 },
  { 677, 5, 6, 11, 3, -6 },
  { 681, 16, 34, 17, 1, -34 },
  { 749, 18, 34, 22, 2, -34 },
  { 826, 12, 34, 22, 3, -34 },
  { 877, 18, 34, 22, 2, -34 },
  { 954, 18, 34, 22, 2, -34 },
  { 1031, 20, 34, 22, 1, -34 },
  { 1116, 18, 34, 22, 2, -34 },
  { 1193, 18, 34, 22, 2, -34 },
  { 1270, 18, 34, 22, 2, -34 },
  { 1347, 18, 34, 22, 2, -34 },
  { 1424, 18, 34, 22, 2, -34 },
  { 1501, 5, 26, 11, 3, -26 },
  { 1518, 6, 32, 11, 2, -26 },
  { 1542, 18, 22, 22, 2, -28 },
  { 1592, 18, 13, 22, 2, -23 },
  { 1622, 19, 22, 22, 2, -28 },
  { 1675, 15, 34, 17, 1, -34 },
  { 1739, 30, 38, 34, 2, -34 },
  { 1882, 24, 34, 24, 0, -34 },
  { 1984, 19, 34, 25, 4, -34 },
  { 2065, 20, 34, 24, 2, -34 },
  { 2150, 21, 34, 27, 4, -34 },
  { 2240, 15, 34, 21, 4, -34 },
  { 2304, 15, 34, 20, 4, -34 },
  { 2368, 23, 34, 28, 2, -34 },
  { 2466, 20, 34, 28, 4, -34 },
  { 2551, 10, 34, 14, 2, -34 },
  { 2594, 11, 43, 11, -3, -34 },
  { 2654, 20, 34, 23, 4, -34 },
  { 2739, 15, 34, 20, 4, -34 },
  { 2803, 29, 34, 36, 4, -34 },
  { 2927, 22, 34, 29, 4, -34 },
  { 3021, 25, 34, 29, 2, -34 },
  { 3128, 17, 34, 23, 4, -34 },
  { 3201, 25, 42, 29, 2, -34 },
  { 3333, 19, 34, 24, 4, -34 },
  { 3414, 17, 34, 21, 2, -34 },
  { 3487, 20, 34, 20, 0, -34 },
  { 3572, 21, 34, 28, 3, -34 },
  { 3662, 23, 34, 23, 0, -34 },
  { 3760, 36, 34, 37, 0, -34 },
  { 3913, 21, 34, 21, 0, -34 },
  { 4003, 21, 34, 21, 0, -34 },
  { 4093, 18, 34, 20, 1, -34 },
  { 4170, 11, 42, 15, 3, -34 },
  { 4228, 16, 34, 17, 1, -34 },
  { 4296, 10, 42, 15, 1, -34 },
  { 4349, 21, 19, 23, 1, -34 },
  { 4399, 21, 3, 21, 0, 4 },
  { 4407, 9, 8, 13, 2, -36 },
  { 4416, 16, 26, 22, 2, -26 },
  { 4468, 19, 36, 24, 3, -36 },
  { 4554, 15, 26, 18, 2, -26 },
  { 4603, 19, 36, 24, 2, -36 },
  { 4689, 18, 26, 22, 2, -26 },
  { 4748, 14, 36, 13, 1, -36 },
  { 4811, 19, 37, 24, 2, -26 },
  { 4899, 17, 36, 24, 3, -36 },
  { 4976, 5, 35, 11, 3, -35 },
  { 4998, 9, 46, 11, -1, -35 },
  { 5050, 17, 36, 21, 3, -36 },
  { 5127, 4, 36, 11, 3, -36 },
  { 5145, 29, 26, 36, 3, -26 },
  { 5240, 17, 26, 24, 3, -26 },
  { 5296, 19, 26, 23, 2, -26 },
  { 5358, 19, 37, 24, 3, -26 },
  { 5446, 19, 37, 24, 2, -26 },
  { 5534, 12, 26, 16, 3, -26 },
  { 5573, 14, 26, 18, 2, -26 },
  { 5619, 12, 31, 14, 1, -31 },
  { 5666, 17, 25, 24, 3, -25 },
  { 5720, 19, 25, 19, 0, -25 },
  { 5780, 31, 25, 31, 0, -25 },
  { 5877, 18, 25, 20, 1, -25 },
  { 5934, 19, 36, 19, 0, -25 },
  { 6020, 14, 25, 17, 1, -25 },
  { 6064, 13, 42, 17, 2, -34 },
  { 6133, 3, 47, 21, 9, -36 },
  { 6151, 14, 42, 17, 2, -34 },
  { 6225, 19, 6, 22, 2, -20 },
};

const GFXfont NotoSans_Condensed_Regular47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular47pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_CONDENSED_REGULAR47PT7B_H_
