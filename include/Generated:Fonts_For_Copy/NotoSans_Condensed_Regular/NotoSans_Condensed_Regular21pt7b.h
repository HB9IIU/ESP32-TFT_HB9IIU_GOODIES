#ifndef _NOTOSANS_CONDENSED_REGULAR21PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular21pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xA4, 0x92, 0x49, 0x05, 0xF8, 0xCF, 0x3C, 0xD3, 0x4C, 0x08,
  0x82, 0x60, 0x98, 0x66, 0x7F, 0xDF, 0xF1, 0x10, 0x44, 0x13, 0x3F, 0xF3,
  0x30, 0xC8, 0x32, 0x08, 0x82, 0x60, 0x18, 0x18, 0x7F, 0xFA, 0xD8, 0xD8,
  0xD8, 0x78, 0x3C, 0x1E, 0x1B, 0x1B, 0x1B, 0xFE, 0x7C, 0x18, 0x18, 0x70,
  0x46, 0xC6, 0x22, 0x21, 0x13, 0x08, 0x90, 0x44, 0x82, 0x2D, 0xDB, 0x5B,
  0x76, 0x98, 0x24, 0x41, 0x22, 0x19, 0x10, 0x89, 0x8C, 0x6C, 0x41, 0xC0,
  0x3C, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0x60, 0x58, 0x0E, 0x03, 0xC0, 0x6C,
  0xD9, 0x9B, 0x1E, 0x61, 0xCC, 0x39, 0xDF, 0x1F, 0x38, 0xFD, 0x40, 0x19,
  0x98, 0xC4, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x21, 0x8C, 0x21, 0xC0, 0xC4,
  0x66, 0x33, 0x33, 0x33, 0x33, 0x33, 0x26, 0x4C, 0x18, 0x10, 0x92, 0xFE,
  0x39, 0x2C, 0x6E, 0x24, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x7B, 0x68, 0xF0, 0x5F, 0x80, 0x03, 0x06, 0x06, 0x04, 0x0C,
  0x0C, 0x18, 0x18, 0x10, 0x30, 0x30, 0x20, 0x60, 0x60, 0xC0, 0x3C, 0x66,
  0x46, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x46, 0x66,
  0x3C, 0x1C, 0xF6, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC0, 0x7C, 0xEE, 0x86, 0x03, 0x02, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x30,
  0x60, 0x60, 0xFF, 0xFF, 0x7C, 0xC6, 0x02, 0x03, 0x02, 0x06, 0x3C, 0x3C,
  0x06, 0x03, 0x03, 0x03, 0x03, 0xCE, 0xFC, 0x03, 0x01, 0xC0, 0x70, 0x2C,
  0x1B, 0x04, 0xC3, 0x30, 0x8C, 0x63, 0x10, 0xCF, 0xFF, 0xFF, 0x03, 0x00,
  0xC0, 0x30, 0x7E, 0x7E, 0x40, 0x40, 0xC0, 0xC0, 0xFC, 0x4E, 0x03, 0x03,
  0x03, 0x03, 0x07, 0xCE, 0xFC, 0x1E, 0x32, 0x60, 0x40, 0xC0, 0xC0, 0xFE,
  0xE6, 0xC3, 0xC3, 0xC3, 0xC3, 0x43, 0x66, 0x3C, 0xFF, 0xFF, 0x03, 0x02,
  0x06, 0x06, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x10, 0x30, 0x30, 0x60, 0x3C,
  0x66, 0xC3, 0xC3, 0xC3, 0x66, 0x3C, 0x3C, 0x66, 0xC3, 0xC3, 0xC3, 0xC3,
  0xE6, 0x7E, 0x3C, 0x6E, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0x7F, 0x03,
  0x02, 0x06, 0x06, 0x9C, 0x78, 0xFC, 0x00, 0x00, 0x5F, 0x80, 0xFC, 0x00,
  0x00, 0x0F, 0x6D, 0x00, 0x01, 0x07, 0x1C, 0x70, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x0E, 0x38, 0xE0, 0x80, 0xFC, 0x9C, 0x18, 0x30, 0x60, 0x83, 0x0C, 0x10,
  0x60, 0xC0, 0x01, 0x06, 0x0C, 0x00, 0x0F, 0xC0, 0xC3, 0x0C, 0x0C, 0xC0,
  0x24, 0x79, 0xA6, 0x47, 0x22, 0x39, 0x11, 0xC8, 0x8E, 0x44, 0x72, 0x67,
  0x9E, 0xE4, 0x66, 0x30, 0x00, 0x80, 0x07, 0xB8, 0x0F, 0x80, 0x0C, 0x01,
  0xC0, 0x38, 0x0D, 0x01, 0xB0, 0x26, 0x0C, 0xC1, 0x88, 0x31, 0x87, 0xF1,
  0x86, 0x30, 0x66, 0x0D, 0x81, 0xB0, 0x18, 0xFC, 0xFE, 0x83, 0x83, 0x83,
  0x82, 0xFE, 0xFE, 0x87, 0x83, 0x83, 0x83, 0x83, 0xFE, 0xFC, 0x1F, 0x9C,
  0xD8, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0C, 0x06,
  0x01, 0xCC, 0x7E, 0xFC, 0x7F, 0x20, 0xD0, 0x68, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x68, 0x37, 0xF3, 0xF0, 0xFF, 0xF8, 0x20, 0x82,
  0x0F, 0xFF, 0x82, 0x08, 0x20, 0x83, 0xFF, 0xC0, 0xFF, 0xF8, 0x20, 0x82,
  0x08, 0x3F, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x00, 0x1F, 0xCE, 0x37, 0x01,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x0F, 0xC3, 0xF0, 0x1C, 0x05, 0x81, 0x60,
  0x4E, 0x31, 0xFC, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xFF, 0xFF,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0xFB, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x33, 0xE0, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x3F, 0xE0, 0x83, 0x43, 0x21, 0x91, 0x89, 0x84, 0xC2, 0xC1,
  0xE0, 0xD8, 0x46, 0x23, 0x10, 0xC8, 0x64, 0x1A, 0x0E, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0xFF, 0xC0, 0xC0, 0x3F, 0x01,
  0xF8, 0x1F, 0x40, 0xBB, 0x05, 0xD8, 0x6E, 0x43, 0x73, 0x13, 0x99, 0x9C,
  0x4C, 0xE3, 0x47, 0x1E, 0x38, 0x71, 0xC3, 0x0E, 0x18, 0x60, 0xC0, 0xF0,
  0x78, 0x36, 0x1B, 0x0C, 0xC6, 0x63, 0x19, 0x8C, 0xC3, 0x61, 0xB0, 0x78,
  0x3C, 0x0E, 0x06, 0x1F, 0x07, 0x71, 0x83, 0x30, 0x6C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xB0, 0x66, 0x0C, 0x77, 0x07, 0xC0,
  0xF8, 0xFE, 0x86, 0x83, 0x83, 0x82, 0x86, 0x8E, 0xFC, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x1F, 0x07, 0x71, 0x83, 0x30, 0x6C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xB0, 0x66, 0x0C, 0x77, 0x07, 0xC0,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0xFC, 0xFE, 0x86, 0x83, 0x83, 0x82,
  0x86, 0xFC, 0xF8, 0x8C, 0x8C, 0x86, 0x86, 0x83, 0x83, 0x3E, 0x76, 0xC0,
  0xC0, 0xC0, 0xE0, 0x70, 0x3C, 0x0E, 0x06, 0x03, 0x03, 0x06, 0xEE, 0xFC,
  0xFF, 0xFF, 0xC2, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x37, 0x39, 0xF8, 0xC0, 0xF0,
  0x36, 0x0D, 0x86, 0x61, 0x88, 0x63, 0x10, 0xCC, 0x33, 0x04, 0xC1, 0xA0,
  0x78, 0x1E, 0x03, 0x80, 0xC0, 0xC1, 0x83, 0xC1, 0x83, 0x61, 0xC3, 0x61,
  0xC3, 0x63, 0x46, 0x63, 0x46, 0x22, 0x66, 0x32, 0x66, 0x36, 0x64, 0x36,
  0x2C, 0x36, 0x2C, 0x14, 0x3C, 0x1C, 0x3C, 0x1C, 0x18, 0x1C, 0x18, 0xE1,
  0xB0, 0xC8, 0xC6, 0x61, 0x60, 0xF0, 0x30, 0x18, 0x1C, 0x0B, 0x0C, 0x86,
  0x66, 0x33, 0x0F, 0x06, 0xC1, 0xA0, 0xD8, 0xCC, 0x63, 0x21, 0xB0, 0x58,
  0x38, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0xFF, 0xFC, 0x18,
  0x60, 0xC3, 0x06, 0x18, 0x30, 0x41, 0x83, 0x0C, 0x1F, 0xFF, 0x80, 0xF8,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0xC0, 0x60, 0x60, 0x20,
  0x30, 0x30, 0x10, 0x18, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x06, 0x03, 0xF3,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x0C, 0x03, 0x01, 0xE0,
  0x48, 0x33, 0x08, 0x46, 0x1B, 0x83, 0xFF, 0x80, 0xC6, 0x30, 0x7C, 0x8C,
  0x18, 0x33, 0xEE, 0xF1, 0xE3, 0xC7, 0x9D, 0xE8, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0xF3, 0x8D, 0xC2, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x1B,
  0xCD, 0xBC, 0x3E, 0xC7, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0xC8, 0xF0,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x7F, 0x67, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0x67, 0x3D, 0x3C, 0x66, 0xC3, 0xC3, 0xFF, 0xFF, 0xC0, 0xC0,
  0xC0, 0x62, 0x3E, 0x1C, 0xD3, 0x0C, 0x33, 0xF3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x7D, 0x67, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x65, 0x3F, 0x03, 0x03, 0x03, 0x6E, 0x7C, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xDE, 0xE3, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x74,
  0x3F, 0xFF, 0xFF, 0x13, 0x10, 0x03, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x3F, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC1, 0xC6, 0xC6, 0xCC, 0xD8, 0xD8,
  0xF8, 0xEC, 0xCC, 0xC6, 0xC6, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0xFF,
  0x1C, 0xF8, 0xC3, 0x86, 0x1C, 0x30, 0xE1, 0x87, 0x0C, 0x38, 0x61, 0xC3,
  0x0E, 0x18, 0x70, 0xC2, 0xDE, 0xE3, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0x7E, 0x63, 0xC3, 0xC3, 0xC1, 0xC1, 0xC1, 0xC3, 0xC3,
  0x66, 0x3C, 0xDE, 0x71, 0xB8, 0x58, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE3,
  0x79, 0xB7, 0x98, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x7D, 0x67, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x65, 0x3F, 0x03, 0x03, 0x03, 0x03, 0x03,
  0xDF, 0xCE, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x00, 0x7F, 0x18, 0x30,
  0x70, 0xE0, 0xC3, 0x0E, 0x3F, 0x80, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x34, 0xF0, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0x43, 0x67, 0x3D, 0xC1, 0xA1, 0x98, 0xCC, 0x46, 0x61, 0x30, 0xD8,
  0x68, 0x1C, 0x0E, 0x06, 0x00, 0xC3, 0x0D, 0x0C, 0x26, 0x79, 0x99, 0xE6,
  0x65, 0x98, 0x92, 0x42, 0xCB, 0x0F, 0x3C, 0x38, 0xF0, 0xE1, 0x81, 0x86,
  0x00, 0xE3, 0x31, 0x0D, 0x86, 0x81, 0xC0, 0xE0, 0x70, 0x6C, 0x26, 0x31,
  0xB0, 0xE0, 0xC1, 0xA1, 0x98, 0xCC, 0x42, 0x61, 0xB0, 0xD8, 0x68, 0x1C,
  0x0E, 0x06, 0x03, 0x01, 0x80, 0xC3, 0xC1, 0xC0, 0xFC, 0x21, 0x86, 0x30,
  0xC6, 0x18, 0xC3, 0x0F, 0xC0, 0x1C, 0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0xE3,
  0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xC1, 0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x1C, 0x73, 0x0C, 0x30, 0xC3,
  0x0C, 0x63, 0x80, 0x61, 0xFF, 0x8E,
};

const GFXglyph NotoSans_Condensed_Regular21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 15, 5, 1, -15 },
  { 7, 6, 5, 8, 1, -15 },
  { 11, 10, 15, 11, 0, -15 },
  { 30, 8, 17, 10, 1, -16 },
  { 47, 13, 15, 15, 1, -15 },
  { 72, 11, 15, 12, 1, -15 },
  { 93, 2, 5, 4, 1, -15 },
  { 95, 5, 18, 6, 1, -15 },
  { 107, 4, 18, 6, 1, -15 },
  { 116, 8, 8, 9, 1, -16 },
  { 124, 8, 10, 10, 1, -12 },
  { 134, 3, 5, 5, 1, -2 },
  { 136, 4, 1, 6, 1, -6 },
  { 137, 3, 3, 5, 1, -3 },
  { 139, 8, 15, 8, 0, -15 },
  { 154, 8, 15, 10, 1, -15 },
  { 169, 6, 15, 10, 1, -15 },
  { 181, 8, 15, 10, 1, -15 },
  { 196, 8, 15, 10, 1, -15 },
  { 211, 10, 15, 10, 0, -15 },
  { 230, 8, 15, 10, 1, -15 },
  { 245, 8, 15, 10, 1, -15 },
  { 260, 8, 15, 10, 1, -15 },
  { 275, 8, 15, 10, 1, -15 },
  { 290, 8, 15, 10, 1, -15 },
  { 305, 3, 11, 5, 1, -11 },
  { 310, 3, 14, 5, 1, -11 },
  { 316, 8, 9, 10, 1, -12 },
  { 325, 8, 6, 10, 1, -10 },
  { 331, 8, 9, 10, 1, -12 },
  { 340, 7, 15, 7, 0, -15 },
  { 354, 13, 17, 15, 1, -15 },
  { 382, 11, 15, 11, 0, -15 },
  { 403, 8, 15, 11, 2, -15 },
  { 418, 9, 15, 11, 1, -15 },
  { 435, 9, 15, 12, 2, -15 },
  { 452, 6, 15, 9, 2, -15 },
  { 464, 6, 15, 9, 2, -15 },
  { 476, 10, 15, 13, 1, -15 },
  { 495, 9, 15, 13, 2, -15 },
  { 512, 5, 15, 6, 1, -15 },
  { 522, 4, 19, 5, -1, -15 },
  { 532, 9, 15, 10, 2, -15 },
  { 549, 6, 15, 9, 2, -15 },
  { 561, 13, 15, 16, 2, -15 },
  { 586, 9, 15, 13, 2, -15 },
  { 603, 11, 15, 13, 1, -15 },
  { 624, 8, 15, 10, 2, -15 },
  { 639, 11, 19, 13, 1, -15 },
  { 666, 8, 15, 11, 2, -15 },
  { 681, 8, 15, 10, 1, -15 },
  { 696, 9, 15, 9, 0, -15 },
  { 713, 9, 15, 12, 2, -15 },
  { 730, 10, 15, 10, 0, -15 },
  { 749, 16, 15, 16, 0, -15 },
  { 779, 9, 15, 10, 0, -15 },
  { 796, 9, 15, 9, 0, -15 },
  { 813, 7, 15, 9, 1, -15 },
  { 827, 4, 18, 7, 2, -15 },
  { 836, 8, 15, 8, 0, -15 },
  { 851, 4, 18, 7, 1, -15 },
  { 860, 10, 8, 10, 0, -15 },
  { 870, 9, 1, 9, 0, 2 },
  { 872, 4, 3, 6, 1, -16 },
  { 874, 7, 11, 10, 1, -11 },
  { 884, 9, 16, 11, 1, -16 },
  { 902, 7, 11, 8, 1, -11 },
  { 912, 8, 16, 11, 1, -16 },
  { 928, 8, 11, 10, 1, -11 },
  { 939, 6, 16, 6, 0, -16 },
  { 951, 8, 16, 11, 1, -11 },
  { 967, 8, 16, 11, 1, -16 },
  { 983, 2, 16, 5, 1, -16 },
  { 987, 4, 21, 5, -1, -16 },
  { 998, 8, 16, 9, 1, -16 },
  { 1014, 2, 16, 5, 1, -16 },
  { 1018, 13, 11, 16, 1, -11 },
  { 1036, 8, 11, 11, 1, -11 },
  { 1047, 8, 11, 10, 1, -11 },
  { 1058, 9, 16, 11, 1, -11 },
  { 1076, 8, 16, 11, 1, -11 },
  { 1092, 6, 11, 7, 1, -11 },
  { 1101, 6, 11, 8, 1, -11 },
  { 1110, 6, 14, 6, 0, -14 },
  { 1121, 8, 11, 11, 1, -11 },
  { 1132, 9, 11, 9, 0, -11 },
  { 1145, 14, 11, 14, 0, -11 },
  { 1165, 9, 11, 9, 0, -11 },
  { 1178, 9, 16, 9, 0, -11 },
  { 1196, 6, 11, 7, 1, -11 },
  { 1205, 6, 18, 8, 1, -15 },
  { 1219, 2, 21, 9, 4, -16 },
  { 1225, 6, 18, 8, 1, -15 },
  { 1239, 8, 3, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_Regular21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular21pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_CONDENSED_REGULAR21PT7B_H_
