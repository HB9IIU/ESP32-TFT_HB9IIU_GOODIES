#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC8PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x21, 0x80, 0x7A, 0x29, 0xBE, 0xAF, 0x50, 0x17, 0x43, 0x1E,
  0x40, 0x4D, 0x94, 0x67, 0x58, 0x35, 0x67, 0xBF, 0xE8, 0x2A, 0x49, 0x22,
  0x22, 0x11, 0x22, 0x48, 0x5D, 0x50, 0x2F, 0x24, 0xE0, 0xE0, 0xC0, 0x18,
  0x88, 0x44, 0x22, 0x00, 0x35, 0x5B, 0x96, 0x17, 0x22, 0x2F, 0x35, 0x12,
  0x4F, 0x35, 0x17, 0x1E, 0x13, 0x59, 0xF2, 0x3A, 0x10, 0x61, 0x70, 0x1B,
  0x19, 0x29, 0x38, 0xF2, 0x24, 0x88, 0x32, 0xD4, 0xE9, 0x78, 0x35, 0x57,
  0x1E, 0x43, 0x43, 0x80, 0x3C, 0x61, 0x70, 0xF0, 0x61, 0x68, 0xE4, 0xA1,
  0x00, 0x32, 0x6F, 0x6D, 0x59, 0x80, 0x33, 0x55, 0xF9, 0x35, 0x57, 0x9F,
  0x32, 0x51, 0x0C, 0x38, 0x65, 0x55, 0x9E, 0x3A, 0x10, 0xE4, 0x78, 0x3A,
  0x10, 0xE4, 0x40, 0x32, 0x51, 0x29, 0x38, 0x4A, 0x54, 0xE9, 0x48, 0x79,
  0x08, 0x42, 0x78, 0x38, 0x84, 0x21, 0x70, 0x4A, 0x98, 0xCA, 0x48, 0x44,
  0x44, 0x8F, 0x4A, 0xD5, 0x69, 0x48, 0x4A, 0x5D, 0x6B, 0x48, 0x32, 0x97,
  0x29, 0x30, 0x32, 0xD2, 0xE8, 0x40, 0x32, 0x97, 0x29, 0x31, 0x06, 0x65,
  0x57, 0xA9, 0x32, 0x50, 0x61, 0x70, 0xF4, 0x44, 0x48, 0x4A, 0x55, 0x29,
  0x70, 0x99, 0xAA, 0xCC, 0x4A, 0x5B, 0x6F, 0x48, 0x4A, 0x8C, 0x45, 0x48,
  0x9B, 0xA4, 0x48, 0x78, 0x88, 0x44, 0x78, 0x39, 0x08, 0x84, 0x23, 0x80,
  0xFE, 0x71, 0x22, 0x22, 0xC0, 0x13, 0x5D, 0xF8, 0xC0, 0x79, 0x9F, 0x64,
  0x75, 0x9E, 0x7C, 0x87, 0x08, 0x9D, 0x29, 0x38, 0x79, 0xE7, 0x1C, 0x53,
  0x84, 0x20, 0x8A, 0x10, 0x79, 0x97, 0xA4, 0x64, 0x75, 0x9B, 0x43, 0x28,
  0xC0, 0x10, 0x71, 0x22, 0xA4, 0x62, 0x54, 0xC6, 0x48, 0xC9, 0x29, 0xC0,
  0x7B, 0x99, 0x75, 0x9B, 0x79, 0x96, 0x75, 0x9E, 0x80, 0x75, 0x97, 0x20,
  0x74, 0x48, 0x76, 0x1E, 0x5E, 0x4E, 0x55, 0x9F, 0xBA, 0xCC, 0xCD, 0xBD,
  0x40, 0x59, 0x19, 0x20, 0x2C, 0xA3, 0x0C, 0x23, 0x00, 0x72, 0x4F, 0x74,
  0x48, 0x88, 0xC0, 0x29, 0x25, 0x20, 0x72, 0x21, 0x24, 0xC0, 0xF0,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 6, 4, 1, -6 },
  { 4, 4, 2, 4, 1, -6 },
  { 5, 5, 6, 4, 0, -6 },
  { 9, 4, 7, 4, 0, -6 },
  { 13, 5, 6, 4, 0, -6 },
  { 17, 4, 6, 4, 0, -6 },
  { 20, 2, 3, 4, 2, -6 },
  { 21, 3, 8, 4, 1, -6 },
  { 24, 4, 8, 4, 0, -6 },
  { 28, 3, 4, 4, 1, -6 },
  { 30, 4, 4, 4, 0, -4 },
  { 32, 2, 2, 4, 1, -1 },
  { 33, 3, 1, 4, 1, -3 },
  { 34, 2, 1, 4, 1, -1 },
  { 35, 5, 7, 4, 0, -6 },
  { 40, 4, 6, 4, 0, -6 },
  { 43, 4, 6, 4, 0, -6 },
  { 46, 4, 6, 4, 0, -6 },
  { 49, 4, 6, 4, 0, -6 },
  { 52, 4, 6, 4, 0, -6 },
  { 55, 5, 6, 4, 0, -6 },
  { 59, 5, 6, 4, 0, -6 },
  { 63, 4, 6, 4, 1, -6 },
  { 66, 5, 6, 4, 0, -6 },
  { 70, 4, 6, 4, 0, -6 },
  { 73, 2, 4, 4, 1, -4 },
  { 74, 2, 5, 4, 1, -4 },
  { 76, 4, 4, 4, 0, -4 },
  { 78, 4, 3, 4, 0, -4 },
  { 80, 4, 4, 4, 0, -4 },
  { 82, 3, 6, 4, 1, -6 },
  { 85, 5, 7, 4, 0, -6 },
  { 90, 4, 6, 4, 0, -6 },
  { 93, 4, 6, 4, 0, -6 },
  { 96, 5, 6, 4, 0, -6 },
  { 100, 4, 6, 4, 0, -6 },
  { 103, 5, 6, 4, 0, -6 },
  { 107, 5, 6, 4, 0, -6 },
  { 111, 5, 6, 4, 0, -6 },
  { 115, 5, 6, 4, 0, -6 },
  { 119, 5, 6, 4, 0, -6 },
  { 123, 5, 6, 4, 0, -6 },
  { 127, 5, 6, 4, 0, -6 },
  { 131, 4, 6, 4, 0, -6 },
  { 134, 5, 6, 4, 0, -6 },
  { 138, 5, 6, 4, 0, -6 },
  { 142, 5, 6, 4, 0, -6 },
  { 146, 5, 6, 4, 0, -6 },
  { 150, 5, 8, 4, 0, -6 },
  { 155, 4, 6, 4, 0, -6 },
  { 158, 5, 6, 4, 0, -6 },
  { 162, 4, 6, 4, 1, -6 },
  { 165, 5, 6, 4, 0, -6 },
  { 169, 4, 6, 4, 1, -6 },
  { 172, 5, 6, 4, 0, -6 },
  { 176, 5, 6, 4, 0, -6 },
  { 180, 4, 6, 4, 1, -6 },
  { 183, 5, 6, 4, 0, -6 },
  { 187, 5, 7, 4, 0, -6 },
  { 192, 1, 7, 4, 2, -6 },
  { 193, 4, 7, 4, 0, -6 },
  { 197, 4, 4, 4, 0, -6 },
  { 199, 5, 1, 4, -1, 1 },
  { 200, 2, 1, 4, 2, -6 },
  { 201, 4, 4, 4, 0, -4 },
  { 203, 4, 6, 4, 0, -6 },
  { 206, 4, 4, 4, 0, -4 },
  { 208, 5, 6, 4, 0, -6 },
  { 212, 4, 4, 4, 0, -4 },
  { 214, 6, 8, 4, -1, -6 },
  { 220, 4, 6, 4, 0, -4 },
  { 223, 4, 6, 4, 0, -6 },
  { 226, 3, 6, 4, 1, -6 },
  { 229, 4, 8, 4, 0, -6 },
  { 233, 5, 6, 4, 0, -6 },
  { 237, 3, 6, 4, 1, -6 },
  { 240, 4, 4, 4, 0, -4 },
  { 242, 4, 4, 4, 0, -4 },
  { 244, 4, 4, 4, 0, -4 },
  { 246, 4, 5, 4, 0, -4 },
  { 249, 4, 5, 4, 0, -4 },
  { 252, 4, 4, 4, 0, -4 },
  { 254, 4, 4, 4, 0, -4 },
  { 256, 3, 5, 4, 1, -5 },
  { 258, 4, 4, 4, 0, -4 },
  { 260, 4, 4, 4, 1, -4 },
  { 262, 5, 4, 4, 0, -4 },
  { 265, 5, 4, 4, 0, -4 },
  { 268, 6, 6, 4, -1, -4 },
  { 273, 4, 4, 4, 0, -4 },
  { 275, 4, 7, 4, 1, -6 },
  { 279, 3, 7, 4, 1, -6 },
  { 282, 4, 7, 4, 0, -6 },
  { 286, 4, 1, 4, 0, -3 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic8pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic8pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic8pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC8PT7B_H_
