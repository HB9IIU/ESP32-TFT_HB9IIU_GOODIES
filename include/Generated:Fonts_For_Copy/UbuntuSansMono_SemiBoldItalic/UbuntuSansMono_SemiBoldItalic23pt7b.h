#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC23PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x78, 0xE1, 0xC3, 0x87, 0x1C, 0x38, 0x70, 0x00, 0x07,
  0x0E, 0x3C, 0x38, 0x73, 0xB9, 0x99, 0xDC, 0xEE, 0x66, 0x30, 0x03, 0x9C,
  0x0C, 0x60, 0x73, 0x81, 0x8C, 0x3F, 0xFC, 0xFF, 0xE4, 0xC6, 0x07, 0x38,
  0x18, 0xC0, 0x67, 0x0F, 0xFF, 0x3F, 0xFC, 0x73, 0x01, 0x8C, 0x06, 0x70,
  0x39, 0x80, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x0F, 0xF0, 0xFF, 0x0E, 0x08,
  0x70, 0x03, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x71, 0x03, 0x8F, 0xFC, 0xFF, 0xC0, 0xF0, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0x00, 0x0F, 0x07, 0x1F, 0x0E, 0x19, 0x0C, 0x11, 0x18, 0x33, 0x30, 0x33,
  0x60, 0x1E, 0xC0, 0x0D, 0x80, 0x03, 0xB0, 0x03, 0x78, 0x06, 0xD8, 0x0C,
  0xC8, 0x18, 0x98, 0x31, 0x98, 0x71, 0xF8, 0xE0, 0xF0, 0x07, 0xE0, 0xFE,
  0x0C, 0x61, 0xC6, 0x1C, 0xE1, 0xDC, 0x0F, 0x80, 0xF2, 0x3F, 0x37, 0x77,
  0x63, 0xEE, 0x1E, 0xE1, 0xCE, 0x3C, 0x7F, 0xE3, 0xE6, 0x7B, 0x9C, 0xC6,
  0x33, 0x00, 0x01, 0x80, 0xF0, 0x78, 0x3C, 0x1C, 0x0F, 0x03, 0x81, 0xC0,
  0x70, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x38,
  0x06, 0x01, 0xC0, 0x38, 0x0C, 0x00, 0x02, 0x01, 0xC0, 0x38, 0x0E, 0x01,
  0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0xE0,
  0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x18, 0x00, 0x0E, 0x01,
  0xC1, 0x39, 0x3A, 0xEF, 0xFE, 0x1C, 0x06, 0xC1, 0xDC, 0x7B, 0xC2, 0x20,
  0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x61, 0xFF, 0xFF, 0xF8, 0x70, 0x0C,
  0x01, 0x80, 0x70, 0x0E, 0x00, 0x39, 0xF7, 0xCE, 0x19, 0xCE, 0x30, 0xFF,
  0xFF, 0xF8, 0x77, 0xFE, 0xE0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0xC1, 0xFE, 0x1C, 0xE3, 0x87, 0x70, 0x77, 0x07, 0x66, 0x7E, 0xE6, 0xEE,
  0x6E, 0x0E, 0xE0, 0xEE, 0x1C, 0xE1, 0xCE, 0x38, 0x7F, 0x03, 0xE0, 0x01,
  0xC0, 0xF0, 0xF8, 0xFE, 0x3B, 0x88, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0,
  0x60, 0x38, 0x0E, 0x03, 0x8F, 0xFF, 0xFE, 0x07, 0xE0, 0xFF, 0x87, 0x1E,
  0x10, 0x70, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0x78, 0x03, 0x80, 0x38, 0x01, 0xFF, 0x9F, 0xF8, 0x0F, 0xE0, 0xFF,
  0x08, 0x70, 0x03, 0x00, 0x70, 0x07, 0x07, 0xE0, 0x78, 0x0F, 0xC0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE4, 0x1E, 0xFF, 0xCF, 0xF8, 0x00, 0x78, 0x07,
  0x80, 0x7C, 0x07, 0xE0, 0x77, 0x07, 0x30, 0x71, 0x83, 0x1C, 0x30, 0xE3,
  0x87, 0x1F, 0xFD, 0xFF, 0xE0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07,
  0xF8, 0x3F, 0xC1, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x7C, 0x03, 0xF8,
  0x03, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x20, 0xF3, 0xFF, 0x1F,
  0xF0, 0x00, 0xF0, 0x7F, 0x0F, 0xC1, 0xE0, 0x38, 0x07, 0x00, 0x7F, 0x87,
  0xFC, 0xF1, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xE7, 0x1C, 0x7F, 0x83,
  0xF0, 0x7F, 0xF7, 0xFF, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0x0F, 0xC1, 0xFE, 0x1C, 0x73, 0x87, 0x38, 0x73, 0x86, 0x1D, 0xE1,
  0xF8, 0x3F, 0x87, 0x1C, 0xE0, 0xCE, 0x0E, 0xE0, 0xCE, 0x1C, 0xFF, 0x87,
  0xF0, 0x0F, 0xC1, 0xFE, 0x38, 0xE7, 0x07, 0x70, 0x77, 0x07, 0x70, 0x77,
  0x8F, 0x3F, 0xE1, 0xEE, 0x00, 0xE0, 0x1C, 0x07, 0x81, 0xF0, 0xFE, 0x0F,
  0x00, 0x1C, 0x7C, 0xF0, 0xE0, 0x00, 0x00, 0x00, 0x71, 0xF3, 0xE3, 0x80,
  0x0E, 0x1F, 0x1E, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x7C, 0x7C, 0x38,
  0x18, 0x70, 0xE0, 0xC0, 0x00, 0x30, 0x1F, 0x07, 0xF3, 0xF8, 0x7C, 0x0F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3C, 0x00, 0x80, 0x3F, 0xF9, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x01, 0x3F, 0xF3, 0xFF, 0x80, 0x10, 0x03, 0xC0,
  0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x0F, 0x07, 0xF3, 0xF8, 0xFE, 0x07, 0x00,
  0x80, 0x00, 0x3F, 0x1F, 0xE2, 0x3C, 0x07, 0x03, 0x81, 0xE0, 0xF0, 0x70,
  0x38, 0x0C, 0x04, 0x00, 0x00, 0x60, 0x3C, 0x0F, 0x03, 0xC0, 0x07, 0xE0,
  0xFF, 0x1C, 0x33, 0x83, 0x70, 0x36, 0x3F, 0xE7, 0xFC, 0xE7, 0xCC, 0x7C,
  0xC6, 0xCC, 0x6D, 0xCE, 0xCC, 0xEC, 0xFC, 0xC7, 0xCE, 0x00, 0xE0, 0x07,
  0xF0, 0x3F, 0x00, 0x00, 0xE0, 0x1E, 0x01, 0xF0, 0x3F, 0x03, 0x70, 0x77,
  0x06, 0x70, 0xE7, 0x0C, 0x71, 0xC7, 0x3F, 0xF3, 0xFF, 0x30, 0x77, 0x07,
  0x60, 0x7E, 0x07, 0x0F, 0xE0, 0xFF, 0x87, 0x1E, 0x38, 0x71, 0xC3, 0x8C,
  0x38, 0xE7, 0xC7, 0xF8, 0x3F, 0xE1, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x0F,
  0x30, 0xF3, 0xFF, 0x1F, 0xE0, 0x03, 0xF0, 0x7F, 0xC7, 0x8C, 0x78, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0F, 0x00, 0x3C, 0x61, 0xFF, 0x07, 0xF0, 0x0F, 0xC0, 0xFF, 0x07, 0x3C,
  0x38, 0xE1, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x06, 0x30, 0x73, 0x83, 0x9C,
  0x1C, 0xE1, 0xC7, 0x1E, 0x73, 0xE3, 0xFE, 0x1F, 0xC0, 0x1F, 0xF8, 0xFF,
  0x87, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xFF, 0x07, 0xF8, 0x7F, 0xC3,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0x1F, 0xF8, 0x1F,
  0xF8, 0xFF, 0xC7, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x87, 0xF8,
  0x7F, 0xC3, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0x07, 0xF8, 0x7F, 0x87, 0x8C, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC3, 0x8E, 0x1C, 0x38, 0xE1,
  0xFF, 0x07, 0xF0, 0x0C, 0x1C, 0x70, 0x71, 0xC1, 0x87, 0x0E, 0x18, 0x38,
  0xE0, 0xE3, 0xFF, 0x8F, 0xFC, 0x3F, 0xF1, 0xC1, 0xC7, 0x07, 0x1C, 0x38,
  0x60, 0xE3, 0x83, 0x8E, 0x0E, 0x38, 0x70, 0x0F, 0xFC, 0x3F, 0xE1, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x07, 0xFC, 0x3F, 0xF0, 0x07,
  0xF8, 0x3F, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x31, 0xE3, 0xFE, 0x0F,
  0xE0, 0x0E, 0x1C, 0x70, 0xE1, 0xC7, 0x07, 0x3C, 0x1D, 0xE0, 0xEF, 0x03,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xDE, 0x07, 0x38, 0x1C, 0x70, 0x71, 0xC1,
  0x87, 0x8E, 0x0E, 0x38, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0xFF,
  0xFF, 0x07, 0x0E, 0x0E, 0x3C, 0x3C, 0x70, 0x79, 0xE0, 0xF3, 0xC3, 0x6D,
  0x86, 0xDB, 0x0D, 0xEE, 0x3B, 0x98, 0x67, 0x30, 0xC0, 0x61, 0x81, 0xC7,
  0x03, 0x8E, 0x06, 0x18, 0x0C, 0x70, 0x38, 0x0C, 0x1C, 0x78, 0x71, 0xE1,
  0x87, 0x86, 0x1E, 0x38, 0xEC, 0xE3, 0xB3, 0x8C, 0xCC, 0x33, 0x31, 0xC7,
  0xC7, 0x1F, 0x18, 0x78, 0x61, 0xE3, 0x87, 0x8E, 0x0E, 0x30, 0x30, 0x07,
  0xC1, 0xFE, 0x3C, 0xF3, 0x87, 0x70, 0x77, 0x07, 0x60, 0x7E, 0x07, 0xE0,
  0x7E, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1, 0xCE, 0x38, 0x7F, 0x83, 0xE0, 0x0F,
  0xE0, 0x7F, 0x87, 0x1E, 0x38, 0x71, 0xC3, 0x8C, 0x1C, 0xE0, 0xE7, 0x0E,
  0x3F, 0xE1, 0xFE, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x00, 0x07, 0xC1, 0xFE, 0x3C, 0xF3, 0x87, 0x70, 0x77, 0x07, 0x60, 0x7E,
  0x07, 0xE0, 0x6E, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1, 0xCE, 0x38, 0x7F, 0x83,
  0xE0, 0x18, 0x01, 0xC0, 0x1F, 0x80, 0x70, 0x0F, 0xE0, 0xFF, 0x87, 0x1E,
  0x38, 0x71, 0xC3, 0x9C, 0x1C, 0xE1, 0xC7, 0x3E, 0x3F, 0xE1, 0xFC, 0x1C,
  0xE0, 0xE3, 0x87, 0x1C, 0x30, 0x63, 0x83, 0x9C, 0x1C, 0x07, 0xF0, 0x7F,
  0xC7, 0x84, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x30, 0xF3, 0xFF, 0x0F, 0xF0, 0xFF,
  0xFF, 0xFC, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x38, 0x39, 0xC1,
  0xCE, 0x1C, 0x70, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0x8E, 0x1C, 0x60, 0xE7,
  0x07, 0x38, 0x31, 0xC3, 0x8E, 0x1C, 0x71, 0xC3, 0xFE, 0x0F, 0xE0, 0x70,
  0x3B, 0x03, 0x98, 0x1C, 0xC1, 0xC6, 0x0E, 0x30, 0xE1, 0x87, 0x0C, 0x30,
  0x73, 0x83, 0x98, 0x1D, 0xC0, 0xEC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x1C, 0x0E, 0x30, 0x18, 0x60, 0x71, 0xC0, 0xE3, 0x81, 0x86, 0x03,
  0x0C, 0xCE, 0x1B, 0xDC, 0x77, 0xB0, 0xDB, 0x61, 0xB6, 0xC3, 0xCF, 0x07,
  0x9E, 0x0E, 0x3C, 0x3C, 0x70, 0x70, 0xE0, 0x0E, 0x0F, 0x07, 0x0E, 0x07,
  0x1C, 0x07, 0x38, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1C, 0x60, 0x38, 0x70, 0x78,
  0x70, 0xF0, 0x70, 0xE0, 0x7E, 0x0E, 0xE1, 0xCE, 0x1C, 0x63, 0x86, 0x70,
  0x77, 0x07, 0xE0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x0F, 0xFC, 0x3F, 0xE1, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0xFE, 0x3F, 0xF0, 0x03, 0xF8, 0x3F, 0x81, 0xC0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0xE3, 0x18, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE3, 0x18, 0xC7, 0x39, 0xCE, 0x73, 0x9C, 0x03, 0xF8, 0x3F,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0x80, 0x7C,
  0x07, 0xC0, 0xFC, 0x1C, 0xE3, 0x8E, 0x78, 0xEF, 0x07, 0x60, 0x60, 0x7F,
  0xFF, 0xFF, 0x41, 0x8F, 0x8F, 0x08, 0x0F, 0xE7, 0xFD, 0xE3, 0xB8, 0x7E,
  0x0D, 0xC3, 0xB8, 0x77, 0x0E, 0xE1, 0xDC, 0x7B, 0xFF, 0x3E, 0xE0, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1F, 0xE1, 0xFE, 0x3C,
  0x73, 0x87, 0x38, 0x73, 0x87, 0x70, 0x77, 0x0E, 0x70, 0xE7, 0x3C, 0x7F,
  0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x3C, 0x27, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0x08, 0x7F, 0xC3, 0xFC, 0x00, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x3F, 0xC3, 0xFC, 0x38, 0xE3, 0x87,
  0x38, 0x39, 0xC3, 0x8E, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x78, 0xFF, 0xC3,
  0xEE, 0x00, 0x0F, 0xC7, 0xFC, 0xE3, 0xB8, 0x3E, 0x0F, 0xCF, 0xBF, 0xE7,
  0xC0, 0xE0, 0x1E, 0x09, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x09,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x4E, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0xE3, 0x87, 0x0E, 0x18, 0x38,
  0xE0, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x7F, 0xC1, 0xFE, 0x00, 0x38,
  0x00, 0xE1, 0x07, 0x07, 0xF8, 0x3F, 0xC0, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x1F, 0xE1, 0xFE, 0x38, 0xF3, 0x87, 0x38, 0x73,
  0x8E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0C, 0x61, 0xCE, 0x1C, 0x06, 0x07,
  0x83, 0xC1, 0xC0, 0x00, 0x01, 0xF9, 0xFC, 0x1C, 0x0E, 0x07, 0x03, 0x83,
  0x81, 0xC0, 0xE0, 0x71, 0x3F, 0x8F, 0xC0, 0x00, 0x38, 0x03, 0xC0, 0x1E,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x70, 0x03, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0xE0, 0x8F, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0xE3, 0x8E, 0x1C, 0xE0, 0xDE, 0x0F,
  0xE0, 0x7C, 0x03, 0xF0, 0x19, 0xC1, 0xCF, 0x0E, 0x38, 0x71, 0xE7, 0x07,
  0x00, 0x7E, 0xFE, 0xFC, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x30,
  0x70, 0x70, 0x70, 0x70, 0x71, 0x7F, 0x3F, 0x3F, 0xF1, 0xFF, 0xCC, 0xCE,
  0x66, 0x67, 0x33, 0x3B, 0x99, 0x9D, 0xCC, 0x0E, 0xE0, 0x67, 0x03, 0x30,
  0x39, 0x81, 0xC0, 0x1F, 0xE1, 0xFE, 0x18, 0xF3, 0x87, 0x38, 0x73, 0x86,
  0x38, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x71, 0xCE, 0x1C, 0x0F, 0xC7, 0xF9,
  0xE3, 0xB8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x06, 0xE1, 0xDC, 0x73, 0xFE,
  0x3F, 0x00, 0x0F, 0xF0, 0x7F, 0x87, 0x0E, 0x38, 0x71, 0xC3, 0x8E, 0x1C,
  0xE0, 0xE7, 0x0E, 0x38, 0x71, 0xCF, 0x0F, 0xF0, 0xFF, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x1C, 0x00, 0x0F, 0xF1, 0xFE, 0x38, 0xE7, 0x0E, 0x70, 0xEE,
  0x0C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x3C, 0x7F, 0x87, 0xF8, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x1F, 0xF3, 0xFE, 0x3C, 0x23, 0x80, 0x38, 0x03,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0x1F, 0xE7,
  0xF8, 0xE1, 0x1C, 0x03, 0xC0, 0x7E, 0x03, 0xE0, 0x1E, 0x01, 0xD8, 0x73,
  0xFE, 0x7F, 0x80, 0x02, 0x01, 0xC0, 0x70, 0x0E, 0x07, 0xFF, 0xFF, 0x8E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xF1, 0x1F, 0xE1,
  0xFC, 0x38, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x0C, 0xC3, 0xB8, 0x77, 0x0E,
  0xE1, 0xDC, 0x73, 0xFF, 0x3E, 0xE0, 0xE0, 0xFC, 0x1F, 0x87, 0x70, 0xEE,
  0x39, 0xC7, 0x19, 0xC3, 0xB0, 0x7E, 0x0F, 0x81, 0xE0, 0x1C, 0x00, 0x60,
  0x3B, 0x01, 0xB8, 0x0D, 0xCC, 0xEE, 0xE6, 0x67, 0x33, 0x6B, 0x9B, 0x78,
  0xF3, 0xC7, 0x9C, 0x38, 0xE1, 0x87, 0x00, 0x1C, 0x1C, 0x38, 0xE0, 0xE7,
  0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x7C, 0x03, 0xF0, 0x0E, 0xE0, 0x73,
  0x83, 0x8E, 0x3C, 0x1C, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x70, 0x70, 0xE0,
  0x63, 0x80, 0xE7, 0x01, 0xCC, 0x03, 0xB8, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0x00, 0x1C, 0x00, 0x38, 0x09, 0xE0, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0xF8,
  0xFF, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0xC0, 0x1F, 0xF1, 0xFF, 0x80, 0x01, 0xF0, 0x7F, 0x07, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0xF8, 0x0F, 0x00,
  0x30, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x7E, 0x03, 0xE0, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C,
  0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C,
  0x0E, 0x07, 0x07, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x00, 0xF0, 0x0F, 0x01, 0xC0,
  0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x7E, 0x0F,
  0xC0, 0x1C, 0x39, 0xF9, 0x9F, 0xFD, 0xC7, 0xC0,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 7, 16, 13, 3, -16 },
  { 15, 9, 6, 13, 4, -17 },
  { 22, 14, 16, 13, 0, -16 },
  { 50, 13, 21, 13, 0, -18 },
  { 85, 16, 16, 13, -1, -16 },
  { 117, 12, 16, 13, 0, -16 },
  { 141, 5, 7, 13, 6, -17 },
  { 146, 10, 22, 13, 3, -18 },
  { 174, 10, 22, 13, 0, -18 },
  { 202, 11, 10, 13, 2, -16 },
  { 216, 11, 12, 13, 1, -13 },
  { 233, 6, 8, 13, 2, -4 },
  { 239, 7, 3, 13, 3, -8 },
  { 242, 5, 4, 13, 3, -4 },
  { 245, 15, 22, 13, -1, -18 },
  { 287, 12, 16, 13, 1, -16 },
  { 311, 10, 16, 13, 1, -16 },
  { 331, 13, 16, 13, 0, -16 },
  { 357, 12, 16, 13, 0, -16 },
  { 381, 13, 16, 13, 0, -16 },
  { 407, 13, 16, 13, 0, -16 },
  { 433, 12, 16, 13, 1, -16 },
  { 457, 12, 16, 13, 2, -16 },
  { 481, 12, 16, 13, 1, -16 },
  { 505, 12, 16, 13, 1, -16 },
  { 529, 7, 12, 13, 3, -12 },
  { 540, 8, 16, 13, 2, -12 },
  { 556, 12, 11, 13, 1, -12 },
  { 573, 13, 7, 13, 0, -10 },
  { 585, 12, 11, 13, 0, -12 },
  { 602, 10, 16, 13, 3, -16 },
  { 622, 12, 19, 13, 1, -16 },
  { 651, 12, 16, 13, -1, -16 },
  { 675, 13, 16, 13, 0, -16 },
  { 701, 13, 16, 13, 1, -16 },
  { 727, 13, 16, 13, 0, -16 },
  { 753, 13, 16, 13, 1, -16 },
  { 779, 13, 16, 13, 1, -16 },
  { 805, 13, 16, 13, 1, -16 },
  { 831, 14, 16, 13, 0, -16 },
  { 859, 14, 16, 13, 0, -16 },
  { 887, 13, 16, 13, 0, -16 },
  { 913, 14, 16, 13, 0, -16 },
  { 941, 10, 16, 13, 0, -16 },
  { 961, 15, 16, 13, -1, -16 },
  { 991, 14, 16, 13, 0, -16 },
  { 1019, 12, 16, 13, 1, -16 },
  { 1043, 13, 16, 13, 0, -16 },
  { 1069, 12, 20, 13, 1, -16 },
  { 1099, 13, 16, 13, 0, -16 },
  { 1125, 13, 16, 13, 0, -16 },
  { 1151, 11, 16, 13, 3, -16 },
  { 1173, 13, 16, 13, 1, -16 },
  { 1199, 13, 16, 13, 2, -16 },
  { 1225, 15, 16, 13, 0, -16 },
  { 1255, 16, 16, 13, -1, -16 },
  { 1287, 12, 16, 13, 3, -16 },
  { 1311, 14, 16, 13, 0, -16 },
  { 1339, 13, 22, 13, 1, -18 },
  { 1375, 5, 22, 13, 4, -18 },
  { 1389, 13, 22, 13, -1, -18 },
  { 1425, 12, 9, 13, 1, -16 },
  { 1439, 12, 2, 13, -2, 2 },
  { 1442, 6, 5, 13, 5, -18 },
  { 1446, 11, 12, 13, 1, -12 },
  { 1463, 12, 18, 13, 0, -18 },
  { 1490, 12, 12, 13, 1, -12 },
  { 1508, 13, 18, 13, 1, -18 },
  { 1538, 11, 12, 13, 1, -12 },
  { 1555, 16, 22, 13, -2, -18 },
  { 1599, 14, 16, 13, -1, -12 },
  { 1627, 12, 18, 13, 0, -18 },
  { 1654, 9, 18, 13, 2, -18 },
  { 1675, 13, 22, 13, -1, -18 },
  { 1711, 13, 18, 13, 0, -18 },
  { 1741, 8, 18, 13, 3, -18 },
  { 1759, 13, 12, 13, 0, -12 },
  { 1779, 12, 12, 13, 0, -12 },
  { 1797, 11, 12, 13, 1, -12 },
  { 1814, 13, 16, 13, -1, -12 },
  { 1840, 12, 16, 13, 1, -12 },
  { 1864, 12, 12, 13, 1, -12 },
  { 1882, 11, 12, 13, 1, -12 },
  { 1899, 11, 16, 13, 2, -16 },
  { 1921, 11, 12, 13, 1, -12 },
  { 1938, 11, 12, 13, 2, -12 },
  { 1955, 13, 12, 13, 1, -12 },
  { 1975, 14, 12, 13, -1, -12 },
  { 1996, 15, 16, 13, -2, -12 },
  { 2026, 13, 12, 13, 0, -12 },
  { 2046, 12, 22, 13, 2, -18 },
  { 2079, 9, 22, 13, 2, -18 },
  { 2104, 12, 22, 13, -1, -18 },
  { 2137, 13, 4, 13, 0, -9 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic23pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic23pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic23pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC23PT7B_H_
