#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC69PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xE0,
  0x7F, 0xCF, 0xF8, 0x1F, 0xE3, 0xFE, 0x0F, 0xF8, 0xFF, 0x03, 0xFE, 0x7F,
  0xC0, 0xFF, 0x9F, 0xF0, 0x3F, 0xC7, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xFC,
  0x7F, 0x81, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07,
  0xF8, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0x83, 0xF8,
  0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x40, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x02, 0x00, 0x00,
  0x7F, 0xC0, 0x1E, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x07,
  0xC0, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x1F,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x7C,
  0x07, 0xE0, 0x00, 0x0F, 0x81, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0x03, 0xF0,
  0x7F, 0x00, 0x00, 0x7E, 0x07, 0xC1, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x83,
  0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x3F,
  0x00, 0x00, 0x03, 0xF3, 0xF8, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE3, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x8F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xF1, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC7, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0x8F, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x3F, 0xBF, 0x80,
  0x00, 0x03, 0xF8, 0xFE, 0x3F, 0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x3E, 0x00,
  0x00, 0x1F, 0x83, 0xE0, 0x7C, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0xF8, 0x00,
  0x01, 0xF8, 0x1F, 0x81, 0xF0, 0x00, 0x07, 0xF0, 0x3E, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x7C, 0x0F, 0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0xFC, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0x0F,
  0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x00, 0xFE,
  0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x8F, 0xF8, 0x00,
  0x07, 0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x60, 0x00, 0x7F,
  0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0x03, 0xFF, 0xFC, 0x0F, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFE, 0x0F, 0xFB, 0xFE, 0x0F, 0xE1, 0xFF, 0x1F, 0xF1,
  0xFC, 0x1F, 0xE0, 0xFF, 0x1F, 0xC3, 0xFC, 0x0F, 0xFB, 0xF8, 0x7F, 0x80,
  0x7F, 0xBF, 0x87, 0xF8, 0x03, 0xFF, 0xF0, 0xFF, 0x00, 0x3F, 0xFF, 0x0F,
  0xF0, 0x01, 0xFF, 0xE0, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0xFF,
  0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x00,
  0x1F, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0xFF, 0x03, 0xFF, 0xFF, 0xCF,
  0xF0, 0x1F, 0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xF8, 0x07, 0xFF,
  0x80, 0x7F, 0x80, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0x87, 0xFC,
  0x3F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xC3, 0xFE, 0x1F,
  0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0,
  0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x1C, 0x07, 0xF0, 0x1C, 0x3E, 0x0F, 0xE0, 0xF8,
  0x7F, 0x0F, 0x87, 0xF9, 0xFF, 0x9F, 0x1F, 0xF3, 0xFF, 0xBE, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F,
  0xCF, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xF0, 0x1F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8,
  0x07, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x07,
  0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xC0,
  0x0F, 0xC0, 0x02, 0x00, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFC, 0x0F, 0xC1, 0xFF, 0x9F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x9F, 0xF8, 0x7F, 0x81, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xF0,
  0x07, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x7F,
  0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xF0, 0x38, 0x0F, 0xF3, 0xFC, 0x1F,
  0xC1, 0xFE, 0x7F, 0x87, 0xF8, 0x3F, 0xCF, 0xF0, 0xFF, 0x07, 0xFB, 0xFC,
  0x3F, 0xE1, 0xFE, 0x7F, 0x87, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0x87, 0xF9,
  0xFE, 0x1F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFC, 0x3F, 0xEF, 0xF0, 0x3F, 0x07,
  0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x07, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xE3, 0xFC,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC7,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xBF, 0xE0, 0x07, 0xFC,
  0xFF, 0x80, 0x1F, 0xC3, 0xFC, 0x00, 0x7C, 0x0F, 0xF0, 0x01, 0x80, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xC0, 0x3F, 0xF8, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x0E, 0x00, 0x03, 0xFE,
  0x00, 0x20, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x0F, 0xFF, 0x00, 0x0F, 0x00,
  0x1F, 0xF8, 0x00, 0x20, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x10, 0x00, 0x03, 0xFF, 0x81, 0xE0, 0x00, 0x3F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x23, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x10, 0x00, 0x03, 0xFF, 0x00, 0x1E, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xC0, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0xCF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00,
  0x7F, 0x87, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xC1, 0xFF,
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x7F,
  0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x83,
  0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F,
  0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xBF, 0xC0, 0x03, 0xFF, 0xE7, 0xFC, 0x00,
  0x03, 0xE0, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x80,
  0x1F, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFC, 0x0F, 0xFF, 0x07, 0x00, 0x1F, 0xF8,
  0x20, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xE3, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x03, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x80,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0xFF, 0x0F, 0xE0, 0x07,
  0xFF, 0xFC, 0x7F, 0x80, 0x7F, 0xFF, 0xF1, 0xFC, 0x03, 0xFF, 0xFF, 0xC7,
  0xF0, 0x1F, 0xFF, 0xFE, 0x3F, 0x80, 0xFF, 0xFF, 0xF8, 0xFE, 0x07, 0xFF,
  0xFF, 0xE3, 0xF8, 0x3F, 0xF0, 0x7F, 0x9F, 0xC0, 0xFF, 0x01, 0xFC, 0x7F,
  0x07, 0xF8, 0x07, 0xF1, 0xFC, 0x1F, 0xE0, 0x3F, 0xC7, 0xF0, 0x7F, 0x00,
  0xFF, 0x1F, 0x83, 0xFC, 0x03, 0xF8, 0xFE, 0x0F, 0xE0, 0x0F, 0xE3, 0xF8,
  0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0xFE, 0x01, 0xFE, 0x3F, 0x83, 0xF8, 0x07,
  0xF0, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xE1,
  0xFE, 0x03, 0xFC, 0x3F, 0x07, 0xF8, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0x3F,
  0x83, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x83,
  0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0xFC,
  0x0F, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x40, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x01,
  0xFE, 0x7F, 0x00, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0xC7, 0xF0,
  0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xF8,
  0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x07, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x01, 0xFF, 0x83, 0xFE,
  0x00, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xF0, 0x3F, 0xC0, 0x07, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xE0, 0x0F, 0xFE, 0x00,
  0x06, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x20,
  0x03, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xFC, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F,
  0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF,
  0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xE0,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xF0,
  0x0F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x01,
  0xE0, 0x03, 0xFF, 0x80, 0x01, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03,
  0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F,
  0xE0, 0x03, 0xFF, 0xF7, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x06, 0x00, 0x03, 0xFE, 0x00, 0x0E, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE7, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x07, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x7F,
  0xE0, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xC1, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x00, 0x07, 0xF9,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x7F, 0xF0,
  0x0F, 0xBF, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x03, 0xF7, 0xE0, 0x7D,
  0xF8, 0x00, 0x7E, 0xFC, 0x1F, 0xBF, 0x00, 0x1F, 0xDF, 0x83, 0xE7, 0xE0,
  0x03, 0xFB, 0xF0, 0xFD, 0xFC, 0x00, 0x7E, 0x7E, 0x1F, 0x3F, 0x80, 0x1F,
  0xC7, 0xC7, 0xE7, 0xF0, 0x03, 0xF8, 0xF8, 0xF8, 0xFC, 0x00, 0x7F, 0x1F,
  0x3F, 0x1F, 0x80, 0x0F, 0xC3, 0xE7, 0xC7, 0xF0, 0x03, 0xF8, 0x7D, 0xF8,
  0xFE, 0x00, 0x7F, 0x0F, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFF, 0xC7, 0xF0,
  0x03, 0xF8, 0x3F, 0xF0, 0xFE, 0x00, 0x7F, 0x07, 0xFE, 0x1F, 0xC0, 0x0F,
  0xE0, 0xFF, 0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x03,
  0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0,
  0x7F, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0x80, 0x0F, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0x80, 0x07, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0xFC, 0x01, 0xFE,
  0x00, 0x3F, 0xDF, 0xC0, 0x3F, 0xC0, 0x07, 0xFB, 0xF8, 0x07, 0xF8, 0x00,
  0xFF, 0x3F, 0x00, 0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x3F, 0xC0, 0x03, 0xF8,
  0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xE1, 0xF8,
  0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0xFF,
  0x00, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xC3, 0xF8, 0x00,
  0x7F, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x9F, 0xE0, 0x03, 0xFC,
  0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x80, 0x7E, 0x7F, 0x00, 0x0F, 0xE0, 0x0F,
  0xCF, 0xE0, 0x01, 0xFC, 0x01, 0xFB, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0x7F,
  0x80, 0x0F, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xE7, 0xFC,
  0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x03, 0xFE,
  0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00,
  0x7F, 0xCF, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x03,
  0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xFB, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xC0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFE, 0x00,
  0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF,
  0x1F, 0xF0, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x01, 0xFE,
  0x7F, 0x80, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00,
  0x3F, 0xCF, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF0,
  0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01,
  0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xFB, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x07, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xF0, 0x00,
  0xFF, 0x80, 0x00, 0x60, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x08, 0x00, 0x00, 0x7F, 0xC0, 0x1C, 0x00, 0x01, 0xFF, 0x00, 0x3E,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0xF7, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00,
  0x07, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x03, 0xFE, 0x7F,
  0x80, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x3F,
  0xC0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFC, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0xC1, 0xFC, 0x07, 0xF0,
  0x07, 0xF8, 0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x0F, 0xF8, 0x3F, 0x80, 0x1F,
  0xC1, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0xE0, 0xFE, 0x00, 0x7F, 0x0F,
  0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xFF, 0x87, 0xF0, 0x03, 0xF8, 0x7D, 0xF0,
  0xFE, 0x00, 0x7F, 0x1F, 0xBE, 0x1F, 0xC0, 0x0F, 0xE3, 0xE7, 0xC7, 0xF0,
  0x01, 0xF8, 0xFC, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0x1F, 0x1F, 0xC0, 0x0F,
  0xE7, 0xE3, 0xE3, 0xF0, 0x01, 0xFC, 0xF8, 0x7C, 0xFE, 0x00, 0x3F, 0x3F,
  0x0F, 0x9F, 0xC0, 0x07, 0xEF, 0xC1, 0xF3, 0xF8, 0x00, 0xFD, 0xF8, 0x3F,
  0x7E, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x07, 0xEF, 0xC0, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xBF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x00, 0x7F,
  0xC7, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xE1, 0xFE, 0x00,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0,
  0x00, 0x7F, 0x83, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xE3,
  0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x81,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x7F,
  0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x7F,
  0xE0, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xEF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0x80, 0x00, 0x3F,
  0x87, 0xC0, 0x00, 0x0F, 0x80, 0x60, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFE, 0x00,
  0x7C, 0x00, 0x38, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0x83, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xC0, 0x0F,
  0xF8, 0x3F, 0xF0, 0x01, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE1,
  0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xC0, 0x01,
  0xFC, 0x02, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF1, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8,
  0x01, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF,
  0x07, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xE0,
  0x00, 0x7F, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x03, 0xFE, 0x1F,
  0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC,
  0x1F, 0xE0, 0x01, 0xFF, 0x83, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x1F,
  0xFC, 0x1F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE1, 0xF8, 0x07, 0xFF, 0xC0, 0x01, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0x00,
  0xFF, 0xF0, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x7F, 0xC0, 0x03, 0xFF, 0x80,
  0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x7F,
  0xFD, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFD, 0xFE, 0x00,
  0x07, 0xFF, 0xF1, 0xFE, 0x00, 0x03, 0xFF, 0xC1, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x03,
  0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF1, 0xFF, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xCF, 0xF0,
  0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x0F, 0xFE, 0x7F,
  0x80, 0x0F, 0xFF, 0x3F, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0C, 0x07, 0xFF,
  0xC0, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x20, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x20,
  0x00, 0x07, 0xFC, 0x00, 0x3C, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xC0, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x03, 0xFC, 0x0F, 0xF8, 0x00,
  0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF8,
  0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x07,
  0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x0C, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x30,
  0x00, 0x7F, 0xC0, 0x00, 0x78, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0x01,
  0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0xE0, 0x00, 0x1F, 0xE3, 0xFF, 0x00, 0x00, 0x7F, 0xCF,
  0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFE,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x01,
  0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x03, 0x80, 0x00, 0x3F, 0xFC, 0x3F, 0xE0, 0x03, 0xFF,
  0xFD, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFE,
  0x0F, 0xF0, 0xFF, 0x01, 0xFC, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0x83,
  0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F,
  0x81, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0xFF, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x0F,
  0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0xFE, 0x07,
  0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xDF, 0xFF, 0x01,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F,
  0xF0, 0x7F, 0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xE0,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07,
  0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8,
  0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F,
  0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x9F,
  0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x80,
  0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xC7, 0xF8,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x07, 0xFD,
  0xFE, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F,
  0xE7, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x01,
  0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x1F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x03,
  0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x87, 0xFE,
  0x07, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0xC0, 0x0F, 0xF0, 0x3F, 0xF0, 0x01,
  0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F,
  0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x07, 0xF8,
  0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x07,
  0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xE0, 0x7F,
  0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0xFE, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFB, 0xFE, 0x00, 0x00, 0xF8, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x02,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x10, 0x00, 0x0F,
  0xFC, 0x0F, 0x00, 0x07, 0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xC0,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC1, 0xFF,
  0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFE, 0x0F,
  0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0xF8,
  0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x01,
  0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFD, 0xFE, 0x01, 0xFF, 0xFE, 0x7F, 0xC0, 0x1F, 0xFE, 0x0F,
  0xE0, 0x00, 0xFC, 0x02, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x07, 0xFC, 0xFF,
  0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC,
  0x0F, 0xF8, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F,
  0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x1F, 0xEF, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFE, 0x0F,
  0xE0, 0x3F, 0x03, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xFE, 0x0F, 0xC0, 0x7F,
  0x07, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xBE,
  0x1F, 0x80, 0x7F, 0x1F, 0xBE, 0x3F, 0x80, 0x7F, 0x3F, 0x3E, 0x3F, 0x80,
  0x7E, 0x3F, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x3F, 0x7F, 0x00, 0x7E, 0x7E,
  0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x3F, 0xFE,
  0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x7F,
  0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F,
  0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x0F, 0xF8,
  0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x10, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xF3,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x02, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x07, 0xFF, 0xE0, 0x07, 0xF0, 0xFF,
  0xFF, 0x00, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x87, 0xFF,
  0xFF, 0x0F, 0xE0, 0x1F, 0xFF, 0xE0, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xC0,
  0x03, 0xFF, 0x80, 0x1C, 0x00, 0x1F, 0xE0, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 21, 49, 39, 10, -48 },
  { 130, 26, 20, 39, 13, -52 },
  { 195, 41, 48, 39, 0, -48 },
  { 441, 38, 62, 39, 1, -54 },
  { 736, 47, 50, 39, -3, -49 },
  { 1030, 36, 50, 39, 1, -49 },
  { 1255, 13, 22, 39, 19, -52 },
  { 1291, 30, 68, 39, 8, -55 },
  { 1546, 30, 68, 39, 1, -55 },
  { 1801, 31, 30, 39, 7, -48 },
  { 1918, 33, 35, 39, 3, -38 },
  { 2063, 18, 24, 39, 5, -12 },
  { 2117, 22, 8, 39, 9, -24 },
  { 2139, 13, 13, 39, 10, -12 },
  { 2161, 45, 67, 39, -4, -54 },
  { 2538, 35, 50, 39, 3, -49 },
  { 2757, 30, 48, 39, 3, -48 },
  { 2937, 37, 49, 39, 1, -49 },
  { 3164, 37, 50, 39, 0, -49 },
  { 3396, 38, 48, 39, 0, -48 },
  { 3624, 40, 49, 39, 0, -48 },
  { 3869, 37, 49, 39, 3, -48 },
  { 4096, 36, 48, 39, 7, -48 },
  { 4312, 37, 50, 39, 2, -49 },
  { 4544, 36, 49, 39, 2, -49 },
  { 4765, 19, 37, 39, 10, -36 },
  { 4853, 24, 48, 39, 5, -36 },
  { 4997, 35, 32, 39, 3, -36 },
  { 5137, 37, 22, 39, 1, -31 },
  { 5239, 35, 32, 39, 1, -36 },
  { 5379, 29, 50, 39, 9, -49 },
  { 5561, 38, 59, 39, 2, -49 },
  { 5842, 38, 48, 39, -4, -48 },
  { 6070, 38, 49, 39, 0, -48 },
  { 6303, 37, 50, 39, 4, -49 },
  { 6535, 38, 49, 39, 0, -48 },
  { 6768, 39, 48, 39, 2, -48 },
  { 7002, 40, 48, 39, 2, -48 },
  { 7242, 38, 50, 39, 3, -49 },
  { 7480, 43, 48, 39, -1, -48 },
  { 7738, 40, 48, 39, 1, -48 },
  { 7978, 39, 49, 39, 1, -48 },
  { 8217, 43, 48, 39, 0, -48 },
  { 8475, 30, 48, 39, 1, -48 },
  { 8655, 43, 48, 39, -2, -48 },
  { 8913, 43, 48, 39, -1, -48 },
  { 9171, 36, 50, 39, 3, -49 },
  { 9396, 40, 48, 39, 0, -48 },
  { 9636, 36, 62, 39, 3, -49 },
  { 9915, 38, 48, 39, 0, -48 },
  { 10143, 39, 50, 39, 0, -49 },
  { 10387, 35, 48, 39, 8, -48 },
  { 10597, 39, 49, 39, 3, -48 },
  { 10836, 37, 48, 39, 8, -48 },
  { 11058, 43, 48, 39, 1, -48 },
  { 11316, 47, 48, 39, -3, -48 },
  { 11598, 37, 48, 39, 8, -48 },
  { 11820, 42, 48, 39, -1, -48 },
  { 12072, 37, 67, 39, 4, -54 },
  { 12382, 15, 67, 39, 13, -54 },
  { 12508, 37, 67, 39, -2, -54 },
  { 12818, 34, 28, 39, 4, -48 },
  { 12937, 36, 8, 39, -5, 5 },
  { 12973, 16, 14, 39, 16, -53 },
  { 13001, 35, 38, 39, 2, -37 },
  { 13168, 35, 55, 39, 1, -54 },
  { 13409, 35, 38, 39, 3, -37 },
  { 13576, 40, 55, 39, 2, -54 },
  { 13851, 34, 38, 39, 3, -37 },
  { 14013, 48, 67, 39, -5, -54 },
  { 14415, 40, 50, 39, -2, -37 },
  { 14665, 35, 54, 39, 0, -54 },
  { 14902, 26, 55, 39, 6, -54 },
  { 15081, 39, 67, 39, -3, -54 },
  { 15408, 39, 54, 39, 1, -54 },
  { 15672, 23, 54, 39, 9, -53 },
  { 15828, 39, 37, 39, -1, -37 },
  { 16009, 34, 37, 39, 1, -37 },
  { 16167, 34, 38, 39, 2, -37 },
  { 16329, 39, 50, 39, -3, -37 },
  { 16573, 35, 50, 39, 3, -37 },
  { 16792, 35, 37, 39, 3, -37 },
  { 16954, 34, 38, 39, 2, -37 },
  { 17116, 32, 48, 39, 6, -47 },
  { 17308, 34, 37, 39, 3, -36 },
  { 17466, 34, 36, 39, 6, -36 },
  { 17619, 40, 36, 39, 2, -36 },
  { 17799, 41, 36, 39, -2, -36 },
  { 17984, 45, 49, 39, -6, -36 },
  { 18260, 37, 36, 39, 1, -36 },
  { 18427, 37, 67, 39, 5, -54 },
  { 18737, 25, 67, 39, 7, -54 },
  { 18947, 37, 67, 39, -3, -54 },
  { 19257, 36, 13, 39, 2, -27 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic69pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic69pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic69pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC69PT7B_H_
