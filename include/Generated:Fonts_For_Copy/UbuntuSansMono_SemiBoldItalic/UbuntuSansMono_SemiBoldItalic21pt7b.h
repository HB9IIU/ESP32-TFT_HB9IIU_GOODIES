#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC21PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC7, 0x38, 0xE3, 0x8E, 0x30, 0xC0, 0x00, 0xF3, 0xCE,
  0x00, 0x67, 0xE7, 0xE6, 0xC6, 0xCE, 0xCC, 0x03, 0x30, 0x73, 0x06, 0x70,
  0x66, 0x3F, 0xF7, 0xFF, 0x1C, 0xC1, 0x9C, 0x19, 0x8F, 0xFE, 0xFF, 0xE7,
  0x30, 0x66, 0x06, 0x60, 0xCE, 0x00, 0x01, 0xC0, 0x18, 0x07, 0xE1, 0xFF,
  0x1C, 0x21, 0x80, 0x18, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xC0, 0x0C,
  0x01, 0xC7, 0x3C, 0xFF, 0x81, 0xE0, 0x1C, 0x01, 0x80, 0x0E, 0x0C, 0x7C,
  0x31, 0xB1, 0x84, 0xCC, 0x33, 0x60, 0xDB, 0x01, 0xD8, 0x00, 0x60, 0x03,
  0x70, 0x1B, 0xC0, 0xD9, 0x06, 0x64, 0x31, 0xB1, 0x86, 0xCE, 0x1E, 0x00,
  0x07, 0x81, 0xF8, 0x73, 0x0C, 0x61, 0x8C, 0x33, 0x07, 0xC0, 0xF3, 0x3E,
  0x6C, 0xFF, 0x8F, 0x71, 0xCE, 0x38, 0xFF, 0x9F, 0x30, 0x7E, 0xEE, 0xCC,
  0xC0, 0x00, 0x80, 0x60, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70,
  0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x03,
  0x80, 0xE0, 0x10, 0x00, 0x02, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x1C, 0x1C, 0x1C, 0x1E,
  0x1E, 0x1C, 0x04, 0x00, 0x0C, 0x03, 0x04, 0xC9, 0xB6, 0xFF, 0xC3, 0x03,
  0xE1, 0xDE, 0x33, 0x00, 0x80, 0x06, 0x01, 0x80, 0xE0, 0x30, 0xFF, 0xFF,
  0xF1, 0xC0, 0x60, 0x18, 0x06, 0x00, 0x18, 0xF3, 0xCF, 0x18, 0xEF, 0x20,
  0xFF, 0xF0, 0x6F, 0xFE, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0x07, 0x83, 0xF8, 0xF7, 0x18, 0x77, 0x0E, 0xC1, 0xDB,
  0xBF, 0x76, 0xEC, 0xD8, 0x3B, 0x07, 0x61, 0xCE, 0x31, 0xFE, 0x1F, 0x80,
  0x01, 0x81, 0xC3, 0xE7, 0xE3, 0xF1, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03,
  0x81, 0x81, 0xC7, 0xFF, 0xFC, 0x07, 0xC1, 0xFE, 0x1C, 0xE1, 0x07, 0x00,
  0x60, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70,
  0x07, 0xFC, 0xFF, 0xC0, 0x07, 0x83, 0xFC, 0x23, 0x80, 0x30, 0x06, 0x01,
  0xC3, 0xF0, 0x7C, 0x03, 0xC0, 0x18, 0x03, 0x00, 0x64, 0x1D, 0xFF, 0x3F,
  0xC0, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x3E, 0x06, 0xE0, 0xCC, 0x18, 0xC3,
  0x8C, 0x71, 0xC7, 0xFE, 0xFF, 0xE0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00,
  0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xC0, 0x0C, 0x01, 0xC0, 0x1F, 0x03, 0xF8,
  0x03, 0xC0, 0x1C, 0x00, 0xC0, 0x1C, 0x41, 0xCF, 0xF8, 0xFF, 0x00, 0x00,
  0xE0, 0xFC, 0x3F, 0x8E, 0x03, 0x80, 0xE0, 0x1B, 0xC7, 0xFC, 0xE1, 0xDC,
  0x3B, 0x87, 0x70, 0xEE, 0x38, 0xFF, 0x0F, 0x80, 0x7F, 0xEF, 0xFD, 0xFF,
  0x80, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xE0, 0x38,
  0x07, 0x00, 0xC0, 0x38, 0x00, 0x07, 0x83, 0xF8, 0xE3, 0x98, 0x73, 0x0E,
  0x61, 0x8F, 0xE0, 0xF8, 0x77, 0x9C, 0x73, 0x07, 0x60, 0xCC, 0x39, 0xFF,
  0x1F, 0x80, 0x0F, 0x03, 0xF8, 0xE7, 0x38, 0x76, 0x0E, 0xC1, 0xDC, 0x3B,
  0xFE, 0x3F, 0xC0, 0x38, 0x0E, 0x03, 0xC1, 0xF1, 0xF8, 0x3C, 0x00, 0x18,
  0xF3, 0xCE, 0x00, 0x00, 0x18, 0xF3, 0xCE, 0x00, 0x06, 0x0F, 0x0F, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x3C, 0x3C, 0x3C, 0x18, 0x38, 0xF0, 0x80, 0x00,
  0x40, 0x7C, 0x3F, 0x3F, 0x0F, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80,
  0x20, 0x3F, 0xF3, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xC0,
  0x10, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x07, 0xC7, 0xE3, 0xF0, 0xF0,
  0x08, 0x00, 0x3E, 0x3F, 0x99, 0xC0, 0x70, 0x70, 0x78, 0x78, 0x70, 0x70,
  0x38, 0x00, 0x00, 0x0E, 0x07, 0x03, 0x80, 0x07, 0x83, 0xFC, 0xE1, 0x98,
  0x36, 0x06, 0xCF, 0xF3, 0xFE, 0x67, 0xDC, 0xDB, 0x1B, 0x63, 0x6E, 0xED,
  0xF9, 0x9F, 0x30, 0x07, 0x00, 0x7F, 0x07, 0xC0, 0x00, 0xC0, 0x3C, 0x0F,
  0x81, 0xF0, 0x76, 0x0C, 0xC3, 0x98, 0x63, 0x1C, 0x63, 0xFC, 0xFF, 0x9F,
  0xF7, 0x06, 0xC0, 0xF8, 0x18, 0x0F, 0x81, 0xFE, 0x1D, 0xE1, 0x87, 0x18,
  0x73, 0x86, 0x3F, 0xC3, 0xF8, 0x33, 0xC7, 0x0E, 0x70, 0xE6, 0x0E, 0x61,
  0xCF, 0xF8, 0xFF, 0x00, 0x03, 0xC0, 0xFF, 0x1E, 0x63, 0x80, 0x30, 0x07,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x87,
  0xF8, 0x3F, 0x80, 0x0F, 0x01, 0xFC, 0x1F, 0xE1, 0x8E, 0x38, 0x63, 0x87,
  0x30, 0x63, 0x06, 0x70, 0xE7, 0x0E, 0x70, 0xE6, 0x1C, 0xE3, 0x8F, 0xF0,
  0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x1F, 0xF1, 0xC0, 0x1C, 0x01, 0x80, 0x1F,
  0xC3, 0xFC, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0xFC, 0xFF,
  0xC0, 0x1F, 0xF1, 0xFF, 0x1F, 0xE3, 0x80, 0x38, 0x03, 0x00, 0x3F, 0xC7,
  0xF8, 0x7F, 0x86, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x00,
  0x03, 0xC1, 0xFC, 0x79, 0x9C, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE1,
  0xDC, 0x3B, 0x86, 0x70, 0xCE, 0x38, 0xFF, 0x0F, 0xC0, 0x1C, 0x38, 0xE1,
  0xC6, 0x0C, 0x30, 0xE3, 0x87, 0x1C, 0x38, 0xFF, 0x87, 0xFC, 0x70, 0xE3,
  0x87, 0x18, 0x30, 0xC1, 0x8E, 0x1C, 0x70, 0xE3, 0x86, 0x00, 0x0F, 0xF1,
  0xFF, 0x1F, 0xF0, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x07, 0xF8, 0xFF, 0x80, 0x07, 0xF0, 0x7F,
  0x0F, 0xF0, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x43, 0x8F, 0xF0, 0x7E, 0x00, 0x1C, 0x38, 0xE3, 0x87,
  0x18, 0x31, 0xC3, 0x9C, 0x1D, 0xC0, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xB8,
  0x1C, 0xE0, 0xC7, 0x06, 0x1C, 0x70, 0xE3, 0x87, 0x00, 0x0C, 0x07, 0x01,
  0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0,
  0x60, 0x5F, 0xEF, 0xF8, 0x06, 0x1C, 0x38, 0x60, 0xE3, 0x83, 0x8E, 0x1A,
  0x78, 0x6B, 0x61, 0xAD, 0x8E, 0xEC, 0x33, 0xB0, 0xCC, 0xC3, 0x03, 0x1C,
  0x1C, 0x60, 0x61, 0x81, 0x8E, 0x0E, 0x00, 0x1C, 0x38, 0xE1, 0xC7, 0x0C,
  0x3C, 0x63, 0xE3, 0x1B, 0x38, 0xD9, 0x86, 0x6C, 0x73, 0x63, 0x1F, 0x18,
  0xF0, 0xC7, 0x8E, 0x1C, 0x70, 0xE3, 0x06, 0x00, 0x07, 0x83, 0xF8, 0xF7,
  0x18, 0x77, 0x0E, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xD8, 0x3B, 0x07, 0x61,
  0xCE, 0x39, 0xFE, 0x1F, 0x80, 0x0F, 0x81, 0xFE, 0x1F, 0xF1, 0x87, 0x18,
  0x73, 0x87, 0x38, 0x73, 0x9E, 0x3F, 0xC7, 0xF0, 0x70, 0x07, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x00, 0x07, 0x83, 0xF8, 0xF7, 0x18, 0x77, 0x0E, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xD8, 0x3B, 0x07, 0x61, 0xCE, 0x39, 0xFE, 0x1F,
  0x81, 0xC0, 0x18, 0x03, 0xE0, 0x18, 0x00, 0x0F, 0x81, 0xFE, 0x1D, 0xE1,
  0x87, 0x38, 0x73, 0x86, 0x38, 0xE3, 0xFC, 0x3F, 0x87, 0xF0, 0x73, 0x86,
  0x38, 0x61, 0x8E, 0x1C, 0xE1, 0xC0, 0x07, 0xE0, 0xFF, 0x1C, 0x61, 0x80,
  0x18, 0x01, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1C, 0x00, 0xC0, 0x0C,
  0x41, 0xCF, 0xF8, 0x7F, 0x00, 0x7F, 0xEF, 0xFF, 0xFF, 0x87, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60,
  0x1C, 0x00, 0x38, 0x73, 0x86, 0x30, 0x67, 0x0E, 0x70, 0xE7, 0x0C, 0x60,
  0xC6, 0x1C, 0xE1, 0xCE, 0x1C, 0xC1, 0x8C, 0x38, 0xE3, 0x8F, 0xF0, 0x7E,
  0x00, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x0C, 0xE1, 0xCE, 0x18, 0xE3, 0x86,
  0x30, 0x67, 0x06, 0x60, 0x6E, 0x06, 0xC0, 0x7C, 0x07, 0x80, 0x70, 0x00,
  0x18, 0x18, 0xC0, 0xCE, 0x0E, 0x60, 0x73, 0x03, 0x18, 0x18, 0xDC, 0xCE,
  0xEC, 0x6F, 0x63, 0x7B, 0x1E, 0xD8, 0xE7, 0x87, 0x1C, 0x70, 0xE3, 0x86,
  0x00, 0x0E, 0x0C, 0x38, 0x70, 0x63, 0x81, 0xDC, 0x07, 0x60, 0x0F, 0x80,
  0x3C, 0x00, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0xEC, 0x07, 0x30, 0x38, 0xE1,
  0xC3, 0x8F, 0x06, 0x00, 0xE0, 0x76, 0x0E, 0x60, 0xC7, 0x1C, 0x73, 0x87,
  0x30, 0x37, 0x03, 0xE0, 0x3C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x70, 0x00, 0x0F, 0xF8, 0xFF, 0x87, 0xFC, 0x01, 0xC0, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x7F, 0xE3, 0xFE, 0x00, 0x07, 0xE0, 0xFC, 0x38, 0x07, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C,
  0x03, 0x80, 0x70, 0x0C, 0x01, 0xF8, 0x7F, 0x00, 0xEE, 0xEE, 0xE6, 0x66,
  0x66, 0x77, 0x77, 0x77, 0x33, 0x33, 0x0F, 0xE1, 0xF8, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x83, 0xF0, 0x7E, 0x00, 0x03, 0x00,
  0xF0, 0x3E, 0x0E, 0xC1, 0xDC, 0x73, 0x9C, 0x37, 0x07, 0x20, 0x80, 0x7F,
  0xFF, 0xFC, 0x47, 0x1E, 0x20, 0x1F, 0xCF, 0xF7, 0x1F, 0x87, 0xE1, 0xB0,
  0x6C, 0x3B, 0x0E, 0xE3, 0xBF, 0xE7, 0xD8, 0x0E, 0x01, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x3F, 0x8F, 0xF1, 0xC7, 0x38, 0xE6, 0x1D, 0xC3, 0xB8, 0x77,
  0x1C, 0xC7, 0xBF, 0xE7, 0xF0, 0x0F, 0xCF, 0xF7, 0x81, 0xC0, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x9F, 0xE3, 0xF8, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0xFC, 0x3F, 0xC7, 0x1C, 0x61, 0xCE, 0x18, 0xC1, 0x8C,
  0x38, 0xC3, 0x8E, 0x38, 0xFF, 0x87, 0xD8, 0x1F, 0x8F, 0xF7, 0x0D, 0x83,
  0xE1, 0xFF, 0xEF, 0xE3, 0x00, 0xE0, 0x9F, 0xE3, 0xF8, 0x00, 0xFC, 0x07,
  0xE0, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0C, 0x02, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0x03, 0xF8, 0x7F, 0x87,
  0x8C, 0x30, 0xE3, 0x87, 0x1C, 0x30, 0xE1, 0x87, 0x1C, 0x3F, 0xE0, 0xFE,
  0x00, 0x30, 0x03, 0x86, 0x38, 0x7F, 0xC1, 0xF8, 0x00, 0x0E, 0x01, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x3F, 0x8F, 0xF1, 0xC7, 0x38, 0xE6, 0x19, 0xC3,
  0x38, 0xE7, 0x1C, 0xC3, 0x98, 0x67, 0x1C, 0x0E, 0x1E, 0x0C, 0x00, 0x00,
  0xFC, 0xFC, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x30, 0x38, 0x3F, 0x1F, 0x00,
  0x70, 0x0F, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x0E, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03,
  0x04, 0x70, 0xFE, 0x07, 0xC0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C,
  0x01, 0xC7, 0x18, 0xE3, 0x9C, 0x3B, 0x83, 0xE0, 0x3E, 0x03, 0x70, 0x73,
  0x87, 0x38, 0x61, 0xCE, 0x1C, 0xFD, 0xF8, 0x61, 0xC3, 0x87, 0x0C, 0x18,
  0x70, 0xE1, 0x83, 0x0E, 0x1C, 0x5F, 0xBF, 0x3F, 0xE3, 0xFE, 0x33, 0x77,
  0x66, 0x66, 0x66, 0x66, 0x66, 0xE6, 0x0C, 0xC0, 0xCC, 0x0C, 0xC1, 0xC0,
  0x1F, 0xC3, 0xFC, 0xE3, 0x9C, 0x73, 0x0E, 0x61, 0x9C, 0x33, 0x8E, 0x61,
  0xCC, 0x33, 0x8E, 0x00, 0x1F, 0x8F, 0xF7, 0x1D, 0x87, 0xE1, 0xF8, 0x7C,
  0x1F, 0x0E, 0xE3, 0xBF, 0xC7, 0xE0, 0x0F, 0xE1, 0xFE, 0x1C, 0x71, 0xC7,
  0x18, 0x73, 0x87, 0x38, 0x73, 0x8E, 0x31, 0xE3, 0xFC, 0x7F, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x00, 0x0F, 0xE7, 0xF9, 0xE7, 0x38, 0xEE, 0x1D,
  0xC3, 0x30, 0x67, 0x1C, 0xE3, 0x9F, 0xE1, 0xFC, 0x03, 0x80, 0x70, 0x0C,
  0x03, 0x80, 0x1F, 0xE7, 0xF8, 0xE1, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x0F, 0xE3, 0xF8, 0x60, 0x0C, 0x01,
  0xE0, 0x1F, 0x00, 0xF0, 0x0E, 0x41, 0xCF, 0xF3, 0xFC, 0x00, 0x1C, 0x0E,
  0x06, 0x1F, 0xFF, 0xF9, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x27,
  0xF1, 0xF8, 0x70, 0xDC, 0x77, 0x1D, 0x87, 0x61, 0xB8, 0xEE, 0x3B, 0x8E,
  0xE7, 0xBF, 0xE7, 0xF8, 0xE1, 0xF8, 0x6E, 0x3B, 0x8E, 0xE7, 0x39, 0x8E,
  0xE1, 0xB0, 0x7C, 0x1E, 0x07, 0x00, 0x60, 0x7E, 0x06, 0xC6, 0x6C, 0xEE,
  0xCE, 0xCD, 0xEC, 0xD7, 0x8F, 0x78, 0xE7, 0x8E, 0x70, 0xC7, 0x00, 0x1C,
  0x38, 0x63, 0x83, 0xB8, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF8,
  0x1D, 0xC1, 0xC6, 0x3C, 0x38, 0x0E, 0x1C, 0x38, 0x60, 0xE3, 0x83, 0x8E,
  0x0E, 0x30, 0x19, 0xC0, 0x66, 0x01, 0xB8, 0x07, 0xC0, 0x1E, 0x00, 0x38,
  0x01, 0xC0, 0x4E, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0F, 0xF3, 0xFE, 0x00,
  0x03, 0xF0, 0x7E, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x1C, 0x07, 0x00, 0xF8, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x3E, 0x01, 0xE0, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0C,
  0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x60,
  0x60, 0xE0, 0x07, 0xC1, 0xF8, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60,
  0x0C, 0x01, 0xC0, 0x1C, 0x07, 0x81, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30,
  0x0E, 0x01, 0xC1, 0xF0, 0x7C, 0x00, 0x3C, 0x77, 0xFE, 0x67, 0xCC, 0x38,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 6, 15, 12, 3, -15 },
  { 13, 8, 6, 12, 4, -16 },
  { 19, 12, 15, 12, 0, -15 },
  { 42, 12, 18, 12, 0, -16 },
  { 69, 14, 15, 12, -1, -15 },
  { 96, 11, 15, 12, 0, -15 },
  { 117, 4, 7, 12, 6, -16 },
  { 121, 10, 21, 12, 2, -17 },
  { 148, 9, 21, 12, 0, -17 },
  { 172, 10, 10, 12, 2, -15 },
  { 185, 10, 10, 12, 1, -11 },
  { 198, 6, 8, 12, 1, -4 },
  { 204, 6, 2, 12, 3, -7 },
  { 206, 4, 4, 12, 3, -4 },
  { 208, 14, 20, 12, -1, -16 },
  { 243, 11, 15, 12, 1, -15 },
  { 264, 9, 15, 12, 1, -15 },
  { 281, 12, 15, 12, 0, -15 },
  { 304, 11, 15, 12, 0, -15 },
  { 325, 12, 15, 12, 0, -15 },
  { 348, 12, 15, 12, 0, -15 },
  { 371, 11, 15, 12, 1, -15 },
  { 392, 11, 15, 12, 2, -15 },
  { 413, 11, 15, 12, 1, -15 },
  { 434, 11, 15, 12, 1, -15 },
  { 455, 6, 11, 12, 3, -11 },
  { 464, 8, 15, 12, 1, -11 },
  { 479, 11, 10, 12, 1, -11 },
  { 493, 12, 7, 12, 0, -10 },
  { 504, 11, 10, 12, 0, -11 },
  { 518, 9, 15, 12, 3, -15 },
  { 535, 11, 18, 12, 1, -15 },
  { 560, 11, 15, 12, -1, -15 },
  { 581, 12, 15, 12, 0, -15 },
  { 604, 12, 15, 12, 1, -15 },
  { 627, 12, 15, 12, 0, -15 },
  { 650, 12, 15, 12, 0, -15 },
  { 673, 12, 15, 12, 1, -15 },
  { 696, 11, 15, 12, 1, -15 },
  { 717, 13, 15, 12, 0, -15 },
  { 742, 12, 15, 12, 0, -15 },
  { 765, 12, 15, 12, 0, -15 },
  { 788, 13, 15, 12, 0, -15 },
  { 813, 10, 15, 12, 0, -15 },
  { 832, 14, 15, 12, -1, -15 },
  { 859, 13, 15, 12, 0, -15 },
  { 884, 11, 15, 12, 1, -15 },
  { 905, 12, 15, 12, 0, -15 },
  { 928, 11, 19, 12, 1, -15 },
  { 955, 12, 15, 12, 0, -15 },
  { 978, 12, 15, 12, 0, -15 },
  { 1001, 11, 15, 12, 2, -15 },
  { 1022, 12, 15, 12, 1, -15 },
  { 1045, 12, 15, 12, 2, -15 },
  { 1068, 13, 15, 12, 0, -15 },
  { 1093, 14, 15, 12, -1, -15 },
  { 1120, 12, 15, 12, 2, -15 },
  { 1143, 13, 15, 12, 0, -15 },
  { 1168, 11, 20, 12, 1, -16 },
  { 1196, 4, 20, 12, 4, -16 },
  { 1206, 11, 20, 12, 0, -16 },
  { 1234, 11, 9, 12, 1, -15 },
  { 1247, 11, 2, 12, -2, 2 },
  { 1250, 5, 4, 12, 5, -16 },
  { 1253, 10, 11, 12, 1, -11 },
  { 1267, 11, 16, 12, 0, -16 },
  { 1289, 10, 11, 12, 1, -11 },
  { 1303, 12, 16, 12, 1, -16 },
  { 1327, 10, 11, 12, 1, -11 },
  { 1341, 14, 20, 12, -1, -16 },
  { 1376, 13, 15, 12, -1, -11 },
  { 1401, 11, 16, 12, 0, -16 },
  { 1423, 8, 16, 12, 2, -16 },
  { 1439, 12, 20, 12, -1, -16 },
  { 1469, 12, 16, 12, 0, -16 },
  { 1493, 7, 16, 12, 3, -16 },
  { 1507, 12, 11, 12, 0, -11 },
  { 1524, 11, 11, 12, 0, -11 },
  { 1540, 10, 11, 12, 1, -11 },
  { 1554, 12, 15, 12, -1, -11 },
  { 1577, 11, 15, 12, 1, -11 },
  { 1598, 11, 11, 12, 1, -11 },
  { 1614, 11, 11, 12, 0, -11 },
  { 1630, 9, 14, 12, 2, -14 },
  { 1646, 10, 11, 12, 1, -11 },
  { 1660, 10, 11, 12, 2, -11 },
  { 1674, 12, 11, 12, 1, -11 },
  { 1691, 13, 11, 12, -1, -11 },
  { 1709, 14, 15, 12, -2, -11 },
  { 1736, 11, 11, 12, 0, -11 },
  { 1752, 12, 20, 12, 1, -16 },
  { 1782, 8, 20, 12, 2, -16 },
  { 1802, 11, 20, 12, -1, -16 },
  { 1830, 12, 4, 12, 0, -8 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic21pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic21pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic21pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC21PT7B_H_
