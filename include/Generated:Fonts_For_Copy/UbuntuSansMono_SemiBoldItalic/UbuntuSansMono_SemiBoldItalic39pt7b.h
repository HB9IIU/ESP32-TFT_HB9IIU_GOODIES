#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC39PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E,
  0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xE0, 0x10, 0x00, 0x3E, 0x3E, 0x7C, 0x7D, 0xF1, 0xF3, 0xE3, 0xE7,
  0xC7, 0xCF, 0x0F, 0x9E, 0x1E, 0x3C, 0x3C, 0xF0, 0x79, 0xE0, 0xE3, 0xC3,
  0xC7, 0x07, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0,
  0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x1E,
  0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF8, 0x01, 0xE1, 0xE0, 0x03, 0xC3,
  0xC0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x81, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00,
  0x78, 0x78, 0x01, 0xF1, 0xF0, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xC0, 0x60, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x60, 0x0F, 0xC3, 0xF7, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x03, 0xFF,
  0xC0, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7E, 0x00, 0xF0, 0x3F, 0x80,
  0x78, 0x1E, 0xF0, 0x3C, 0x0F, 0x3C, 0x1E, 0x03, 0x8F, 0x0F, 0x00, 0xE3,
  0xC3, 0x80, 0x38, 0xE1, 0xC0, 0x1E, 0x38, 0xF0, 0x07, 0x9E, 0x78, 0x00,
  0xE7, 0x3C, 0x00, 0x3F, 0xDE, 0x00, 0x0F, 0xE7, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xF8, 0x00, 0x3C,
  0xFF, 0x00, 0x0E, 0x79, 0xC0, 0x07, 0x1C, 0x70, 0x03, 0xCF, 0x1C, 0x01,
  0xE3, 0x87, 0x00, 0xF0, 0xE3, 0xC0, 0x78, 0x38, 0xE0, 0x3C, 0x0E, 0x38,
  0x0E, 0x03, 0xFE, 0x07, 0x00, 0xFF, 0x03, 0xC0, 0x1F, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0xC0, 0x3E, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x07,
  0xC3, 0xC0, 0x1E, 0x3E, 0x00, 0xF3, 0xE0, 0x07, 0xBE, 0x00, 0x3F, 0xE0,
  0x00, 0xFC, 0x20, 0x1F, 0xC1, 0xE1, 0xFF, 0x1E, 0x1F, 0x7C, 0xF1, 0xF3,
  0xE7, 0x9F, 0x0F, 0xF8, 0xF0, 0x3F, 0xC7, 0x81, 0xFC, 0x7C, 0x07, 0xC3,
  0xE0, 0x3E, 0x0F, 0x03, 0xF8, 0x7E, 0x7F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFE,
  0xF8, 0x3F, 0xC3, 0xC0, 0x3E, 0xFD, 0xF3, 0xE7, 0xCF, 0xBE, 0x7C, 0xF1,
  0xE3, 0xC7, 0x0E, 0x00, 0x00, 0x01, 0x00, 0x00, 0xE0, 0x00, 0xF8, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x01, 0xF8, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x71, 0xE3, 0x1E, 0x73, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0x3F, 0xFF, 0x40, 0xF8, 0x00, 0x7F, 0x00, 0x3D, 0xF0, 0x1F,
  0x7E, 0x0F, 0xCF, 0xC1, 0xE3, 0xE0, 0x38, 0x70, 0x04, 0x10, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE0, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x03, 0xE1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xFC, 0x1E, 0x07, 0x87, 0xCF, 0xE3, 0xF0,
  0xF0, 0x20, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x38,
  0xFB, 0xFF, 0xFF, 0xFF, 0xBF, 0x10, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xF8, 0x03, 0xFF,
  0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0xF8, 0x3E, 0x1F, 0x01, 0xE1, 0xF0,
  0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC6, 0x1E, 0x78,
  0xF1, 0xEF, 0x9F, 0x1E, 0xF9, 0xF3, 0xEF, 0x9F, 0x3E, 0xF0, 0xE3, 0xEF,
  0x00, 0x3C, 0xF0, 0x07, 0xCF, 0x00, 0x7C, 0xF0, 0x0F, 0x8F, 0x00, 0xF8,
  0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8,
  0x01, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0x7C, 0x0E,
  0x3E, 0x04, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x81, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xE0, 0x7C, 0x04, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0x3F, 0x80, 0x80, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x1F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x8C, 0x01, 0xF8, 0x7E, 0x7F, 0xC3,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xEF, 0x00, 0x1F, 0x7C, 0x00, 0xF9, 0xF0,
  0x07, 0xC7, 0x80, 0x3E, 0x1E, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x3C,
  0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xF0, 0x7C, 0x07, 0xC9, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x08, 0x03, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xC0,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x1F, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3,
  0xF0, 0x3F, 0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xC7, 0xC0, 0x1E, 0x3E, 0x00,
  0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x0F,
  0xEF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x03, 0x80,
  0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7E, 0x3F, 0x83, 0xE0,
  0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0x83,
  0xE0, 0x7C, 0x0F, 0x87, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0xF0, 0x1F, 0x1F, 0x81, 0xF0, 0x3E, 0x1F, 0x01, 0xF0, 0xF0,
  0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x1F, 0x1F, 0x81, 0xF8,
  0x7F, 0x3F, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0xFE, 0x7F, 0x07, 0xC0, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x1F, 0x1E,
  0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF1, 0xF0, 0x0F,
  0x0F, 0xC1, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFD, 0xE0, 0x07,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF0,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0x83, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0,
  0xF8, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x81, 0xF0,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x08, 0x00, 0x00, 0xF0, 0x0F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xC0, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xF0, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xC0, 0x1E, 0x03, 0xE0, 0xFE,
  0x07, 0xE0, 0x3C, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7C, 0x00,
  0x3F, 0x80, 0x3F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0x40, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x27, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x00,
  0x0C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x03, 0xFC,
  0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0x07,
  0xE0, 0x00, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0xFC, 0x3F,
  0xFE, 0x3F, 0xFF, 0x1E, 0x7F, 0x10, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7C, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xE0, 0xF8, 0x1F, 0x01, 0xF0, 0xF8, 0x03,
  0xC7, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0xF0, 0x3F, 0xF3, 0xC3, 0xFF, 0x8F,
  0x1F, 0xFE, 0x78, 0x7F, 0xF9, 0xE3, 0xE3, 0xE7, 0x8F, 0x0F, 0x3C, 0x78,
  0x3C, 0xF1, 0xE0, 0xF3, 0xC7, 0x87, 0xCF, 0x1E, 0x1E, 0x3C, 0x78, 0x78,
  0xF1, 0xE1, 0xE3, 0xC7, 0x87, 0x8F, 0x1F, 0xBC, 0x3C, 0x7F, 0xF0, 0xF0,
  0xFF, 0xC3, 0xC1, 0xFF, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xFB, 0xC0, 0x07, 0x9E,
  0x00, 0x7C, 0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xE1, 0xF0, 0x1F,
  0x0F, 0x80, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF8,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xF0, 0x0F, 0x8F, 0x00,
  0x7C, 0xF8, 0x03, 0xE7, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xFE,
  0x00, 0x3E, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xE0, 0x1E,
  0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x3F, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0x80, 0xFC, 0x1E, 0x01,
  0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3C, 0x01, 0xF1,
  0xF0, 0x0F, 0x87, 0xC0, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x03, 0xFF, 0x80, 0x3F,
  0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xF0, 0x18, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x60, 0x7F, 0xFF, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7C, 0x3F, 0x03,
  0xE0, 0x7C, 0x1E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x03,
  0xC3, 0xE0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C,
  0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0xFC,
  0x78, 0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x07, 0xE1, 0xF0, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01,
  0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x03, 0xFF, 0x80,
  0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xF0, 0x18, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x0F, 0x9F, 0x00, 0xF8,
  0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x80,
  0xF8, 0x7C, 0x07, 0xC3, 0xF0, 0x3E, 0x1F, 0x81, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x03,
  0xE0, 0x1F, 0x03, 0xE0, 0x1E, 0x03, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07,
  0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F,
  0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x00, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3E, 0x01, 0xF0, 0x3E,
  0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xE0, 0x7C, 0x03, 0xE0, 0x7C,
  0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xC0, 0xF8, 0x07, 0xC0, 0xF8,
  0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0x01, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x04, 0x01, 0xF0, 0x0E, 0x07, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0xE0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x03, 0xC0, 0xFC, 0x07,
  0xC1, 0xF8, 0x07, 0xC3, 0xF0, 0x07, 0xC7, 0xE0, 0x07, 0x8F, 0xC0, 0x0F,
  0x9F, 0x80, 0x0F, 0xBF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3E,
  0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7C,
  0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78,
  0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF8, 0x00, 0xF0, 0x0F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x7F,
  0x03, 0xF8, 0x7F, 0x03, 0xB8, 0xFE, 0x07, 0xB8, 0xEE, 0x07, 0xB9, 0xFE,
  0x07, 0x39, 0xDE, 0x0F, 0x3B, 0x9E, 0x0F, 0x3B, 0x9C, 0x0F, 0x3F, 0x3C,
  0x0F, 0x3F, 0x3C, 0x1E, 0x3E, 0x3C, 0x1E, 0x3E, 0x3C, 0x1E, 0x3C, 0x7C,
  0x3E, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0xF8,
  0x7C, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF8, 0x01, 0xF0,
  0xF8, 0x01, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1E,
  0x03, 0xE0, 0x1E, 0x07, 0xF0, 0x1E, 0x07, 0xF0, 0x3E, 0x07, 0xF0, 0x3E,
  0x07, 0xF0, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0x78, 0x7C, 0x0F, 0x78, 0x7C,
  0x0F, 0x38, 0x78, 0x1F, 0x3C, 0x78, 0x1E, 0x3C, 0x78, 0x1E, 0x3C, 0xF8,
  0x1E, 0x1C, 0xF0, 0x3E, 0x1E, 0xF0, 0x3E, 0x1E, 0xF0, 0x3C, 0x1F, 0xF0,
  0x3C, 0x0F, 0xE0, 0x7C, 0x0F, 0xE0, 0x7C, 0x0F, 0xE0, 0x78, 0x0F, 0xE0,
  0x78, 0x0F, 0xC0, 0x78, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF0, 0x07, 0xC0,
  0xF0, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xE0, 0xFC, 0x3E, 0x03, 0xE3, 0xF0, 0x1F,
  0x1F, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xC0,
  0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3,
  0xC0, 0x0F, 0x9E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7C, 0x3C, 0x03,
  0xE1, 0xF0, 0x3E, 0x0F, 0x83, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xC0, 0xFC, 0x1F, 0x01,
  0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x0F, 0x07, 0x80, 0x7C, 0x3E, 0x01, 0xF0,
  0xF8, 0x07, 0xC3, 0xE0, 0x3E, 0x0F, 0x81, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xE0, 0xFC, 0x3E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0xF9, 0xF0,
  0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xC0, 0x0F, 0xBE, 0x00, 0x7D,
  0xF0, 0x03, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xC0, 0x0F, 0x9E, 0x00,
  0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7C, 0x3C, 0x03, 0xE1, 0xF0, 0x3E, 0x0F,
  0x83, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x07, 0xC1, 0xE0, 0x1F, 0x0F, 0x80, 0x78, 0x3E, 0x03, 0xE0, 0xF8,
  0x0F, 0x83, 0xC0, 0x7C, 0x1F, 0x0F, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F,
  0x83, 0xC0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x1F, 0x01,
  0xF0, 0x78, 0x07, 0xC3, 0xE0, 0x0F, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFD, 0xF8,
  0x1F, 0x80, 0x40, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x0C, 0x01, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0xF8, 0x3E,
  0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0x81, 0xF0, 0x1F, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x07,
  0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0xF8,
  0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0x81, 0xE0, 0x1F, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0x07, 0xE0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7D, 0xF0, 0x03,
  0xEF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x0F, 0x83, 0xC0, 0x7C, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xE0,
  0x3C, 0x1F, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x78, 0x03, 0xC7,
  0xC0, 0x1F, 0x3C, 0x00, 0xFB, 0xE0, 0x07, 0xDE, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x0F, 0x83, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC1, 0xF0,
  0x01, 0xE0, 0xF8, 0x01, 0xF0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E,
  0x00, 0x3C, 0x1F, 0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x07, 0x8F, 0x0F, 0x03,
  0xC7, 0x87, 0x81, 0xE7, 0xC7, 0x81, 0xE3, 0xF3, 0xC0, 0xF3, 0xB9, 0xE0,
  0x79, 0xDC, 0xF0, 0x3D, 0xCE, 0xF0, 0x1C, 0xE7, 0x78, 0x0E, 0xE3, 0xBC,
  0x0F, 0x71, 0xDC, 0x07, 0xF0, 0xFE, 0x03, 0xB8, 0x7F, 0x01, 0xF8, 0x3F,
  0x00, 0xFC, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xCF,
  0x80, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7D, 0xF0,
  0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x8F, 0x00, 0x07, 0xC3, 0xE0, 0x03, 0xE0,
  0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x07, 0x80, 0x7E, 0x01, 0xF0, 0x1F,
  0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x3E, 0xF8,
  0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x0F, 0xC7, 0x80, 0xF8, 0x78, 0x1F, 0x07,
  0xC3, 0xF0, 0x7C, 0x3E, 0x07, 0xC7, 0xC0, 0x3C, 0xF8, 0x03, 0xEF, 0x80,
  0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0x78, 0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C,
  0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E,
  0x1E, 0x1F, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x80,
  0x7C, 0x7C, 0x0F, 0x87, 0xC1, 0xF8, 0x7C, 0x3F, 0x03, 0xE7, 0xE0, 0x3E,
  0xFC, 0x03, 0xE7, 0x80, 0x1F, 0x30, 0x01, 0x80, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x30, 0x3C, 0x1F, 0x1F, 0xC3,
  0xF0, 0xFC, 0x1C, 0x04, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xF0,
  0xFF, 0xFF, 0x1F, 0xE1, 0xE1, 0xF8, 0x3E, 0x3F, 0x03, 0xE3, 0xE0, 0x3E,
  0x7C, 0x03, 0xC7, 0xC0, 0x7C, 0x78, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07,
  0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0x7C, 0x1F, 0x87, 0xFF,
  0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xE7, 0xC0, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0xF0, 0x07, 0xFF,
  0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFE, 0x3F, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1E,
  0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3C, 0x07, 0xC7,
  0xC1, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x80,
  0x01, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFE, 0x0C, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x01, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFC, 0x3E, 0x07, 0xE0, 0xF8,
  0x1F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x03,
  0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xE0, 0x7C,
  0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x3F, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFC, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0xF1, 0xF8, 0x7E, 0x7C, 0x07, 0xDF, 0x00,
  0xFB, 0xE0, 0x1F, 0xF8, 0x07, 0xDF, 0x07, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF,
  0x0F, 0xFF, 0x81, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x01,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x04, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x43, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0x87, 0xC0, 0xFC, 0x0F, 0x83,
  0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C,
  0x03, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0x78, 0x0F, 0xC3, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x07, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x30, 0x0F, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7D, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFC, 0x7F, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0x1F,
  0x1F, 0x01, 0xE1, 0xF0, 0x3E, 0x1E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03,
  0xC3, 0xE0, 0x7C, 0x3C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0x87, 0xC0,
  0xF8, 0x78, 0x0F, 0x8F, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x3F, 0xF8, 0xFF, 0xC3, 0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x30, 0x3E, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x10, 0x78, 0x1F, 0x83,
  0xE0, 0xFC, 0x0F, 0x87, 0xE0, 0x3E, 0x3F, 0x00, 0xF1, 0xF8, 0x07, 0xCF,
  0xC0, 0x1F, 0x7E, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3E, 0xF8, 0x00, 0xFB, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x0F, 0x80, 0x7C,
  0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x03, 0xE0, 0xF8, 0x0F,
  0x83, 0xE0, 0x3F, 0x00, 0x7F, 0xF3, 0xFF, 0x3F, 0xF9, 0xFF, 0xC0, 0x3E,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x5F, 0xFE,
  0x7F, 0xF3, 0xFF, 0x8F, 0xF8, 0x00, 0xF0, 0x70, 0x1F, 0xF7, 0xE0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0x1F, 0x3C, 0x3C, 0x78, 0xF0, 0xF1, 0xE3,
  0xC3, 0xC7, 0x8F, 0x1E, 0x1E, 0x3C, 0x78, 0xF1, 0xE1, 0xE3, 0xC7, 0x87,
  0x8F, 0x1E, 0x3C, 0x3C, 0x78, 0xF1, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00,
  0x3C, 0x7C, 0x00, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x1E, 0x1E, 0x00, 0x78,
  0xF8, 0x01, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF,
  0xF1, 0xF8, 0xFE, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1E, 0x03,
  0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x1F, 0x03, 0xE3, 0xC0, 0x7C, 0xF8, 0x0F,
  0x9F, 0x01, 0xE3, 0xE0, 0x7C, 0x78, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3C,
  0x7C, 0x0F, 0x8F, 0x81, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0xFF,
  0x07, 0xFF, 0xF1, 0xFC, 0x7E, 0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F,
  0x7C, 0x01, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xE0, 0x7E, 0x7C, 0x1F, 0x8F, 0xFF, 0xE1,
  0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7C, 0x1F, 0x83,
  0xE0, 0x7C, 0x1F, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x7C, 0x03,
  0xC3, 0xE0, 0x3E, 0x1E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0x7C,
  0x0F, 0xC3, 0xC0, 0xFC, 0x3E, 0x0F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xC3,
  0xE3, 0xF0, 0x3E, 0x7E, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xCF, 0x80,
  0x7C, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0xF8,
  0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0xD0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC1, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xE0, 0xFC, 0x0C, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xE0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x60, 0x1F, 0x8F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x7F, 0xFF, 0x03, 0xFF, 0x80, 0x02, 0x00, 0x00, 0x00, 0x20, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x10, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0x03, 0xE7, 0xC0, 0x7C, 0xF8,
  0x0F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0,
  0x7C, 0x7C, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F, 0x8F, 0x81,
  0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC1, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF,
  0xE1, 0xFF, 0xBC, 0x1F, 0xE7, 0xC0, 0xF8, 0x03, 0xFF, 0x00, 0xFD, 0xE0,
  0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x07, 0xC3, 0xE0,
  0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF1, 0xF0, 0x1E, 0x3E, 0x03, 0xCF,
  0x80, 0x7B, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x78,
  0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xC7, 0x87, 0x87, 0x8F, 0x0F, 0x0F, 0x1E,
  0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0x79, 0xF8, 0xF0, 0xF3, 0xF3, 0xC1, 0xCF,
  0xE7, 0x83, 0x9D, 0xCE, 0x07, 0x7B, 0xBC, 0x0E, 0xE7, 0xF8, 0x1F, 0xC7,
  0xE0, 0x7F, 0x0F, 0xC0, 0xFC, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xE0, 0x78,
  0x07, 0x80, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0xF8, 0x0F, 0x83,
  0xE0, 0x1F, 0x0F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7D, 0xF0, 0x01, 0xF3, 0xE0, 0x07,
  0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x7E, 0x07, 0xC1, 0xF8, 0x0F, 0x87, 0xE0,
  0x1F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF0,
  0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E,
  0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xC0, 0x61, 0xFE,
  0x0F, 0x3F, 0xF9, 0xF7, 0xFF, 0xFE, 0x79, 0xFF, 0xCF, 0x07, 0xFC, 0x60,
  0x1F, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 11, 28, 22, 6, -27 },
  { 40, 15, 12, 22, 7, -30 },
  { 63, 23, 27, 22, 0, -27 },
  { 141, 21, 34, 22, 1, -30 },
  { 231, 26, 29, 22, -1, -28 },
  { 326, 21, 28, 22, 0, -28 },
  { 400, 7, 13, 22, 11, -30 },
  { 412, 18, 38, 22, 4, -31 },
  { 498, 18, 38, 22, 0, -31 },
  { 584, 18, 17, 22, 4, -27 },
  { 623, 19, 19, 22, 2, -21 },
  { 669, 10, 14, 22, 3, -7 },
  { 687, 12, 5, 22, 5, -14 },
  { 695, 7, 8, 22, 6, -7 },
  { 702, 25, 38, 22, -2, -31 },
  { 821, 20, 29, 22, 2, -28 },
  { 894, 17, 27, 22, 2, -27 },
  { 952, 21, 28, 22, 0, -28 },
  { 1026, 21, 29, 22, 0, -28 },
  { 1103, 22, 27, 22, 0, -27 },
  { 1178, 23, 28, 22, 0, -27 },
  { 1259, 21, 28, 22, 2, -27 },
  { 1333, 20, 27, 22, 4, -27 },
  { 1401, 21, 29, 22, 1, -28 },
  { 1478, 21, 28, 22, 1, -28 },
  { 1552, 10, 22, 22, 6, -21 },
  { 1580, 13, 28, 22, 3, -21 },
  { 1626, 19, 18, 22, 2, -20 },
  { 1669, 21, 13, 22, 1, -18 },
  { 1704, 19, 18, 22, 1, -20 },
  { 1747, 16, 29, 22, 5, -28 },
  { 1805, 22, 34, 22, 1, -28 },
  { 1899, 21, 27, 22, -2, -27 },
  { 1970, 22, 27, 22, 0, -27 },
  { 2045, 21, 29, 22, 2, -28 },
  { 2122, 21, 27, 22, 0, -27 },
  { 2193, 22, 27, 22, 1, -27 },
  { 2268, 23, 27, 22, 1, -27 },
  { 2346, 21, 29, 22, 2, -28 },
  { 2423, 24, 27, 22, 0, -27 },
  { 2504, 23, 27, 22, 0, -27 },
  { 2582, 23, 28, 22, 0, -27 },
  { 2663, 24, 27, 22, 0, -27 },
  { 2744, 18, 27, 22, 0, -27 },
  { 2805, 24, 27, 22, -1, -27 },
  { 2886, 24, 27, 22, 0, -27 },
  { 2967, 21, 29, 22, 1, -28 },
  { 3044, 22, 27, 22, 0, -27 },
  { 3119, 21, 35, 22, 1, -28 },
  { 3211, 22, 27, 22, 0, -27 },
  { 3286, 22, 29, 22, 0, -28 },
  { 3366, 21, 27, 22, 4, -27 },
  { 3437, 23, 28, 22, 1, -27 },
  { 3518, 21, 27, 22, 4, -27 },
  { 3589, 25, 27, 22, 0, -27 },
  { 3674, 26, 27, 22, -1, -27 },
  { 3762, 20, 27, 22, 5, -27 },
  { 3830, 23, 27, 22, 0, -27 },
  { 3908, 21, 38, 22, 2, -31 },
  { 4008, 8, 38, 22, 8, -31 },
  { 4046, 21, 38, 22, -1, -31 },
  { 4146, 20, 15, 22, 2, -27 },
  { 4184, 21, 4, 22, -3, 3 },
  { 4195, 9, 8, 22, 9, -30 },
  { 4204, 20, 21, 22, 1, -21 },
  { 4257, 20, 31, 22, 0, -30 },
  { 4335, 19, 21, 22, 2, -21 },
  { 4385, 23, 30, 22, 1, -30 },
  { 4472, 19, 22, 22, 2, -21 },
  { 4525, 27, 37, 22, -3, -30 },
  { 4650, 23, 28, 22, -1, -21 },
  { 4731, 20, 30, 22, 0, -30 },
  { 4806, 14, 30, 22, 4, -30 },
  { 4859, 22, 37, 22, -2, -30 },
  { 4961, 22, 30, 22, 1, -30 },
  { 5044, 13, 30, 22, 5, -30 },
  { 5093, 22, 21, 22, -1, -21 },
  { 5151, 19, 21, 22, 1, -21 },
  { 5201, 19, 22, 22, 1, -21 },
  { 5254, 21, 28, 22, -1, -21 },
  { 5328, 20, 28, 22, 2, -21 },
  { 5398, 20, 21, 22, 2, -21 },
  { 5451, 19, 22, 22, 1, -21 },
  { 5504, 17, 27, 22, 4, -27 },
  { 5562, 19, 20, 22, 2, -20 },
  { 5610, 19, 20, 22, 3, -20 },
  { 5658, 23, 20, 22, 1, -20 },
  { 5716, 23, 20, 22, -1, -20 },
  { 5774, 25, 27, 22, -3, -20 },
  { 5859, 20, 20, 22, 1, -20 },
  { 5909, 21, 38, 22, 3, -31 },
  { 6009, 14, 38, 22, 4, -31 },
  { 6076, 21, 38, 22, -2, -31 },
  { 6176, 20, 7, 22, 1, -15 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic39pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic39pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic39pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC39PT7B_H_
