#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC40PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x7C, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x07, 0x80, 0x20, 0x00, 0x3E, 0x3F, 0x3E,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0x78,
  0x78, 0x70, 0x78, 0xF0, 0x70, 0xF0, 0x70, 0xE0, 0x70, 0x00, 0x1E, 0x1F,
  0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xE0,
  0x03, 0xC3, 0xC0, 0x07, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x07, 0x87, 0x80,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0x1E, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x3C, 0x00,
  0x78, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xF0, 0xF0, 0x7E, 0x00, 0x83,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC3, 0x80, 0x7E, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF8, 0x01, 0xE0, 0x7F, 0x00, 0x78,
  0x1F, 0xF0, 0x1E, 0x03, 0x8E, 0x07, 0x80, 0xF1, 0xC1, 0xE0, 0x1C, 0x38,
  0x78, 0x03, 0x87, 0x0E, 0x00, 0x71, 0xE3, 0xC0, 0x0E, 0x38, 0xF0, 0x01,
  0xCF, 0x3C, 0x00, 0x3F, 0xCF, 0x00, 0x07, 0xFB, 0xC0, 0x00, 0x7E, 0x70,
  0x00, 0x02, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0x79, 0xFC, 0x00, 0x1E, 0x7F, 0x80, 0x07, 0x9E, 0x78, 0x00, 0xE3, 0x8F,
  0x00, 0x3C, 0x71, 0xE0, 0x0F, 0x1E, 0x38, 0x03, 0xC3, 0x87, 0x00, 0xF0,
  0x70, 0xE0, 0x3C, 0x0E, 0x38, 0x07, 0x01, 0xFF, 0x01, 0xE0, 0x1F, 0xC0,
  0x78, 0x03, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0x00, 0x3F, 0xF8, 0x03, 0xF7, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0xF8, 0x0F,
  0x07, 0x80, 0x78, 0x3C, 0x03, 0xC3, 0xE0, 0x1E, 0x3E, 0x00, 0xF3, 0xE0,
  0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x3C, 0x1F, 0xE1, 0xE1, 0xFF,
  0x0F, 0x1F, 0x7C, 0xF1, 0xE1, 0xF7, 0x9F, 0x0F, 0xFC, 0xF0, 0x3F, 0xC7,
  0x80, 0xFC, 0x7C, 0x07, 0xE3, 0xE0, 0x3F, 0x0F, 0x83, 0xF8, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFE, 0x78, 0x3F, 0xC3, 0xE0, 0x3E, 0x7D, 0xFB,
  0xE7, 0xCF, 0x9E, 0x3C, 0xF9, 0xE3, 0xC7, 0x8E, 0x00, 0x00, 0x01, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x18, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x0E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x61, 0xE1, 0x9E, 0x79, 0xE7, 0xEE, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xBC, 0x07, 0xCF, 0x83,
  0xF3, 0xF0, 0x78, 0x78, 0x06, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x83, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xFC, 0x1E, 0x07, 0x87, 0xCF, 0xE3, 0xF0,
  0xF8, 0x30, 0x00, 0x7F, 0xFB, 0xFF, 0x9F, 0xFD, 0xFF, 0xEF, 0xFF, 0x00,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xC3, 0xF1,
  0xF8, 0x1F, 0x1F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x1F,
  0x7C, 0x01, 0xF7, 0xC7, 0x1F, 0x78, 0xF9, 0xFF, 0x9F, 0x9F, 0xF9, 0xF1,
  0xEF, 0x8F, 0x3E, 0xF8, 0x43, 0xEF, 0x00, 0x3E, 0xF0, 0x07, 0xCF, 0x00,
  0x7C, 0xF0, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0xFF,
  0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xF0, 0x7F,
  0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0x3E, 0x06, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0,
  0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7C,
  0x1F, 0x81, 0x80, 0x7C, 0x08, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x4F, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x18, 0x03, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x78, 0xF0, 0x03,
  0xC7, 0xC0, 0x1E, 0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xC1, 0xE0, 0x3E, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF8, 0x3C, 0x03, 0xC1, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x10, 0x07, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x01,
  0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFB, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xE7,
  0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3C, 0x7C, 0x03,
  0xE3, 0xE0, 0x1F, 0x0F, 0x81, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7E, 0x0F, 0x83,
  0xE0, 0x3C, 0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x7C, 0x07,
  0xC1, 0xF0, 0x7C, 0x0F, 0xCF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x01, 0xF7, 0xF0, 0x1F, 0x0F, 0xC1, 0xF0, 0x3F, 0x1F, 0x00, 0xF8,
  0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x80,
  0xF8, 0x7F, 0x3F, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFC, 0x1F, 0x8F, 0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F,
  0x1E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF1, 0xF0,
  0x0F, 0x8F, 0xE7, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x03, 0xFD, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x3F,
  0xF0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x81, 0xF8, 0x7F, 0x8F, 0xF1, 0xFC,
  0x3F, 0x83, 0xE0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x03, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x07, 0xC0, 0x20, 0x00,
  0x00, 0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F,
  0xC0, 0x1E, 0x00, 0x78, 0x07, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0x80, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00,
  0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x0F,
  0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x01,
  0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x00,
  0x08, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF1, 0x81, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x01,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFE,
  0x3F, 0x07, 0xE0, 0x3C, 0x3E, 0x00, 0xF0, 0xF0, 0x03, 0xC7, 0xC0, 0x0F,
  0x1E, 0x03, 0xFC, 0xF0, 0x7F, 0xF3, 0xC3, 0xFF, 0xDF, 0x1F, 0xFF, 0x78,
  0x7C, 0x79, 0xE3, 0xE1, 0xE7, 0x8F, 0x07, 0xBC, 0x7C, 0x3E, 0xF1, 0xE0,
  0xF3, 0xC7, 0x83, 0xCF, 0x1E, 0x0F, 0x3C, 0x78, 0x7C, 0xF1, 0xE1, 0xE3,
  0xC7, 0xC7, 0x8F, 0x1F, 0xFE, 0x3C, 0x3F, 0xF8, 0xF0, 0xFF, 0xC3, 0xE0,
  0xFF, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3C,
  0xF8, 0x01, 0xF3, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1E, 0x00, 0xF0, 0x78,
  0x07, 0xC1, 0xE0, 0x1E, 0x07, 0x80, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7C, 0x01,
  0xE1, 0xE0, 0x07, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x7D, 0xF0, 0x01, 0xF7,
  0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xE0, 0xFC, 0x1F, 0x01, 0xF0, 0x7C, 0x07,
  0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x3E, 0x01, 0xE0, 0xF8, 0x1F, 0x83,
  0xE7, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x1F, 0x01, 0xF0, 0x78, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E,
  0x3E, 0x01, 0xF0, 0xF0, 0x07, 0xC7, 0xC0, 0x3F, 0x1F, 0x03, 0xF8, 0x7F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xF0, 0x38,
  0x3F, 0x00, 0x40, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xC3, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0xC1, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07,
  0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0xC7,
  0xC0, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x0F, 0x80,
  0xFC, 0x7C, 0x03, 0xF1, 0xF0, 0x1F, 0x87, 0xC0, 0xFC, 0x1F, 0x0F, 0xF0,
  0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xF0, 0x30, 0x3F, 0x00, 0x41, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x3E, 0x00,
  0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0,
  0xF8, 0x07, 0xC3, 0xE0, 0x3E, 0x0F, 0xC0, 0xF8, 0x1F, 0x83, 0xE0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03,
  0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07,
  0xC0, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x04, 0x03, 0xF0, 0x1C, 0x0F, 0xC0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x18, 0x00,
  0x00, 0x03, 0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x7C,
  0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x0F,
  0x8F, 0xC0, 0x07, 0xCF, 0xC0, 0x07, 0xCF, 0xC0, 0x03, 0xEF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0xC0,
  0x07, 0xC3, 0xE0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3C, 0x01, 0xF0, 0x3E, 0x00,
  0xF8, 0x1F, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x0F, 0x80,
  0x78, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x83, 0xF0,
  0x1F, 0xC1, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0x71, 0xFE, 0x07, 0xB8, 0xEF,
  0x03, 0xDC, 0xF7, 0x81, 0xEE, 0x77, 0x81, 0xE7, 0x7B, 0xC0, 0xF3, 0xB9,
  0xE0, 0x79, 0xFC, 0xF0, 0x7C, 0xFC, 0x78, 0x3C, 0x7E, 0x78, 0x1E, 0x3E,
  0x3C, 0x0F, 0x1E, 0x1E, 0x0F, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x83, 0xC0,
  0x07, 0x81, 0xE0, 0x03, 0xC1, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xF0, 0x78,
  0x00, 0xF8, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x1F, 0x03, 0xF0, 0x1F,
  0x07, 0xF0, 0x1E, 0x07, 0xF0, 0x1E, 0x07, 0xF8, 0x1E, 0x07, 0xF8, 0x3E,
  0x0F, 0xF8, 0x3C, 0x0F, 0xB8, 0x3C, 0x0F, 0x3C, 0x3C, 0x0F, 0x3C, 0x7C,
  0x1F, 0x3C, 0x7C, 0x1F, 0x1C, 0x78, 0x1E, 0x1E, 0x78, 0x1E, 0x1E, 0xF8,
  0x3E, 0x1E, 0xF8, 0x3E, 0x0E, 0xF0, 0x3C, 0x0E, 0xF0, 0x3C, 0x0F, 0xF0,
  0x7C, 0x0F, 0xF0, 0x7C, 0x0F, 0xE0, 0x78, 0x07, 0xE0, 0x78, 0x07, 0xE0,
  0x78, 0x07, 0xE0, 0xF8, 0x07, 0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xC0,
  0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFC,
  0x3F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x00, 0xFB,
  0xE0, 0x07, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00,
  0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E,
  0x00, 0xF9, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xC3, 0xE0, 0x7E,
  0x1F, 0x87, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3E, 0x1F, 0xE0, 0x7C, 0x0F, 0xC1, 0xF0,
  0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x3E, 0x00,
  0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x7F, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFC, 0x3F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0x3E,
  0x00, 0xFB, 0xE0, 0x07, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xEF, 0x80, 0x1F,
  0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x03, 0xE7, 0xC0,
  0x1F, 0x3E, 0x00, 0xF9, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xC3,
  0xE0, 0x7E, 0x1F, 0x87, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xE1, 0xFC, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07,
  0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x3E, 0x0F, 0x81,
  0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00,
  0xFF, 0xFC, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF0,
  0x3E, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0x01, 0x80, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x08, 0x00, 0xF8,
  0x18, 0x03, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE8, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x3E,
  0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03,
  0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3,
  0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0,
  0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C,
  0x3E, 0x01, 0xF0, 0xF0, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x81, 0xF8, 0x3E,
  0x0F, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xEF, 0xC0, 0x0F,
  0xBF, 0x00, 0x7C, 0xFC, 0x01, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3E, 0x1F,
  0x01, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80,
  0x7C, 0x7C, 0x01, 0xF1, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3C, 0x00, 0x7D,
  0xF0, 0x01, 0xF7, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x07,
  0x83, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF8, 0x00,
  0xF0, 0x7C, 0x00, 0x78, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x0F, 0x00,
  0x1E, 0x0F, 0x80, 0x0F, 0x07, 0x87, 0x8F, 0x83, 0xC7, 0xC7, 0x81, 0xE3,
  0xE3, 0xC0, 0xF3, 0xF1, 0xE0, 0xF9, 0xF9, 0xF0, 0x79, 0xFC, 0xF0, 0x3C,
  0xEE, 0x78, 0x1E, 0xF7, 0x3C, 0x0F, 0x73, 0xBC, 0x07, 0x71, 0xDE, 0x07,
  0xB8, 0xEF, 0x03, 0xF8, 0x77, 0x01, 0xFC, 0x3F, 0x80, 0xFC, 0x0F, 0xC0,
  0x7E, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x07, 0xC0,
  0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0x3E,
  0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x03,
  0xF1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0xFC, 0x0F,
  0x80, 0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x0F,
  0xE0, 0x07, 0xC0, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0xFD, 0xF0,
  0x07, 0xCF, 0x80, 0x7C, 0x3C, 0x03, 0xE1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0,
  0x7C, 0x1F, 0x03, 0xE1, 0xF0, 0x0F, 0x1F, 0x00, 0x7D, 0xF8, 0x03, 0xEF,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xE0, 0x00, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x78,
  0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03,
  0xF7, 0xC0, 0x7E, 0x7C, 0x0F, 0xC7, 0xC0, 0xF8, 0x3E, 0x1F, 0x03, 0xE3,
  0xF0, 0x3E, 0x7E, 0x01, 0xFF, 0xC0, 0x1F, 0x78, 0x01, 0xE1, 0x00, 0x18,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x10,
  0x0E, 0x07, 0xC3, 0xF8, 0x3F, 0x07, 0xF0, 0x78, 0x0C, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFC, 0x1F, 0x0F, 0x80,
  0xF8, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1E,
  0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F,
  0x1F, 0x81, 0xF0, 0x7C, 0x1F, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x81, 0xFE, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0x07, 0xE1, 0xF0, 0x3F, 0x0F,
  0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F,
  0x8F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xE1, 0xF0,
  0x3F, 0x1F, 0x07, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x03,
  0xFF, 0xE0, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xE1, 0xFF, 0xFE, 0x1F, 0xC0, 0x43, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x01, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01,
  0xFF, 0xFE, 0x07, 0xF0, 0x7C, 0x0F, 0xC0, 0xF8, 0x3F, 0x03, 0xE0, 0x7C,
  0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3C, 0x0F, 0x00,
  0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x1F,
  0x81, 0xF0, 0x7F, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x07, 0xF8, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x07,
  0xFF, 0xF1, 0xFF, 0xFE, 0x7E, 0x07, 0xCF, 0x80, 0x7B, 0xE0, 0x0F, 0x7C,
  0x03, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xE1, 0xFF,
  0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x21, 0xFF,
  0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xF8, 0x40, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x04, 0x1F, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0x07, 0xC0, 0xFC, 0x0F, 0x83, 0xF0, 0x1F,
  0x07, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F,
  0xC7, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x30, 0x0F,
  0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x3E, 0x3E,
  0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x07, 0xC7,
  0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x0F, 0x80, 0x00, 0xF0,
  0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x80, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x47, 0xFF, 0x0F,
  0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x60, 0x7E, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x3E, 0x1F,
  0x80, 0xF8, 0xFC, 0x03, 0xE7, 0xE0, 0x1F, 0x3F, 0x00, 0x7D, 0xF8, 0x01,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xE7,
  0xC0, 0x0F, 0x9F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0,
  0x1F, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3F, 0x0F, 0x80, 0x7C, 0x00,
  0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x3F, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x8F,
  0xFE, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0x80, 0x03, 0xFC, 0xF8, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFD, 0xF0, 0xF1, 0xF1, 0xE1, 0xE3, 0xC3,
  0xC3, 0xC7, 0x8F, 0x87, 0x8F, 0x1E, 0x1F, 0x1E, 0x3C, 0x3C, 0x3C, 0x78,
  0x78, 0xF1, 0xF0, 0xF1, 0xE3, 0xC3, 0xE3, 0xC7, 0x87, 0x80, 0x0F, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0,
  0x03, 0xC3, 0xC0, 0x0F, 0x8F, 0x80, 0x1E, 0x00, 0x03, 0xFF, 0x80, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x83, 0xE1, 0xF0, 0x3F, 0x1F,
  0x03, 0xF1, 0xF0, 0x3E, 0x1F, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3,
  0xE0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C,
  0x7C, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F,
  0x00, 0x00, 0x0C, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xE1, 0xF8, 0x3F, 0x1F, 0x03, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF7,
  0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x3E,
  0xFC, 0x03, 0xEF, 0xC0, 0x7C, 0x7C, 0x0F, 0xC7, 0xC1, 0xF8, 0x7F, 0xFF,
  0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xC0,
  0xFC, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x0F, 0x80, 0x7C,
  0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C,
  0x07, 0xE1, 0xF0, 0x1F, 0x07, 0xC1, 0xFC, 0x3E, 0x0F, 0xE0, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x1F, 0x83, 0xE3, 0xF0, 0x3E, 0x7E, 0x03, 0xE7, 0xC0, 0x7E,
  0xFC, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F,
  0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xFC, 0x1F, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xC0, 0x41, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFE,
  0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xF8, 0x04, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x86, 0x00, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x03,
  0xFF, 0xC0, 0x01, 0x80, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xE0, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x60, 0xFF, 0xF8, 0x3F,
  0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0x01, 0xF1, 0xF0, 0x3E, 0x3E,
  0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x07, 0xC7,
  0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8,
  0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xFC, 0x3F,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xCF, 0x80, 0xFC,
  0x03, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x7C, 0x07, 0xC7,
  0xC0, 0xFC, 0x7C, 0x0F, 0x87, 0xC1, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xF0,
  0x7C, 0x3E, 0x03, 0xC7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x7C, 0xF0, 0x00,
  0xF1, 0xE0, 0x01, 0xE7, 0xC0, 0x03, 0xCF, 0x8F, 0x0F, 0x1E, 0x1E, 0x1E,
  0x3C, 0x3C, 0x3C, 0x78, 0xFC, 0xF0, 0xF1, 0xF9, 0xE1, 0xE7, 0xF3, 0xC3,
  0xDF, 0xEF, 0x07, 0x39, 0xDE, 0x0E, 0xF3, 0xBC, 0x1D, 0xC7, 0xF0, 0x3F,
  0x8F, 0xE0, 0xFE, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF0, 0x7C, 0x07, 0xC0,
  0xF8, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x7E, 0x03,
  0xE0, 0x7C, 0x03, 0xE0, 0xF8, 0x01, 0xF1, 0xF0, 0x01, 0xF3, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0xEF, 0x80, 0x07, 0xC7, 0xC0, 0x0F, 0xC7, 0xC0, 0x1F, 0x83, 0xE0, 0x3F,
  0x03, 0xE0, 0x7E, 0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1F,
  0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF8,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00,
  0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x40, 0xFF, 0x03, 0xCF, 0xFC, 0x3C,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7C, 0x7F, 0xF3, 0xC0, 0xFF, 0x06, 0x03,
  0xE0,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 12, 29, 22, 6, -28 },
  { 45, 16, 12, 22, 7, -30 },
  { 69, 24, 28, 22, 0, -28 },
  { 153, 21, 35, 22, 1, -31 },
  { 245, 27, 29, 22, -1, -28 },
  { 343, 21, 28, 22, 0, -28 },
  { 417, 7, 13, 22, 11, -30 },
  { 429, 17, 40, 22, 5, -32 },
  { 514, 18, 40, 22, 0, -32 },
  { 604, 18, 18, 22, 4, -28 },
  { 645, 19, 20, 22, 2, -22 },
  { 693, 10, 14, 22, 3, -7 },
  { 711, 13, 5, 22, 5, -14 },
  { 720, 7, 8, 22, 6, -7 },
  { 727, 26, 38, 22, -2, -31 },
  { 851, 20, 29, 22, 2, -28 },
  { 924, 17, 28, 22, 2, -28 },
  { 984, 21, 28, 22, 1, -28 },
  { 1058, 22, 29, 22, 0, -28 },
  { 1138, 22, 28, 22, 0, -28 },
  { 1215, 23, 29, 22, 0, -28 },
  { 1299, 21, 29, 22, 2, -28 },
  { 1376, 21, 28, 22, 4, -28 },
  { 1450, 21, 29, 22, 1, -28 },
  { 1527, 21, 28, 22, 1, -28 },
  { 1601, 11, 22, 22, 6, -21 },
  { 1632, 14, 28, 22, 3, -21 },
  { 1681, 20, 19, 22, 2, -21 },
  { 1729, 21, 13, 22, 1, -18 },
  { 1764, 20, 19, 22, 1, -21 },
  { 1812, 17, 29, 22, 5, -28 },
  { 1874, 22, 34, 22, 1, -28 },
  { 1968, 22, 28, 22, -2, -28 },
  { 2045, 22, 28, 22, 0, -28 },
  { 2122, 22, 29, 22, 2, -28 },
  { 2202, 22, 28, 22, 0, -28 },
  { 2279, 23, 28, 22, 1, -28 },
  { 2360, 23, 28, 22, 1, -28 },
  { 2441, 22, 29, 22, 2, -28 },
  { 2521, 24, 28, 22, 0, -28 },
  { 2605, 24, 28, 22, 0, -28 },
  { 2689, 23, 29, 22, 0, -28 },
  { 2773, 25, 28, 22, 0, -28 },
  { 2861, 18, 28, 22, 0, -28 },
  { 2924, 25, 28, 22, -1, -28 },
  { 3012, 24, 28, 22, 0, -28 },
  { 3096, 21, 29, 22, 2, -28 },
  { 3173, 23, 28, 22, 0, -28 },
  { 3254, 21, 36, 22, 2, -28 },
  { 3349, 22, 28, 22, 0, -28 },
  { 3426, 23, 29, 22, 0, -28 },
  { 3510, 21, 28, 22, 4, -28 },
  { 3584, 22, 29, 22, 2, -28 },
  { 3664, 22, 28, 22, 4, -28 },
  { 3741, 25, 28, 22, 0, -28 },
  { 3829, 28, 28, 22, -2, -28 },
  { 3927, 21, 28, 22, 5, -28 },
  { 4001, 24, 28, 22, 0, -28 },
  { 4085, 22, 38, 22, 2, -31 },
  { 4190, 8, 38, 22, 8, -31 },
  { 4228, 21, 38, 22, -1, -31 },
  { 4328, 20, 16, 22, 2, -28 },
  { 4368, 21, 4, 22, -3, 3 },
  { 4379, 10, 8, 22, 9, -31 },
  { 4389, 21, 21, 22, 1, -21 },
  { 4445, 21, 32, 22, 0, -31 },
  { 4529, 20, 21, 22, 2, -21 },
  { 4582, 23, 31, 22, 1, -31 },
  { 4672, 19, 23, 22, 2, -22 },
  { 4727, 28, 39, 22, -3, -31 },
  { 4864, 23, 29, 22, -1, -21 },
  { 4948, 20, 31, 22, 0, -31 },
  { 5026, 14, 31, 22, 4, -31 },
  { 5081, 23, 39, 22, -2, -31 },
  { 5194, 22, 31, 22, 1, -31 },
  { 5280, 14, 31, 22, 5, -31 },
  { 5335, 23, 21, 22, -1, -21 },
  { 5396, 20, 21, 22, 1, -21 },
  { 5449, 20, 23, 22, 1, -22 },
  { 5507, 22, 28, 22, -1, -21 },
  { 5584, 20, 28, 22, 2, -21 },
  { 5654, 20, 21, 22, 2, -21 },
  { 5707, 20, 23, 22, 1, -22 },
  { 5765, 18, 27, 22, 4, -27 },
  { 5826, 20, 21, 22, 2, -21 },
  { 5879, 20, 21, 22, 3, -21 },
  { 5932, 23, 21, 22, 1, -21 },
  { 5993, 24, 21, 22, -1, -21 },
  { 6056, 26, 29, 22, -3, -21 },
  { 6151, 21, 21, 22, 1, -21 },
  { 6207, 21, 38, 22, 3, -31 },
  { 6307, 15, 38, 22, 4, -31 },
  { 6379, 22, 38, 22, -2, -31 },
  { 6484, 21, 8, 22, 1, -16 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic40pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic40pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic40pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC40PT7B_H_
