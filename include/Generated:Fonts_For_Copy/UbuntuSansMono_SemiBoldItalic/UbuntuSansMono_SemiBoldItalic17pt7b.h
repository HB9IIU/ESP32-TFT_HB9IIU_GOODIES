#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC17PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x61, 0x8E, 0x38, 0xC3, 0x0C, 0x01, 0x8E, 0x18, 0x6E, 0xDB,
  0x36, 0x6C, 0x80, 0x06, 0xC3, 0x30, 0xD9, 0xFF, 0x7F, 0xC4, 0xC3, 0x23,
  0xFE, 0xFF, 0x9B, 0x04, 0xC3, 0x60, 0x03, 0x01, 0x07, 0xE7, 0x13, 0x01,
  0xC0, 0x70, 0x1E, 0x03, 0x01, 0x90, 0xDF, 0xE3, 0xC0, 0xC0, 0xC0, 0x1C,
  0x31, 0x66, 0x34, 0xC2, 0x48, 0x3D, 0x01, 0xA0, 0x06, 0x80, 0xDC, 0x1A,
  0x43, 0x24, 0x22, 0xCC, 0x38, 0x0F, 0x0F, 0x84, 0x46, 0x61, 0x60, 0xE0,
  0xF6, 0xDB, 0xC7, 0x63, 0x3B, 0xCF, 0x60, 0xFB, 0x69, 0x00, 0x06, 0x1C,
  0x71, 0xC7, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x0C, 0x1C, 0x10,
  0x0C, 0x0E, 0x06, 0x06, 0x03, 0x03, 0x03, 0x07, 0x06, 0x06, 0x0E, 0x0C,
  0x18, 0x30, 0xE0, 0x40, 0x18, 0x23, 0x5F, 0xF3, 0x8D, 0x9B, 0x94, 0x0C,
  0x08, 0x18, 0xFF, 0xFF, 0x10, 0x30, 0x30, 0x33, 0xCE, 0x6E, 0x60, 0x7F,
  0xE0, 0x6F, 0x60, 0x00, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0x1E, 0x3F, 0x73, 0x63, 0xC3, 0xDB, 0xDB, 0xC3, 0xC6, 0xC6, 0xFC,
  0x78, 0x06, 0x1C, 0xFB, 0xE0, 0xC1, 0x87, 0x0C, 0x18, 0x33, 0xFF, 0xF0,
  0x0F, 0x1F, 0xC4, 0x60, 0x30, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x1F,
  0xDF, 0xE0, 0x1F, 0x0F, 0xC0, 0x60, 0x30, 0x38, 0xF0, 0x7C, 0x06, 0x03,
  0x01, 0xBF, 0xDF, 0xC0, 0x01, 0x81, 0xC1, 0xE1, 0xB1, 0xB1, 0x99, 0x8C,
  0xFF, 0xFF, 0x83, 0x01, 0x80, 0xC0, 0x0F, 0xC7, 0xF1, 0x80, 0x60, 0x10,
  0x0F, 0x80, 0xF0, 0x0C, 0x03, 0x00, 0xCF, 0xF3, 0xF8, 0x03, 0x8F, 0xCE,
  0x0E, 0x06, 0x07, 0xF3, 0x9D, 0x86, 0xC3, 0x63, 0xBB, 0x8F, 0x80, 0x7F,
  0xFF, 0x81, 0x81, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18,
  0x00, 0x1E, 0x1F, 0x98, 0xEC, 0x67, 0x31, 0xF1, 0xF9, 0x8C, 0xC7, 0x63,
  0x3B, 0x8F, 0x80, 0x0F, 0x1F, 0xCC, 0x66, 0x37, 0x19, 0x8C, 0xFE, 0x13,
  0x03, 0x03, 0x1F, 0x1E, 0x00, 0x39, 0xCE, 0x00, 0x01, 0x9E, 0x60, 0x1C,
  0x71, 0xC0, 0x00, 0x03, 0x1E, 0x38, 0xCE, 0x30, 0x01, 0x07, 0x3E, 0xF0,
  0xE0, 0x78, 0x1E, 0x06, 0x7F, 0xBF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x20,
  0x3C, 0x07, 0x80, 0xF0, 0x79, 0xF3, 0xE1, 0x80, 0x3C, 0xFC, 0x18, 0x30,
  0xC3, 0x0C, 0x30, 0x00, 0xC3, 0x87, 0x00, 0x0F, 0x87, 0x73, 0x0C, 0xC3,
  0x67, 0xDB, 0x24, 0x99, 0x66, 0xD9, 0xB7, 0x64, 0xF1, 0x80, 0x60, 0x0F,
  0x80, 0xC0, 0x03, 0x81, 0xC1, 0xE1, 0xB0, 0xD8, 0xCC, 0x66, 0x7F, 0x3F,
  0xB0, 0xD8, 0x78, 0x30, 0x1F, 0x0F, 0xCC, 0x66, 0x33, 0x19, 0xF9, 0xFC,
  0xC3, 0x61, 0xB1, 0xFF, 0xDF, 0xC0, 0x0F, 0x9F, 0xCC, 0x2C, 0x06, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0x8F, 0xC0, 0x1E, 0x1F, 0xCC, 0x66,
  0x33, 0x1B, 0x8D, 0x86, 0xC3, 0x63, 0x73, 0xBF, 0x9F, 0x80, 0x1F, 0xC7,
  0xF1, 0x80, 0xE0, 0x30, 0x0F, 0xC3, 0xF1, 0xC0, 0x60, 0x18, 0x07, 0xF3,
  0xFC, 0x1F, 0xC7, 0xF1, 0x80, 0xE0, 0x30, 0x0F, 0xE3, 0xF0, 0xC0, 0x60,
  0x18, 0x06, 0x03, 0x80, 0x0F, 0x9F, 0xDC, 0x2C, 0x0E, 0x06, 0x03, 0x0D,
  0x86, 0xC6, 0x63, 0x3F, 0x8F, 0xC0, 0x18, 0xCC, 0x33, 0x0C, 0xC7, 0x31,
  0x9F, 0xE7, 0xF9, 0x86, 0x63, 0x38, 0xCC, 0x33, 0x1C, 0x1F, 0xC7, 0xF0,
  0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x07, 0xF3, 0xF8,
  0x0F, 0xC7, 0xF0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x11,
  0xCF, 0xE1, 0xF0, 0x18, 0xE7, 0x38, 0xCE, 0x1B, 0x83, 0xE0, 0x78, 0x1F,
  0x03, 0x70, 0x66, 0x0C, 0xE3, 0x0C, 0x61, 0x80, 0x18, 0x18, 0x38, 0x30,
  0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x7F, 0xFE, 0x0C, 0x61, 0x8C, 0x73,
  0x8A, 0xF1, 0x56, 0x6E, 0x8D, 0xB1, 0xB6, 0x60, 0xCC, 0x19, 0x86, 0x70,
  0xC0, 0x18, 0xCE, 0x33, 0x8C, 0xF3, 0x3D, 0x9B, 0x66, 0x59, 0x96, 0x67,
  0x31, 0xCC, 0x33, 0x0C, 0x1E, 0x1F, 0x9C, 0xCC, 0x7C, 0x3E, 0x1B, 0x0D,
  0x86, 0xC7, 0x63, 0x3F, 0x0F, 0x00, 0x1F, 0x07, 0xE3, 0x1C, 0xC3, 0x31,
  0xCC, 0x67, 0xF1, 0xF8, 0x60, 0x18, 0x0E, 0x03, 0x00, 0x1E, 0x1F, 0x9C,
  0xCC, 0x7C, 0x3E, 0x1B, 0x0D, 0x86, 0xC7, 0x63, 0x3F, 0x0F, 0x03, 0x01,
  0xC0, 0x70, 0x1F, 0x1F, 0xCC, 0x66, 0x33, 0x19, 0x9D, 0xFC, 0xFC, 0x66,
  0x33, 0x30, 0xD8, 0x60, 0x0F, 0xC7, 0xE3, 0x00, 0xC0, 0x38, 0x07, 0x80,
  0xF0, 0x0C, 0x03, 0x00, 0xCF, 0xF3, 0xF8, 0xFF, 0xFF, 0x86, 0x03, 0x03,
  0x81, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x00, 0x31, 0xB0, 0xD8,
  0x6C, 0x66, 0x36, 0x1B, 0x0D, 0x8E, 0xC6, 0x63, 0x3F, 0x0F, 0x80, 0xC1,
  0xE1, 0xB0, 0xD8, 0xCC, 0x66, 0x63, 0x31, 0xB0, 0xD8, 0x78, 0x3C, 0x1C,
  0x00, 0x30, 0x66, 0x08, 0xC3, 0x10, 0x66, 0x4C, 0xD9, 0x1B, 0x62, 0xAC,
  0x57, 0x0C, 0xE3, 0x9C, 0x63, 0x80, 0x1C, 0x70, 0xC6, 0x0C, 0xC0, 0x78,
  0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x1B, 0x83, 0x98, 0x31, 0x8E, 0x18,
  0xC1, 0xE1, 0xB1, 0xCC, 0xC6, 0xC3, 0xE1, 0xE0, 0x60, 0x30, 0x30, 0x18,
  0x0C, 0x00, 0x1F, 0xCF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x81, 0xC0, 0x60,
  0x30, 0x18, 0x0F, 0xF3, 0xFC, 0x0F, 0x86, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x03, 0xF1, 0xF0, 0xCC,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x67, 0x33, 0x1F, 0x81, 0x80, 0xC0, 0x60,
  0x70, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC3, 0xE1,
  0xF0, 0x0E, 0x0E, 0x1E, 0x37, 0x63, 0xE3, 0x43, 0xFF, 0xFF, 0x80, 0x4E,
  0x30, 0x1F, 0x7F, 0xE3, 0xC6, 0xC6, 0xC6, 0xC6, 0xFE, 0xFE, 0x18, 0x0C,
  0x06, 0x06, 0x03, 0xF1, 0xFC, 0xC6, 0xE3, 0x61, 0xB1, 0xD8, 0xDF, 0xCF,
  0xC0, 0x1F, 0x7F, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0x7E, 0x01, 0x80,
  0xC0, 0x60, 0x61, 0xF3, 0xF9, 0x8D, 0x8E, 0xC6, 0x63, 0x31, 0x9F, 0xC7,
  0xE0, 0x1E, 0x7F, 0x63, 0xC3, 0xFE, 0xF8, 0xC0, 0xFE, 0x7E, 0x01, 0xF0,
  0x3E, 0x07, 0x00, 0x60, 0x1F, 0xE1, 0xFC, 0x06, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0xF8, 0x0F, 0x00, 0x07, 0xC7,
  0xF1, 0x8C, 0xC3, 0x31, 0x8C, 0x63, 0x38, 0xFE, 0x03, 0x00, 0xC7, 0xF3,
  0xF0, 0x18, 0x0C, 0x06, 0x07, 0x03, 0xF1, 0xF8, 0xCE, 0xE7, 0x63, 0x31,
  0x98, 0xDC, 0xEC, 0x60, 0x18, 0xE1, 0x00, 0xFB, 0xC3, 0x0C, 0x71, 0x86,
  0x1F, 0x3C, 0x01, 0xC0, 0x70, 0x08, 0x00, 0x1F, 0x87, 0xE0, 0x18, 0x0E,
  0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x87, 0xE3, 0xF0, 0x1C, 0x06,
  0x01, 0x80, 0x60, 0x39, 0xCC, 0xE3, 0x70, 0xF0, 0x7C, 0x1B, 0x06, 0x61,
  0x9C, 0xE3, 0x00, 0x7B, 0xE1, 0x8C, 0x30, 0xC3, 0x18, 0x61, 0x86, 0x1F,
  0x7C, 0x3F, 0x9F, 0xDB, 0x6D, 0xB6, 0xDA, 0x4F, 0x05, 0x86, 0xC3, 0x00,
  0x3F, 0x1F, 0xCC, 0x66, 0x36, 0x33, 0x19, 0x8C, 0xC6, 0xC6, 0x00, 0x3E,
  0x7F, 0xE3, 0xC3, 0xC3, 0xC7, 0xC6, 0xFC, 0x78, 0x1F, 0x87, 0xF1, 0x8C,
  0xE3, 0x30, 0xCC, 0x73, 0x19, 0xFC, 0x7E, 0x18, 0x06, 0x03, 0x80, 0x1F,
  0x7F, 0x63, 0xC3, 0xC6, 0xC6, 0xC6, 0xFE, 0x7C, 0x0C, 0x0C, 0x1C, 0x3F,
  0x3F, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0x1F, 0x9F, 0x8C, 0x07,
  0x01, 0xE0, 0x38, 0x0C, 0xFE, 0xFE, 0x00, 0x08, 0x60, 0xC7, 0xFF, 0xEC,
  0x18, 0x30, 0xE1, 0x83, 0xF3, 0xE0, 0x63, 0x63, 0x63, 0xC6, 0xC6, 0xC6,
  0xC6, 0xFE, 0xFE, 0xE3, 0xB1, 0x98, 0xCC, 0xC6, 0x63, 0x61, 0xE0, 0xF0,
  0x30, 0x00, 0xC1, 0xE0, 0xF6, 0x5B, 0x6B, 0xB5, 0x53, 0xB9, 0x9C, 0xCC,
  0x00, 0x31, 0xCC, 0xE1, 0xB0, 0x78, 0x0C, 0x07, 0x83, 0x61, 0x9C, 0xC3,
  0x00, 0x18, 0xE3, 0x18, 0x63, 0x0C, 0xC1, 0x98, 0x36, 0x06, 0xC0, 0x70,
  0x0E, 0x01, 0x83, 0xE0, 0x78, 0x00, 0x3F, 0x9F, 0xC1, 0xC1, 0xC1, 0xC1,
  0xC0, 0xC0, 0xFE, 0xFE, 0x00, 0x07, 0x86, 0x03, 0x01, 0x01, 0x80, 0xC0,
  0x61, 0xE0, 0xF0, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0xF0, 0x78, 0x0C,
  0x61, 0x86, 0x18, 0xC3, 0x0C, 0x31, 0xC6, 0x18, 0x63, 0x8C, 0x30, 0x0F,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x03, 0x83, 0x01, 0x01,
  0x80, 0xC0, 0x61, 0xE1, 0xF0, 0x10, 0xBE, 0xFB, 0xC8, 0xC0,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 12, 10, 2, -12 },
  { 10, 7, 5, 10, 3, -13 },
  { 15, 10, 12, 10, 0, -12 },
  { 30, 9, 15, 10, 0, -13 },
  { 47, 12, 12, 10, -1, -12 },
  { 65, 9, 12, 10, 0, -12 },
  { 79, 3, 6, 10, 5, -13 },
  { 82, 7, 16, 10, 2, -13 },
  { 96, 8, 16, 10, 0, -13 },
  { 112, 7, 8, 10, 2, -12 },
  { 119, 8, 8, 10, 1, -9 },
  { 127, 5, 6, 10, 1, -3 },
  { 131, 6, 2, 10, 2, -6 },
  { 133, 4, 3, 10, 2, -3 },
  { 135, 11, 16, 10, -1, -13 },
  { 157, 8, 12, 10, 1, -12 },
  { 169, 7, 12, 10, 1, -12 },
  { 180, 9, 12, 10, 0, -12 },
  { 194, 9, 12, 10, 0, -12 },
  { 208, 9, 12, 10, 0, -12 },
  { 222, 10, 12, 10, 0, -12 },
  { 237, 9, 12, 10, 1, -12 },
  { 251, 9, 12, 10, 2, -12 },
  { 265, 9, 12, 10, 1, -12 },
  { 279, 9, 12, 10, 0, -12 },
  { 293, 5, 9, 10, 2, -9 },
  { 299, 6, 12, 10, 1, -9 },
  { 308, 8, 8, 10, 1, -9 },
  { 316, 9, 6, 10, 0, -8 },
  { 323, 9, 8, 10, 0, -9 },
  { 332, 7, 12, 10, 2, -12 },
  { 343, 10, 15, 10, 0, -12 },
  { 362, 9, 12, 10, -1, -12 },
  { 376, 9, 12, 10, 0, -12 },
  { 390, 9, 12, 10, 1, -12 },
  { 404, 9, 12, 10, 0, -12 },
  { 418, 10, 12, 10, 0, -12 },
  { 433, 10, 12, 10, 0, -12 },
  { 448, 9, 12, 10, 1, -12 },
  { 462, 10, 12, 10, 0, -12 },
  { 477, 10, 12, 10, 0, -12 },
  { 492, 10, 12, 10, 0, -12 },
  { 507, 11, 12, 10, 0, -12 },
  { 524, 8, 12, 10, 0, -12 },
  { 536, 11, 12, 10, -1, -12 },
  { 553, 10, 12, 10, 0, -12 },
  { 568, 9, 12, 10, 1, -12 },
  { 582, 10, 12, 10, 0, -12 },
  { 597, 9, 15, 10, 1, -12 },
  { 614, 9, 12, 10, 0, -12 },
  { 628, 10, 12, 10, 0, -12 },
  { 643, 9, 12, 10, 2, -12 },
  { 657, 9, 12, 10, 1, -12 },
  { 671, 9, 12, 10, 2, -12 },
  { 685, 11, 12, 10, 0, -12 },
  { 702, 12, 12, 10, -1, -12 },
  { 720, 9, 12, 10, 2, -12 },
  { 734, 10, 12, 10, 0, -12 },
  { 749, 9, 16, 10, 1, -13 },
  { 767, 4, 16, 10, 3, -13 },
  { 775, 9, 16, 10, 0, -13 },
  { 793, 8, 7, 10, 1, -12 },
  { 800, 9, 2, 10, -1, 1 },
  { 803, 4, 3, 10, 4, -13 },
  { 805, 8, 9, 10, 1, -9 },
  { 814, 9, 13, 10, 0, -13 },
  { 829, 8, 9, 10, 1, -9 },
  { 838, 9, 13, 10, 1, -13 },
  { 853, 8, 9, 10, 1, -9 },
  { 862, 12, 16, 10, -1, -13 },
  { 886, 10, 12, 10, -1, -9 },
  { 901, 9, 13, 10, 0, -13 },
  { 916, 6, 13, 10, 2, -13 },
  { 926, 10, 16, 10, -1, -13 },
  { 946, 10, 13, 10, 0, -13 },
  { 963, 6, 13, 10, 2, -13 },
  { 973, 9, 9, 10, 0, -9 },
  { 984, 9, 9, 10, 0, -9 },
  { 995, 8, 9, 10, 1, -9 },
  { 1004, 10, 12, 10, -1, -9 },
  { 1019, 8, 12, 10, 1, -9 },
  { 1031, 8, 9, 10, 1, -9 },
  { 1040, 9, 9, 10, 0, -9 },
  { 1051, 7, 12, 10, 2, -12 },
  { 1062, 8, 9, 10, 1, -9 },
  { 1071, 9, 9, 10, 1, -9 },
  { 1082, 9, 9, 10, 1, -9 },
  { 1093, 10, 9, 10, 0, -9 },
  { 1105, 11, 12, 10, -1, -9 },
  { 1122, 9, 9, 10, 0, -9 },
  { 1133, 9, 16, 10, 1, -13 },
  { 1151, 6, 16, 10, 2, -13 },
  { 1163, 9, 16, 10, -1, -13 },
  { 1181, 9, 4, 10, 0, -7 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic17pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic17pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic17pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC17PT7B_H_
