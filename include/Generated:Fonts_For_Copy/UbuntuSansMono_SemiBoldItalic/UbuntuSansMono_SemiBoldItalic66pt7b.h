#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC66PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xE0, 0x7F, 0x9F, 0xF0, 0x7F, 0xCF,
  0xF8, 0x3F, 0xE7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x0F, 0xF9,
  0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF,
  0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x3F, 0xC3, 0xF0, 0x1F,
  0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01,
  0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xC3, 0xFC, 0x00, 0xFF, 0xC0, 0x03,
  0x80, 0x0F, 0xF8, 0x00, 0x08, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x10, 0x00, 0x03, 0xFE, 0x01, 0xC0, 0x00,
  0x7F, 0xC0, 0x1F, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF7, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x3E, 0x00, 0x3F, 0x00, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0x01, 0xF8,
  0x3E, 0x00, 0xFC, 0x00, 0x1F, 0x83, 0xE0, 0x1F, 0x80, 0x01, 0xF0, 0x3E,
  0x03, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x3E, 0x07,
  0xE0, 0x00, 0x3F, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x1F, 0x80,
  0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x7E, 0x00, 0x00,
  0x3F, 0x1F, 0x8F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0xE3, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xC7, 0xFF, 0x00,
  0x00, 0x01, 0xF8, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xF1, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x0F, 0xC0, 0x00, 0x0F,
  0xC3, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x07,
  0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x7C, 0x0F, 0x80, 0x00, 0xFE, 0x07, 0xC0,
  0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0x01, 0xF8, 0x0F, 0xC1, 0xF8,
  0x00, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x00,
  0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x07, 0xF0, 0x07,
  0xE0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0x01, 0xFF, 0xF0, 0x1F,
  0xC0, 0xFF, 0xFE, 0x07, 0xF0, 0x7F, 0xFF, 0x81, 0xF8, 0x3F, 0xCF, 0xF0,
  0xFE, 0x1F, 0xE3, 0xFE, 0x3F, 0x8F, 0xF0, 0x7F, 0x9F, 0xC3, 0xF8, 0x0F,
  0xF7, 0xF1, 0xFC, 0x03, 0xFF, 0xF8, 0x7F, 0x00, 0x7F, 0xFE, 0x3F, 0xC0,
  0x0F, 0xFF, 0x0F, 0xE0, 0x03, 0xFF, 0x83, 0xF8, 0x00, 0x7F, 0xE0, 0xFE,
  0x00, 0x1F, 0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x83,
  0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0xF1,
  0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0x80, 0x7F, 0xF0, 0x0F, 0xF0, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F,
  0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF0, 0x7F,
  0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x02, 0x01, 0xFC, 0x00, 0x0E, 0x07, 0xF0, 0x38,
  0x7E, 0x0F, 0x83, 0xF1, 0xFE, 0x3E, 0x3F, 0xC7, 0xFC, 0xF9, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x40, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0,
  0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x30, 0x07, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0xFF, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xF8, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xF8, 0x07, 0xF0, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xC7, 0xF8, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xE0,
  0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xE3, 0xFC, 0x04,
  0x03, 0xF8, 0xFF, 0x07, 0xC0, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x9F, 0xE1,
  0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0x87, 0xF9, 0xFE, 0x1F, 0xE1, 0xFE, 0x7F,
  0x07, 0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0x3F, 0xCF, 0xF0, 0x7F, 0x0F, 0xF3,
  0xFC, 0x0F, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF0,
  0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFB, 0xFC, 0x03,
  0xFF, 0x7F, 0xC0, 0x3F, 0xC7, 0xF8, 0x01, 0xF0, 0x7F, 0x80, 0x1C, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0xE0, 0x07, 0x80, 0x07, 0xFC, 0x00, 0xC0, 0x00, 0x7F, 0x80, 0x10,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x0F, 0xFE,
  0x00, 0x0E, 0x00, 0x3F, 0xE0, 0x00, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x10, 0x00, 0x03, 0xFE, 0x03, 0x80, 0x00, 0xFF, 0xE0,
  0x3F, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x40, 0x00, 0x0F, 0xF8, 0x01, 0x80, 0x00,
  0xFF, 0xE0, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x07, 0x00, 0x00,
  0x7F, 0x9F, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC1, 0xFE,
  0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xE0, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xF8, 0x0F,
  0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x07, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x07, 0xFE, 0x7F,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xF9, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x83,
  0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xCF, 0xF0, 0x00, 0x02, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xE0, 0x1F, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x7E, 0x07, 0xFF, 0x0E, 0x00, 0x3F, 0xE1, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0xFE,
  0x1F, 0xC0, 0x1F, 0xFF, 0xF0, 0xFE, 0x03, 0xFF, 0xFF, 0x87, 0xE0, 0x3F,
  0xFF, 0xFC, 0x7F, 0x03, 0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F,
  0x81, 0xFF, 0x07, 0xF1, 0xFC, 0x1F, 0xE0, 0x7F, 0x8F, 0xE0, 0xFE, 0x03,
  0xF8, 0x7E, 0x0F, 0xF0, 0x1F, 0xC3, 0xF0, 0x7F, 0x00, 0xFE, 0x3F, 0x83,
  0xF8, 0x07, 0xF1, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE1, 0xFC, 0x03, 0xF8,
  0x7E, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0x83, 0xF8,
  0x0F, 0xE0, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0xFE, 0x03, 0xF8, 0x3F,
  0x07, 0xF0, 0x1F, 0xC1, 0xF8, 0x3F, 0x81, 0xFE, 0x0F, 0xC1, 0xFE, 0x0F,
  0xE0, 0x7E, 0x0F, 0xF8, 0x7F, 0x03, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0x81,
  0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0x80, 0x7F, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x60, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0x7F, 0x87, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x1F,
  0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x1F,
  0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xBF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xE3, 0xFE, 0x01, 0xFF, 0xE0,
  0x07, 0x80, 0x3F, 0xF0, 0x00, 0x20, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x10,
  0x03, 0xFF, 0x00, 0x0E, 0x00, 0x7F, 0xFC, 0x0F, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x07, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF0,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x1F,
  0xF0, 0x3F, 0xC0, 0x03, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xC0,
  0x0F, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xC1, 0xFC,
  0x00, 0xFF, 0xE0, 0x03, 0xC0, 0x1F, 0xF8, 0x00, 0x08, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07,
  0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0x00, 0x01,
  0xFF, 0x00, 0x0E, 0x00, 0x0F, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x00,
  0x3F, 0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x1F, 0xE0,
  0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFD, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0x3F,
  0xC1, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x81, 0xF7, 0xE0, 0x03, 0xF7,
  0xC1, 0xFB, 0xF0, 0x03, 0xF3, 0xE0, 0xFB, 0xF0, 0x01, 0xF9, 0xF0, 0xFD,
  0xF8, 0x00, 0xFC, 0xF8, 0x7C, 0xFC, 0x00, 0xFE, 0x7C, 0x7E, 0x7E, 0x00,
  0x7E, 0x3E, 0x3E, 0x7F, 0x00, 0x3F, 0x1F, 0x3F, 0x3F, 0x80, 0x3F, 0x8F,
  0x9F, 0x1F, 0x80, 0x1F, 0xC7, 0xDF, 0x8F, 0xC0, 0x0F, 0xC3, 0xEF, 0x8F,
  0xE0, 0x0F, 0xE1, 0xFF, 0x87, 0xF0, 0x07, 0xF0, 0xFF, 0xC3, 0xF8, 0x03,
  0xF8, 0x7F, 0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0xE1, 0xFC, 0x01, 0xFC, 0x1F,
  0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xF0, 0x3F,
  0x80, 0x7F, 0x81, 0xF8, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xF8, 0x00,
  0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xC0, 0x07,
  0xFF, 0xF0, 0x0F, 0xE0, 0x03, 0xF9, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0xFC,
  0x07, 0xF8, 0x00, 0xFE, 0x7E, 0x03, 0xF8, 0x00, 0xFF, 0x3F, 0x81, 0xFC,
  0x00, 0x7F, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x87, 0xE0, 0xFF, 0x00, 0x1F,
  0xC3, 0xF0, 0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0x7E,
  0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0x8F, 0xF0,
  0x03, 0xFC, 0x0F, 0xC7, 0xF0, 0x01, 0xFC, 0x03, 0xF3, 0xF8, 0x00, 0xFE,
  0x01, 0xF9, 0xFC, 0x00, 0x7F, 0x00, 0xFD, 0xFE, 0x00, 0x7F, 0x80, 0x7E,
  0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0x80,
  0x0F, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xF8,
  0x01, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xCF, 0xFE, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF1,
  0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F,
  0xCF, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xF7, 0xF8, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xF3,
  0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F,
  0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0x03, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF0,
  0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x3F,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xCF,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F,
  0xF7, 0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xFB, 0xFC, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFE, 0x3F,
  0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFF,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x3F,
  0xC0, 0x0F, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFC,
  0x00, 0x7F, 0xE0, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0x02, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x00, 0x0F, 0xF8, 0x03,
  0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0xFF, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07,
  0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0xF8,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x01, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFC, 0xFF,
  0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x1F,
  0xC0, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xF8, 0x7F,
  0x00, 0x7F, 0x0F, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xFE, 0x1F, 0xC0, 0x1F,
  0xC7, 0xFF, 0x0F, 0xC0, 0x0F, 0xC3, 0xEF, 0x8F, 0xE0, 0x07, 0xE3, 0xE7,
  0xC7, 0xF0, 0x07, 0xF3, 0xF3, 0xE3, 0xF0, 0x03, 0xF9, 0xF1, 0xF1, 0xF8,
  0x01, 0xF9, 0xF8, 0xF9, 0xFC, 0x00, 0xFC, 0xF8, 0x7C, 0xFE, 0x00, 0x7E,
  0xFC, 0x3E, 0x7E, 0x00, 0x3F, 0x7C, 0x1F, 0x3F, 0x00, 0x3F, 0x7E, 0x0F,
  0xBF, 0x80, 0x1F, 0xBE, 0x07, 0xDF, 0x80, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x01, 0xFF,
  0x7F, 0x80, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03,
  0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x07, 0xF1,
  0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x03,
  0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x7F, 0xEF, 0xF0, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0x87, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x03,
  0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xFC, 0x03, 0xFC, 0x0F,
  0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFE, 0x3F, 0xE0, 0x01, 0xFE, 0x7F,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x7F,
  0x00, 0x00, 0xFF, 0x1E, 0x00, 0x00, 0x7C, 0x04, 0x00, 0x00, 0x60, 0x7F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x0E, 0x00, 0x1F, 0x00,
  0x3F, 0x80, 0x7F, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE,
  0x03, 0xFF, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x18, 0x00, 0x08, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x03, 0xFC, 0x0F, 0xFE, 0x00, 0xFF,
  0x03, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x07,
  0xF8, 0x3F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xFC, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFC,
  0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0xFF, 0x00, 0x3F,
  0xF8, 0x3F, 0x80, 0x01, 0xF0, 0x08, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFC,
  0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F,
  0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xF1,
  0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x07, 0xFC,
  0x7F, 0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFE, 0x1F, 0xE0, 0x03, 0xFE,
  0x1F, 0xF0, 0x07, 0xFF, 0x0F, 0xF0, 0x07, 0xFF, 0x07, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x08, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x0C, 0x07, 0xFF, 0xE0, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFB, 0xF8, 0x00, 0x3F, 0xFF, 0xCF, 0xF0, 0x00, 0x3F, 0xFC, 0x3F,
  0x80, 0x00, 0x1F, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x1F, 0xF0,
  0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x07, 0xFE, 0x7F, 0x00,
  0x3F, 0xFC, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x20, 0x7F, 0xF0, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x08, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x04, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0xFF, 0x00, 0x00, 0x07, 0xE1, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0C, 0x00,
  0x03, 0xFE, 0x00, 0x1E, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x07,
  0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xE0,
  0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0,
  0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x03,
  0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80,
  0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F,
  0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x01, 0x03,
  0xFF, 0xDF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x10, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x07,
  0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0x81, 0xFF,
  0x80, 0x01, 0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x03, 0xFD, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x0F, 0xF1,
  0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x02, 0x3F,
  0xF9, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8,
  0x1F, 0xC0, 0x03, 0xFF, 0xF3, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xF0, 0xFF, 0x1F, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x03, 0xF8,
  0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x7F, 0x03, 0xF8, 0x3F,
  0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0x7E, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x83,
  0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x03, 0xFF,
  0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F,
  0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x07,
  0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF8, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0,
  0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xFC,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xE0, 0xFF,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x3F, 0xC3, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00,
  0x07, 0xFC, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0xC0,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xF3, 0xFE,
  0x00, 0x07, 0xF9, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x03, 0xFC, 0x7F,
  0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x07,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x0F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xC0,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xFE, 0x00, 0xFF,
  0x8F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x03,
  0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFE, 0x1F, 0xF0,
  0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF,
  0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFE,
  0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF7, 0xFC, 0x00, 0x01, 0xC1, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x40, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xF8, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xE1, 0xFC,
  0x01, 0xFF, 0x00, 0x0C, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x20, 0x00, 0x0F, 0xF0, 0x38, 0x00, 0x1F, 0xF0,
  0x3F, 0x00, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x06, 0x01, 0xFF, 0xE3, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0,
  0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xFC,
  0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xE0, 0xFF,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x3F,
  0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F,
  0xF8, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x3F, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xE7, 0xF8, 0x03, 0xFF, 0xC1,
  0xFC, 0x00, 0x3F, 0x80, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80,
  0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80,
  0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F, 0xCF,
  0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x0F, 0xF1,
  0xFC, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0,
  0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0xFF, 0x03, 0xF0, 0x3F,
  0x03, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0xC1,
  0xF8, 0x1F, 0xC3, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F, 0xFC, 0x3F, 0x01, 0xF8,
  0x7F, 0xF0, 0xFC, 0x07, 0xE1, 0xF7, 0xC7, 0xF0, 0x1F, 0x8F, 0xDF, 0x1F,
  0x80, 0x7E, 0x3E, 0x7C, 0x7E, 0x01, 0xF9, 0xF9, 0xF3, 0xF8, 0x07, 0xE7,
  0xC7, 0xCF, 0xC0, 0x1F, 0xBF, 0x1F, 0xBF, 0x00, 0x7F, 0xF8, 0x7F, 0xF8,
  0x01, 0xF7, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC3, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x04, 0x00,
  0x3F, 0xF0, 0x00, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0x83, 0xFF, 0xF8, 0x07,
  0xF0, 0xFF, 0xFF, 0xC1, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x83, 0xFF, 0xFF, 0x0F, 0xE0,
  0x3F, 0xFF, 0xC3, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0x00, 0x1F, 0xF8, 0x00,
  0x40, 0x00, 0x7C, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 19, 47, 37, 10, -46 },
  { 113, 25, 20, 37, 12, -50 },
  { 176, 39, 46, 37, 0, -46 },
  { 401, 36, 58, 37, 1, -51 },
  { 662, 44, 48, 37, -2, -47 },
  { 926, 34, 48, 37, 1, -47 },
  { 1130, 12, 21, 37, 18, -50 },
  { 1162, 29, 64, 37, 8, -52 },
  { 1394, 29, 64, 37, 1, -52 },
  { 1626, 30, 29, 37, 7, -46 },
  { 1735, 32, 33, 37, 3, -36 },
  { 1867, 17, 23, 37, 5, -12 },
  { 1916, 21, 8, 37, 8, -23 },
  { 1937, 12, 13, 37, 10, -12 },
  { 1957, 44, 64, 37, -4, -52 },
  { 2309, 34, 48, 37, 3, -47 },
  { 2513, 28, 46, 37, 3, -46 },
  { 2674, 35, 47, 37, 1, -47 },
  { 2880, 36, 48, 37, 0, -47 },
  { 3096, 37, 46, 37, 0, -46 },
  { 3309, 38, 47, 37, 0, -46 },
  { 3533, 35, 47, 37, 3, -46 },
  { 3739, 35, 46, 37, 6, -46 },
  { 3941, 35, 48, 37, 2, -47 },
  { 4151, 35, 47, 37, 2, -47 },
  { 4357, 17, 36, 37, 10, -35 },
  { 4434, 22, 46, 37, 5, -35 },
  { 4561, 33, 32, 37, 3, -35 },
  { 4693, 36, 21, 37, 1, -30 },
  { 4788, 34, 32, 37, 1, -35 },
  { 4924, 27, 48, 37, 9, -47 },
  { 5086, 37, 57, 37, 2, -47 },
  { 5350, 35, 46, 37, -3, -46 },
  { 5552, 37, 47, 37, 0, -46 },
  { 5770, 35, 48, 37, 4, -47 },
  { 5980, 36, 47, 37, 0, -46 },
  { 6192, 37, 46, 37, 2, -46 },
  { 6405, 38, 46, 37, 2, -46 },
  { 6624, 36, 48, 37, 3, -47 },
  { 6840, 41, 46, 37, -1, -46 },
  { 7076, 38, 46, 37, 1, -46 },
  { 7295, 37, 47, 37, 1, -46 },
  { 7513, 41, 46, 37, 0, -46 },
  { 7749, 29, 46, 37, 1, -46 },
  { 7916, 41, 46, 37, -2, -46 },
  { 8152, 41, 46, 37, -1, -46 },
  { 8388, 34, 48, 37, 3, -47 },
  { 8592, 38, 46, 37, 0, -46 },
  { 8811, 34, 59, 37, 3, -47 },
  { 9062, 37, 46, 37, 0, -46 },
  { 9275, 37, 48, 37, 0, -47 },
  { 9497, 35, 46, 37, 7, -46 },
  { 9699, 37, 47, 37, 3, -46 },
  { 9917, 36, 46, 37, 7, -46 },
  { 10124, 41, 46, 37, 1, -46 },
  { 10360, 45, 46, 37, -3, -46 },
  { 10619, 35, 46, 37, 8, -46 },
  { 10821, 40, 46, 37, -1, -46 },
  { 11051, 35, 64, 37, 4, -52 },
  { 11331, 13, 64, 37, 13, -52 },
  { 11435, 35, 64, 37, -1, -52 },
  { 11715, 32, 26, 37, 4, -46 },
  { 11819, 35, 7, 37, -5, 5 },
  { 11850, 16, 14, 37, 15, -51 },
  { 11878, 34, 36, 37, 2, -35 },
  { 12031, 33, 52, 37, 1, -51 },
  { 12246, 33, 36, 37, 3, -35 },
  { 12395, 38, 52, 37, 2, -51 },
  { 12642, 32, 37, 37, 3, -36 },
  { 12790, 45, 63, 37, -4, -51 },
  { 13145, 39, 47, 37, -2, -35 },
  { 13375, 34, 51, 37, 0, -51 },
  { 13592, 24, 53, 37, 6, -52 },
  { 13751, 37, 64, 37, -3, -52 },
  { 14047, 38, 51, 37, 1, -51 },
  { 14290, 22, 52, 37, 9, -51 },
  { 14433, 37, 35, 37, -1, -35 },
  { 14595, 33, 35, 37, 1, -35 },
  { 14740, 33, 37, 37, 2, -36 },
  { 14893, 37, 47, 37, -2, -35 },
  { 15111, 34, 47, 37, 3, -35 },
  { 15311, 34, 35, 37, 3, -35 },
  { 15460, 32, 37, 37, 2, -36 },
  { 15608, 30, 46, 37, 6, -45 },
  { 15781, 33, 36, 37, 3, -35 },
  { 15930, 32, 35, 37, 6, -35 },
  { 16070, 38, 35, 37, 2, -35 },
  { 16237, 40, 35, 37, -2, -35 },
  { 16412, 43, 47, 37, -5, -35 },
  { 16665, 35, 35, 37, 1, -35 },
  { 16819, 36, 64, 37, 4, -52 },
  { 17107, 24, 64, 37, 7, -52 },
  { 17299, 36, 64, 37, -3, -52 },
  { 17587, 35, 13, 37, 1, -26 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic66pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic66pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic66pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC66PT7B_H_
