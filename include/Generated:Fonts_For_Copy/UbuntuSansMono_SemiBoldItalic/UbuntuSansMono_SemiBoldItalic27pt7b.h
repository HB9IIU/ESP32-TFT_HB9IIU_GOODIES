#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC27PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x38,
  0x38, 0x00, 0x00, 0x00, 0x70, 0xF8, 0xF0, 0xF0, 0x79, 0xDC, 0x77, 0x3F,
  0xCE, 0xE3, 0xB8, 0xEE, 0x33, 0x0C, 0xC3, 0x00, 0x00, 0xC7, 0x01, 0xC6,
  0x01, 0xCE, 0x03, 0x8E, 0x03, 0x9C, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFE,
  0x0E, 0x38, 0x0E, 0x70, 0x1C, 0x70, 0x1C, 0x60, 0xFF, 0xFC, 0xFF, 0xFC,
  0x39, 0xC0, 0x71, 0xC0, 0x73, 0x80, 0x63, 0x80, 0xE7, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0x83, 0x81, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0xE1, 0xF1, 0xFF, 0xC7, 0xFF, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x80, 0xC3, 0xF0, 0x61,
  0xDC, 0x30, 0x63, 0x1C, 0x19, 0xCE, 0x06, 0x67, 0x01, 0x9B, 0x80, 0x7C,
  0xC0, 0x1F, 0x60, 0x00, 0x38, 0x00, 0x1D, 0xE0, 0x0E, 0xF8, 0x07, 0x77,
  0x01, 0x99, 0xC0, 0xC6, 0x60, 0x61, 0x98, 0x38, 0x66, 0x1C, 0x1F, 0x0E,
  0x07, 0xC0, 0x01, 0xF0, 0x1F, 0xE0, 0x7F, 0x83, 0x8E, 0x0E, 0x38, 0x38,
  0xE0, 0xE7, 0x03, 0xB8, 0x07, 0xC0, 0x3C, 0x31, 0xF9, 0xCE, 0xF7, 0x71,
  0xF9, 0xC3, 0xEE, 0x0F, 0x3C, 0x3C, 0x7B, 0xF1, 0xFE, 0xE3, 0xF3, 0x80,
  0x77, 0xFF, 0xEE, 0xEC, 0xC0, 0x00, 0x60, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0x80, 0x01, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x80, 0x70, 0x06, 0x00, 0x0E,
  0x00, 0xE0, 0x0E, 0x0E, 0x66, 0xF6, 0xEF, 0xFF, 0x1F, 0x81, 0xF0, 0x3B,
  0x87, 0x9E, 0x39, 0xC1, 0x08, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x7C, 0xF9, 0xF3, 0xE1, 0x87, 0x7C, 0xF1,
  0x00, 0x7F, 0xBF, 0xFF, 0xC0, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xE0,
  0xFF, 0x87, 0x8F, 0x3C, 0x1C, 0xE0, 0x77, 0x81, 0xDC, 0x47, 0x73, 0x9D,
  0xDE, 0xFF, 0x33, 0xB8, 0x0E, 0xE0, 0x7B, 0x81, 0xCE, 0x0F, 0x3C, 0x38,
  0x7B, 0xE1, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x70, 0x0F, 0x03, 0xE0, 0xFE,
  0x3F, 0xE1, 0xDE, 0x11, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x7F, 0xFF, 0xFE, 0xFF, 0xE0, 0x03,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x70, 0xF0, 0x81, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x7F, 0xF8, 0xFF, 0xF3, 0xFF, 0xC0, 0x03,
  0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x20, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x3C, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x20, 0x3C, 0x73, 0xF1, 0xFF, 0xC1, 0xFF, 0x00, 0x00,
  0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x1D, 0xC0, 0x73, 0x81, 0xCF,
  0x07, 0x1C, 0x1E, 0x38, 0x38, 0x70, 0xE1, 0xE3, 0x83, 0x87, 0xFF, 0xDF,
  0xFF, 0x80, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x03,
  0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x40, 0x78, 0x7B, 0xF0, 0xFF, 0xE0, 0x7F,
  0xC0, 0x00, 0x3E, 0x03, 0xF8, 0x0F, 0xF0, 0x7E, 0x01, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x3C, 0xE0, 0x7F, 0xF0, 0xFF, 0xE1, 0xC1, 0xE7, 0x81, 0xCF,
  0x03, 0x9E, 0x07, 0x3C, 0x1E, 0x38, 0x38, 0x79, 0xF0, 0x7F, 0xC0, 0x7F,
  0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xA0, 0x1C, 0x00, 0xE0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x03,
  0xF0, 0x3F, 0xE1, 0xFF, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0xC3, 0xC7,
  0x9E, 0x0F, 0xF0, 0x3F, 0x03, 0xFE, 0x1E, 0x3C, 0xF0, 0x73, 0x81, 0xEE,
  0x07, 0x38, 0x1C, 0xF1, 0xF1, 0xFF, 0x83, 0xF8, 0x00, 0x07, 0xE0, 0x3F,
  0xC1, 0xFF, 0x8F, 0x0F, 0x38, 0x1D, 0xE0, 0x77, 0x81, 0xDE, 0x07, 0x78,
  0x3C, 0xFF, 0xF1, 0xFF, 0x83, 0xCE, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0x80, 0x00, 0x0C, 0x3C, 0xF9, 0xF1, 0xC0,
  0x00, 0x00, 0x00, 0xE3, 0xE7, 0xCF, 0x9E, 0x00, 0x03, 0x03, 0xC3, 0xE1,
  0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0x30, 0x38, 0xF8, 0x78, 0x20, 0x00, 0x00, 0x0C, 0x01, 0xF0, 0x1F, 0xC3,
  0xFC, 0x3F, 0x81, 0xF0, 0x0F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x00, 0x38, 0x00, 0x20, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x9F, 0xFE, 0x7F, 0xFC, 0x30, 0x01, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7C, 0x03, 0xE0, 0xFF, 0x1F, 0xC7, 0xF8,
  0x3E, 0x01, 0xC0, 0x08, 0x00, 0x00, 0x3F, 0x8F, 0xF9, 0xFF, 0xA0, 0xF0,
  0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x1F, 0x07, 0x80, 0xE0, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xF8, 0x0F,
  0xF8, 0x3C, 0x70, 0xE0, 0x73, 0x80, 0xE7, 0x01, 0xDC, 0x7F, 0xB9, 0xFE,
  0xE7, 0x9D, 0xCE, 0x3B, 0x9C, 0x77, 0x71, 0xCC, 0xE3, 0x99, 0xC7, 0x33,
  0xCE, 0x63, 0xF8, 0xE7, 0xF1, 0xC3, 0xC3, 0x80, 0x03, 0x80, 0x07, 0xE4,
  0x07, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E,
  0x01, 0xDC, 0x0E, 0x70, 0x39, 0xC1, 0xC7, 0x07, 0x1C, 0x38, 0x70, 0xE1,
  0xC7, 0x07, 0x1F, 0xFC, 0xFF, 0xF3, 0x81, 0xDE, 0x07, 0x70, 0x1F, 0xC0,
  0x7E, 0x01, 0xC0, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x70, 0xF1, 0xE0,
  0xE3, 0xC1, 0xC7, 0x07, 0x0E, 0x1E, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xE1,
  0xC1, 0xE3, 0x81, 0xCF, 0x03, 0x9C, 0x0F, 0x38, 0x3C, 0x7F, 0xF9, 0xFF,
  0xE3, 0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xF1, 0xFF, 0xCF, 0x82, 0x3C, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x08, 0xFF, 0xC1, 0xFF, 0x83, 0xFC,
  0x00, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x71, 0xE1, 0xE1, 0xE3, 0x83,
  0xC7, 0x07, 0x8E, 0x0F, 0x3C, 0x1E, 0x70, 0x3C, 0xE0, 0x71, 0xC0, 0xE7,
  0x83, 0xCE, 0x07, 0x1C, 0x1E, 0x38, 0x78, 0xFF, 0xE1, 0xFF, 0x83, 0xFC,
  0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF,
  0x80, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x00, 0x01, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0xF8, 0x21, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x73, 0xC0, 0xE7, 0x83, 0xCF,
  0x07, 0x9E, 0x0E, 0x3C, 0x1C, 0x38, 0x78, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F,
  0x80, 0x0F, 0x07, 0x87, 0x03, 0x83, 0x81, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0,
  0xE0, 0x70, 0x70, 0x38, 0x78, 0x3C, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0x07, 0x87, 0x83, 0xC3, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0xF0, 0xF0,
  0x78, 0x70, 0x38, 0x38, 0x1C, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x20, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0x80, 0x0F, 0x07,
  0x87, 0x87, 0x83, 0x87, 0x81, 0xC7, 0x81, 0xE3, 0x80, 0xF3, 0x80, 0x73,
  0xC0, 0x3B, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x0E, 0xF0, 0x07, 0x78, 0x07,
  0x9E, 0x03, 0xC7, 0x01, 0xC3, 0xC0, 0xE0, 0xE0, 0x70, 0x78, 0x78, 0x3C,
  0x38, 0x0E, 0x00, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x7F, 0xF7, 0xFF, 0xFF, 0xF0, 0x03, 0x83, 0x83, 0xC3,
  0xC1, 0xE1, 0xE0, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0xD8, 0x36, 0x6C, 0x3B,
  0x6E, 0x1D, 0xB7, 0x0E, 0xF3, 0x8E, 0x79, 0x87, 0x39, 0xC3, 0x80, 0xE1,
  0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x38, 0x07,
  0x00, 0x0E, 0x07, 0x87, 0x83, 0x83, 0xC1, 0xC3, 0xE0, 0xE1, 0xF0, 0xF0,
  0xFC, 0x70, 0x7E, 0x38, 0x3B, 0x1C, 0x39, 0xCE, 0x1C, 0xEE, 0x0E, 0x77,
  0x07, 0x1B, 0x87, 0x0D, 0xC3, 0x87, 0xC1, 0xC3, 0xE0, 0xE0, 0xF0, 0xE0,
  0x78, 0x70, 0x38, 0x38, 0x1C, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0xC7,
  0x8F, 0x3C, 0x1C, 0xE0, 0x77, 0x81, 0xDC, 0x07, 0x70, 0x1F, 0xC0, 0xFF,
  0x03, 0xF8, 0x0E, 0xE0, 0x3B, 0x81, 0xEE, 0x07, 0x3C, 0x3C, 0x7F, 0xE1,
  0xFF, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x0E, 0x1E,
  0x0E, 0x0E, 0x1E, 0x0F, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x1E, 0x3C, 0xFC,
  0x3F, 0xF8, 0x3F, 0xE0, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0xC7,
  0x8F, 0x3C, 0x1C, 0xE0, 0x77, 0x81, 0xDC, 0x07, 0x70, 0x1F, 0xC0, 0xFF,
  0x03, 0xF8, 0x0E, 0xE0, 0x3B, 0x81, 0xEE, 0x07, 0x3C, 0x3C, 0x7F, 0xE1,
  0xFF, 0x03, 0xF8, 0x07, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x70,
  0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x70, 0xF1, 0xE1, 0xE3, 0xC1, 0xC7,
  0x07, 0x8E, 0x0E, 0x3C, 0x3C, 0x7F, 0xF0, 0xFF, 0xC1, 0xFE, 0x03, 0x9E,
  0x0F, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x70, 0x71, 0xE0, 0xF3, 0x80, 0xE0,
  0x01, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x70, 0x21, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x00, 0x0E, 0x20, 0x3C, 0x7F, 0xF1, 0xFF, 0xC1, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x0E,
  0x38, 0x1C, 0x70, 0x79, 0xE0, 0xF3, 0xC1, 0xC7, 0x03, 0x8E, 0x0F, 0x3C,
  0x1E, 0x78, 0x38, 0xE0, 0x71, 0xC0, 0xE7, 0x83, 0xCF, 0x07, 0x1C, 0x0E,
  0x38, 0x3C, 0x78, 0x70, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xE0, 0x1F,
  0x80, 0xFE, 0x03, 0xB8, 0x0E, 0xE0, 0x7B, 0x81, 0xCE, 0x0F, 0x38, 0x38,
  0xE1, 0xE3, 0x87, 0x0E, 0x3C, 0x3C, 0xE0, 0xF7, 0x81, 0xDC, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x0E, 0x03, 0x8E, 0x01,
  0xC7, 0x00, 0xE3, 0x80, 0xE1, 0xC0, 0x70, 0xC0, 0x38, 0xE0, 0x18, 0x73,
  0x9C, 0x39, 0xCE, 0x1D, 0xE7, 0x0C, 0xF3, 0x0E, 0xDB, 0x87, 0x6D, 0xC3,
  0xE6, 0xC1, 0xF3, 0x60, 0xF1, 0xF0, 0x78, 0xF0, 0x78, 0x38, 0x3C, 0x1C,
  0x00, 0x07, 0x01, 0xC1, 0xE0, 0xE0, 0x78, 0x78, 0x0E, 0x3C, 0x03, 0xCE,
  0x00, 0x77, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xCE, 0x01, 0xE3, 0x80, 0x70,
  0xE0, 0x3C, 0x3C, 0x1E, 0x07, 0x0F, 0x01, 0xC0, 0xF0, 0x1F, 0xE0, 0x79,
  0xC0, 0xE3, 0x83, 0xC7, 0x0F, 0x0E, 0x1C, 0x1E, 0x78, 0x1D, 0xE0, 0x3B,
  0x80, 0x7E, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFC,
  0x0F, 0xF0, 0x7F, 0x81, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0xF3, 0xCF, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x79, 0xE7, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8F, 0x3C, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x3F,
  0xC0, 0x7F, 0x81, 0xFF, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x3F, 0x01, 0xFC,
  0x0F, 0x70, 0x39, 0xE1, 0xE7, 0x8F, 0x0E, 0x78, 0x3F, 0xC0, 0xF2, 0x01,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0xE3, 0xE1, 0xF1, 0xC0,
  0x80, 0x07, 0xFC, 0x7F, 0xE3, 0xE3, 0x9E, 0x0E, 0x70, 0x7B, 0xC1, 0xCF,
  0x07, 0x38, 0x1C, 0xE0, 0xF3, 0x83, 0xCF, 0x0E, 0x3F, 0xF8, 0x7F, 0xF0,
  0xFD, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x7D, 0xF1, 0xC3, 0xCF, 0x07, 0x3C,
  0x1C, 0xE0, 0x73, 0x83, 0xDE, 0x0F, 0x78, 0x79, 0xC3, 0xE7, 0xFF, 0x1F,
  0xF8, 0xFF, 0x80, 0x00, 0x40, 0x1F, 0xF1, 0xFF, 0x8F, 0xE6, 0x3C, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x7F, 0xE1, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x07, 0xFC, 0x1F, 0xF8,
  0x3E, 0x38, 0x3C, 0x38, 0x78, 0x78, 0xF0, 0x78, 0xF0, 0x70, 0xE0, 0x70,
  0xE0, 0xF0, 0xE0, 0xF0, 0xF0, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0x70,
  0x00, 0x80, 0x3F, 0x87, 0xFE, 0x7C, 0x77, 0x83, 0xB8, 0x1D, 0xC1, 0xFF,
  0xFE, 0xFF, 0xE7, 0xF0, 0x38, 0x01, 0xE0, 0x07, 0xEE, 0x3F, 0xF0, 0x7F,
  0x80, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFF, 0x07, 0xFF, 0x0F, 0xCE, 0x0F, 0x0E, 0x1E,
  0x0E, 0x1C, 0x1E, 0x3C, 0x1C, 0x3C, 0x1C, 0x3C, 0x1C, 0x3C, 0x3C, 0x1F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xB8, 0x00, 0x78, 0x00, 0x70, 0x40, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC0, 0x7F, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0xFC, 0x1F, 0xF8, 0x7D, 0xF1, 0xC3,
  0xCF, 0x0F, 0x3C, 0x3C, 0xE0, 0xE3, 0x83, 0x8E, 0x1E, 0x78, 0x79, 0xC1,
  0xC7, 0x07, 0x1C, 0x1C, 0xF0, 0xF0, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x7F, 0x3F, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81,
  0xE0, 0x70, 0x1C, 0x07, 0x01, 0xFC, 0x7F, 0x0F, 0xC0, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x07, 0xFC, 0x1F, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x10, 0x70, 0x3F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x1F, 0x1C, 0x78, 0x79, 0xE0, 0xE7, 0x81, 0xDE, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0xE0, 0x39, 0xC0, 0x73, 0xC1, 0xE3, 0x83, 0xC7, 0x87, 0x07, 0x0E,
  0x0F, 0x00, 0xFF, 0x7F, 0x3F, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C,
  0x1C, 0x0E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x3F, 0xCF,
  0xE7, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE6,
  0x33, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xC0, 0x33, 0x80, 0xE7, 0x01,
  0xCE, 0x03, 0x9C, 0x0E, 0x00, 0x0F, 0xF8, 0x7F, 0xE1, 0xF7, 0xC7, 0x0F,
  0x1C, 0x3C, 0xF0, 0xF3, 0xC3, 0x8E, 0x0E, 0x38, 0x39, 0xE1, 0xE7, 0x87,
  0x9C, 0x1C, 0x70, 0x73, 0xC3, 0xC0, 0x00, 0x80, 0x7F, 0x07, 0xFC, 0x7D,
  0xF7, 0x87, 0xB8, 0x1D, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1D,
  0xE1, 0xEF, 0xFE, 0x3F, 0xE0, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x3C,
  0xF8, 0x70, 0x71, 0xE0, 0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x0F, 0x1C, 0x1E,
  0x78, 0x78, 0xE1, 0xF1, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x07, 0xFC, 0x7F, 0xF3, 0xF3,
  0x8F, 0x0E, 0x78, 0x39, 0xC1, 0xEF, 0x07, 0x3C, 0x1C, 0xE0, 0x73, 0x83,
  0xCF, 0x0F, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x80, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0xFC, 0x7F, 0xE1, 0xFF, 0x87, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x80, 0x7F, 0xC7, 0xFE, 0x3C,
  0x63, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0x00, 0x39,
  0x01, 0xCF, 0xFE, 0x7F, 0xE3, 0xFE, 0x00, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1C, 0x07, 0xFF, 0xBF, 0xFB, 0xFF, 0xC3, 0x80, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0xFF,
  0x00, 0x3C, 0x3C, 0xE0, 0xE3, 0x83, 0x9E, 0x1E, 0x78, 0x79, 0xC1, 0xC7,
  0x07, 0x1C, 0x3C, 0xF0, 0xF3, 0xC3, 0x8F, 0x0E, 0x3F, 0xF8, 0x7F, 0xF0,
  0xF9, 0xC0, 0xF0, 0x3F, 0x83, 0xFC, 0x1C, 0xE1, 0xE7, 0x0E, 0x38, 0xF1,
  0xC7, 0x0E, 0x78, 0x73, 0x83, 0xFC, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1E,
  0x00, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x33, 0x1C, 0xEE, 0x39, 0xDC, 0xF3,
  0x39, 0xEE, 0x76, 0xDC, 0xED, 0xB1, 0xF3, 0xE3, 0xE7, 0xC7, 0x8F, 0x0F,
  0x1E, 0x1C, 0x38, 0x00, 0x1E, 0x0F, 0x0F, 0x0E, 0x07, 0x1C, 0x07, 0xBC,
  0x03, 0xF8, 0x03, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF0,
  0x1E, 0x78, 0x1C, 0x78, 0x38, 0x38, 0xF0, 0x3C, 0x07, 0x03, 0x83, 0x83,
  0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0xF0, 0x38, 0x70, 0x1E, 0x78, 0x0F,
  0x38, 0x03, 0xBC, 0x01, 0xDC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x7F, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0x87,
  0xFF, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x0F,
  0x80, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1F, 0xE0, 0x3F, 0x80,
  0x7C, 0x00, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C,
  0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0E,
  0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x00, 0x03,
  0xE0, 0x0F, 0xC0, 0x7F, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x00, 0x08, 0x10, 0xF8,
  0x77, 0xFF, 0xBF, 0xFE, 0xC3, 0xF1, 0x03, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 8, 19, 15, 4, -19 },
  { 20, 10, 9, 15, 5, -21 },
  { 32, 16, 19, 15, 0, -19 },
  { 70, 15, 24, 15, 0, -21 },
  { 115, 18, 19, 15, -1, -19 },
  { 158, 14, 19, 15, 0, -19 },
  { 192, 4, 9, 15, 8, -21 },
  { 197, 12, 26, 15, 3, -21 },
  { 236, 12, 26, 15, 0, -21 },
  { 275, 12, 12, 15, 3, -19 },
  { 293, 13, 14, 15, 1, -15 },
  { 316, 7, 10, 15, 2, -5 },
  { 325, 9, 3, 15, 3, -9 },
  { 329, 5, 5, 15, 4, -5 },
  { 333, 18, 26, 15, -2, -21 },
  { 392, 14, 19, 15, 1, -19 },
  { 426, 12, 19, 15, 1, -19 },
  { 455, 15, 19, 15, 0, -19 },
  { 491, 15, 19, 15, 0, -19 },
  { 527, 15, 19, 15, 0, -19 },
  { 563, 16, 19, 15, 0, -19 },
  { 601, 15, 19, 15, 1, -19 },
  { 637, 14, 19, 15, 3, -19 },
  { 671, 14, 19, 15, 1, -19 },
  { 705, 14, 19, 15, 1, -19 },
  { 739, 7, 14, 15, 4, -14 },
  { 752, 9, 19, 15, 2, -14 },
  { 774, 14, 13, 15, 1, -14 },
  { 797, 15, 8, 15, 0, -12 },
  { 812, 13, 13, 15, 1, -14 },
  { 834, 11, 19, 15, 4, -19 },
  { 861, 15, 23, 15, 1, -19 },
  { 905, 14, 19, 15, -1, -19 },
  { 939, 15, 19, 15, 0, -19 },
  { 975, 14, 19, 15, 2, -19 },
  { 1009, 15, 19, 15, 0, -19 },
  { 1045, 15, 19, 15, 1, -19 },
  { 1081, 15, 19, 15, 1, -19 },
  { 1117, 15, 19, 15, 1, -19 },
  { 1153, 17, 19, 15, 0, -19 },
  { 1194, 16, 19, 15, 0, -19 },
  { 1232, 16, 19, 15, 0, -19 },
  { 1270, 17, 19, 15, 0, -19 },
  { 1311, 12, 19, 15, 0, -19 },
  { 1340, 17, 19, 15, -1, -19 },
  { 1381, 17, 19, 15, 0, -19 },
  { 1422, 14, 19, 15, 1, -19 },
  { 1456, 16, 19, 15, 0, -19 },
  { 1494, 14, 24, 15, 1, -19 },
  { 1536, 15, 19, 15, 0, -19 },
  { 1572, 15, 19, 15, 0, -19 },
  { 1608, 14, 19, 15, 3, -19 },
  { 1642, 15, 19, 15, 1, -19 },
  { 1678, 14, 19, 15, 3, -19 },
  { 1712, 17, 19, 15, 0, -19 },
  { 1753, 18, 19, 15, -1, -19 },
  { 1796, 15, 19, 15, 3, -19 },
  { 1832, 16, 19, 15, 0, -19 },
  { 1870, 14, 26, 15, 2, -21 },
  { 1916, 6, 26, 15, 5, -21 },
  { 1936, 15, 26, 15, -1, -21 },
  { 1985, 14, 11, 15, 1, -19 },
  { 2005, 14, 3, 15, -2, 2 },
  { 2011, 7, 6, 15, 6, -21 },
  { 2017, 14, 14, 15, 1, -14 },
  { 2042, 14, 21, 15, 0, -21 },
  { 2079, 14, 15, 15, 1, -15 },
  { 2106, 16, 21, 15, 1, -21 },
  { 2148, 13, 15, 15, 1, -15 },
  { 2173, 19, 26, 15, -2, -21 },
  { 2235, 16, 19, 15, -1, -14 },
  { 2273, 14, 21, 15, 0, -21 },
  { 2310, 10, 21, 15, 2, -21 },
  { 2337, 15, 26, 15, -1, -21 },
  { 2386, 15, 21, 15, 1, -21 },
  { 2426, 9, 21, 15, 4, -21 },
  { 2450, 15, 14, 15, 0, -14 },
  { 2477, 14, 14, 15, 0, -14 },
  { 2502, 13, 15, 15, 1, -15 },
  { 2527, 15, 19, 15, -1, -14 },
  { 2563, 14, 19, 15, 1, -14 },
  { 2597, 14, 14, 15, 1, -14 },
  { 2622, 13, 15, 15, 1, -15 },
  { 2647, 13, 18, 15, 2, -18 },
  { 2677, 14, 14, 15, 1, -14 },
  { 2702, 13, 14, 15, 2, -14 },
  { 2725, 15, 14, 15, 1, -14 },
  { 2752, 16, 14, 15, -1, -14 },
  { 2780, 17, 19, 15, -2, -14 },
  { 2821, 15, 14, 15, 0, -14 },
  { 2848, 14, 26, 15, 2, -21 },
  { 2894, 10, 26, 15, 3, -21 },
  { 2927, 14, 26, 15, -1, -21 },
  { 2973, 14, 6, 15, 1, -11 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic27pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic27pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic27pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC27PT7B_H_
