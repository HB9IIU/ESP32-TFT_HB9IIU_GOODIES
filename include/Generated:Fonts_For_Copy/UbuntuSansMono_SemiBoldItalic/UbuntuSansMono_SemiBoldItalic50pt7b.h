#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC50PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x80, 0xFE, 0x01, 0xF8, 0x00, 0xC0, 0x00, 0x3F, 0x87, 0xE7,
  0xE1, 0xFC, 0xFC, 0x3F, 0xBF, 0x87, 0xE7, 0xF0, 0xFC, 0xFC, 0x1F, 0x9F,
  0x87, 0xE3, 0xF0, 0xFC, 0x7C, 0x1F, 0x8F, 0x83, 0xE1, 0xF0, 0x7C, 0x7C,
  0x0F, 0x8F, 0x81, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x00, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x7C,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF8, 0x3E,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3F, 0x00,
  0x03, 0xE0, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x01, 0xF0,
  0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x3F,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFE, 0xFE, 0x01, 0xFC,
  0x00, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0x00, 0x07, 0xF0, 0x3C, 0x01, 0xFE,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x1F, 0xE0, 0x03, 0xE0, 0x0F,
  0xFC, 0x01, 0xF0, 0x07, 0xFF, 0x00, 0x78, 0x01, 0xE3, 0xC0, 0x3E, 0x00,
  0xF0, 0xF0, 0x1F, 0x00, 0x3C, 0x3C, 0x0F, 0x80, 0x0F, 0x0F, 0x07, 0xC0,
  0x07, 0x83, 0xC3, 0xE0, 0x01, 0xE0, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x78,
  0x00, 0x1E, 0x1E, 0x3E, 0x00, 0x07, 0xCF, 0x9F, 0x00, 0x01, 0xFF, 0xCF,
  0x80, 0x00, 0x3F, 0xE7, 0xC0, 0x00, 0x07, 0xF1, 0xE0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x18, 0x00, 0x00,
  0x1F, 0x3F, 0x80, 0x00, 0x0F, 0x9F, 0xF0, 0x00, 0x07, 0xCF, 0xFE, 0x00,
  0x01, 0xE3, 0xEF, 0x80, 0x00, 0xF9, 0xF1, 0xE0, 0x00, 0x7C, 0x78, 0x78,
  0x00, 0x3E, 0x1E, 0x1E, 0x00, 0x1F, 0x0F, 0x07, 0x80, 0x0F, 0x83, 0xC1,
  0xE0, 0x03, 0xC0, 0xF0, 0xF0, 0x01, 0xE0, 0x3C, 0x3C, 0x00, 0xF8, 0x0F,
  0x1F, 0x00, 0x7C, 0x03, 0xE7, 0x80, 0x3E, 0x00, 0xFF, 0xE0, 0x1F, 0x00,
  0x1F, 0xF0, 0x0F, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x0F, 0xC0,
  0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x0F,
  0x83, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0x7D, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x04, 0x00, 0xFF, 0x81, 0xF0, 0x7F, 0xE0,
  0xF8, 0x7F, 0xFC, 0x3E, 0x3F, 0xBF, 0x9F, 0x8F, 0x87, 0xE7, 0xC7, 0xE0,
  0xFD, 0xF3, 0xF0, 0x3F, 0xF8, 0xFC, 0x07, 0xFE, 0x3E, 0x00, 0xFF, 0x0F,
  0x80, 0x3F, 0x83, 0xE0, 0x07, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x01, 0xFF,
  0x0F, 0xF3, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0x7E, 0x0F, 0xFF,
  0x1F, 0x81, 0xFF, 0x83, 0xF0, 0x04, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xCF,
  0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3E, 0x3F, 0x1F, 0x0F, 0x87, 0xC3,
  0xC1, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x7E, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x06, 0x0F,
  0x81, 0x1F, 0x1F, 0x1E, 0x3F, 0x3C, 0x7E, 0x7F, 0xBB, 0xFD, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xE0, 0x0F, 0xCF, 0xE0, 0x3F, 0x8F, 0xE0,
  0xFE, 0x1F, 0xC0, 0x7C, 0x1F, 0x00, 0x70, 0x38, 0x00, 0x20, 0x20, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0xE0, 0x7F, 0x81, 0xFF, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFF, 0x81, 0xFE, 0x03, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xFC,
  0x0F, 0xE3, 0xFF, 0x07, 0xF8, 0x1F, 0x80, 0x78, 0x00, 0x3F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x1E, 0x0F, 0xE7,
  0xF9, 0xFF, 0xFF, 0xFF, 0xEF, 0xF9, 0xFE, 0x7F, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xE0,
  0x7F, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03,
  0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC1,
  0x83, 0xF3, 0xF1, 0xF0, 0xF9, 0xF8, 0xFC, 0x7E, 0x7E, 0x3F, 0x1F, 0x9F,
  0x8F, 0xC7, 0xE7, 0xE3, 0xF1, 0xF9, 0xF0, 0xF8, 0x7E, 0xFC, 0x1C, 0x3F,
  0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0xFE,
  0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xDF, 0xC0, 0x7C, 0x7E, 0x01, 0xC1, 0xF8, 0x04, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x17,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x78,
  0x03, 0xF0, 0x0C, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xE0, 0x3F, 0xC0, 0x10, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x82,
  0x00, 0x07, 0xF0, 0x60, 0x03, 0xFC, 0x1F, 0xE7, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xF0, 0x03,
  0xE0, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE2, 0x7F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x02,
  0x00, 0x0F, 0xE0, 0x1C, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x07, 0x00, 0x0F, 0xCF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0x00, 0x3F,
  0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xE0,
  0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x01, 0xF8,
  0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x0F, 0xF9,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xF0, 0x7E, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x00,
  0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0x3F,
  0x8F, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xBF, 0xE0, 0x1F, 0x83, 0xFC, 0x0F, 0xC0, 0x7F,
  0x07, 0xE0, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0x3F,
  0x80, 0x7F, 0x0F, 0xF8, 0x7F, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xF0, 0x3F, 0x81, 0xF8, 0x03, 0xF0, 0x7F, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xF0, 0x03,
  0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFD, 0xF8, 0x00, 0x78, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x0F,
  0xE0, 0x7F, 0x81, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x81, 0xFE, 0x03,
  0xF0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0xC3, 0xFF, 0x0F,
  0xF8, 0x3F, 0xE0, 0x7F, 0x81, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x06,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1,
  0xC0, 0x7F, 0x10, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x1F,
  0xC0, 0x3F, 0x03, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x1D, 0xF1, 0xF8, 0x1F, 0xFF, 0x1F,
  0x03, 0xFF, 0xF3, 0xF0, 0x7F, 0xFE, 0x3E, 0x0F, 0xFF, 0xE3, 0xE1, 0xFC,
  0x7E, 0x7C, 0x3F, 0x87, 0xE7, 0xC3, 0xF0, 0x7E, 0x7C, 0x3E, 0x07, 0xC7,
  0xC7, 0xE0, 0x7C, 0x7C, 0x7C, 0x0F, 0xC7, 0x87, 0xC0, 0xFC, 0xF8, 0x7C,
  0x0F, 0x8F, 0x87, 0xC0, 0xF8, 0xF8, 0x7C, 0x1F, 0x8F, 0x87, 0xC1, 0xF8,
  0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x7F, 0xFF, 0x0F, 0x83,
  0xFF, 0xF0, 0xFC, 0x1F, 0xFE, 0x07, 0xC0, 0xFF, 0xE0, 0x7C, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x03, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xBE, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x1F,
  0x1F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x0F, 0xC0,
  0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xE0, 0x03, 0xF0, 0xFC,
  0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3F,
  0x3F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0x81, 0xFE, 0x01, 0xF8, 0x07, 0xF0,
  0x1F, 0x80, 0x7F, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0,
  0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x01, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFC, 0x3F, 0xF8, 0x1F, 0xC0, 0x3F,
  0x81, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F,
  0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x03,
  0xF8, 0x3F, 0x00, 0x7F, 0x87, 0xE0, 0x1F, 0xF0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFC, 0x0F, 0x01, 0xFE,
  0x00, 0x20, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x01, 0x00, 0xFF, 0x00, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xF0, 0xFF,
  0x80, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF1, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x3F,
  0x80, 0xFF, 0x07, 0xE0, 0x3F, 0xE0, 0xFC, 0x1F, 0xF8, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xE0, 0x3C, 0x03, 0xFC, 0x00, 0x80, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x07,
  0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00,
  0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xF8,
  0x1F, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F,
  0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x08, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x01, 0x80, 0x1F, 0xC0, 0x1E, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80,
  0x7F, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x1F,
  0xC0, 0x03, 0xF0, 0x7F, 0x80, 0x07, 0xE1, 0xFE, 0x00, 0x0F, 0xC7, 0xF8,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFD, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFC,
  0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0xF7, 0x87, 0xBE, 0x01, 0xF7, 0x87, 0xBC, 0x01, 0xF7, 0x8F, 0x3C, 0x01,
  0xF7, 0x8F, 0x7C, 0x03, 0xE7, 0x9E, 0x7C, 0x03, 0xE7, 0x9E, 0x7C, 0x03,
  0xE7, 0xBC, 0x78, 0x03, 0xE3, 0xBC, 0xF8, 0x07, 0xC3, 0xF8, 0xF8, 0x07,
  0xC3, 0xF8, 0xF8, 0x07, 0xC3, 0xF0, 0xF8, 0x0F, 0xC3, 0xF1, 0xF8, 0x0F,
  0x83, 0xE1, 0xF0, 0x0F, 0x83, 0xC1, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x1F,
  0x80, 0x03, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3F,
  0x00, 0x03, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x3E,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x1F,
  0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0x1F, 0x00, 0xFF, 0x80, 0x3E, 0x01, 0xFF,
  0x80, 0xFC, 0x03, 0xFF, 0x01, 0xF8, 0x07, 0xFE, 0x03, 0xE0, 0x1F, 0xBC,
  0x07, 0xC0, 0x3F, 0x7C, 0x1F, 0x80, 0x7E, 0xF8, 0x3F, 0x00, 0xF9, 0xF0,
  0x7C, 0x01, 0xF1, 0xE0, 0xF8, 0x07, 0xE3, 0xE3, 0xF0, 0x0F, 0xC7, 0xC7,
  0xE0, 0x1F, 0x0F, 0x8F, 0x80, 0x3E, 0x0F, 0x1F, 0x00, 0xFC, 0x1F, 0x3E,
  0x01, 0xF8, 0x3E, 0xFC, 0x03, 0xE0, 0x7D, 0xF8, 0x07, 0xC0, 0x7B, 0xE0,
  0x1F, 0x80, 0xF7, 0xC0, 0x3F, 0x01, 0xFF, 0x80, 0x7C, 0x03, 0xFF, 0x00,
  0xF8, 0x07, 0xFC, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xE0, 0x0F, 0xF0, 0x0F,
  0x80, 0x1F, 0xE0, 0x1F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x0F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xFE,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0xFD,
  0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xEF, 0xE0, 0x01,
  0xFB, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xCF, 0xC0,
  0x03, 0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x8F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x1F, 0xC1, 0xFE,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFE, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00,
  0x7F, 0x01, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFE,
  0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x1F,
  0x80, 0x1F, 0xC0, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0xE0, 0x7F, 0x3F,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x0F, 0xE0, 0x7F,
  0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xF1,
  0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03,
  0xF7, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xDF, 0x80,
  0x07, 0xE7, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xBF,
  0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7E,
  0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xF0, 0xFE, 0x03,
  0xF8, 0x1F, 0xC1, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0x81, 0xFE, 0x01,
  0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x00,
  0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0,
  0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x03, 0xFC, 0x0F, 0xE0,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8,
  0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x7E,
  0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xE0, 0x1C, 0x01, 0xF8, 0x00, 0x40, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x30, 0x00, 0x7F, 0x03, 0xC0,
  0x0F, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0xFE,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F,
  0xC1, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F,
  0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0x83, 0xF0, 0x03,
  0xF8, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x07,
  0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0xFE, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0,
  0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x07,
  0xEF, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF8,
  0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0xFE, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x01,
  0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0,
  0x01, 0xF8, 0x0F, 0x87, 0xC1, 0xF0, 0x0F, 0x87, 0xC1, 0xF0, 0x0F, 0x8F,
  0xE3, 0xF0, 0x1F, 0x8F, 0xE3, 0xE0, 0x1F, 0x1F, 0xE3, 0xE0, 0x1F, 0x1F,
  0xE3, 0xE0, 0x1F, 0x3D, 0xE7, 0xC0, 0x1F, 0x3D, 0xE7, 0xC0, 0x3E, 0x79,
  0xE7, 0xC0, 0x3E, 0x79, 0xE7, 0xC0, 0x3E, 0xF1, 0xE7, 0x80, 0x3E, 0xF1,
  0xEF, 0x80, 0x3D, 0xE1, 0xEF, 0x80, 0x3D, 0xE1, 0xEF, 0x00, 0x7F, 0xC1,
  0xEF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0xC0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x00, 0xFE, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x07,
  0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x1F,
  0xC7, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0,
  0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x7F, 0x00, 0xFC, 0x0F, 0xC0,
  0x1F, 0x83, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x3E, 0x3F, 0x80, 0x07, 0xE7,
  0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01,
  0xFD, 0xFC, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x1F, 0xC0,
  0xFE, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0x7E,
  0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xCF, 0x00, 0x07, 0x81, 0x00, 0x03,
  0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x10, 0x06, 0x01, 0xF0, 0x3F, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xC0, 0x30, 0x02, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xF7, 0xF8, 0x7F, 0x80, 0xFC, 0x7F, 0x80, 0x7E, 0x3F,
  0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xCF,
  0xE0, 0x0F, 0xE7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8,
  0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F,
  0x0F, 0xC0, 0x3F, 0x87, 0xF0, 0x3F, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0x7E, 0x07, 0xFE, 0x3F, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x1E, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xF8,
  0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xCF,
  0xC0, 0x0F, 0xE7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF9,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x3F, 0x03, 0xFE,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xE0, 0x04, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x01, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1D, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xF7, 0xF8, 0x07, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x03,
  0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0xC0,
  0x0F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F,
  0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0xFE, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x3F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0x7E, 0x00, 0x3F, 0xE3, 0xF0, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xC3, 0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0x00,
  0x3F, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x1F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0,
  0x1F, 0xE7, 0xC0, 0x7F, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0xC1, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x06, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xF8, 0x01,
  0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFE,
  0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x00,
  0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xBF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x80, 0x07, 0xF0, 0x03, 0xC0, 0x3F, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x00,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC1, 0xFC, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01,
  0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0,
  0x1F, 0x87, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8,
  0x03, 0xF0, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F,
  0x00, 0x7E, 0x1F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x87,
  0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xE0, 0x00, 0x1E, 0x00,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x04, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F,
  0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x02, 0x00, 0x7E, 0x00, 0x38, 0x1F, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xF0, 0x0F, 0xE0, 0x3F,
  0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x7E, 0x0F, 0xF0, 0x07, 0xE1, 0xFE,
  0x00, 0x7E, 0x3F, 0xC0, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xBF, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x03,
  0xF8, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x03,
  0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0,
  0x7E, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x03, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F,
  0xFF, 0x1F, 0xFF, 0x0F, 0xFE, 0x00, 0xC0, 0x00, 0x0E, 0x01, 0x00, 0x1F,
  0xF9, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x7E, 0x3F, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x07,
  0xC3, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xF0, 0xF8, 0x7C,
  0x3E, 0x0F, 0x87, 0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xC7, 0xE1,
  0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xC1, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8,
  0x7E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x1F, 0x81, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0x87, 0xE0,
  0x1F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xC3,
  0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0xFE, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x1F, 0xE0, 0x7F, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x3F, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFF, 0x07,
  0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x01,
  0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x00,
  0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x07, 0xF0,
  0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xE0,
  0x1F, 0xC0, 0xFC, 0x03, 0xFC, 0x0F, 0xC0, 0x7F, 0x80, 0xFC, 0x1F, 0xF8,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xF3, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xDF, 0xE0, 0xFF, 0x03, 0xF8,
  0x7F, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F, 0xC7, 0xF0, 0x07,
  0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x8F, 0xE0,
  0x0F, 0xE3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F,
  0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x02, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x20, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xE1, 0xF0, 0x1F, 0xC0, 0x08,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x82, 0x00, 0x1F, 0xC1, 0xC0, 0x0F, 0xE1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x87, 0xE0,
  0x1F, 0xC3, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3,
  0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0xFE, 0x01, 0xF8,
  0x7F, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE,
  0xFC, 0x0F, 0xFC, 0x7E, 0x00, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3,
  0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF8,
  0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0xFE,
  0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x3F,
  0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x3F, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xE7,
  0xC0, 0xF0, 0x7C, 0x7C, 0x1F, 0x07, 0xC7, 0xC1, 0xF0, 0x7C, 0x7C, 0x3F,
  0x0F, 0x87, 0xC3, 0xF0, 0xF8, 0x7C, 0x7F, 0x0F, 0x8F, 0x87, 0xF1, 0xF0,
  0xF8, 0xFF, 0x1F, 0x0F, 0x8F, 0xF1, 0xF0, 0xF9, 0xEF, 0x3E, 0x0F, 0x9E,
  0xF3, 0xE0, 0xFB, 0xC7, 0xBC, 0x0F, 0xFC, 0x7F, 0xC0, 0xF7, 0x87, 0xFC,
  0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFE,
  0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x7C,
  0x00, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7E, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x81, 0xF8, 0x01,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x1F, 0xBF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x20,
  0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0xE0, 0xFF, 0xC0, 0x7C, 0x7F, 0xFC,
  0x3F, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xE3, 0xFF, 0xF3, 0xF0,
  0x7F, 0xF8, 0xF8, 0x07, 0xFC, 0x06, 0x00, 0x7C, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 15, 36, 28, 7, -35 },
  { 69, 19, 15, 28, 9, -38 },
  { 105, 30, 35, 28, 0, -35 },
  { 237, 27, 44, 28, 1, -39 },
  { 386, 34, 36, 28, -2, -35 },
  { 539, 26, 36, 28, 1, -35 },
  { 656, 9, 16, 28, 14, -38 },
  { 674, 22, 49, 28, 6, -40 },
  { 809, 22, 49, 28, 1, -40 },
  { 944, 23, 22, 28, 5, -35 },
  { 1008, 24, 25, 28, 2, -27 },
  { 1083, 14, 17, 28, 3, -9 },
  { 1113, 16, 6, 28, 6, -17 },
  { 1125, 10, 10, 28, 7, -9 },
  { 1138, 33, 48, 28, -3, -39 },
  { 1336, 26, 36, 28, 2, -35 },
  { 1453, 22, 35, 28, 2, -35 },
  { 1550, 27, 35, 28, 1, -35 },
  { 1669, 27, 36, 28, 0, -35 },
  { 1791, 28, 35, 28, 0, -35 },
  { 1914, 29, 36, 28, 0, -35 },
  { 2045, 27, 36, 28, 2, -35 },
  { 2167, 26, 35, 28, 5, -35 },
  { 2281, 26, 36, 28, 2, -35 },
  { 2398, 27, 35, 28, 1, -35 },
  { 2517, 14, 27, 28, 7, -26 },
  { 2565, 18, 34, 28, 3, -26 },
  { 2642, 26, 23, 28, 2, -26 },
  { 2717, 27, 16, 28, 1, -23 },
  { 2771, 25, 23, 28, 1, -26 },
  { 2843, 20, 36, 28, 7, -35 },
  { 2933, 28, 43, 28, 1, -35 },
  { 3084, 27, 35, 28, -3, -35 },
  { 3203, 28, 35, 28, 0, -35 },
  { 3326, 27, 36, 28, 3, -35 },
  { 3448, 27, 35, 28, 0, -35 },
  { 3567, 29, 35, 28, 1, -35 },
  { 3694, 29, 35, 28, 1, -35 },
  { 3821, 28, 36, 28, 2, -35 },
  { 3947, 32, 35, 28, -1, -35 },
  { 4087, 30, 35, 28, 0, -35 },
  { 4219, 29, 36, 28, 0, -35 },
  { 4350, 31, 35, 28, 0, -35 },
  { 4486, 22, 35, 28, 1, -35 },
  { 4583, 32, 35, 28, -2, -35 },
  { 4723, 31, 35, 28, 0, -35 },
  { 4859, 26, 36, 28, 2, -35 },
  { 4976, 29, 35, 28, 0, -35 },
  { 5103, 26, 44, 28, 2, -35 },
  { 5246, 28, 35, 28, 0, -35 },
  { 5369, 28, 36, 28, 0, -35 },
  { 5495, 26, 35, 28, 5, -35 },
  { 5609, 28, 36, 28, 2, -35 },
  { 5735, 27, 35, 28, 5, -35 },
  { 5854, 32, 35, 28, 0, -35 },
  { 5994, 34, 35, 28, -2, -35 },
  { 6143, 27, 35, 28, 6, -35 },
  { 6262, 30, 35, 28, 0, -35 },
  { 6394, 27, 48, 28, 3, -39 },
  { 6556, 10, 48, 28, 10, -39 },
  { 6616, 27, 48, 28, -1, -39 },
  { 6778, 25, 20, 28, 3, -35 },
  { 6841, 26, 5, 28, -4, 4 },
  { 6858, 11, 11, 28, 12, -39 },
  { 6874, 25, 28, 28, 2, -27 },
  { 6962, 25, 40, 28, 1, -39 },
  { 7087, 25, 28, 28, 2, -27 },
  { 7175, 29, 40, 28, 2, -39 },
  { 7320, 25, 28, 28, 2, -27 },
  { 7408, 34, 48, 28, -3, -39 },
  { 7612, 30, 36, 28, -2, -27 },
  { 7747, 25, 39, 28, 0, -39 },
  { 7869, 19, 39, 28, 4, -39 },
  { 7962, 28, 48, 28, -2, -39 },
  { 8130, 28, 39, 28, 1, -39 },
  { 8267, 16, 40, 28, 7, -39 },
  { 8347, 28, 27, 28, -1, -27 },
  { 8442, 25, 27, 28, 1, -27 },
  { 8527, 24, 28, 28, 2, -27 },
  { 8611, 28, 36, 28, -2, -27 },
  { 8737, 26, 36, 28, 2, -27 },
  { 8854, 26, 27, 28, 2, -27 },
  { 8942, 25, 28, 28, 1, -27 },
  { 9030, 22, 35, 28, 5, -34 },
  { 9127, 25, 27, 28, 2, -26 },
  { 9212, 25, 26, 28, 4, -26 },
  { 9294, 28, 26, 28, 2, -26 },
  { 9385, 30, 26, 28, -1, -26 },
  { 9483, 32, 35, 28, -4, -26 },
  { 9623, 26, 26, 28, 1, -26 },
  { 9708, 27, 48, 28, 3, -39 },
  { 9870, 18, 48, 28, 5, -39 },
  { 9978, 27, 48, 28, -2, -39 },
  { 10140, 26, 10, 28, 1, -20 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic50pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic50pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic50pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC50PT7B_H_
