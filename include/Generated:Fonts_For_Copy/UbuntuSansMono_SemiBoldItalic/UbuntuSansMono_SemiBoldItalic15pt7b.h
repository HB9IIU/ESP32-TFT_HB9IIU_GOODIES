#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC15PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x66, 0x30, 0x00, 0xE7, 0x00, 0xDE, 0xE7, 0x20, 0x0D,
  0x8C, 0x9F, 0xEF, 0xF3, 0x61, 0x23, 0xFC, 0xD8, 0x48, 0x6C, 0x00, 0x06,
  0x06, 0x1F, 0x3B, 0x30, 0x30, 0x1C, 0x0E, 0x06, 0x06, 0xFE, 0x78, 0x30,
  0x30, 0x08, 0x23, 0x98, 0x92, 0x16, 0x83, 0xA0, 0x28, 0x03, 0xE0, 0xD4,
  0x14, 0x84, 0x93, 0x1C, 0x00, 0x0C, 0x1E, 0x32, 0x36, 0x3C, 0x3A, 0x7B,
  0xCE, 0xC6, 0xCE, 0x7A, 0x7B, 0x60, 0x04, 0x31, 0x8C, 0x61, 0x0C, 0x30,
  0xC2, 0x0C, 0x30, 0xC1, 0x82, 0x00, 0x08, 0x38, 0x30, 0x20, 0x60, 0xC1,
  0x83, 0x0C, 0x18, 0x60, 0xC3, 0x1C, 0x10, 0x00, 0x32, 0xDF, 0xCC, 0xFD,
  0x20, 0x18, 0x30, 0x47, 0xF3, 0x06, 0x08, 0x00, 0x27, 0x73, 0xE8, 0xFF,
  0x80, 0x5F, 0x80, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x00, 0x0C, 0x7D,
  0x9A, 0x1D, 0x3A, 0xE5, 0xC3, 0x8D, 0xBB, 0xE0, 0x1C, 0xF6, 0x86, 0x18,
  0x61, 0x0C, 0xFF, 0xF0, 0x0E, 0x3F, 0x23, 0x03, 0x03, 0x06, 0x1C, 0x30,
  0x60, 0x7E, 0xFE, 0x0C, 0x3F, 0x23, 0x03, 0x06, 0x1C, 0x06, 0x06, 0x06,
  0xCE, 0xFC, 0x07, 0x0F, 0x1B, 0x12, 0x26, 0x66, 0xFF, 0x04, 0x0C, 0x0C,
  0x1F, 0x88, 0x04, 0x06, 0x03, 0xC0, 0x30, 0x18, 0x0C, 0x4E, 0x7E, 0x00,
  0x1F, 0x38, 0x60, 0xC8, 0xFC, 0xC6, 0xC6, 0xC6, 0xCC, 0x78, 0x7F, 0x06,
  0x06, 0x0C, 0x18, 0x30, 0x30, 0x60, 0x60, 0xE0, 0x0E, 0x1F, 0x31, 0x31,
  0x33, 0x1E, 0x36, 0x63, 0xC2, 0x66, 0x7C, 0x0C, 0x3F, 0x33, 0x61, 0x61,
  0x77, 0x3F, 0x02, 0x06, 0x3C, 0xF0, 0x37, 0x30, 0x04, 0xEE, 0x19, 0xC6,
  0x00, 0x11, 0xCE, 0x37, 0x20, 0x02, 0x1D, 0xE7, 0x0F, 0x07, 0x83, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0xFE, 0x20, 0x78, 0x1E, 0x07, 0x1E, 0xF8, 0xC0,
  0x39, 0xF4, 0xC3, 0x18, 0xC6, 0x00, 0x03, 0x8C, 0x00, 0x06, 0x0F, 0x8C,
  0x6C, 0x36, 0xFA, 0xC9, 0x6D, 0xB6, 0xDB, 0x6F, 0x10, 0x0C, 0x03, 0xC0,
  0x07, 0x07, 0x0F, 0x1B, 0x1B, 0x31, 0x3F, 0x7F, 0x63, 0xC3, 0x04, 0x3F,
  0x33, 0x33, 0x23, 0x7C, 0x66, 0x63, 0x43, 0xEE, 0xFC, 0x0E, 0x3F, 0x71,
  0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE4, 0x7C, 0x08, 0x3E, 0x33, 0x33,
  0x63, 0x63, 0x63, 0x63, 0xC6, 0xFC, 0xF8, 0x1F, 0x98, 0x0C, 0x06, 0x03,
  0xE3, 0x01, 0x80, 0xC0, 0x7E, 0x7F, 0x00, 0x1F, 0x98, 0x0C, 0x06, 0x03,
  0xF3, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x00, 0x0E, 0x3F, 0x71, 0x60, 0xC0,
  0xC0, 0xC6, 0xC6, 0xCC, 0xEC, 0x7C, 0x31, 0x98, 0xCC, 0x4C, 0x67, 0xF3,
  0x19, 0x8D, 0x8C, 0xC6, 0x63, 0x00, 0x3F, 0x86, 0x03, 0x01, 0x80, 0xC0,
  0xC0, 0x60, 0x30, 0x7E, 0x7E, 0x00, 0x1F, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x30, 0x18, 0x0C, 0x4C, 0x7E, 0x00, 0x31, 0x99, 0x8D, 0x85, 0x87, 0x83,
  0xC1, 0xB0, 0x98, 0xC6, 0x63, 0x00, 0x38, 0x60, 0xC1, 0x86, 0x0C, 0x18,
  0x30, 0x7F, 0xFC, 0x31, 0x99, 0xCC, 0xEF, 0xA7, 0xD2, 0x5B, 0x0D, 0x86,
  0xC2, 0x43, 0x00, 0x31, 0x9C, 0xCE, 0x4D, 0x26, 0xB3, 0x79, 0x3D, 0x8C,
  0xC6, 0x63, 0x00, 0x0C, 0x7D, 0x9A, 0x1C, 0x38, 0xF1, 0xC3, 0x8D, 0xBB,
  0xE0, 0x04, 0x1F, 0x8C, 0xE6, 0x32, 0x13, 0x39, 0xF8, 0xC0, 0x60, 0x60,
  0x30, 0x00, 0x0C, 0x7D, 0x9A, 0x1C, 0x38, 0xF1, 0xC3, 0x8D, 0xBB, 0xE3,
  0x03, 0x83, 0x00, 0x08, 0x3F, 0x33, 0x33, 0x23, 0x6F, 0x7C, 0x6C, 0x44,
  0xC6, 0xC6, 0x0E, 0x0F, 0xCC, 0x46, 0x03, 0x00, 0xE0, 0x38, 0x0C, 0x06,
  0x67, 0x3F, 0x00, 0xFE, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x61, 0x80,
  0x63, 0x63, 0x42, 0xC6, 0xC6, 0xC6, 0xC4, 0x8C, 0xDC, 0xF8, 0xC7, 0xC6,
  0xCC, 0xCC, 0xC8, 0xD8, 0xD0, 0xF0, 0xE0, 0xE0, 0x30, 0xC8, 0x66, 0x19,
  0xB4, 0x6D, 0x17, 0xC7, 0x73, 0x98, 0xE6, 0x31, 0x80, 0x18, 0xE1, 0xB0,
  0x34, 0x03, 0x80, 0x60, 0x1C, 0x06, 0x81, 0x98, 0x33, 0x1C, 0x60, 0xC7,
  0xC6, 0xCC, 0x58, 0x70, 0x70, 0x60, 0x60, 0x60, 0xC0, 0x3F, 0x81, 0x81,
  0x81, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0x7F, 0x00, 0x1F, 0x1F, 0x18,
  0x10, 0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xF8, 0xF0,
  0xDB, 0x6D, 0xB2, 0x4D, 0xB6, 0xD8, 0x1F, 0x1E, 0x06, 0x06, 0x06, 0x04,
  0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0xF0, 0xF0, 0x1C, 0x78, 0xDB,
  0x3C, 0x68, 0x80, 0xFF, 0xFE, 0x4E, 0x30, 0x1F, 0x3F, 0x63, 0x62, 0x46,
  0xC6, 0x6E, 0x7E, 0x08, 0x10, 0x30, 0x30, 0x3E, 0x3F, 0x63, 0x63, 0x63,
  0x66, 0xCE, 0xFC, 0x3E, 0xFF, 0x06, 0x0C, 0x18, 0x3B, 0x3E, 0x01, 0x03,
  0x03, 0x02, 0x3E, 0x7E, 0xC6, 0xC4, 0x8C, 0x8C, 0xDC, 0xFC, 0x3C, 0xEF,
  0x1E, 0x7F, 0x90, 0x31, 0x3E, 0x01, 0xC0, 0xF0, 0x60, 0x18, 0x1F, 0x87,
  0xE0, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x3C, 0x0E, 0x00,
  0x0F, 0x8E, 0xCC, 0x66, 0x33, 0x31, 0x98, 0xFC, 0x16, 0x06, 0x3F, 0x3E,
  0x00, 0x08, 0x10, 0x30, 0x30, 0x3E, 0x3F, 0x63, 0x62, 0x66, 0x66, 0xC6,
  0xC6, 0x18, 0x61, 0x80, 0x7B, 0xC3, 0x0C, 0x30, 0xC3, 0x4F, 0x01, 0x01,
  0xC0, 0x40, 0x01, 0xF0, 0xF8, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0xC3, 0xE3, 0xE0, 0x08, 0x0C, 0x04, 0x06, 0x03, 0x39, 0xB0, 0xF0, 0xF0,
  0x78, 0x36, 0x19, 0x98, 0xC0, 0xF7, 0x8C, 0x62, 0x31, 0x8C, 0x46, 0x3A,
  0xF0, 0x3F, 0x6F, 0x69, 0x4B, 0x5B, 0xC2, 0xC2, 0x86, 0x3E, 0x3F, 0x23,
  0x63, 0x66, 0x66, 0x46, 0xC6, 0x3C, 0xFF, 0x1E, 0x38, 0x71, 0xB7, 0x7C,
  0x1F, 0x0F, 0xCC, 0x66, 0x33, 0x19, 0x99, 0xBC, 0xF8, 0x60, 0x30, 0x30,
  0x00, 0x3E, 0xFF, 0x1E, 0x3C, 0xD1, 0xB7, 0x7E, 0x18, 0x30, 0x60, 0x3E,
  0xFD, 0x83, 0x0C, 0x18, 0x30, 0x60, 0x1F, 0x3E, 0x30, 0x38, 0x1E, 0x06,
  0x4E, 0xFC, 0x18, 0x61, 0xFF, 0xF3, 0x04, 0x18, 0x30, 0x74, 0x78, 0x66,
  0x8F, 0x1E, 0x6C, 0xD9, 0xB7, 0x7E, 0xC7, 0xC6, 0xC6, 0x4C, 0x68, 0x78,
  0x70, 0x60, 0xC3, 0xC3, 0x92, 0xB6, 0xBE, 0xFC, 0xDC, 0x88, 0x63, 0x99,
  0x85, 0x83, 0x81, 0xC1, 0xE1, 0x99, 0x8C, 0x31, 0xCC, 0x61, 0x18, 0x6C,
  0x1B, 0x07, 0x81, 0xE0, 0x30, 0x18, 0x3C, 0x0E, 0x00, 0x3F, 0x3F, 0x06,
  0x0C, 0x18, 0x30, 0x7E, 0xFE, 0x07, 0x0F, 0x18, 0x18, 0x18, 0x10, 0x30,
  0xE0, 0x60, 0x20, 0x60, 0x60, 0x60, 0x78, 0x38, 0x18, 0xC4, 0x63, 0x18,
  0x8C, 0x63, 0x11, 0x8C, 0x63, 0x00, 0x0E, 0x1E, 0x03, 0x02, 0x06, 0x06,
  0x06, 0x03, 0x06, 0x0C, 0x0C, 0x08, 0x18, 0x78, 0xF0, 0x31, 0x7F, 0xCE,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 10, 8, 2, -10 },
  { 8, 5, 4, 8, 3, -11 },
  { 11, 9, 10, 8, 0, -10 },
  { 23, 8, 14, 8, 0, -12 },
  { 37, 11, 11, 8, -1, -11 },
  { 53, 8, 11, 8, 0, -11 },
  { 64, 3, 4, 8, 4, -11 },
  { 66, 6, 15, 8, 2, -12 },
  { 78, 7, 15, 8, 0, -12 },
  { 92, 6, 6, 8, 2, -10 },
  { 97, 7, 7, 8, 1, -8 },
  { 104, 4, 6, 8, 1, -3 },
  { 107, 5, 2, 8, 2, -5 },
  { 109, 3, 3, 8, 2, -3 },
  { 111, 10, 15, 8, -1, -12 },
  { 130, 7, 11, 8, 1, -11 },
  { 140, 6, 10, 8, 1, -10 },
  { 148, 8, 11, 8, 0, -11 },
  { 159, 8, 11, 8, 0, -11 },
  { 170, 8, 10, 8, 0, -10 },
  { 180, 9, 10, 8, 0, -10 },
  { 192, 8, 10, 8, 1, -10 },
  { 202, 8, 10, 8, 1, -10 },
  { 212, 8, 11, 8, 0, -11 },
  { 223, 8, 11, 8, 0, -11 },
  { 234, 4, 8, 8, 2, -8 },
  { 238, 5, 11, 8, 1, -8 },
  { 245, 7, 7, 8, 1, -8 },
  { 252, 8, 5, 8, 0, -7 },
  { 257, 8, 7, 8, 0, -8 },
  { 264, 6, 11, 8, 2, -11 },
  { 273, 9, 13, 8, 0, -11 },
  { 288, 8, 10, 8, -1, -10 },
  { 298, 8, 11, 8, 0, -11 },
  { 309, 8, 11, 8, 1, -11 },
  { 320, 8, 11, 8, 0, -11 },
  { 331, 9, 10, 8, 0, -10 },
  { 343, 9, 10, 8, 0, -10 },
  { 355, 8, 11, 8, 1, -11 },
  { 366, 9, 10, 8, 0, -10 },
  { 378, 9, 10, 8, 0, -10 },
  { 390, 9, 10, 8, 0, -10 },
  { 402, 9, 10, 8, 0, -10 },
  { 414, 7, 10, 8, 0, -10 },
  { 423, 9, 10, 8, 0, -10 },
  { 435, 9, 10, 8, 0, -10 },
  { 447, 7, 11, 8, 1, -11 },
  { 457, 9, 11, 8, 0, -11 },
  { 470, 7, 14, 8, 1, -11 },
  { 483, 8, 11, 8, 0, -11 },
  { 494, 9, 11, 8, 0, -11 },
  { 507, 7, 10, 8, 2, -10 },
  { 516, 8, 10, 8, 1, -10 },
  { 526, 8, 10, 8, 2, -10 },
  { 536, 10, 10, 8, 0, -10 },
  { 549, 11, 10, 8, -1, -10 },
  { 563, 8, 10, 8, 2, -10 },
  { 573, 9, 10, 8, 0, -10 },
  { 585, 8, 15, 8, 1, -12 },
  { 600, 3, 15, 8, 3, -12 },
  { 606, 8, 15, 8, 0, -12 },
  { 621, 7, 6, 8, 1, -10 },
  { 627, 8, 2, 8, -1, 1 },
  { 629, 4, 3, 8, 3, -12 },
  { 631, 8, 8, 8, 0, -8 },
  { 639, 8, 12, 8, 0, -12 },
  { 651, 7, 8, 8, 1, -8 },
  { 658, 8, 12, 8, 1, -12 },
  { 670, 7, 8, 8, 1, -8 },
  { 677, 10, 15, 8, -1, -12 },
  { 696, 9, 11, 8, -1, -8 },
  { 709, 8, 12, 8, 0, -12 },
  { 721, 6, 12, 8, 1, -12 },
  { 730, 9, 15, 8, -1, -12 },
  { 747, 9, 12, 8, 0, -12 },
  { 761, 5, 12, 8, 2, -12 },
  { 769, 8, 8, 8, 0, -8 },
  { 777, 8, 8, 8, 0, -8 },
  { 785, 7, 8, 8, 1, -8 },
  { 792, 9, 11, 8, -1, -8 },
  { 805, 7, 11, 8, 1, -8 },
  { 815, 7, 8, 8, 1, -8 },
  { 822, 8, 8, 8, 0, -8 },
  { 830, 7, 10, 8, 1, -10 },
  { 839, 7, 8, 8, 1, -8 },
  { 846, 8, 8, 8, 1, -8 },
  { 854, 8, 8, 8, 1, -8 },
  { 862, 9, 8, 8, 0, -8 },
  { 871, 10, 11, 8, -1, -8 },
  { 885, 8, 8, 8, 0, -8 },
  { 893, 8, 15, 8, 1, -12 },
  { 908, 5, 15, 8, 2, -12 },
  { 918, 8, 15, 8, -1, -12 },
  { 933, 8, 3, 8, 0, -6 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic15pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic15pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic15pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC15PT7B_H_
