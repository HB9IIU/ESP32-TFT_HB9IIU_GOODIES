#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC14PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x32, 0x66, 0x40, 0xCC, 0xDE, 0xE5, 0x29, 0x00, 0x09, 0x1B,
  0x12, 0x7F, 0x36, 0x24, 0xFE, 0xFE, 0x58, 0xD0, 0x04, 0x04, 0x3F, 0x31,
  0x30, 0x38, 0x1C, 0x06, 0x06, 0xFC, 0x78, 0x30, 0x20, 0x18, 0xCB, 0x22,
  0x90, 0xA8, 0x34, 0x03, 0xC1, 0xF8, 0x56, 0x25, 0x31, 0xC0, 0x1C, 0x6C,
  0x99, 0x23, 0x8F, 0x53, 0xE6, 0xCC, 0xEC, 0x7E, 0x80, 0x08, 0x73, 0x18,
  0x43, 0x0C, 0x20, 0x82, 0x0C, 0x30, 0x61, 0x00, 0x18, 0x60, 0xC3, 0x04,
  0x10, 0x43, 0x0C, 0x63, 0x1C, 0xC2, 0x00, 0x10, 0x21, 0xFD, 0xC2, 0x8D,
  0x80, 0x18, 0x41, 0x3F, 0xFC, 0x86, 0x00, 0x77, 0x2C, 0xFF, 0xF8, 0x01,
  0x80, 0xC0, 0xC0, 0x60, 0x60, 0x20, 0x30, 0x10, 0x18, 0x18, 0x0C, 0x0C,
  0x06, 0x06, 0x00, 0x1C, 0xF9, 0x9E, 0x3F, 0x76, 0xA1, 0x46, 0xD9, 0xE0,
  0x0C, 0x67, 0x96, 0x18, 0x43, 0x0C, 0x37, 0xE0, 0x1E, 0x3F, 0x23, 0x03,
  0x06, 0x1C, 0x30, 0x60, 0x42, 0xFC, 0x1E, 0x3E, 0x03, 0x06, 0x1C, 0x1C,
  0x06, 0x06, 0x8C, 0xFC, 0x03, 0x06, 0x0A, 0x16, 0x26, 0x66, 0xFE, 0xFE,
  0x0C, 0x0C, 0x1F, 0x1F, 0x10, 0x30, 0x38, 0x0E, 0x06, 0x06, 0x8C, 0xFC,
  0x06, 0x7D, 0x82, 0x0F, 0x99, 0xA1, 0x46, 0xCC, 0xF0, 0x7F, 0x7E, 0x06,
  0x0C, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC0, 0x1E, 0x3F, 0x33, 0x33, 0x3E,
  0x3C, 0x66, 0xC6, 0x46, 0x7C, 0x1C, 0x3E, 0x63, 0x63, 0x63, 0x3E, 0x06,
  0x0C, 0x3C, 0xF0, 0x77, 0x00, 0x0E, 0xC0, 0x39, 0xC0, 0x00, 0x39, 0xC4,
  0xC0, 0x0E, 0x7B, 0x87, 0x07, 0x83, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x70,
  0x78, 0x38, 0x77, 0x98, 0x00, 0x79, 0xF0, 0xC6, 0x31, 0x84, 0x00, 0xC3,
  0x00, 0x0E, 0x3B, 0x21, 0x6F, 0x5F, 0x53, 0xD2, 0xD2, 0xDE, 0x40, 0x60,
  0x3C, 0x06, 0x06, 0x0F, 0x0B, 0x1B, 0x33, 0x3F, 0x7F, 0x63, 0xC3, 0x3E,
  0x3F, 0x33, 0x23, 0x7E, 0x7E, 0x66, 0x46, 0xCE, 0xFC, 0x1E, 0x7D, 0x86,
  0x0C, 0x18, 0x30, 0x60, 0xC8, 0xF8, 0x3C, 0x3E, 0x23, 0x63, 0x63, 0x62,
  0x46, 0x46, 0xDC, 0xF8, 0x1F, 0x3F, 0x30, 0x30, 0x3E, 0x7E, 0x60, 0x60,
  0x42, 0xFC, 0x1F, 0x9F, 0x8C, 0x06, 0x03, 0xE3, 0xF1, 0x80, 0xC0, 0x40,
  0x60, 0x00, 0x1E, 0x7D, 0x86, 0x0C, 0x10, 0xA3, 0x46, 0xCC, 0xF0, 0x31,
  0x98, 0x88, 0xCC, 0x67, 0xF3, 0xF1, 0x19, 0x8C, 0xC6, 0x66, 0x00, 0x3F,
  0x3F, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x10, 0xFC, 0x1F, 0x1F, 0x03,
  0x02, 0x06, 0x06, 0x06, 0x04, 0x4C, 0xF8, 0x31, 0x99, 0x8D, 0x85, 0x87,
  0x83, 0xC1, 0xA0, 0x98, 0xC4, 0x63, 0x00, 0x30, 0xC3, 0x08, 0x61, 0x86,
  0x10, 0x43, 0xF0, 0x31, 0x33, 0x33, 0x75, 0x77, 0x5B, 0x5A, 0xC2, 0xC6,
  0x86, 0x31, 0x98, 0x8C, 0xCF, 0x66, 0xB3, 0x51, 0x29, 0x9C, 0xCE, 0x62,
  0x00, 0x3C, 0xFD, 0x9E, 0x3C, 0x70, 0xE1, 0x46, 0xD9, 0xE0, 0x3E, 0x3F,
  0x33, 0x23, 0x63, 0x7E, 0x78, 0x40, 0xC0, 0xC0, 0x3C, 0xFD, 0x9E, 0x3C,
  0x70, 0xE1, 0x46, 0xD9, 0xE1, 0x81, 0xC0, 0x80, 0x3C, 0x3E, 0x33, 0x23,
  0x66, 0x7C, 0x6C, 0x4C, 0xC4, 0xC6, 0x1E, 0x3F, 0x20, 0x30, 0x38, 0x1C,
  0x06, 0x06, 0x4C, 0xFC, 0xFF, 0xFC, 0xC1, 0x06, 0x0C, 0x18, 0x20, 0x41,
  0x80, 0x62, 0xCD, 0x1E, 0x3C, 0x59, 0xA3, 0x46, 0xD9, 0xF0, 0x87, 0x0E,
  0x34, 0x69, 0x93, 0x2C, 0x50, 0xE1, 0x80, 0x31, 0x90, 0xD8, 0x4C, 0x25,
  0xB2, 0xD1, 0xE9, 0xD4, 0xEE, 0x66, 0x00, 0x18, 0xC6, 0x60, 0x90, 0x3C,
  0x0E, 0x03, 0x81, 0xE0, 0xC8, 0x33, 0x38, 0xC0, 0x87, 0x8B, 0x36, 0xC5,
  0x0E, 0x18, 0x30, 0x41, 0x80, 0x3F, 0x3F, 0x06, 0x0C, 0x0C, 0x18, 0x30,
  0x60, 0xC2, 0xFC, 0x1E, 0x20, 0x41, 0x83, 0x04, 0x08, 0x30, 0x60, 0xC1,
  0x06, 0x0F, 0x1E, 0x00, 0x9B, 0x6D, 0xB6, 0xC9, 0x24, 0xC0, 0x1E, 0x0C,
  0x18, 0x20, 0xC1, 0x83, 0x04, 0x18, 0x30, 0x60, 0x8F, 0x1E, 0x00, 0x18,
  0x38, 0xF3, 0x6C, 0x70, 0x80, 0xFF, 0xFC, 0x5C, 0x80, 0x04, 0x3F, 0x66,
  0x66, 0x46, 0xC6, 0x6C, 0x7E, 0x10, 0x60, 0xC1, 0x83, 0xEC, 0xD8, 0xB3,
  0x47, 0x9B, 0xE0, 0x08, 0xFF, 0x86, 0x08, 0x10, 0x32, 0x3C, 0x01, 0x81,
  0x80, 0xC0, 0x63, 0xF3, 0x11, 0x98, 0x8C, 0xC6, 0x37, 0x1F, 0x80, 0x10,
  0xFB, 0x1E, 0x6F, 0x90, 0x31, 0x3C, 0x03, 0xC1, 0xE0, 0x40, 0x30, 0x1F,
  0x8B, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0xF0, 0x30, 0x00,
  0x04, 0x3F, 0x62, 0x66, 0x46, 0x46, 0x7C, 0x2C, 0x0C, 0xF8, 0x60, 0x10,
  0x60, 0xC1, 0xC3, 0xEC, 0xD9, 0xB3, 0x47, 0x8B, 0x30, 0x18, 0xC0, 0x0F,
  0x18, 0xC6, 0x23, 0xCE, 0x03, 0x03, 0x00, 0x00, 0x1F, 0x02, 0x06, 0x06,
  0x06, 0x04, 0x0C, 0x0C, 0xF8, 0x30, 0x18, 0x10, 0x30, 0x30, 0x37, 0x2C,
  0x78, 0x78, 0x6C, 0x4C, 0xC6, 0xF7, 0x88, 0xC6, 0x31, 0x08, 0xC6, 0x5E,
  0x7F, 0x6B, 0x5A, 0x5A, 0xC6, 0xC6, 0x84, 0x08, 0x7C, 0x9B, 0x36, 0x6C,
  0xD1, 0x66, 0x08, 0x7D, 0x9B, 0x14, 0x78, 0xDB, 0x3C, 0x04, 0x1F, 0x33,
  0x31, 0x33, 0x23, 0x66, 0x7C, 0x60, 0x40, 0xC0, 0x08, 0xFF, 0x96, 0x68,
  0xD1, 0xB6, 0x7C, 0x18, 0x30, 0x40, 0x7E, 0xC1, 0x06, 0x0C, 0x18, 0x20,
  0x00, 0x0C, 0x7C, 0x81, 0x81, 0xC0, 0x93, 0x7E, 0x08, 0x60, 0xCF, 0xE2,
  0x0C, 0x18, 0x30, 0x64, 0xF0, 0x47, 0x9B, 0x36, 0x68, 0x9B, 0x3F, 0x00,
  0xC7, 0x9B, 0x32, 0xC5, 0x8E, 0x18, 0x00, 0x61, 0x4B, 0x5B, 0x5A, 0x6E,
  0x6C, 0xCC, 0x63, 0x36, 0x1C, 0x18, 0x3C, 0x6C, 0xC6, 0x31, 0x98, 0x84,
  0xC2, 0x41, 0xE0, 0xE0, 0x70, 0x30, 0xF0, 0x60, 0x00, 0x3F, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xFC, 0x0E, 0x30, 0x60, 0x83, 0x06, 0x38, 0x70, 0x60,
  0xC1, 0x82, 0x07, 0x86, 0x00, 0x08, 0xC6, 0x31, 0x18, 0xC6, 0x23, 0x18,
  0xC4, 0x60, 0x1E, 0x06, 0x06, 0x06, 0x06, 0x04, 0x07, 0x07, 0x0C, 0x08,
  0x08, 0x18, 0x70, 0xE0, 0x7B, 0xCE,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 10, 8, 2, -10 },
  { 6, 5, 5, 8, 3, -11 },
  { 10, 8, 10, 8, 0, -10 },
  { 20, 8, 13, 8, 0, -11 },
  { 33, 10, 10, 8, -1, -10 },
  { 46, 7, 10, 8, 0, -10 },
  { 55, 2, 5, 8, 4, -11 },
  { 57, 6, 14, 8, 2, -11 },
  { 68, 6, 14, 8, 0, -11 },
  { 79, 7, 6, 8, 1, -10 },
  { 85, 6, 7, 8, 1, -8 },
  { 91, 4, 4, 8, 1, -2 },
  { 93, 4, 2, 8, 2, -5 },
  { 94, 3, 2, 8, 2, -2 },
  { 95, 9, 14, 8, -1, -11 },
  { 111, 7, 10, 8, 1, -10 },
  { 120, 6, 10, 8, 1, -10 },
  { 128, 8, 10, 8, 0, -10 },
  { 138, 8, 10, 8, 0, -10 },
  { 148, 8, 10, 8, 0, -10 },
  { 158, 8, 10, 8, 0, -10 },
  { 168, 7, 10, 8, 1, -10 },
  { 177, 8, 10, 8, 1, -10 },
  { 187, 8, 10, 8, 0, -10 },
  { 197, 8, 10, 8, 0, -10 },
  { 207, 4, 7, 8, 2, -7 },
  { 211, 5, 9, 8, 1, -7 },
  { 217, 7, 6, 8, 1, -7 },
  { 223, 8, 4, 8, 0, -6 },
  { 227, 7, 6, 8, 0, -7 },
  { 233, 6, 10, 8, 2, -10 },
  { 241, 8, 12, 8, 0, -10 },
  { 253, 8, 10, 8, -1, -10 },
  { 263, 8, 10, 8, 0, -10 },
  { 273, 7, 10, 8, 1, -10 },
  { 282, 8, 10, 8, 0, -10 },
  { 292, 8, 10, 8, 0, -10 },
  { 302, 9, 10, 8, 0, -10 },
  { 314, 7, 10, 8, 1, -10 },
  { 323, 9, 10, 8, 0, -10 },
  { 335, 8, 10, 8, 0, -10 },
  { 345, 8, 10, 8, 0, -10 },
  { 355, 9, 10, 8, 0, -10 },
  { 367, 6, 10, 8, 0, -10 },
  { 375, 8, 10, 8, 0, -10 },
  { 385, 9, 10, 8, 0, -10 },
  { 397, 7, 10, 8, 1, -10 },
  { 406, 8, 10, 8, 0, -10 },
  { 416, 7, 13, 8, 1, -10 },
  { 428, 8, 10, 8, 0, -10 },
  { 438, 8, 10, 8, 0, -10 },
  { 448, 7, 10, 8, 2, -10 },
  { 457, 7, 10, 8, 1, -10 },
  { 466, 7, 10, 8, 2, -10 },
  { 475, 9, 10, 8, 0, -10 },
  { 487, 10, 10, 8, -1, -10 },
  { 500, 7, 10, 8, 2, -10 },
  { 509, 8, 10, 8, 0, -10 },
  { 519, 7, 14, 8, 1, -11 },
  { 532, 3, 14, 8, 3, -11 },
  { 538, 7, 14, 8, 0, -11 },
  { 551, 7, 6, 8, 1, -10 },
  { 557, 7, 2, 8, -1, 1 },
  { 559, 3, 3, 8, 3, -11 },
  { 561, 8, 8, 8, 0, -8 },
  { 569, 7, 11, 8, 0, -11 },
  { 579, 7, 8, 8, 1, -8 },
  { 586, 9, 11, 8, 0, -11 },
  { 599, 7, 8, 8, 1, -8 },
  { 606, 10, 14, 8, -1, -11 },
  { 624, 8, 11, 8, 0, -8 },
  { 635, 7, 11, 8, 0, -11 },
  { 645, 5, 11, 8, 1, -11 },
  { 652, 8, 14, 8, -1, -11 },
  { 666, 8, 11, 8, 0, -11 },
  { 677, 5, 11, 8, 2, -11 },
  { 684, 8, 7, 8, 0, -7 },
  { 691, 7, 8, 8, 0, -8 },
  { 698, 7, 8, 8, 0, -8 },
  { 705, 8, 11, 8, -1, -8 },
  { 716, 7, 11, 8, 1, -8 },
  { 726, 7, 7, 8, 1, -7 },
  { 733, 7, 8, 8, 0, -8 },
  { 740, 7, 10, 8, 1, -10 },
  { 749, 7, 7, 8, 1, -7 },
  { 756, 7, 7, 8, 1, -7 },
  { 763, 8, 7, 8, 0, -7 },
  { 770, 8, 7, 8, 0, -7 },
  { 777, 9, 10, 8, -1, -7 },
  { 789, 8, 7, 8, 0, -7 },
  { 796, 7, 14, 8, 1, -11 },
  { 809, 5, 14, 8, 1, -11 },
  { 818, 8, 14, 8, -1, -11 },
  { 832, 8, 2, 8, 0, -5 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic14pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic14pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic14pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC14PT7B_H_
