#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC13PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x66, 0x64, 0x0C, 0xC0, 0x6A, 0xD7, 0xA0, 0x1B, 0x12, 0x7F,
  0x7E, 0x2C, 0xFE, 0xFE, 0x58, 0x90, 0x0C, 0x38, 0xF9, 0x03, 0x07, 0x03,
  0x02, 0xFC, 0xF0, 0x80, 0x31, 0x52, 0x54, 0x78, 0x18, 0x3E, 0x2A, 0x4A,
  0x8C, 0x1C, 0x48, 0x91, 0x43, 0x2B, 0xF3, 0x66, 0x74, 0xFA, 0x0C, 0x63,
  0x08, 0x61, 0x04, 0x30, 0x41, 0x06, 0x0C, 0x18, 0x60, 0xC3, 0x0C, 0x30,
  0xC2, 0x18, 0xC6, 0x30, 0x31, 0x5F, 0xCC, 0x6C, 0xA0, 0x08, 0x31, 0xFF,
  0xF1, 0x06, 0x00, 0x6C, 0xE0, 0xFF, 0xF0, 0x01, 0x81, 0x80, 0x80, 0xC0,
  0x40, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x18, 0x00, 0x3D, 0xBC, 0x75,
  0xBE, 0x38, 0xA6, 0xF0, 0x0C, 0x72, 0xC2, 0x18, 0x61, 0x84, 0xFC, 0x3E,
  0x4C, 0x18, 0x30, 0xC6, 0x18, 0x20, 0xFC, 0x3E, 0x4C, 0x18, 0x63, 0xC0,
  0x81, 0x46, 0xF8, 0x06, 0x1C, 0x79, 0xA6, 0x59, 0xBF, 0x84, 0x08, 0x1F,
  0x10, 0x30, 0x30, 0x7C, 0x04, 0x04, 0x8C, 0xF8, 0x1E, 0x61, 0x86, 0x8F,
  0x91, 0xA3, 0x64, 0xF0, 0x7E, 0x08, 0x30, 0xC3, 0x04, 0x18, 0x20, 0xC0,
  0x1E, 0x64, 0x89, 0xB3, 0x8C, 0xB1, 0xE6, 0x78, 0x3C, 0x4D, 0x8B, 0x17,
  0xE2, 0xC3, 0x0C, 0xF0, 0x6C, 0x01, 0xB0, 0x33, 0x00, 0x06, 0x62, 0xC0,
  0x04, 0x7F, 0x30, 0x70, 0x60, 0x7E, 0x00, 0x0F, 0xE0, 0x20, 0xE0, 0x78,
  0x77, 0x98, 0x00, 0xFC, 0xC6, 0x66, 0x60, 0x18, 0xC0, 0x1E, 0x33, 0x63,
  0x5E, 0x52, 0xD6, 0xD6, 0xDC, 0x40, 0x60, 0x38, 0x06, 0x1C, 0x28, 0xD1,
  0x26, 0x4F, 0xB1, 0xC2, 0x3E, 0x4C, 0x8B, 0x37, 0xC8, 0xD1, 0xE6, 0xF8,
  0x3E, 0xC9, 0x06, 0x08, 0x10, 0x20, 0x64, 0x78, 0x3C, 0x4D, 0x9B, 0x16,
  0x68, 0xD1, 0x6E, 0xF8, 0x3F, 0x30, 0x20, 0x20, 0x7C, 0x60, 0x60, 0x40,
  0xFC, 0x3F, 0x30, 0x30, 0x22, 0x7C, 0x60, 0x60, 0x40, 0xC0, 0x3E, 0xCB,
  0x06, 0x08, 0xD1, 0xA2, 0x64, 0xF8, 0x33, 0x23, 0x62, 0x66, 0x7E, 0x46,
  0xC4, 0xC4, 0xCC, 0x3F, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x30, 0xFC,
  0x1F, 0x02, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x4C, 0xF8, 0x33, 0x26, 0x2C,
  0x78, 0x70, 0x58, 0x48, 0xCC, 0xC4, 0x30, 0xC2, 0x18, 0x61, 0x84, 0x30,
  0xFC, 0x33, 0x37, 0x76, 0x5A, 0x5A, 0x56, 0xC6, 0x84, 0x84, 0x33, 0x33,
  0x72, 0x72, 0x4E, 0x4E, 0xCC, 0xCC, 0x8C, 0x1E, 0x6D, 0x8B, 0x14, 0x28,
  0xF1, 0xA6, 0x78, 0x3E, 0x4C, 0x8B, 0x17, 0xEF, 0x10, 0x60, 0xC0, 0x1E,
  0x6D, 0x8B, 0x14, 0x28, 0xF1, 0xA6, 0x78, 0x60, 0x70, 0x3C, 0x4C, 0x8B,
  0x37, 0xCF, 0x12, 0x66, 0xC4, 0x3E, 0x64, 0x81, 0x81, 0xC1, 0x81, 0x46,
  0xF8, 0x7F, 0x20, 0x41, 0x83, 0x04, 0x08, 0x30, 0x60, 0x33, 0x22, 0x62,
  0x66, 0x66, 0x46, 0xC4, 0x4C, 0x78, 0xC3, 0x8F, 0x12, 0x64, 0x8B, 0x14,
  0x38, 0x60, 0x21, 0x63, 0x63, 0x5A, 0x5A, 0x6E, 0xEC, 0xCC, 0xCC, 0x19,
  0x8C, 0x82, 0x81, 0xC0, 0xC0, 0xE0, 0xD8, 0x4C, 0xE2, 0x00, 0x8E, 0x3D,
  0xBC, 0x61, 0x84, 0x30, 0xC0, 0x3F, 0x06, 0x04, 0x08, 0x18, 0x30, 0x60,
  0xC0, 0xFC, 0x1E, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x30, 0x41, 0x83, 0x07,
  0x80, 0xAA, 0xBF, 0xFD, 0x3E, 0x08, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x18,
  0x20, 0x47, 0x80, 0x18, 0xE6, 0xF3, 0x84, 0xFE, 0xCC, 0x80, 0x1E, 0xED,
  0x9A, 0x2C, 0xC9, 0x9F, 0x00, 0x30, 0x60, 0x81, 0xE7, 0x6C, 0xD9, 0xA2,
  0xCD, 0xF0, 0x3D, 0x9C, 0x20, 0x83, 0x2F, 0x80, 0x03, 0x03, 0x02, 0x1E,
  0x36, 0x66, 0x44, 0xC4, 0x4C, 0x7C, 0x39, 0xBC, 0xFE, 0x83, 0x2F, 0x80,
  0x07, 0x83, 0x43, 0x03, 0xE3, 0xF0, 0x40, 0x60, 0x30, 0x18, 0x08, 0x0C,
  0x1E, 0x00, 0x1E, 0x6D, 0x9A, 0x24, 0x4F, 0x8B, 0x04, 0xF8, 0x30, 0x60,
  0xC1, 0xE6, 0xEC, 0xD9, 0x22, 0xCD, 0x98, 0x31, 0x81, 0xEF, 0x10, 0x8C,
  0x69, 0xC0, 0x03, 0x03, 0x00, 0x1E, 0x1E, 0x06, 0x06, 0x04, 0x0C, 0x0C,
  0x0C, 0xF8, 0x10, 0x30, 0x30, 0x27, 0x2C, 0x78, 0x70, 0x78, 0x4C, 0xCC,
  0xF2, 0x66, 0x44, 0xCC, 0xDF, 0x76, 0xB5, 0x6A, 0xBC, 0x58, 0xA1, 0x00,
  0x3C, 0xDD, 0x9B, 0x24, 0x49, 0xB3, 0x00, 0x1C, 0xED, 0x9A, 0x3C, 0x49,
  0x9E, 0x00, 0x3C, 0xCD, 0x9B, 0x34, 0x59, 0xBE, 0x60, 0x80, 0x3D, 0xBC,
  0xE2, 0x8A, 0x6F, 0x84, 0x30, 0x7D, 0xF4, 0x30, 0xC3, 0x08, 0x00, 0x1E,
  0x68, 0x81, 0xC0, 0xC9, 0xBE, 0x00, 0x30, 0xCF, 0xFF, 0x61, 0x84, 0x1A,
  0x78, 0x4F, 0x3C, 0xE2, 0x9A, 0x6E, 0x80, 0xC7, 0x3C, 0xB6, 0x51, 0xC6,
  0x00, 0x43, 0x42, 0x5A, 0x5E, 0x6C, 0xEC, 0xC8, 0x66, 0x48, 0xF0, 0xC3,
  0x8D, 0xB3, 0x00, 0x31, 0x33, 0x32, 0x16, 0x16, 0x1C, 0x18, 0x18, 0xF0,
  0x3E, 0x7C, 0x30, 0xC3, 0x0C, 0x3F, 0x00, 0x1E, 0x20, 0x41, 0x83, 0x1C,
  0x30, 0x30, 0x60, 0x81, 0x03, 0x80, 0x18, 0xC4, 0x23, 0x18, 0x84, 0x63,
  0x11, 0x80, 0x1C, 0x0C, 0x18, 0x20, 0x40, 0xC1, 0x84, 0x08, 0x30, 0x67,
  0x80, 0x73, 0xB8,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 9, 7, 2, -9 },
  { 6, 5, 4, 7, 2, -10 },
  { 9, 8, 9, 7, 0, -9 },
  { 18, 7, 11, 7, 0, -10 },
  { 28, 8, 9, 7, 0, -9 },
  { 37, 7, 9, 7, 0, -9 },
  { 45, 2, 4, 7, 4, -10 },
  { 46, 6, 12, 7, 1, -10 },
  { 55, 6, 12, 7, 0, -10 },
  { 64, 6, 6, 7, 1, -9 },
  { 69, 7, 6, 7, 0, -7 },
  { 75, 3, 4, 7, 1, -2 },
  { 77, 4, 2, 7, 2, -5 },
  { 78, 2, 2, 7, 2, -2 },
  { 79, 9, 12, 7, -1, -10 },
  { 93, 6, 9, 7, 1, -9 },
  { 100, 6, 9, 7, 0, -9 },
  { 107, 7, 9, 7, 0, -9 },
  { 115, 7, 9, 7, 0, -9 },
  { 123, 7, 9, 7, 0, -9 },
  { 131, 8, 9, 7, 0, -9 },
  { 140, 7, 9, 7, 1, -9 },
  { 148, 7, 9, 7, 1, -9 },
  { 156, 7, 9, 7, 0, -9 },
  { 164, 7, 9, 7, 0, -9 },
  { 172, 3, 7, 7, 2, -7 },
  { 175, 4, 9, 7, 1, -7 },
  { 180, 6, 6, 7, 1, -7 },
  { 185, 7, 4, 7, 0, -6 },
  { 189, 7, 6, 7, 0, -7 },
  { 195, 5, 9, 7, 2, -9 },
  { 201, 8, 11, 7, 0, -9 },
  { 212, 7, 9, 7, -1, -9 },
  { 220, 7, 9, 7, 0, -9 },
  { 228, 7, 9, 7, 1, -9 },
  { 236, 7, 9, 7, 0, -9 },
  { 244, 8, 9, 7, 0, -9 },
  { 253, 8, 9, 7, 0, -9 },
  { 262, 7, 9, 7, 1, -9 },
  { 270, 8, 9, 7, 0, -9 },
  { 279, 8, 9, 7, 0, -9 },
  { 288, 8, 9, 7, 0, -9 },
  { 297, 8, 9, 7, 0, -9 },
  { 306, 6, 9, 7, 0, -9 },
  { 313, 8, 9, 7, 0, -9 },
  { 322, 8, 9, 7, 0, -9 },
  { 331, 7, 9, 7, 0, -9 },
  { 339, 7, 9, 7, 0, -9 },
  { 347, 7, 11, 7, 0, -9 },
  { 357, 7, 9, 7, 0, -9 },
  { 365, 7, 9, 7, 0, -9 },
  { 373, 7, 9, 7, 1, -9 },
  { 381, 8, 9, 7, 0, -9 },
  { 390, 7, 9, 7, 1, -9 },
  { 398, 8, 9, 7, 0, -9 },
  { 407, 9, 9, 7, -1, -9 },
  { 418, 6, 9, 7, 2, -9 },
  { 425, 8, 9, 7, 0, -9 },
  { 434, 7, 12, 7, 1, -10 },
  { 445, 2, 12, 7, 3, -10 },
  { 448, 7, 12, 7, 0, -10 },
  { 459, 6, 5, 7, 1, -9 },
  { 463, 7, 1, 7, -1, 1 },
  { 464, 3, 3, 7, 3, -10 },
  { 466, 7, 7, 7, 0, -7 },
  { 473, 7, 10, 7, 0, -10 },
  { 482, 6, 7, 7, 1, -7 },
  { 488, 8, 10, 7, 0, -10 },
  { 498, 6, 7, 7, 1, -7 },
  { 504, 9, 12, 7, -1, -10 },
  { 518, 7, 9, 7, 0, -7 },
  { 526, 7, 10, 7, 0, -10 },
  { 535, 5, 10, 7, 1, -10 },
  { 542, 8, 12, 7, -1, -10 },
  { 554, 8, 10, 7, 0, -10 },
  { 564, 4, 10, 7, 2, -10 },
  { 569, 7, 7, 7, 0, -7 },
  { 576, 7, 7, 7, 0, -7 },
  { 583, 7, 7, 7, 0, -7 },
  { 590, 7, 9, 7, 0, -7 },
  { 598, 6, 9, 7, 1, -7 },
  { 605, 6, 7, 7, 1, -7 },
  { 611, 7, 7, 7, 0, -7 },
  { 618, 6, 9, 7, 1, -9 },
  { 625, 6, 7, 7, 1, -7 },
  { 631, 6, 7, 7, 1, -7 },
  { 637, 8, 7, 7, 0, -7 },
  { 644, 7, 7, 7, 0, -7 },
  { 651, 8, 9, 7, -1, -7 },
  { 660, 7, 7, 7, 0, -7 },
  { 667, 7, 12, 7, 1, -10 },
  { 678, 5, 12, 7, 1, -10 },
  { 686, 7, 12, 7, -1, -10 },
  { 697, 7, 2, 7, 0, -5 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic13pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic13pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic13pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC13PT7B_H_
