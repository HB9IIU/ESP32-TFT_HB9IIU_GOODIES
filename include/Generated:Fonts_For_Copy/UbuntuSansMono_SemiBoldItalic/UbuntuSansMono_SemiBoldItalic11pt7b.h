#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC11PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0x2C, 0x26, 0xDB, 0xA0, 0x16, 0x29, 0xF9, 0x46, 0x9F, 0x94,
  0x58, 0x08, 0x23, 0xD8, 0x20, 0x60, 0xA2, 0x70, 0x80, 0x22, 0xA9, 0xA3,
  0x81, 0x86, 0x95, 0x4C, 0x18, 0xA2, 0x8C, 0x77, 0x69, 0xBE, 0xF8, 0x08,
  0xCC, 0xC4, 0x63, 0x18, 0xC2, 0x18, 0x11, 0x86, 0x10, 0x84, 0x62, 0x33,
  0x30, 0x25, 0x7E, 0xE5, 0x80, 0x10, 0x47, 0xEC, 0x20, 0x80, 0x6D, 0x40,
  0x7F, 0xF0, 0x03, 0x02, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60,
  0xC0, 0x18, 0xB6, 0x55, 0x57, 0x34, 0x9C, 0x09, 0xDE, 0x21, 0x08, 0xDF,
  0x19, 0xB0, 0x43, 0x19, 0x84, 0x3E, 0x38, 0xB0, 0x4E, 0x38, 0x20, 0xBE,
  0x04, 0x31, 0xCA, 0x4B, 0xF1, 0x84, 0x3C, 0xF2, 0x1C, 0x18, 0x20, 0xBC,
  0x1B, 0xB1, 0xE9, 0xCE, 0x5E, 0x7F, 0xF1, 0x8C, 0x21, 0x84, 0x30, 0x18,
  0x96, 0x4B, 0x79, 0x3C, 0x9E, 0x39, 0xB4, 0x51, 0x7C, 0x21, 0xB8, 0x78,
  0x0D, 0x80, 0x36, 0x00, 0x66, 0x48, 0x04, 0x76, 0x3C, 0x18, 0x7C, 0x0F,
  0xFE, 0x41, 0xC0, 0xCE, 0xE0, 0x32, 0xC6, 0x66, 0x01, 0x18, 0x1C, 0x94,
  0x57, 0xF6, 0x9B, 0xB4, 0x68, 0xC0, 0x0C, 0x31, 0x45, 0x24, 0xF4, 0x71,
  0x38, 0xB6, 0x5E, 0x79, 0x3C, 0xBE, 0x3D, 0xAC, 0x20, 0x82, 0x08, 0x3C,
  0x39, 0xF6, 0x51, 0x4D, 0x3D, 0xBC, 0x3E, 0x78, 0x83, 0xC7, 0x88, 0x10,
  0x7C, 0x3E, 0x78, 0x83, 0x27, 0x88, 0x10, 0x60, 0x1E, 0x69, 0x82, 0x04,
  0xD9, 0x12, 0x3C, 0x26, 0xC9, 0x93, 0xE7, 0xD9, 0x32, 0x44, 0x3E, 0x78,
  0x40, 0x81, 0x06, 0x08, 0x7C, 0x3C, 0xF0, 0x43, 0x08, 0x29, 0xBC, 0x26,
  0x59, 0xA3, 0x87, 0x0A, 0x36, 0x44, 0x21, 0x18, 0xC4, 0x23, 0x1F, 0x26,
  0x49, 0xB3, 0x65, 0x58, 0xA3, 0x44, 0x26, 0xC9, 0x52, 0xA5, 0x4B, 0x26,
  0x44, 0x18, 0xB6, 0x51, 0x47, 0x3C, 0x9C, 0x38, 0xB6, 0x59, 0x79, 0x0C,
  0x30, 0x18, 0xB6, 0x51, 0x47, 0x3C, 0x9C, 0x20, 0xE0, 0x38, 0xB6, 0x53,
  0x79, 0x4C, 0xA2, 0x1C, 0x96, 0x0C, 0x18, 0x28, 0xBE, 0xFF, 0xF2, 0x08,
  0x21, 0x84, 0x10, 0x26, 0xC9, 0x92, 0x24, 0xD9, 0x32, 0x38, 0xC7, 0x3C,
  0xB6, 0xD3, 0xC6, 0x10, 0x62, 0x8D, 0x12, 0xA7, 0x56, 0xB6, 0x64, 0x66,
  0x48, 0xE0, 0xC3, 0x07, 0x12, 0x64, 0xC7, 0x25, 0x94, 0x61, 0x84, 0x10,
  0x3E, 0x78, 0x20, 0xC3, 0x0C, 0x10, 0x7C, 0x3C, 0x82, 0x18, 0x61, 0x04,
  0x10, 0xC2, 0x0E, 0x00, 0xBF, 0xD5, 0x54, 0x3C, 0x20, 0x82, 0x18, 0x41,
  0x04, 0x30, 0x8E, 0x00, 0x11, 0x97, 0xB8, 0x80, 0xFC, 0xA4, 0x3D, 0xB4,
  0xB2, 0xC9, 0xE0, 0x10, 0x82, 0x1E, 0x6D, 0x34, 0xF2, 0xF0, 0x3D, 0x94,
  0x30, 0x41, 0xE0, 0x02, 0x08, 0x11, 0xE6, 0xC9, 0xB2, 0x64, 0x78, 0x39,
  0x94, 0xFC, 0x41, 0xE0, 0x02, 0x0F, 0x08, 0x3E, 0x18, 0x18, 0x10, 0x10,
  0x10, 0x30, 0xE0, 0x3D, 0xB4, 0xF2, 0x59, 0xA9, 0xBC, 0x10, 0x82, 0x1E,
  0x6D, 0x34, 0xB2, 0xD8, 0x23, 0x0E, 0x26, 0x44, 0x70, 0x08, 0x30, 0x0E,
  0x48, 0x61, 0x84, 0x12, 0xCE, 0x00, 0x10, 0x82, 0x09, 0x69, 0xC5, 0x16,
  0xC8, 0xF2, 0x26, 0x64, 0x47, 0x7D, 0x55, 0x7F, 0x8A, 0x20, 0x79, 0xB4,
  0xD2, 0x4B, 0x60, 0x39, 0xB4, 0xF3, 0xC9, 0xC0, 0x79, 0xB4, 0xD3, 0xDB,
  0xC8, 0x20, 0x3D, 0xB4, 0xF2, 0x49, 0xE1, 0x84, 0x3C, 0x96, 0x10, 0x43,
  0x00, 0x3D, 0x96, 0x06, 0x0B, 0xE0, 0x27, 0xD8, 0x84, 0x61, 0xC0, 0x65,
  0x34, 0x92, 0xC9, 0xE0, 0x8C, 0xE5, 0xEE, 0x20, 0x46, 0xA9, 0x57, 0xED,
  0x9B, 0x00, 0x64, 0xA3, 0x0C, 0x7B, 0x20, 0x22, 0x6C, 0xD1, 0xA1, 0x83,
  0x0C, 0x70, 0x3D, 0x21, 0x08, 0x43, 0xE0, 0x1C, 0xC2, 0x08, 0x23, 0x04,
  0x10, 0x43, 0x06, 0x00, 0x13, 0x32, 0x22, 0x64, 0x44, 0xC0, 0x30, 0xC6,
  0x21, 0x0C, 0x46, 0x21, 0x30, 0x7E, 0x60,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 8, 6, 2, -8 },
  { 4, 4, 3, 6, 2, -8 },
  { 6, 7, 8, 6, 0, -8 },
  { 13, 6, 10, 6, 0, -9 },
  { 21, 7, 8, 6, 0, -8 },
  { 28, 6, 8, 6, 0, -8 },
  { 34, 2, 3, 6, 3, -8 },
  { 35, 5, 11, 6, 1, -9 },
  { 42, 5, 11, 6, 0, -9 },
  { 49, 5, 5, 6, 1, -8 },
  { 53, 6, 6, 6, 0, -6 },
  { 58, 3, 4, 6, 1, -2 },
  { 60, 4, 2, 6, 1, -4 },
  { 61, 2, 2, 6, 2, -2 },
  { 62, 8, 11, 6, -1, -9 },
  { 73, 6, 8, 6, 0, -8 },
  { 79, 5, 8, 6, 0, -8 },
  { 84, 6, 8, 6, 0, -8 },
  { 90, 6, 8, 6, 0, -8 },
  { 96, 6, 8, 6, 0, -8 },
  { 102, 6, 8, 6, 0, -8 },
  { 108, 5, 8, 6, 1, -8 },
  { 113, 6, 8, 6, 1, -8 },
  { 119, 6, 8, 6, 0, -8 },
  { 125, 6, 8, 6, 0, -8 },
  { 131, 3, 6, 6, 2, -6 },
  { 134, 4, 8, 6, 1, -6 },
  { 138, 6, 5, 6, 0, -6 },
  { 142, 6, 4, 6, 0, -5 },
  { 145, 6, 5, 6, 0, -6 },
  { 149, 5, 8, 6, 1, -8 },
  { 154, 6, 10, 6, 0, -8 },
  { 162, 6, 8, 6, -1, -8 },
  { 168, 6, 8, 6, 0, -8 },
  { 174, 6, 8, 6, 1, -8 },
  { 180, 6, 8, 6, 0, -8 },
  { 186, 7, 8, 6, 0, -8 },
  { 193, 7, 8, 6, 0, -8 },
  { 200, 7, 8, 6, 0, -8 },
  { 207, 7, 8, 6, 0, -8 },
  { 214, 7, 8, 6, 0, -8 },
  { 221, 6, 8, 6, 0, -8 },
  { 227, 7, 8, 6, 0, -8 },
  { 234, 5, 8, 6, 0, -8 },
  { 239, 7, 8, 6, 0, -8 },
  { 246, 7, 8, 6, 0, -8 },
  { 253, 6, 8, 6, 0, -8 },
  { 259, 6, 8, 6, 0, -8 },
  { 265, 6, 10, 6, 0, -8 },
  { 273, 6, 8, 6, 0, -8 },
  { 279, 6, 8, 6, 0, -8 },
  { 285, 6, 8, 6, 1, -8 },
  { 291, 7, 8, 6, 0, -8 },
  { 298, 6, 8, 6, 1, -8 },
  { 304, 7, 8, 6, 0, -8 },
  { 311, 7, 8, 6, 0, -8 },
  { 318, 6, 8, 6, 1, -8 },
  { 324, 7, 8, 6, 0, -8 },
  { 331, 6, 11, 6, 1, -9 },
  { 340, 2, 11, 6, 2, -9 },
  { 343, 6, 11, 6, 0, -9 },
  { 352, 5, 5, 6, 1, -8 },
  { 356, 6, 1, 6, -1, 1 },
  { 357, 2, 3, 6, 3, -9 },
  { 358, 6, 6, 6, 0, -6 },
  { 363, 6, 9, 6, 0, -9 },
  { 370, 6, 6, 6, 0, -6 },
  { 375, 7, 9, 6, 0, -9 },
  { 383, 6, 6, 6, 0, -6 },
  { 388, 8, 11, 6, -1, -9 },
  { 399, 6, 8, 6, 0, -6 },
  { 405, 6, 9, 6, 0, -9 },
  { 412, 4, 9, 6, 1, -9 },
  { 417, 6, 11, 6, 0, -9 },
  { 426, 6, 9, 6, 0, -9 },
  { 433, 4, 8, 6, 1, -8 },
  { 437, 6, 6, 6, 0, -6 },
  { 442, 6, 6, 6, 0, -6 },
  { 447, 6, 6, 6, 0, -6 },
  { 452, 6, 8, 6, 0, -6 },
  { 458, 6, 8, 6, 0, -6 },
  { 464, 6, 6, 6, 0, -6 },
  { 469, 6, 6, 6, 0, -6 },
  { 474, 5, 7, 6, 1, -7 },
  { 479, 6, 6, 6, 0, -6 },
  { 484, 5, 6, 6, 1, -6 },
  { 488, 7, 6, 6, 0, -6 },
  { 494, 6, 6, 6, 0, -6 },
  { 499, 7, 8, 6, -1, -6 },
  { 506, 6, 6, 6, 0, -6 },
  { 511, 6, 11, 6, 1, -9 },
  { 520, 4, 11, 6, 1, -9 },
  { 526, 5, 11, 6, 0, -9 },
  { 533, 6, 2, 6, 0, -4 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic11pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic11pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic11pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC11PT7B_H_
