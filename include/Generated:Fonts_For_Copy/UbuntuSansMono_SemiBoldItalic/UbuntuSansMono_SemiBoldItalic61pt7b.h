#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC61PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x01,
  0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0x07, 0xF9, 0xFE,
  0x0F, 0xF3, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE0, 0xFF, 0x3F, 0xC1,
  0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F,
  0x87, 0xE0, 0x7F, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xE0,
  0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x7F, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x01, 0xFC,
  0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xE0, 0x0F, 0xF8, 0x00,
  0x60, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x80, 0x00, 0x7F, 0x80, 0x70, 0x00, 0x7F, 0xC0, 0x7E, 0x00, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xFE, 0x00,
  0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xC0,
  0x07, 0xC3, 0xE0, 0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x0F, 0xC0, 0x03, 0xE0,
  0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x07, 0xE0, 0x01, 0xF0, 0x3E, 0x07,
  0xE0, 0x00, 0xF8, 0x3E, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x07, 0xE0, 0x00,
  0x3E, 0x0F, 0x87, 0xE0, 0x00, 0x1F, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87,
  0xC3, 0xE0, 0x00, 0x07, 0xC7, 0xE3, 0xF0, 0x00, 0x03, 0xFF, 0xE3, 0xF0,
  0x00, 0x01, 0xFF, 0xF3, 0xF0, 0x00, 0x00, 0x7F, 0xF3, 0xF0, 0x00, 0x00,
  0x1F, 0xF1, 0xF0, 0x00, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0xFF, 0xE0, 0x00,
  0x00, 0xF8, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0xFF, 0xFC, 0x00, 0x00, 0xFC,
  0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x7E, 0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x0F,
  0x80, 0x00, 0xFC, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x03, 0xE0, 0x00,
  0x7C, 0x0F, 0x81, 0xF0, 0x00, 0x7E, 0x07, 0xC1, 0xF0, 0x00, 0x7E, 0x03,
  0xE0, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x00, 0xF8, 0x7C,
  0x00, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0xC0,
  0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x30, 0x00, 0xFF, 0xC0, 0x7F,
  0x03, 0xFF, 0xE0, 0x7E, 0x07, 0xFF, 0xE0, 0x7E, 0x0F, 0xFF, 0xF0, 0xFE,
  0x1F, 0xE7, 0xF0, 0xFC, 0x3F, 0x83, 0xF9, 0xFC, 0x3F, 0x03, 0xFD, 0xF8,
  0x7F, 0x01, 0xFF, 0xF8, 0x7E, 0x00, 0xFF, 0xF0, 0xFE, 0x00, 0xFF, 0xF0,
  0xFE, 0x00, 0x7F, 0xE0, 0xFE, 0x00, 0x7F, 0xE0, 0xFE, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x01, 0xFF, 0xE0,
  0xFF, 0xC7, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF7, 0xF0,
  0x3F, 0xFF, 0xE7, 0xF0, 0x1F, 0xFF, 0x83, 0xF8, 0x0F, 0xFE, 0x03, 0xF8,
  0x00, 0xC0, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0xFF,
  0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87, 0xE1, 0xFC, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x02, 0x01,
  0xF8, 0x00, 0x3C, 0x1F, 0x81, 0xC3, 0xE1, 0xF8, 0x7C, 0x7F, 0x8F, 0x1F,
  0xC7, 0xFE, 0xF7, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF9, 0xFC, 0x00,
  0x7F, 0x9F, 0xE0, 0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xE0,
  0x7F, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x08, 0x03, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x01, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x1F,
  0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x7E, 0x00, 0x78, 0x00, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFF, 0xE0, 0x0F, 0x07, 0xF9, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF9, 0xFE, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x07,
  0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F,
  0x80, 0x07, 0xF1, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x0F,
  0x83, 0xFD, 0xFE, 0x3F, 0x87, 0xF3, 0xF8, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE,
  0x1F, 0xCF, 0xE3, 0xFC, 0x3F, 0xBF, 0xC7, 0xF8, 0x7F, 0x7F, 0x07, 0xE1,
  0xFE, 0xFE, 0x0F, 0x83, 0xF9, 0xFC, 0x04, 0x07, 0xF3, 0xF8, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFE,
  0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFD, 0xFC, 0x00, 0xFE, 0x3F, 0x80,
  0x1F, 0x0F, 0xF0, 0x03, 0x81, 0xFE, 0x00, 0x40, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x1F, 0xFC, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0x78, 0x00, 0xFF, 0x80, 0x30, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x0F, 0xFE, 0x00, 0x38, 0x01, 0xFF,
  0x00, 0x10, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x02, 0x00, 0x01, 0xFF, 0x03, 0xC0, 0x03, 0xFF, 0x01,
  0xFF, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xBF, 0xC0,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x40, 0x00, 0x7F,
  0xC0, 0x1E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xCF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0xFF, 0xF0, 0x7F, 0x80, 0x0F,
  0xF0, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07,
  0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07,
  0xF8, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x07,
  0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x1F,
  0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xF1, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x81,
  0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x01,
  0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0xDF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0xFF,
  0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0x80, 0x0F,
  0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x07,
  0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07,
  0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x3F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x03,
  0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFB,
  0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x78, 0x01,
  0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0x80, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0x7E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x10, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3E, 0x07,
  0xFE, 0x1C, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF0, 0x03, 0xFF, 0xE1, 0xFC, 0x03, 0xFF,
  0xF8, 0x7E, 0x03, 0xFF, 0xFE, 0x3F, 0x81, 0xFF, 0xFF, 0x8F, 0xC0, 0xFF,
  0xFF, 0xE3, 0xF0, 0x7F, 0xFF, 0xF1, 0xF8, 0x1F, 0xE1, 0xFC, 0x7E, 0x0F,
  0xE0, 0x7F, 0x1F, 0x87, 0xF8, 0x1F, 0xC7, 0xE1, 0xFC, 0x07, 0xE3, 0xF0,
  0x7E, 0x03, 0xF8, 0xFC, 0x1F, 0x80, 0xFE, 0x3F, 0x0F, 0xE0, 0x3F, 0x8F,
  0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x3F, 0x01, 0xFC,
  0x3F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC3, 0xF0, 0x1F, 0x83, 0xF0, 0xFC, 0x07,
  0xE0, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x0F, 0xF0, 0xFE, 0x0F, 0xC1, 0xFF,
  0x7F, 0x03, 0xF0, 0x7F, 0xFF, 0xC0, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0x03,
  0xFF, 0xFC, 0x0F, 0xC0, 0x7F, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xE3, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x3F, 0x9F, 0x80,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F,
  0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x03, 0xFC, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF8,
  0x07, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x03, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0x80, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xF3, 0xFC, 0x01, 0xFF, 0x80, 0x1C, 0x01, 0xFF, 0x00, 0x02,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x10, 0x03, 0xFF, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x07, 0xFE, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F,
  0xC0, 0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x0F,
  0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF0,
  0x7F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x1F,
  0xE0, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x0F,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF8, 0x1F, 0xC0, 0x0F, 0xFC, 0x0F, 0xE0, 0x0F,
  0xFC, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xE3, 0xF8,
  0x03, 0xFF, 0x00, 0x1C, 0x03, 0xFF, 0x00, 0x04, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xC0,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x0F, 0xE0, 0x3F, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x07,
  0xFE, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x01,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x04, 0x00, 0x0F, 0xF0, 0x03, 0xC0, 0x07,
  0xFC, 0x00, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00,
  0xFF, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x3F,
  0x87, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0xFB, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x1F,
  0x7C, 0x1F, 0x7E, 0x00, 0xFC, 0xF0, 0x7D, 0xF8, 0x03, 0xF3, 0xC3, 0xE7,
  0xC0, 0x0F, 0xCF, 0x0F, 0xBF, 0x00, 0x3E, 0x3E, 0x7C, 0xFC, 0x01, 0xF8,
  0xF9, 0xF3, 0xF0, 0x07, 0xE3, 0xEF, 0x8F, 0xC0, 0x1F, 0x8F, 0xFC, 0x7F,
  0x00, 0xFE, 0x3F, 0xF1, 0xF8, 0x03, 0xF0, 0xFF, 0x87, 0xE0, 0x0F, 0xC3,
  0xFE, 0x1F, 0x80, 0x7F, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0xC3, 0xF8,
  0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x3F, 0x00, 0xFE, 0x0F,
  0xC1, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x00,
  0x7F, 0x00, 0x7F, 0xE0, 0x03, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x1F,
  0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0x00, 0x7F, 0xFC, 0x03, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0x80, 0x1F, 0xBF,
  0x01, 0xFC, 0x01, 0xFC, 0xF8, 0x0F, 0xE0, 0x0F, 0xE7, 0xE0, 0x7F, 0x00,
  0x7F, 0x3F, 0x03, 0xF8, 0x03, 0xF1, 0xF8, 0x1F, 0x80, 0x3F, 0x87, 0xC1,
  0xFC, 0x01, 0xFC, 0x3F, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x7F, 0x00, 0x7E,
  0x0F, 0xC3, 0xF0, 0x07, 0xF0, 0x3E, 0x3F, 0x80, 0x3F, 0x81, 0xF1, 0xFC,
  0x01, 0xFC, 0x0F, 0xCF, 0xE0, 0x0F, 0xC0, 0x7E, 0x7E, 0x00, 0xFE, 0x03,
  0xF7, 0xF0, 0x07, 0xF0, 0x0F, 0xBF, 0x80, 0x3F, 0x80, 0x7D, 0xFC, 0x01,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0xF0, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xF8, 0x01, 0xF8,
  0x00, 0xFF, 0xC0, 0x1F, 0xC0, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xF0,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE7, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0x80, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x00,
  0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01,
  0xFE, 0x7F, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x3F,
  0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x07, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x7F, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFF,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x3F, 0xF8, 0x07, 0xF0, 0x3F,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xE7, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x0F, 0xF0,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xE0,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0,
  0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00,
  0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0xFF, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF8, 0x07,
  0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x1F,
  0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xE0, 0x07, 0xFC, 0x00, 0x38,
  0x00, 0xFF, 0x00, 0x01, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x0C, 0x00,
  0x07, 0xFC, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xF8,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xF8, 0xFF, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x0F, 0xC1,
  0xF8, 0x1F, 0x80, 0x3F, 0x0F, 0xF0, 0x7E, 0x01, 0xFC, 0x3F, 0xC3, 0xF8,
  0x07, 0xE1, 0xFF, 0x0F, 0xC0, 0x1F, 0x87, 0xFC, 0x3F, 0x00, 0x7E, 0x3F,
  0xF0, 0xFC, 0x01, 0xF8, 0xFF, 0xC7, 0xE0, 0x0F, 0xC7, 0xDF, 0x1F, 0x80,
  0x3F, 0x1F, 0x7C, 0x7E, 0x00, 0xFC, 0xF9, 0xF1, 0xF8, 0x03, 0xF3, 0xE7,
  0xCF, 0xC0, 0x0F, 0x9F, 0x1F, 0x3F, 0x00, 0x3E, 0x7C, 0x3C, 0xFC, 0x01,
  0xFB, 0xE0, 0xF3, 0xE0, 0x07, 0xEF, 0x83, 0xDF, 0x80, 0x1F, 0x7C, 0x0F,
  0xFE, 0x00, 0x7D, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07,
  0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x9F, 0xE0, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0x80, 0x00, 0x7F, 0x9F, 0xC0,
  0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC1,
  0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xE1,
  0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x08, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0xFF, 0xBF, 0xC0, 0x03, 0xFE, 0x3F, 0x80, 0x07, 0xF8, 0x7F,
  0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x80, 0xFE, 0x01, 0xFF, 0x01, 0xFE,
  0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF8,
  0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x1F, 0xE7,
  0xE0, 0x00, 0x3F, 0x03, 0x80, 0x00, 0x38, 0x02, 0x00, 0x00, 0x40, 0x3F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x08,
  0x00, 0x70, 0x03, 0xE0, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x83, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x0C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0x01, 0xFE, 0x0F, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xF0, 0x7F,
  0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0xFF, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0xFF, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x07,
  0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFF,
  0x81, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xE7, 0xF0,
  0x07, 0xFF, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x83, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x81, 0xFE, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x03,
  0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x1F,
  0xE1, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0xFE,
  0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFF, 0x87, 0xF0, 0x01, 0xFE, 0x1F,
  0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xF0, 0x7F, 0x00, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x0C, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x02, 0x07, 0xFE, 0x00, 0x78, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xF8, 0x03, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xE0,
  0x01, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x0F,
  0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x9F, 0xC0, 0x01, 0xFF, 0xC3, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xF3, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x0F,
  0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF9, 0xFE,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFF, 0x9F, 0xE0,
  0x07, 0xFE, 0x3F, 0x80, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x06,
  0x01, 0xFF, 0xFB, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x70, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xE7, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x07, 0xF8,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xBF, 0x80,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x30, 0x00, 0x3F, 0xE0, 0x03, 0xE0, 0x0F, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC7,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xC0, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0xFF,
  0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8,
  0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x1F,
  0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0,
  0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x03,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x20, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x0C, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x02,
  0x00, 0x1F, 0xE0, 0x00, 0xC0, 0x0F, 0xF8, 0x00, 0x3E, 0x07, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F,
  0xE3, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x3F, 0xE0, 0x00,
  0x1F, 0xEF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x01, 0xFC, 0xFF, 0x80, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xF0, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x73, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0xF0, 0xFF,
  0x00, 0x7F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x3F, 0xE7, 0xF0, 0x3F, 0x07,
  0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC,
  0x1F, 0x83, 0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x07,
  0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x1F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x0F,
  0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x1F, 0x80, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x1F, 0xE0,
  0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01,
  0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF,
  0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87,
  0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00,
  0x3F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F,
  0xC1, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0,
  0xFF, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xF8,
  0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00,
  0x3F, 0xE1, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0,
  0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xE0, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x1F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xF7, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80,
  0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x01,
  0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0xFF,
  0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0,
  0x7F, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0xFF, 0x03,
  0xFE, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFE, 0xFE, 0x00, 0x01, 0xC1, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xF0, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0x00,
  0x18, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x20, 0x00, 0x3F, 0xC0, 0x78,
  0x00, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x0E, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFC,
  0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F,
  0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0xFF, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x7F,
  0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF,
  0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0,
  0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xF9, 0xFC, 0x03, 0xFF, 0x87, 0xE0, 0x01, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF,
  0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0xC7, 0xF0,
  0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0xFF, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80,
  0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x0F,
  0xF1, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x01, 0xFD,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xE1, 0xF8, 0x1F, 0x81, 0xF8, 0x3F,
  0x03, 0xF0, 0x3F, 0x0F, 0xE0, 0xFE, 0x07, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8,
  0x3F, 0x07, 0xF8, 0x3F, 0x07, 0xE0, 0xFF, 0x07, 0xE0, 0xFC, 0x3F, 0xE1,
  0xF8, 0x1F, 0x87, 0xFC, 0x3F, 0x03, 0xF1, 0xFF, 0x87, 0xE0, 0x7E, 0x3F,
  0xF1, 0xF8, 0x0F, 0xCF, 0xDE, 0x3F, 0x01, 0xF1, 0xF3, 0xC7, 0xC0, 0x3E,
  0x7E, 0x7D, 0xF8, 0x07, 0xCF, 0x8F, 0xBF, 0x00, 0xFB, 0xF1, 0xF7, 0xC0,
  0x3F, 0x7C, 0x3F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0xFF,
  0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xE3,
  0xFC, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01,
  0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x07, 0xF9,
  0xFC, 0x00, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x30, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x20, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x10, 0x03, 0xFF,
  0x00, 0x1E, 0x07, 0xFF, 0xC0, 0x3F, 0x0F, 0xFF, 0xE0, 0x7F, 0x1F, 0xFF,
  0xF8, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0x8F,
  0xFF, 0xF8, 0x7E, 0x03, 0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0xF0, 0x3C, 0x00,
  0x7F, 0xC0, 0x04, 0x00, 0x1F, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 18, 43, 34, 9, -42 },
  { 98, 23, 18, 34, 11, -46 },
  { 150, 36, 42, 34, 0, -42 },
  { 339, 33, 54, 34, 1, -47 },
  { 562, 41, 44, 34, -2, -43 },
  { 788, 32, 44, 34, 1, -43 },
  { 964, 11, 19, 34, 17, -46 },
  { 991, 27, 60, 34, 7, -48 },
  { 1194, 27, 60, 34, 1, -48 },
  { 1397, 28, 26, 34, 6, -42 },
  { 1488, 30, 30, 34, 2, -33 },
  { 1601, 16, 21, 34, 4, -11 },
  { 1643, 19, 7, 34, 8, -21 },
  { 1660, 11, 12, 34, 9, -11 },
  { 1677, 40, 59, 34, -3, -48 },
  { 1972, 31, 44, 34, 3, -43 },
  { 2143, 27, 42, 34, 2, -42 },
  { 2285, 33, 43, 34, 1, -43 },
  { 2463, 33, 44, 34, 0, -43 },
  { 2645, 34, 42, 34, 0, -42 },
  { 2824, 35, 43, 34, 0, -42 },
  { 3013, 32, 44, 34, 3, -43 },
  { 3189, 32, 42, 34, 6, -42 },
  { 3357, 32, 44, 34, 2, -43 },
  { 3533, 32, 43, 34, 2, -43 },
  { 3705, 16, 33, 34, 9, -32 },
  { 3771, 21, 42, 34, 4, -32 },
  { 3882, 31, 29, 34, 3, -32 },
  { 3995, 33, 20, 34, 1, -28 },
  { 4078, 31, 29, 34, 1, -32 },
  { 4191, 25, 44, 34, 8, -43 },
  { 4329, 34, 52, 34, 2, -43 },
  { 4550, 33, 42, 34, -3, -42 },
  { 4724, 34, 43, 34, 0, -43 },
  { 4907, 33, 44, 34, 3, -43 },
  { 5089, 33, 43, 34, 0, -43 },
  { 5267, 35, 42, 34, 1, -42 },
  { 5451, 35, 42, 34, 2, -42 },
  { 5635, 33, 44, 34, 3, -43 },
  { 5817, 38, 42, 34, -1, -42 },
  { 6017, 35, 42, 34, 1, -42 },
  { 6201, 34, 43, 34, 1, -42 },
  { 6384, 38, 42, 34, 0, -42 },
  { 6584, 27, 42, 34, 1, -42 },
  { 6726, 38, 42, 34, -2, -42 },
  { 6926, 37, 42, 34, 0, -42 },
  { 7121, 32, 44, 34, 2, -43 },
  { 7297, 35, 43, 34, 0, -43 },
  { 7486, 32, 54, 34, 2, -43 },
  { 7702, 34, 43, 34, 0, -43 },
  { 7885, 35, 44, 34, 0, -43 },
  { 8078, 31, 42, 34, 7, -42 },
  { 8241, 35, 43, 34, 2, -42 },
  { 8430, 32, 42, 34, 7, -42 },
  { 8598, 38, 42, 34, 1, -42 },
  { 8798, 41, 42, 34, -2, -42 },
  { 9014, 33, 42, 34, 7, -42 },
  { 9188, 36, 42, 34, 0, -42 },
  { 9377, 32, 59, 34, 4, -48 },
  { 9613, 12, 59, 34, 12, -48 },
  { 9702, 32, 59, 34, -1, -48 },
  { 9938, 31, 24, 34, 3, -42 },
  { 10031, 32, 6, 34, -5, 5 },
  { 10055, 14, 12, 34, 14, -47 },
  { 10076, 31, 34, 34, 2, -33 },
  { 10208, 31, 48, 34, 1, -47 },
  { 10394, 30, 34, 34, 3, -33 },
  { 10522, 35, 48, 34, 2, -47 },
  { 10732, 31, 34, 34, 2, -33 },
  { 10864, 42, 58, 34, -4, -47 },
  { 11169, 36, 44, 34, -2, -33 },
  { 11367, 31, 47, 34, 0, -47 },
  { 11550, 23, 49, 34, 5, -48 },
  { 11691, 34, 60, 34, -2, -48 },
  { 11946, 35, 47, 34, 1, -47 },
  { 12152, 20, 48, 34, 8, -47 },
  { 12272, 34, 32, 34, -1, -32 },
  { 12408, 30, 33, 34, 1, -33 },
  { 12532, 30, 34, 34, 2, -33 },
  { 12660, 34, 44, 34, -2, -33 },
  { 12847, 31, 44, 34, 3, -33 },
  { 13018, 31, 33, 34, 3, -33 },
  { 13146, 31, 34, 34, 1, -33 },
  { 13278, 27, 43, 34, 6, -42 },
  { 13424, 30, 33, 34, 3, -32 },
  { 13548, 30, 32, 34, 5, -32 },
  { 13668, 35, 32, 34, 2, -32 },
  { 13808, 37, 32, 34, -2, -32 },
  { 13956, 40, 43, 34, -5, -32 },
  { 14171, 32, 32, 34, 1, -32 },
  { 14299, 33, 59, 34, 4, -48 },
  { 14543, 21, 59, 34, 7, -48 },
  { 14698, 32, 59, 34, -2, -48 },
  { 14934, 32, 12, 34, 1, -24 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic61pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic61pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic61pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC61PT7B_H_
