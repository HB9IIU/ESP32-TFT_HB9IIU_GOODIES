#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC43PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x7E, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0,
  0x3E, 0x00, 0x40, 0x00, 0x3E, 0x1F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0xFC, 0x7E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF0, 0x78,
  0xF0, 0x78, 0xF0, 0x78, 0xE0, 0x70, 0x00, 0x0F, 0x87, 0x80, 0x07, 0x87,
  0xC0, 0x07, 0xC3, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xE0,
  0xF0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x78, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF2, 0x1F, 0x0F, 0x00, 0x0F,
  0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0xC3, 0xE0, 0x03,
  0xC1, 0xE0, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xE0, 0x78, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1E, 0x00,
  0x1E, 0x0F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x87, 0xC0,
  0x07, 0xC3, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF,
  0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xC0, 0x10, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x80, 0x0F, 0xC3, 0xC0, 0x7F,
  0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x07, 0xF8,
  0x03, 0xC0, 0x1F, 0xF0, 0x0F, 0x00, 0xF3, 0xC0, 0x78, 0x03, 0x8F, 0x03,
  0xC0, 0x1E, 0x3C, 0x1E, 0x00, 0x78, 0xF0, 0xF0, 0x01, 0xC3, 0xC7, 0x80,
  0x07, 0x0E, 0x3E, 0x00, 0x1C, 0x78, 0xF0, 0x00, 0x71, 0xE7, 0x80, 0x01,
  0xFF, 0x3C, 0x00, 0x07, 0xF9, 0xE0, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x3F, 0x00, 0x00, 0x79,
  0xFC, 0x00, 0x03, 0xCF, 0xF8, 0x00, 0x1E, 0x79, 0xE0, 0x00, 0xF1, 0xE3,
  0x80, 0x03, 0xC7, 0x0E, 0x00, 0x1E, 0x3C, 0x38, 0x00, 0xF0, 0xF1, 0xE0,
  0x07, 0x83, 0x87, 0x80, 0x3C, 0x0E, 0x1C, 0x01, 0xE0, 0x3C, 0xF0, 0x0F,
  0x80, 0xFF, 0x80, 0x3C, 0x01, 0xFE, 0x03, 0xE0, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x7F, 0xFC, 0x03, 0xE1, 0xF0, 0x0F, 0x03, 0xC0, 0x7C, 0x0F, 0x01, 0xF0,
  0x7C, 0x07, 0xC1, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x7C, 0x01, 0xF7, 0xE0,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x83, 0xC3, 0xFE, 0x1F, 0x1F,
  0xF8, 0x78, 0xF9, 0xF1, 0xE7, 0xC7, 0xEF, 0x9E, 0x0F, 0xBC, 0xF8, 0x1F,
  0xF3, 0xE0, 0x7F, 0x8F, 0x00, 0xFC, 0x3C, 0x03, 0xF0, 0xF8, 0x0F, 0xC3,
  0xE0, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xF9, 0xF0, 0xFF,
  0x87, 0xC0, 0x3F, 0x3E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8,
  0xF8, 0xF0, 0xF0, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x03,
  0x80, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x20, 0xF0,
  0x43, 0x8F, 0x1E, 0x7E, 0xF7, 0xE7, 0xF6, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFE, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xF9, 0xF0, 0x1F,
  0x9F, 0x83, 0xF8, 0xFC, 0x0F, 0x0F, 0x80, 0x70, 0x60, 0x02, 0x04, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x80, 0xF8, 0x3F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x03, 0xC0, 0xF8, 0x3E, 0x7F,
  0x8F, 0xE1, 0xF8, 0x3C, 0x00, 0x3F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFE,
  0xFF, 0xF8, 0x1C, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x10, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF,
  0xFE, 0x07, 0xF1, 0xF8, 0x3F, 0x03, 0xE1, 0xF8, 0x0F, 0xC7, 0xC0, 0x1F,
  0x3F, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x84, 0x1F, 0x7C,
  0x78, 0x7D, 0xF3, 0xF3, 0xE7, 0xCF, 0xCF, 0xBE, 0x3E, 0x3E, 0xF8, 0xF8,
  0xFB, 0xE1, 0x87, 0xEF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xF3,
  0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xF0,
  0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xDF,
  0x03, 0xC7, 0xC0, 0x81, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x7F, 0x0F, 0xC0, 0x70, 0x0F, 0xC0, 0x80, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x0E, 0x0F, 0xE0, 0x10, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x40, 0x03, 0xF0, 0xE0, 0x0F, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8,
  0x07, 0xC0, 0xF8, 0x07, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0,
  0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x20, 0x03, 0xF0, 0x1C, 0x07, 0xF8,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x60, 0x03, 0xEF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0,
  0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7E, 0x01,
  0xF8, 0x7C, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F,
  0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF0, 0x3F, 0x07, 0xC0,
  0x3F, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x0F,
  0xDF, 0xE0, 0x3F, 0x0F, 0xC0, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0x87, 0xC0,
  0x1F, 0x0F, 0x80, 0x3F, 0x3F, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xFC, 0x03,
  0xF0, 0xFC, 0x0F, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFE, 0x0F, 0xC1, 0xF8, 0x0F,
  0x87, 0xE0, 0x1F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xE3, 0xF0, 0x0F, 0xC7,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x01,
  0x83, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x3E, 0x07,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x01, 0x00, 0x00, 0x30,
  0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00,
  0x7C, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x07, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x03, 0xFC,
  0x07, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x00, 0x08, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3C, 0x1F, 0xC8, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0x03, 0xF0, 0x1F, 0x07, 0xC0, 0x1F,
  0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x1F, 0x00, 0x0F, 0x1E, 0x03, 0xFF,
  0x3E, 0x0F, 0xFF, 0x3C, 0x1F, 0xFF, 0x3C, 0x3F, 0xFE, 0x7C, 0x7E, 0x3E,
  0x78, 0x7C, 0x3E, 0x78, 0xF8, 0x3E, 0x78, 0xF8, 0x3C, 0xF8, 0xF0, 0x7C,
  0xF8, 0xF0, 0x7C, 0xF1, 0xF0, 0x7C, 0xF1, 0xF0, 0x78, 0xF1, 0xF0, 0xF8,
  0xF1, 0xF0, 0xF8, 0xF0, 0xF8, 0xF8, 0xF0, 0xFF, 0xF0, 0xF8, 0x7F, 0xF0,
  0xF8, 0x7F, 0xF0, 0xF8, 0x1F, 0xE0, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE7, 0x80, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1E, 0x7C, 0x00, 0x7C, 0x78, 0x00,
  0xF0, 0xF0, 0x03, 0xE1, 0xE0, 0x0F, 0x83, 0xC0, 0x1F, 0x07, 0x80, 0x7C,
  0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x8F, 0x80, 0x1F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFB,
  0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF1, 0xFF,
  0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F,
  0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x1F, 0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x01, 0xF8,
  0x7C, 0x0F, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x03, 0xFC, 0x3C, 0x07, 0xF0, 0x04, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x40, 0x7F, 0x81, 0xC0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x03, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3E,
  0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0xFC,
  0x3E, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x07, 0xF0,
  0x7C, 0x0F, 0xE0, 0x7C, 0x7F, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x08, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x7F, 0x83, 0xC0, 0xFC, 0x00, 0x83, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0xFC, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x8F,
  0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0x7E,
  0x07, 0xC0, 0xFE, 0x0F, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0xFC, 0x01, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F,
  0x81, 0xF8, 0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x07, 0xC0,
  0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x07, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x03,
  0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x0F, 0x81, 0xF0,
  0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x03,
  0xF0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x30,
  0x07, 0xE0, 0x1E, 0x0F, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x07,
  0xE0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x3E,
  0x07, 0xE0, 0x07, 0xC1, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xC3, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7C, 0xFC,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x0F,
  0x81, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x0F, 0x80, 0x7E,
  0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x81, 0xF0,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x01, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00,
  0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0xC1, 0xFC, 0x03,
  0xF8, 0x3F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xDE, 0x03, 0xFC, 0x7B,
  0x80, 0xFB, 0x8E, 0xF0, 0x1E, 0x73, 0xDE, 0x03, 0xCE, 0x73, 0xC0, 0x79,
  0xDE, 0x78, 0x1F, 0x3B, 0x9F, 0x03, 0xC7, 0xF3, 0xC0, 0x78, 0xFC, 0x78,
  0x1F, 0x1F, 0x8F, 0x03, 0xE3, 0xE3, 0xE0, 0x78, 0x7C, 0x7C, 0x0F, 0x00,
  0x0F, 0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x83,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x81, 0xE0, 0x01,
  0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0xE0,
  0x1E, 0x03, 0xF8, 0x0F, 0x80, 0xFE, 0x03, 0xE0, 0x7F, 0x80, 0xF8, 0x1F,
  0xF0, 0x3E, 0x07, 0xFC, 0x0F, 0x01, 0xEF, 0x07, 0xC0, 0xFB, 0xC1, 0xF0,
  0x3E, 0x78, 0x7C, 0x0F, 0x9E, 0x1E, 0x03, 0xC7, 0x8F, 0x81, 0xF1, 0xE3,
  0xE0, 0x7C, 0x3C, 0xF8, 0x1F, 0x0F, 0x3C, 0x07, 0x83, 0xDF, 0x03, 0xE0,
  0xF7, 0xC0, 0xF8, 0x1D, 0xF0, 0x3E, 0x07, 0xF8, 0x0F, 0x01, 0xFE, 0x07,
  0xC0, 0x7F, 0x81, 0xF0, 0x1F, 0xE0, 0x7C, 0x03, 0xF0, 0x1E, 0x00, 0xFC,
  0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x3E, 0x00,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x07, 0xF1, 0xF8, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x1F,
  0x3F, 0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0x7C,
  0x00, 0x7D, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3E, 0xF8, 0x00,
  0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x7C, 0xF8, 0x01, 0xF3,
  0xE0, 0x0F, 0xCF, 0x80, 0x7E, 0x3E, 0x01, 0xF8, 0xFC, 0x0F, 0xC3, 0xF8,
  0x7E, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0x01, 0xF8, 0x0F,
  0x80, 0x7E, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1,
  0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF0,
  0x3E, 0x07, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x07, 0xF1, 0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x1F,
  0x3F, 0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0x7C,
  0x00, 0x7D, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3E, 0xF8, 0x00,
  0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x7C, 0xF8, 0x01, 0xF3,
  0xE0, 0x0F, 0xCF, 0x80, 0x7E, 0x3E, 0x01, 0xF8, 0xFC, 0x0F, 0xC3, 0xF8,
  0x7E, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03,
  0xF1, 0xFE, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07,
  0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F,
  0x80, 0x7E, 0x0F, 0x81, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0x0F, 0x80, 0x3F,
  0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x7E,
  0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0xFC,
  0x01, 0xF0, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x1E, 0x03, 0xE0, 0x04, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x20, 0x03, 0xF0, 0x7C, 0x07, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x00,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x1F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7C, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x3E, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7C, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xF8, 0x03,
  0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x07,
  0xC0, 0xF8, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x1F,
  0x9F, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1,
  0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0xF8, 0x1F,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0,
  0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x07, 0x8F, 0x80, 0x0F, 0x3E,
  0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x01,
  0xF0, 0x7C, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x81, 0xE0, 0x01, 0xF0, 0x3C,
  0x00, 0x3E, 0x0F, 0x87, 0x87, 0x81, 0xF1, 0xF1, 0xF0, 0x3C, 0x7E, 0x3E,
  0x07, 0x8F, 0xC7, 0x80, 0xF3, 0xF8, 0xF0, 0x3E, 0x77, 0x1E, 0x07, 0xDE,
  0xE7, 0xC0, 0xF3, 0x9C, 0xF0, 0x1E, 0xF3, 0x9E, 0x03, 0xDC, 0x73, 0xC0,
  0x7F, 0x8F, 0xF0, 0x1E, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x07,
  0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFC,
  0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF8, 0x3F,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x07, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xF3, 0xE0, 0x0F, 0xC7,
  0xC0, 0x1F, 0x0F, 0x80, 0x7E, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xE0, 0x3E,
  0x0F, 0xC0, 0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x01, 0xF1, 0xF0, 0x01, 0xF7,
  0xE0, 0x03, 0xEF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xF8, 0x7E, 0x3F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7E, 0x3F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xF1, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80,
  0x1F, 0xBE, 0x00, 0xFC, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xC0, 0xFC,
  0x1F, 0x07, 0xE0, 0x7E, 0x3F, 0x01, 0xF9, 0xF8, 0x03, 0xEF, 0xC0, 0x0F,
  0xCF, 0x00, 0x3E, 0x18, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x30, 0x0E, 0x07, 0xC3,
  0xF8, 0x7F, 0x07, 0xF0, 0xF8, 0x0E, 0x01, 0x00, 0x00, 0x1F, 0xE0, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFD, 0xFC, 0x7F, 0x03,
  0xE1, 0xF8, 0x0F, 0x8F, 0xC0, 0x3E, 0x3E, 0x01, 0xF9, 0xF8, 0x07, 0xC7,
  0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xF3, 0xF0, 0x0F, 0x8F, 0xC0,
  0x3E, 0x3F, 0x00, 0xF8, 0xFC, 0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xE1, 0xFE,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0x1F, 0x00,
  0x40, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0xFC, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xBF, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0,
  0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x80, 0x7C,
  0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x3F, 0x3F, 0x00, 0xF8, 0xF8,
  0x07, 0xE3, 0xE0, 0x3F, 0x8F, 0x81, 0xFC, 0x7E, 0x1F, 0xE1, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x60, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xF7, 0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0x7C, 0x0F,
  0x80, 0x7E, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x81,
  0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x7E, 0x01, 0xF0,
  0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE1, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xF1, 0xF0, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF1, 0xFE, 0x3F, 0x9F, 0xC0, 0x7C, 0xFC, 0x03, 0xEF, 0xC0, 0x1F, 0x7C,
  0x01, 0xFB, 0xE0, 0x1F, 0xBE, 0x07, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8,
  0x7F, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x60, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFC, 0x30,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xE3, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x80,
  0xFC, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x3F, 0x07, 0xE0,
  0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C,
  0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x30, 0x07, 0xE0,
  0x1F, 0xBF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xF0, 0x3F,
  0x0F, 0xC0, 0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F, 0x1F,
  0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xC0, 0x7E, 0x3F, 0x01,
  0xF0, 0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0xFC, 0x7E, 0x03, 0xE1,
  0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x01, 0xF8, 0xFC, 0x07, 0xC0, 0x00,
  0x20, 0x00, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0xF8, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC3, 0x0F,
  0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x30, 0x1F, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x07, 0xC0,
  0x7E, 0x07, 0xC0, 0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0x87,
  0xE0, 0x0F, 0x8F, 0xC0, 0x0F, 0x9F, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E,
  0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x0F,
  0x80, 0x7C, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x07, 0xE0, 0xFC, 0x07,
  0xE0, 0xF8, 0x03, 0xF0, 0x7F, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x1D, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF,
  0x1F, 0xF8, 0x04, 0x00, 0x00, 0xFC, 0x3C, 0x01, 0xFF, 0x7F, 0x81, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x78, 0xF8, 0xF8, 0x3C, 0x7C, 0x7C, 0x3E,
  0x3E, 0x3C, 0x1F, 0x1E, 0x1E, 0x0F, 0x0F, 0x1F, 0x07, 0x8F, 0x8F, 0x87,
  0xC7, 0xC7, 0x83, 0xE3, 0xC3, 0xC1, 0xE1, 0xE1, 0xE0, 0xF0, 0xF1, 0xF0,
  0xF8, 0x80, 0xF8, 0x7C, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3E,
  0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x07,
  0xC3, 0xE0, 0x03, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xC0, 0xFC, 0x3E, 0x07, 0xE3, 0xF0,
  0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x7E, 0x7E, 0x03, 0xE3,
  0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0xCF, 0xC0, 0x7C, 0x7E, 0x03,
  0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF9, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x7C,
  0x03, 0xE3, 0xE0, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xC1, 0xF8, 0xFC, 0x07, 0xCF,
  0xC0, 0x3F, 0x7C, 0x01, 0xFF, 0xE0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03,
  0xEF, 0x80, 0x1F, 0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xF8,
  0x07, 0xE7, 0xE0, 0x7E, 0x3F, 0x8F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xCF, 0xF0,
  0x0F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x1F,
  0x81, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01,
  0xF0, 0x3E, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80,
  0xFE, 0x07, 0xC0, 0xFE, 0x07, 0xE1, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFB, 0xF8, 0x7F,
  0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF0, 0x0F,
  0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x8F,
  0x80, 0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0xE1,
  0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x3F, 0x00, 0x40, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x7F, 0x1F, 0x07, 0xE0, 0x08, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE1,
  0x00, 0x3F, 0x1E, 0x03, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF,
  0x80, 0xFF, 0xF8, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x87, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0x80, 0x00, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xC7,
  0xC0, 0x7E, 0x3E, 0x03, 0xF3, 0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07,
  0xC7, 0xC0, 0x7E, 0x7E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x0F, 0xCF, 0xC0, 0x7C, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF8,
  0xF8, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x0F, 0xF1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x3F, 0xFB, 0xE0, 0x7F, 0x9F, 0x80, 0x60, 0x00, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03,
  0xF3, 0xF0, 0x1F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x87, 0xE0, 0xFC, 0x1F,
  0x07, 0xC0, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x01, 0xF3, 0xF0,
  0x0F, 0x9F, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xC7, 0x80, 0x03, 0xE3, 0xC0,
  0x01, 0xF1, 0xE0, 0xE0, 0xF1, 0xF0, 0xF0, 0x78, 0xF8, 0x7C, 0x7C, 0x7C,
  0x7E, 0x3C, 0x3C, 0x3F, 0x1E, 0x1E, 0x3F, 0x9F, 0x0F, 0x1F, 0xCF, 0x07,
  0x9F, 0xE7, 0x83, 0xCE, 0xF7, 0xC1, 0xEF, 0x7B, 0xC0, 0xF7, 0x1D, 0xE0,
  0x7F, 0x8F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8,
  0x07, 0xC0, 0xFC, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xE0,
  0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x01,
  0xF0, 0x7C, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xF7, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x7E, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x0F,
  0xC0, 0x00, 0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC,
  0x07, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8,
  0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x07,
  0xE3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3B, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xC0, 0x10, 0x1F, 0xE0, 0x7C, 0x7F, 0xE0, 0xF1,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0x9F, 0xFE, 0x3E, 0x0F, 0xF8, 0x38,
  0x07, 0xE0,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 13, 31, 24, 6, -30 },
  { 52, 16, 13, 24, 8, -33 },
  { 78, 25, 30, 24, 0, -30 },
  { 172, 23, 38, 24, 1, -33 },
  { 282, 30, 31, 24, -2, -30 },
  { 399, 22, 30, 24, 1, -30 },
  { 482, 8, 14, 24, 12, -33 },
  { 496, 19, 42, 24, 5, -34 },
  { 596, 19, 42, 24, 0, -34 },
  { 696, 20, 19, 24, 4, -30 },
  { 744, 21, 21, 24, 2, -23 },
  { 800, 11, 15, 24, 3, -8 },
  { 821, 14, 5, 24, 5, -15 },
  { 830, 8, 9, 24, 6, -8 },
  { 839, 28, 42, 24, -2, -34 },
  { 986, 22, 31, 24, 2, -30 },
  { 1072, 18, 30, 24, 2, -30 },
  { 1140, 23, 30, 24, 1, -30 },
  { 1227, 23, 31, 24, 0, -30 },
  { 1317, 24, 30, 24, 0, -30 },
  { 1407, 25, 31, 24, 0, -30 },
  { 1504, 23, 31, 24, 2, -30 },
  { 1594, 23, 30, 24, 4, -30 },
  { 1681, 23, 31, 24, 1, -30 },
  { 1771, 23, 30, 24, 1, -30 },
  { 1858, 12, 24, 24, 6, -23 },
  { 1894, 15, 30, 24, 3, -23 },
  { 1951, 22, 21, 24, 2, -23 },
  { 2009, 23, 14, 24, 1, -20 },
  { 2050, 22, 21, 24, 1, -23 },
  { 2108, 18, 31, 24, 6, -30 },
  { 2178, 24, 36, 24, 1, -30 },
  { 2286, 23, 30, 24, -2, -30 },
  { 2373, 24, 30, 24, 0, -30 },
  { 2463, 24, 31, 24, 2, -30 },
  { 2556, 24, 30, 24, 0, -30 },
  { 2646, 25, 30, 24, 1, -30 },
  { 2740, 25, 30, 24, 1, -30 },
  { 2834, 23, 31, 24, 2, -30 },
  { 2924, 26, 30, 24, 0, -30 },
  { 3022, 25, 30, 24, 0, -30 },
  { 3116, 25, 31, 24, 0, -30 },
  { 3213, 27, 30, 24, 0, -30 },
  { 3315, 20, 30, 24, 0, -30 },
  { 3390, 27, 30, 24, -1, -30 },
  { 3492, 26, 30, 24, 0, -30 },
  { 3590, 22, 31, 24, 2, -30 },
  { 3676, 25, 30, 24, 0, -30 },
  { 3770, 22, 38, 24, 2, -30 },
  { 3875, 24, 30, 24, 0, -30 },
  { 3965, 24, 31, 24, 0, -30 },
  { 4058, 22, 30, 24, 5, -30 },
  { 4141, 24, 31, 24, 2, -30 },
  { 4234, 23, 30, 24, 5, -30 },
  { 4321, 27, 30, 24, 0, -30 },
  { 4423, 30, 30, 24, -2, -30 },
  { 4536, 23, 30, 24, 5, -30 },
  { 4623, 26, 30, 24, 0, -30 },
  { 4721, 23, 42, 24, 3, -34 },
  { 4842, 9, 42, 24, 8, -34 },
  { 4890, 23, 42, 24, -1, -34 },
  { 5011, 22, 17, 24, 2, -30 },
  { 5058, 22, 5, 24, -3, 3 },
  { 5072, 10, 9, 24, 10, -33 },
  { 5084, 22, 24, 24, 1, -23 },
  { 5150, 22, 34, 24, 0, -33 },
  { 5244, 21, 24, 24, 2, -23 },
  { 5307, 25, 34, 24, 1, -33 },
  { 5414, 21, 24, 24, 2, -23 },
  { 5477, 30, 41, 24, -3, -33 },
  { 5631, 25, 31, 24, -1, -23 },
  { 5728, 22, 33, 24, 0, -33 },
  { 5819, 16, 34, 24, 4, -34 },
  { 5887, 24, 42, 24, -2, -34 },
  { 6013, 24, 33, 24, 1, -33 },
  { 6112, 14, 34, 24, 6, -33 },
  { 6172, 25, 23, 24, -1, -23 },
  { 6244, 21, 23, 24, 1, -23 },
  { 6305, 21, 24, 24, 2, -23 },
  { 6368, 25, 31, 24, -2, -23 },
  { 6465, 22, 31, 24, 2, -23 },
  { 6551, 22, 23, 24, 2, -23 },
  { 6615, 21, 24, 24, 1, -23 },
  { 6678, 19, 30, 24, 4, -29 },
  { 6750, 21, 24, 24, 2, -23 },
  { 6813, 21, 23, 24, 4, -23 },
  { 6874, 25, 23, 24, 1, -23 },
  { 6946, 26, 23, 24, -1, -23 },
  { 7021, 28, 31, 24, -4, -23 },
  { 7130, 22, 23, 24, 1, -23 },
  { 7194, 23, 42, 24, 3, -34 },
  { 7315, 15, 42, 24, 5, -34 },
  { 7394, 23, 42, 24, -2, -34 },
  { 7515, 23, 8, 24, 1, -17 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic43pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic43pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic43pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC43PT7B_H_
