#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC24PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38,
  0x00, 0x00, 0x30, 0x78, 0xF8, 0x70, 0x73, 0xDC, 0xE7, 0x39, 0x8C, 0x63,
  0x38, 0xCC, 0x60, 0x01, 0x8C, 0x0E, 0x70, 0x31, 0x81, 0xCE, 0x07, 0x30,
  0xFF, 0xF7, 0xFF, 0xC3, 0x18, 0x1C, 0xE0, 0x63, 0x07, 0xFF, 0xBF, 0xFE,
  0xFF, 0xF1, 0xCE, 0x06, 0x30, 0x19, 0xC0, 0xE7, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x07, 0xE0, 0xFF, 0x8F, 0x9C, 0x70, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x03, 0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC8, 0x1C, 0x7F,
  0xE7, 0xFE, 0x07, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x07, 0x03, 0x0F,
  0x86, 0x19, 0x8E, 0x19, 0x9C, 0x19, 0x98, 0x13, 0x30, 0x1F, 0x60, 0x1E,
  0xC0, 0x01, 0xC0, 0x03, 0xB8, 0x03, 0x7C, 0x06, 0xCC, 0x0C, 0xCC, 0x18,
  0xCC, 0x30, 0xD8, 0x70, 0xF8, 0xE0, 0xF0, 0x03, 0xE0, 0x3F, 0x03, 0x9C,
  0x18, 0xE1, 0xC7, 0x0E, 0x70, 0x37, 0x01, 0xF0, 0x1F, 0x39, 0xF9, 0xDC,
  0xEC, 0xC7, 0xEE, 0x1E, 0x70, 0x73, 0xCF, 0x8F, 0xEC, 0x3E, 0x70, 0x7F,
  0xEE, 0xEC, 0xC8, 0x00, 0x80, 0x70, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0xC0,
  0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x40, 0x02, 0x00, 0xE0,
  0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0xC1, 0xE0, 0x18, 0x02, 0x00, 0x0E, 0x01, 0xC0, 0x18, 0x33, 0x77,
  0xFF, 0xFF, 0xC3, 0xC0, 0xFC, 0x3B, 0xC7, 0x30, 0x44, 0x00, 0x03, 0x80,
  0x30, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xE0, 0xE0, 0x0E, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0xF7, 0xCF, 0x18, 0xEF, 0x30, 0x7F, 0xFE,
  0xFE, 0x7B, 0xFE, 0xE0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00,
  0x07, 0xC0, 0xFE, 0x1F, 0xF3, 0xC7, 0x38, 0x77, 0x07, 0x70, 0x77, 0x77,
  0xE7, 0x7E, 0x67, 0xE0, 0x6E, 0x0E, 0xE0, 0xEE, 0x1C, 0xF3, 0xC7, 0xF8,
  0x3F, 0x00, 0x00, 0xC0, 0x70, 0x7C, 0x7F, 0x3F, 0x8E, 0xE0, 0x38, 0x0E,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE3, 0xFF, 0xFF, 0xC0,
  0x03, 0xE0, 0x7F, 0x87, 0xFE, 0x10, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0,
  0x0F, 0xFC, 0xFF, 0xE0, 0x07, 0xE0, 0x7F, 0x83, 0xFE, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0xFC, 0x07, 0xC0, 0x5F, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x00, 0x79, 0x87, 0x9F, 0xF8, 0x7F, 0x80, 0x00, 0x38, 0x03, 0xC0,
  0x3E, 0x03, 0xF0, 0x3B, 0x03, 0xB8, 0x39, 0xC3, 0x8E, 0x38, 0x61, 0x87,
  0x1C, 0x39, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x07, 0xE0, 0x1F, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0x86, 0x1E, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0x78, 0x1F, 0xC1, 0xFE, 0x3E,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0F, 0xF8, 0x7F, 0xE7, 0x07, 0x38, 0x39,
  0xC0, 0xCE, 0x0E, 0x70, 0x71, 0xC7, 0x8F, 0xF8, 0x3F, 0x00, 0x3F, 0xFB,
  0xFF, 0xDF, 0xFC, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0xFF, 0x1E, 0xF3, 0x83, 0x38, 0x33, 0x87, 0x3C,
  0x71, 0xFE, 0x1F, 0x83, 0xBC, 0x71, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1,
  0xCF, 0xFC, 0x7F, 0x00, 0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0x87, 0x70, 0x77,
  0x07, 0x70, 0x77, 0x07, 0x3F, 0xF3, 0xFF, 0x0C, 0xE0, 0x0E, 0x01, 0xC0,
  0x38, 0x3F, 0x0F, 0xE0, 0xF8, 0x00, 0x1E, 0x3C, 0xF8, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0xF3, 0xE3, 0x80, 0x0F, 0x0F, 0x1F, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x3C, 0x7C, 0x3C, 0x18, 0x38, 0xF0, 0xC0, 0x00, 0x10, 0x07,
  0x01, 0xF0, 0xFE, 0x7F, 0x07, 0x80, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xC0, 0x04, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF9, 0xFF, 0xDF, 0xFE, 0x10, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x03, 0xC0, 0xFE, 0x3F, 0x87, 0xE0, 0x1C, 0x01, 0x00, 0x00,
  0x1F, 0x1F, 0xF3, 0xFC, 0x07, 0x01, 0xC0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xE0,
  0x7F, 0x87, 0x8E, 0x70, 0x73, 0x01, 0xB8, 0xFD, 0x8F, 0xFC, 0xFE, 0xCE,
  0x36, 0x73, 0xB3, 0x1D, 0x98, 0xEC, 0xC6, 0x67, 0x73, 0x3F, 0x98, 0xF8,
  0xE0, 0x07, 0x80, 0x1F, 0xE0, 0x7F, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x7C, 0x03, 0x60, 0x3B, 0x01, 0x98, 0x1C, 0xC1, 0xC6, 0x0E, 0x30,
  0xE1, 0xC7, 0x0E, 0x7F, 0xF3, 0xFF, 0xB8, 0x1D, 0xC0, 0xFC, 0x07, 0xE0,
  0x38, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x61,
  0xE7, 0xFE, 0x3F, 0xE1, 0xFF, 0x8C, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x39,
  0xC7, 0x9F, 0xFC, 0xFF, 0x80, 0x01, 0xF0, 0x3F, 0xC3, 0xFE, 0x38, 0x13,
  0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xE3, 0x0F, 0xF8, 0x1F, 0xC0, 0x0F, 0x80, 0x7F,
  0x07, 0xFC, 0x38, 0xF1, 0xC3, 0x8E, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x39,
  0xC1, 0xDC, 0x1E, 0xE0, 0xE7, 0x0F, 0x38, 0xF3, 0x9F, 0x1F, 0xF0, 0xFE,
  0x00, 0x0F, 0xF8, 0xFF, 0xC7, 0xFE, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0xFC, 0x3F, 0xC3, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xE1, 0xFF, 0x87, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x87, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x03,
  0xF0, 0x3F, 0xC7, 0xFE, 0x38, 0x23, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x77, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x78, 0xF1, 0xE7, 0x0F,
  0xF8, 0x3F, 0xC0, 0x0E, 0x0E, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xE1, 0xC1,
  0xC3, 0x87, 0x0E, 0x0E, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE1, 0xC1, 0xC3,
  0x83, 0x87, 0x07, 0x0E, 0x0E, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xE0, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xE1, 0x07, 0x86, 0x3C, 0x3F, 0xF0, 0x7F, 0x00, 0x0E,
  0x1E, 0x1C, 0x38, 0x70, 0xE0, 0xE3, 0x81, 0xCF, 0x03, 0xBC, 0x0E, 0xF0,
  0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xCE, 0x03, 0x9E, 0x07, 0x1C, 0x0E,
  0x3C, 0x1C, 0x38, 0x70, 0x70, 0xE0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0x06, 0x0E, 0x1C, 0x3C,
  0x78, 0x78, 0xF0, 0xF3, 0x63, 0xE7, 0xC7, 0xDB, 0x0D, 0xB6, 0x19, 0xCC,
  0x73, 0xB8, 0xE6, 0x71, 0x80, 0xC7, 0x01, 0x8E, 0x07, 0x1C, 0x0E, 0x30,
  0x1C, 0xE0, 0x30, 0x0C, 0x0E, 0x1C, 0x18, 0x78, 0x70, 0xF0, 0xE1, 0xF1,
  0xC3, 0x63, 0x0E, 0xC6, 0x1D, 0x9C, 0x33, 0xB8, 0x63, 0x61, 0xC6, 0xC3,
  0x8F, 0x87, 0x1F, 0x0C, 0x3E, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xE0, 0x07,
  0xC0, 0x7F, 0x07, 0xFC, 0x78, 0xE3, 0x87, 0x38, 0x1D, 0xC1, 0xCE, 0x0E,
  0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC1, 0xCE, 0x0E, 0x70, 0xE3, 0xCF, 0x0F,
  0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0x87, 0x0F, 0x1C, 0x1C,
  0x70, 0x71, 0xC1, 0xCE, 0x0E, 0x39, 0xF8, 0xFF, 0xC3, 0xFC, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x7F,
  0x07, 0xFC, 0x78, 0xE3, 0x87, 0x38, 0x1D, 0xC1, 0xCE, 0x0E, 0xE0, 0x77,
  0x03, 0xB8, 0x1D, 0xC1, 0xCE, 0x0E, 0x70, 0xE3, 0xCF, 0x0F, 0xF0, 0x3F,
  0x00, 0xC0, 0x07, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x40, 0x0F, 0xC0, 0x7F,
  0x87, 0xFE, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0xE0, 0xE7, 0x0F, 0x3F, 0xF1,
  0xFF, 0x0F, 0xE0, 0xE3, 0x87, 0x1C, 0x38, 0x71, 0xC3, 0x9C, 0x1C, 0xE0,
  0xF0, 0x03, 0xF0, 0x3F, 0xF0, 0xFF, 0x87, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0x87, 0x1E, 0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x1C, 0xE0,
  0xE3, 0x83, 0x8E, 0x0E, 0x38, 0x39, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0x70,
  0x73, 0xC3, 0x8E, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x87, 0x0F, 0x3C, 0x1F,
  0xE0, 0x7F, 0x00, 0xE0, 0x7F, 0x03, 0xB8, 0x3D, 0xC1, 0xCE, 0x0E, 0x70,
  0xE3, 0x87, 0x1C, 0x70, 0xE3, 0x87, 0x38, 0x39, 0xC1, 0xDC, 0x0E, 0xE0,
  0x7E, 0x03, 0xE0, 0x1F, 0x00, 0x70, 0x00, 0x1C, 0x0E, 0x38, 0x1C, 0x60,
  0x38, 0xC0, 0x63, 0x80, 0xC7, 0x03, 0x8C, 0x67, 0x19, 0xCC, 0x37, 0x98,
  0xEF, 0x71, 0xF6, 0xC3, 0x6D, 0x87, 0x9B, 0x0F, 0x3E, 0x1C, 0x38, 0x78,
  0x70, 0xE0, 0xE0, 0x0E, 0x07, 0x07, 0x0F, 0x07, 0x0E, 0x07, 0x1C, 0x03,
  0xB8, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xE0, 0x07,
  0xE0, 0x0F, 0x60, 0x0E, 0x70, 0x1C, 0x70, 0x38, 0x70, 0x78, 0x30, 0xF0,
  0x38, 0xE0, 0x7F, 0x03, 0xB8, 0x39, 0xC3, 0xC6, 0x1C, 0x39, 0xC1, 0xCE,
  0x0E, 0xE0, 0x3E, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x00, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x03,
  0xF8, 0x1F, 0xC1, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x18, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x18, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x3F, 0x83, 0xFC, 0x00, 0x01, 0xC0, 0x3C, 0x07, 0xC0, 0xFE,
  0x0E, 0xE1, 0xCE, 0x38, 0x77, 0x07, 0xF0, 0x72, 0x04, 0x7F, 0xFF, 0xFF,
  0x80, 0x46, 0x3C, 0xF3, 0x80, 0x03, 0xE1, 0xFF, 0x3F, 0xF7, 0x8E, 0x70,
  0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0xE1, 0xCE, 0x1C, 0xF3, 0xCF, 0xFC, 0x7E,
  0xE0, 0x01, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x77,
  0x03, 0xFE, 0x1F, 0xF1, 0xC3, 0x8E, 0x1E, 0x70, 0x63, 0x87, 0x38, 0x39,
  0xC1, 0xCE, 0x1C, 0x73, 0xE3, 0xFE, 0x3F, 0xC0, 0x03, 0xE1, 0xFF, 0x3F,
  0xE7, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF8,
  0xC7, 0xFC, 0x3F, 0xC0, 0x00, 0x04, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x3F, 0x07, 0xFC, 0x3F, 0xF1, 0xE3, 0x87, 0x0E, 0x38,
  0x38, 0xE0, 0xE3, 0x83, 0x8E, 0x1C, 0x38, 0x70, 0xF3, 0xC1, 0xFF, 0x07,
  0xEE, 0x00, 0x07, 0xC1, 0xFE, 0x3F, 0xF7, 0x87, 0x70, 0x7E, 0x0E, 0xFF,
  0xEF, 0xF8, 0xE0, 0x0E, 0x00, 0xF0, 0x47, 0xFC, 0x3F, 0xC0, 0x00, 0x07,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x04, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x40,
  0x00, 0x00, 0xF8, 0x1F, 0xF0, 0xFF, 0xC7, 0x87, 0x1C, 0x38, 0xF0, 0xE3,
  0x83, 0x8E, 0x0E, 0x38, 0x70, 0xF3, 0xC1, 0xFF, 0x03, 0xFC, 0x00, 0x60,
  0x03, 0x84, 0x1E, 0x1F, 0xF0, 0xFF, 0x80, 0x60, 0x00, 0x01, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1F, 0xC1, 0xFF, 0x1F, 0xF3, 0x87,
  0x38, 0x73, 0x87, 0x38, 0x77, 0x87, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E,
  0xE1, 0xC0, 0x06, 0x07, 0x83, 0xC1, 0xE0, 0x00, 0x01, 0xF9, 0xFC, 0xFE,
  0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x3C, 0x8F, 0xC7, 0xE0,
  0x00, 0x10, 0x00, 0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x83, 0xFE, 0x0F, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x43,
  0x83, 0xFE, 0x0F, 0xF0, 0x02, 0x00, 0x01, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE1, 0xC7, 0x0E, 0x1C, 0x70, 0x77, 0x81,
  0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xEE, 0x03, 0xB8, 0x1C, 0x70, 0x71, 0xE1,
  0xC3, 0x8F, 0x0F, 0x00, 0x7E, 0xFE, 0xFE, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x79, 0x7F, 0x3F, 0x0E,
  0x71, 0xFF, 0xCE, 0xFE, 0x67, 0x33, 0x3B, 0xB9, 0x9D, 0xCC, 0xCC, 0xE6,
  0x60, 0x77, 0x03, 0xB8, 0x1D, 0xC0, 0xCC, 0x0E, 0x00, 0x07, 0xC1, 0xFF,
  0x1F, 0xF1, 0xC7, 0x38, 0x73, 0x87, 0x38, 0x73, 0x87, 0x70, 0xE7, 0x0E,
  0x70, 0xE7, 0x0E, 0xE1, 0xC0, 0x07, 0x81, 0xFE, 0x3F, 0xE7, 0x8E, 0x70,
  0xFE, 0x07, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0xF3, 0xC7, 0xF8, 0x7F,
  0x00, 0x03, 0xE0, 0x3F, 0xE0, 0xFF, 0x87, 0x0E, 0x1C, 0x1C, 0x70, 0x71,
  0xC3, 0x8E, 0x0E, 0x38, 0x38, 0xE1, 0xC3, 0x9F, 0x0F, 0xF8, 0x7F, 0x81,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0xE1, 0xFF, 0x3F, 0xF7,
  0x87, 0x70, 0xEF, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1, 0xCE, 0x1C, 0xF3, 0xC7,
  0xFC, 0x7F, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x07, 0xF1, 0xFF,
  0x1F, 0xE3, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0xF1, 0xFE, 0x3F, 0xE3, 0x80, 0x38,
  0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xC0, 0x1C, 0xC3, 0xCF, 0xF8, 0xFF,
  0x00, 0x0E, 0x01, 0xC0, 0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xF1, 0x0F, 0xE1, 0xFC, 0x38,
  0x73, 0x87, 0x70, 0x77, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xEE, 0x1C, 0xE1,
  0xCE, 0x1C, 0xF7, 0xCF, 0xFC, 0x7E, 0xC0, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE,
  0x1C, 0xE1, 0xCE, 0x38, 0x73, 0x87, 0x70, 0x77, 0x07, 0xE0, 0x7C, 0x07,
  0xC0, 0x38, 0x00, 0x60, 0x1D, 0x80, 0x66, 0x03, 0xB9, 0xCC, 0xE7, 0x33,
  0xBD, 0xCC, 0xF6, 0x36, 0xD8, 0xDB, 0xE3, 0xCF, 0x0F, 0x3C, 0x38, 0xE0,
  0xC3, 0x80, 0x1C, 0x1E, 0x1C, 0x38, 0x38, 0xE0, 0x3B, 0x80, 0x7E, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x1D, 0xC0, 0x73, 0x81, 0xC3,
  0x8F, 0x07, 0x00, 0x0E, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x1E, 0x07,
  0x1C, 0x07, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x70, 0x07, 0x70, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x20, 0x00, 0x0F, 0xF8, 0xFF, 0xC7, 0xFE, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xFF, 0xCF, 0xFC,
  0x00, 0x00, 0xF8, 0x1F, 0x81, 0xFC, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F,
  0x80, 0xF8, 0x00, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C,
  0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0,
  0xE0, 0xE0, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xF0, 0x0F, 0x80,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x7F, 0x03, 0xF0, 0x00, 0x7C, 0x37, 0xFF, 0xEF, 0xEC, 0x3C,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 8, 17, 13, 3, -17 },
  { 18, 10, 7, 13, 4, -18 },
  { 27, 14, 17, 13, 0, -17 },
  { 57, 13, 22, 13, 0, -19 },
  { 93, 16, 17, 13, -1, -17 },
  { 127, 13, 17, 13, 0, -17 },
  { 155, 4, 8, 13, 7, -18 },
  { 159, 10, 24, 13, 3, -19 },
  { 189, 11, 24, 13, 0, -19 },
  { 222, 11, 11, 13, 2, -17 },
  { 238, 12, 12, 13, 1, -13 },
  { 256, 6, 8, 13, 2, -4 },
  { 262, 8, 3, 13, 3, -8 },
  { 265, 5, 4, 13, 3, -4 },
  { 268, 15, 23, 13, -1, -19 },
  { 312, 12, 17, 13, 1, -17 },
  { 338, 10, 17, 13, 1, -17 },
  { 360, 13, 17, 13, 0, -17 },
  { 388, 13, 17, 13, 0, -17 },
  { 416, 13, 17, 13, 0, -17 },
  { 444, 14, 17, 13, 0, -17 },
  { 474, 13, 17, 13, 1, -17 },
  { 502, 13, 17, 13, 2, -17 },
  { 530, 12, 17, 13, 1, -17 },
  { 556, 12, 17, 13, 1, -17 },
  { 582, 7, 12, 13, 3, -12 },
  { 593, 8, 16, 13, 2, -12 },
  { 609, 12, 12, 13, 1, -13 },
  { 627, 13, 8, 13, 0, -11 },
  { 640, 13, 12, 13, 0, -13 },
  { 660, 10, 17, 13, 3, -17 },
  { 682, 13, 21, 13, 1, -17 },
  { 717, 13, 17, 13, -1, -17 },
  { 745, 13, 17, 13, 0, -17 },
  { 773, 13, 17, 13, 1, -17 },
  { 801, 13, 17, 13, 0, -17 },
  { 829, 13, 17, 13, 1, -17 },
  { 857, 14, 17, 13, 1, -17 },
  { 887, 13, 17, 13, 1, -17 },
  { 915, 15, 17, 13, 0, -17 },
  { 947, 14, 17, 13, 0, -17 },
  { 977, 14, 17, 13, 0, -17 },
  { 1007, 15, 17, 13, 0, -17 },
  { 1039, 11, 17, 13, 0, -17 },
  { 1063, 15, 17, 13, -1, -17 },
  { 1095, 15, 17, 13, 0, -17 },
  { 1127, 13, 17, 13, 1, -17 },
  { 1155, 14, 17, 13, 0, -17 },
  { 1185, 13, 22, 13, 1, -17 },
  { 1221, 13, 17, 13, 0, -17 },
  { 1249, 14, 17, 13, 0, -17 },
  { 1279, 12, 17, 13, 3, -17 },
  { 1305, 14, 17, 13, 1, -17 },
  { 1335, 13, 17, 13, 3, -17 },
  { 1363, 15, 17, 13, 0, -17 },
  { 1395, 16, 17, 13, -1, -17 },
  { 1429, 13, 17, 13, 3, -17 },
  { 1457, 14, 17, 13, 0, -17 },
  { 1487, 13, 23, 13, 1, -19 },
  { 1525, 5, 23, 13, 5, -19 },
  { 1540, 13, 23, 13, -1, -19 },
  { 1578, 12, 10, 13, 1, -17 },
  { 1593, 13, 2, 13, -2, 2 },
  { 1597, 5, 5, 13, 6, -19 },
  { 1601, 12, 13, 13, 1, -13 },
  { 1621, 13, 19, 13, 0, -19 },
  { 1652, 12, 13, 13, 1, -13 },
  { 1672, 14, 19, 13, 1, -19 },
  { 1706, 12, 13, 13, 1, -13 },
  { 1726, 17, 24, 13, -2, -19 },
  { 1777, 14, 18, 13, -1, -13 },
  { 1809, 12, 19, 13, 0, -19 },
  { 1838, 9, 19, 13, 2, -19 },
  { 1860, 14, 24, 13, -1, -19 },
  { 1902, 14, 19, 13, 0, -19 },
  { 1936, 8, 19, 13, 3, -19 },
  { 1955, 13, 13, 13, 0, -13 },
  { 1977, 12, 13, 13, 0, -13 },
  { 1997, 12, 13, 13, 1, -13 },
  { 2017, 14, 17, 13, -1, -13 },
  { 2047, 12, 17, 13, 1, -13 },
  { 2073, 12, 13, 13, 1, -13 },
  { 2093, 12, 13, 13, 1, -13 },
  { 2113, 11, 16, 13, 2, -16 },
  { 2135, 12, 13, 13, 1, -13 },
  { 2155, 12, 13, 13, 2, -13 },
  { 2175, 14, 13, 13, 1, -13 },
  { 2198, 15, 13, 13, -1, -13 },
  { 2223, 16, 18, 13, -2, -13 },
  { 2259, 13, 13, 13, 0, -13 },
  { 2281, 13, 23, 13, 2, -19 },
  { 2319, 8, 23, 13, 3, -19 },
  { 2342, 13, 23, 13, -1, -19 },
  { 2380, 12, 4, 13, 1, -9 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic24pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic24pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic24pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC24PT7B_H_
