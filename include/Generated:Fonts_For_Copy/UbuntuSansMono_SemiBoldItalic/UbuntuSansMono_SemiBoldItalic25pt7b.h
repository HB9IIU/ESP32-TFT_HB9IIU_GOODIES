#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC25PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x70, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0x61, 0xC0, 0x00,
  0x1C, 0x3C, 0x78, 0xE0, 0x73, 0xF1, 0xF9, 0xDC, 0xEE, 0x76, 0x33, 0x19,
  0x0C, 0x01, 0xCE, 0x07, 0x38, 0x0C, 0x70, 0x38, 0xC3, 0xFF, 0xE7, 0xFF,
  0x9F, 0xFF, 0x06, 0x38, 0x1C, 0x60, 0x39, 0xC3, 0xFF, 0xE7, 0xFF, 0xCF,
  0xFF, 0x8E, 0x70, 0x1C, 0xE0, 0x31, 0x80, 0xE7, 0x00, 0x00, 0x60, 0x03,
  0x80, 0x1F, 0x01, 0xFF, 0x0F, 0xF8, 0x78, 0x21, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x18,
  0x3C, 0x7F, 0xE3, 0xFF, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x87, 0xC1, 0x87, 0x61, 0x83, 0x31, 0xC1, 0x99, 0xC0, 0xCC,
  0xC0, 0x6C, 0xC0, 0x3E, 0xC0, 0x0E, 0xC0, 0x00, 0xE0, 0x00, 0xEF, 0x00,
  0x6F, 0x80, 0x66, 0xE0, 0x66, 0x60, 0x63, 0x30, 0x71, 0x98, 0x70, 0xF8,
  0x70, 0x3C, 0x00, 0x01, 0xC0, 0x3F, 0x83, 0xFC, 0x1C, 0x60, 0xC3, 0x06,
  0x38, 0x33, 0x81, 0xF8, 0x0F, 0x80, 0xF8, 0xCF, 0xEE, 0xE7, 0x76, 0x1F,
  0x70, 0xF3, 0x83, 0x9E, 0x7C, 0x7F, 0xF1, 0xF3, 0x80, 0x77, 0x7F, 0xEE,
  0xCC, 0x00, 0x40, 0x18, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xE0,
  0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xC0, 0x10, 0x00,
  0x01, 0x00, 0x60, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0xC0,
  0x70, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x03, 0x00, 0x40, 0x00, 0x0E,
  0x01, 0xC3, 0x31, 0x7E, 0xEF, 0xFE, 0x3C, 0x07, 0xC1, 0xDC, 0x73, 0xC6,
  0x20, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x00, 0x3C, 0xF3, 0xCF,
  0x1C, 0xEF, 0x38, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x3F, 0x07, 0xFC, 0x38, 0xF3, 0x83, 0x9C, 0x1D, 0xC0, 0xEE, 0x67, 0x77,
  0x3F, 0x3B, 0xB9, 0x9D, 0xC0, 0xEE, 0x0F, 0x70, 0x73, 0x87, 0x9E, 0x78,
  0x7F, 0x81, 0xF8, 0x00, 0x01, 0xE0, 0x78, 0x3F, 0x1F, 0xE3, 0xDC, 0x27,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x1F, 0xE1, 0xFF, 0x83, 0x0F, 0x08,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0xFC, 0x7F, 0xF3, 0xFF, 0x80,
  0x01, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0x0E, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x7C, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x18, 0x78, 0xFF, 0xE1, 0xFE, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x80, 0x7E, 0x03, 0xB8, 0x1C, 0xE0, 0xE7, 0x07, 0x1C, 0x38, 0x71,
  0xC1, 0xC7, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0xC6, 0x3E, 0x3F, 0xF8, 0x7F, 0x80, 0x01, 0xF8, 0x3F, 0xC3,
  0xF0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xDE, 0x0F, 0xFC, 0x7F, 0xF7, 0x03,
  0xB8, 0x1D, 0xC0, 0xEE, 0x07, 0x78, 0x71, 0xC7, 0x8F, 0xF8, 0x3F, 0x80,
  0x3F, 0xFD, 0xFF, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x7F, 0x87, 0xFE, 0x38,
  0x73, 0x83, 0x9C, 0x1C, 0xE1, 0xC3, 0x9E, 0x1F, 0xE0, 0xFE, 0x0E, 0x78,
  0xE1, 0xCE, 0x0F, 0x70, 0x7B, 0x83, 0x9E, 0x3C, 0xFF, 0xC1, 0xFC, 0x00,
  0x03, 0x80, 0x7F, 0x07, 0xFC, 0x78, 0xE3, 0x83, 0xB8, 0x1D, 0xC0, 0xEE,
  0x07, 0x78, 0x79, 0xFF, 0x87, 0xFC, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F,
  0x07, 0xF0, 0xFE, 0x07, 0xC0, 0x00, 0x3C, 0xF3, 0xCF, 0x00, 0x00, 0x00,
  0x03, 0xCF, 0x3C, 0xF0, 0x0F, 0x0F, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x38, 0xF0, 0xE0, 0x00, 0x18, 0x07,
  0xC0, 0xFE, 0x3F, 0x87, 0xF0, 0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x3F, 0x00, 0x70, 0x00, 0x80, 0x3F, 0xFC, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x3F, 0xFC, 0x18, 0x00, 0xF0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3C, 0x07, 0xE1, 0xFE, 0x3F, 0x87, 0xE0, 0x1C,
  0x01, 0x00, 0x00, 0x07, 0x07, 0xF8, 0xFF, 0x10, 0xF0, 0x1E, 0x03, 0x80,
  0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x07,
  0xC0, 0xF8, 0x0E, 0x00, 0x01, 0xE0, 0x1F, 0xE0, 0xFF, 0x87, 0x07, 0x38,
  0x1D, 0xC0, 0x77, 0x1F, 0x98, 0xFE, 0xE7, 0x3B, 0xB8, 0xEC, 0xE3, 0x33,
  0x9C, 0xCE, 0x73, 0x39, 0xCC, 0xF7, 0x31, 0xF8, 0xE3, 0xE3, 0x80, 0x0F,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x3E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x7E,
  0x03, 0x70, 0x3B, 0x83, 0x9C, 0x1C, 0xE1, 0xC7, 0x0E, 0x38, 0xE1, 0xC7,
  0xFE, 0x7F, 0xF3, 0xFF, 0xB8, 0x1D, 0xC0, 0xFE, 0x07, 0xE0, 0x38, 0x00,
  0x80, 0x3F, 0xE0, 0xFF, 0x87, 0x8F, 0x1C, 0x1C, 0x70, 0x71, 0xC3, 0x87,
  0x3E, 0x3F, 0xE0, 0xFF, 0xC3, 0x8F, 0x8E, 0x0E, 0x70, 0x39, 0xC0, 0xE7,
  0x07, 0x1C, 0xFC, 0xFF, 0xE3, 0xFE, 0x00, 0x00, 0xF0, 0x1F, 0xF0, 0xFF,
  0x87, 0x82, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1F, 0x30, 0x3F,
  0xE0, 0x7F, 0x00, 0x01, 0x00, 0x3F, 0x80, 0xFF, 0x07, 0x1E, 0x1C, 0x38,
  0x70, 0xF1, 0xC1, 0xCE, 0x07, 0x38, 0x3C, 0xE0, 0xE3, 0x83, 0x9C, 0x0E,
  0x70, 0x79, 0xC3, 0xC7, 0x1F, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0x0F,
  0xFC, 0x7F, 0xE1, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0F,
  0xF8, 0x3F, 0xE1, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0xFE, 0x3F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xF1, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0F, 0xFC, 0x3F, 0xE1, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x1F, 0xF0, 0xFF, 0x87, 0x82, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0xC1, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0xE3, 0x83, 0x8F,
  0x0E, 0x1E, 0x38, 0x7F, 0xC0, 0xFF, 0x00, 0x0E, 0x0E, 0x3C, 0x1C, 0x70,
  0x78, 0xE0, 0xE1, 0xC1, 0xC3, 0x83, 0x8E, 0x07, 0x1F, 0xFC, 0x3F, 0xF8,
  0x70, 0x71, 0xC0, 0xE3, 0x83, 0x87, 0x07, 0x0E, 0x0E, 0x38, 0x1C, 0x70,
  0x70, 0xE0, 0xE0, 0x0F, 0xFE, 0x1F, 0xF8, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE0, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x08,
  0x1C, 0x1C, 0xF8, 0x7F, 0xE0, 0x7F, 0x80, 0x0E, 0x1F, 0x0E, 0x1C, 0x1E,
  0x38, 0x1C, 0x70, 0x1C, 0xF0, 0x1D, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F,
  0x00, 0x3B, 0x80, 0x7B, 0xC0, 0x71, 0xC0, 0x71, 0xE0, 0x70, 0xE0, 0x70,
  0xF0, 0xE0, 0x70, 0xE0, 0x70, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x1F, 0xFB, 0xFF, 0xFF, 0xE0, 0x07, 0x07, 0x07, 0x0F, 0x0F, 0x0F, 0x0F,
  0x1E, 0x0D, 0x3E, 0x1D, 0xB6, 0x1D, 0xFE, 0x19, 0xEE, 0x19, 0xCE, 0x39,
  0xCC, 0x39, 0x9C, 0x30, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x38, 0x60,
  0x38, 0xE0, 0x38, 0x0E, 0x0E, 0x1C, 0x1C, 0x7C, 0x38, 0xF8, 0x61, 0xF1,
  0xC3, 0x63, 0x8E, 0xE7, 0x1C, 0xCC, 0x39, 0xB8, 0x63, 0x71, 0xC6, 0xE3,
  0x8F, 0x87, 0x0F, 0x0C, 0x1E, 0x38, 0x3C, 0x70, 0x70, 0xE0, 0xE0, 0x01,
  0xC0, 0x3F, 0x87, 0xFC, 0x38, 0xF3, 0x83, 0xBC, 0x1D, 0xC0, 0xEE, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x73, 0x87, 0x9E,
  0x78, 0x7F, 0x81, 0xF8, 0x00, 0x00, 0xC0, 0x3F, 0xE0, 0xFF, 0xC3, 0x8F,
  0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x3C, 0x3C, 0xFF, 0xE3, 0xFF,
  0x0F, 0xE0, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x3F, 0x87, 0xFC, 0x38, 0xF3, 0x83, 0xBC, 0x1D, 0xC0,
  0xEE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x73,
  0x87, 0x9E, 0x78, 0x7F, 0x81, 0xF8, 0x07, 0x00, 0x38, 0x00, 0xFC, 0x03,
  0xC0, 0x06, 0x00, 0x01, 0x80, 0x3F, 0xC0, 0xFF, 0x87, 0x8F, 0x1C, 0x1C,
  0x70, 0x71, 0xC1, 0xCF, 0x0E, 0x38, 0x78, 0xFF, 0xC3, 0xFC, 0x0F, 0xF0,
  0x71, 0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0xE0, 0x73, 0x81, 0xC0, 0x00,
  0xF0, 0x1F, 0xF0, 0xFF, 0xC7, 0x82, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x1C, 0x7C, 0xFF, 0xE1, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x83, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x00, 0x1C,
  0x1C, 0xF0, 0x73, 0x83, 0x8E, 0x0E, 0x38, 0x39, 0xE0, 0xE7, 0x07, 0x1C,
  0x1C, 0x70, 0x73, 0xC1, 0xCE, 0x0F, 0x38, 0x38, 0xE0, 0xE3, 0x87, 0x8F,
  0x3C, 0x1F, 0xE0, 0x7F, 0x00, 0xE0, 0x3F, 0x03, 0xB8, 0x1D, 0xC1, 0xCE,
  0x0E, 0x70, 0xE3, 0x87, 0x1C, 0x70, 0xE3, 0x87, 0x38, 0x39, 0xC1, 0xDC,
  0x0E, 0xE0, 0x7E, 0x03, 0xF0, 0x0F, 0x00, 0x70, 0x00, 0x1C, 0x07, 0x1C,
  0x06, 0x1C, 0x0E, 0x18, 0x0E, 0x38, 0x0E, 0x38, 0x0C, 0x39, 0x9C, 0x33,
  0x9C, 0x33, 0x98, 0x77, 0x98, 0x7E, 0xB8, 0x6C, 0xF8, 0x78, 0xF0, 0x78,
  0xF0, 0x70, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0x0F, 0x07, 0x83, 0x87, 0x81,
  0xE3, 0x80, 0x73, 0x80, 0x3B, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xF0, 0x01, 0xDC, 0x01, 0xEE, 0x00, 0xE7, 0x00, 0xE3,
  0x80, 0xF0, 0xE0, 0xF0, 0x70, 0xF0, 0x38, 0x00, 0xE0, 0x7F, 0x03, 0xB8,
  0x3C, 0xE1, 0xC7, 0x1C, 0x39, 0xC1, 0xCE, 0x07, 0xE0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x00,
  0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xF8, 0x3F, 0xC1,
  0xFC, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0xFC, 0x1F, 0xC0, 0xFE,
  0x00, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xF3, 0x9C, 0xE7, 0x38, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x07, 0xF0, 0x1F, 0xC0, 0xFF,
  0x00, 0x01, 0xC0, 0x1F, 0x01, 0xF8, 0x1F, 0xC1, 0xEF, 0x1E, 0x38, 0xE1,
  0xCE, 0x0F, 0xF0, 0x39, 0x01, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x63,
  0xC7, 0x8F, 0x08, 0x0F, 0xF8, 0xFF, 0x8F, 0x1C, 0xF0, 0xE7, 0x0F, 0x70,
  0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x0F, 0x3C, 0xF8, 0xFF, 0xC7, 0xEE,
  0x00, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x7F,
  0xC3, 0xFE, 0x1E, 0x79, 0xE1, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0xBC, 0x3D,
  0xC1, 0xCE, 0x1E, 0x73, 0xE3, 0xFE, 0x3F, 0xE0, 0x07, 0xF8, 0xFF, 0x8F,
  0x84, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80,
  0x1F, 0x30, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x7F, 0x87, 0xFC, 0x3C, 0x71, 0xE1, 0xC7,
  0x07, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x38, 0x78, 0xF3, 0xE1,
  0xFF, 0x87, 0xEE, 0x00, 0x0F, 0xE1, 0xFF, 0x3C, 0x77, 0x07, 0x70, 0x7E,
  0x1F, 0xFF, 0xEF, 0xF8, 0xE0, 0x0E, 0x00, 0x78, 0x47, 0xFC, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0x88, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x01, 0xC0, 0x00, 0x01, 0xFE, 0x0F, 0xFC, 0x3C, 0x70,
  0xF0, 0xE1, 0xC1, 0xC7, 0x87, 0x8E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x79,
  0xF0, 0x7F, 0xC0, 0x7F, 0x80, 0x07, 0x00, 0x1E, 0x10, 0x78, 0x3F, 0xE0,
  0xFF, 0x80, 0x38, 0x00, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x7F, 0xC3, 0xFE, 0x1C, 0x79, 0xE3, 0xCE, 0x1E, 0x70, 0xE3,
  0x87, 0x3C, 0x39, 0xC1, 0xCE, 0x1E, 0x70, 0xE3, 0x87, 0x38, 0x38, 0x02,
  0x01, 0xC0, 0xF8, 0x3C, 0x02, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x03, 0x80,
  0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x07, 0xB1, 0xFC, 0x3F,
  0x00, 0x08, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC1, 0x0F, 0x0F, 0xF8, 0x3F, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x11, 0xC3, 0x8E, 0x1C, 0x39, 0xE0,
  0xEF, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xDC, 0x07, 0x38, 0x3C, 0xE0,
  0xE1, 0xC3, 0x87, 0x8E, 0x0E, 0x00, 0x7F, 0x7F, 0x03, 0x81, 0xC1, 0xE0,
  0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0,
  0x79, 0x3F, 0xCF, 0xE0, 0x1F, 0x78, 0xFF, 0xF3, 0xB9, 0xCC, 0xE7, 0x33,
  0x99, 0xCE, 0x67, 0x33, 0x9D, 0xCE, 0x60, 0x33, 0x80, 0xCE, 0x07, 0x38,
  0x1C, 0xC0, 0x60, 0x1F, 0xF0, 0xFF, 0x87, 0x1E, 0x38, 0x73, 0xC3, 0x9C,
  0x3C, 0xE1, 0xC7, 0x0E, 0x78, 0x73, 0x83, 0x9C, 0x38, 0xE1, 0xCF, 0x0E,
  0x00, 0x0F, 0xE1, 0xFE, 0x3C, 0xF7, 0x87, 0x70, 0x7E, 0x07, 0xE0, 0x7E,
  0x0F, 0xE0, 0xEE, 0x1E, 0xF3, 0xC7, 0xF8, 0x3F, 0x00, 0x0F, 0xF0, 0x3F,
  0xE0, 0xE3, 0xC7, 0x87, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xCF, 0x0F, 0x38,
  0x38, 0xE1, 0xE3, 0xBF, 0x0F, 0xF8, 0x7F, 0x81, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x07, 0xF8, 0xFF, 0xCF, 0x9C, 0xF0, 0xE7,
  0x07, 0x78, 0x7B, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x0F, 0x3C, 0xF0, 0xFF,
  0x83, 0xFC, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x0F,
  0xF8, 0xFF, 0x87, 0xFC, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x0F, 0xF1, 0xFF,
  0x3C, 0x23, 0x80, 0x3C, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x01, 0xE0, 0x1E,
  0xE3, 0xCF, 0xFC, 0xFF, 0x00, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x7F,
  0xFF, 0xFE, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x7D, 0xC3, 0xFC, 0x1F, 0xC0, 0x38, 0x79, 0xC3, 0x9E, 0x1C,
  0xE0, 0xE7, 0x0E, 0x38, 0x71, 0xC3, 0x9C, 0x1C, 0xE1, 0xE7, 0x0E, 0x3D,
  0xF0, 0xFF, 0xC7, 0xEE, 0x00, 0xE0, 0x7E, 0x0F, 0xE0, 0xEF, 0x0E, 0xF1,
  0xC7, 0x1C, 0x73, 0x87, 0x78, 0x77, 0x07, 0xE0, 0x7E, 0x03, 0xC0, 0x38,
  0x00, 0x70, 0x1D, 0x80, 0x76, 0x01, 0xB9, 0xCE, 0xE7, 0x3B, 0xBC, 0xCE,
  0xF7, 0x37, 0xD8, 0xDB, 0x63, 0xCF, 0x8F, 0x3C, 0x38, 0x70, 0xE1, 0x80,
  0x1E, 0x0E, 0x1C, 0x38, 0x1C, 0xE0, 0x3B, 0x80, 0x3F, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x3D, 0xE0, 0x71, 0xC1, 0xC3, 0x8F, 0x03,
  0x80, 0x0F, 0x07, 0x0F, 0x0F, 0x0F, 0x0E, 0x07, 0x0E, 0x07, 0x1C, 0x07,
  0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x70, 0x03, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x70,
  0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0xFF, 0xE0,
  0x00, 0x38, 0x0F, 0xC0, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x07, 0x01, 0xF8, 0x0F, 0x00, 0x7C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xFC, 0x07, 0xE0, 0x0F, 0x00, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x70,
  0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38,
  0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x00, 0x03, 0x80,
  0x3F, 0x01, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xF0, 0x07, 0x80, 0x7C, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x81, 0xF8, 0x1F,
  0xC0, 0xF0, 0x00, 0x1C, 0x23, 0xF1, 0xFF, 0xFD, 0xCF, 0xCC, 0x3C, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 7, 17, 14, 4, -17 },
  { 16, 9, 8, 14, 5, -19 },
  { 25, 15, 17, 14, 0, -17 },
  { 57, 14, 22, 14, 0, -19 },
  { 96, 17, 18, 14, -1, -18 },
  { 135, 13, 18, 14, 0, -18 },
  { 165, 4, 8, 14, 7, -19 },
  { 169, 11, 25, 14, 3, -20 },
  { 204, 11, 25, 14, 0, -20 },
  { 239, 11, 10, 14, 3, -17 },
  { 253, 12, 13, 14, 1, -14 },
  { 273, 6, 8, 14, 2, -4 },
  { 279, 8, 3, 14, 3, -9 },
  { 282, 4, 4, 14, 4, -4 },
  { 284, 16, 25, 14, -1, -20 },
  { 334, 13, 18, 14, 1, -18 },
  { 364, 11, 17, 14, 1, -17 },
  { 388, 14, 18, 14, 0, -18 },
  { 420, 14, 18, 14, 0, -18 },
  { 452, 14, 17, 14, 0, -17 },
  { 482, 14, 17, 14, 0, -17 },
  { 512, 13, 17, 14, 1, -17 },
  { 540, 14, 17, 14, 2, -17 },
  { 570, 13, 18, 14, 1, -18 },
  { 600, 13, 18, 14, 1, -18 },
  { 630, 6, 13, 14, 4, -13 },
  { 640, 8, 17, 14, 2, -13 },
  { 657, 13, 12, 14, 1, -13 },
  { 677, 14, 8, 14, 0, -11 },
  { 691, 13, 12, 14, 0, -13 },
  { 711, 11, 18, 14, 3, -18 },
  { 736, 14, 22, 14, 1, -18 },
  { 775, 13, 17, 14, -1, -17 },
  { 803, 14, 18, 14, 0, -18 },
  { 835, 14, 18, 14, 1, -18 },
  { 867, 14, 18, 14, 0, -18 },
  { 899, 14, 17, 14, 1, -17 },
  { 929, 14, 17, 14, 1, -17 },
  { 959, 14, 18, 14, 1, -18 },
  { 991, 15, 17, 14, 0, -17 },
  { 1023, 15, 17, 14, 0, -17 },
  { 1055, 15, 17, 14, 0, -17 },
  { 1087, 16, 17, 14, 0, -17 },
  { 1121, 11, 17, 14, 0, -17 },
  { 1145, 16, 17, 14, -1, -17 },
  { 1179, 15, 17, 14, 0, -17 },
  { 1211, 13, 18, 14, 1, -18 },
  { 1241, 14, 18, 14, 0, -18 },
  { 1273, 13, 23, 14, 1, -18 },
  { 1311, 14, 18, 14, 0, -18 },
  { 1343, 14, 18, 14, 0, -18 },
  { 1375, 13, 17, 14, 3, -17 },
  { 1403, 14, 17, 14, 1, -17 },
  { 1433, 13, 17, 14, 3, -17 },
  { 1461, 16, 17, 14, 0, -17 },
  { 1495, 17, 17, 14, -1, -17 },
  { 1532, 13, 17, 14, 3, -17 },
  { 1560, 15, 17, 14, 0, -17 },
  { 1592, 13, 25, 14, 2, -20 },
  { 1633, 5, 25, 14, 5, -20 },
  { 1649, 14, 25, 14, -1, -20 },
  { 1693, 13, 10, 14, 1, -17 },
  { 1710, 13, 3, 14, -2, 2 },
  { 1715, 6, 5, 14, 6, -19 },
  { 1719, 13, 13, 14, 1, -13 },
  { 1741, 13, 19, 14, 0, -19 },
  { 1772, 13, 13, 14, 1, -13 },
  { 1794, 14, 19, 14, 1, -19 },
  { 1828, 12, 13, 14, 1, -13 },
  { 1848, 18, 24, 14, -2, -19 },
  { 1902, 15, 18, 14, -1, -13 },
  { 1936, 13, 19, 14, 0, -19 },
  { 1967, 10, 20, 14, 2, -20 },
  { 1992, 14, 25, 14, -1, -20 },
  { 2036, 14, 19, 14, 1, -19 },
  { 2070, 9, 19, 14, 3, -19 },
  { 2092, 14, 13, 14, 0, -13 },
  { 2115, 13, 13, 14, 0, -13 },
  { 2137, 12, 13, 14, 1, -13 },
  { 2157, 14, 18, 14, -1, -13 },
  { 2189, 13, 18, 14, 1, -13 },
  { 2219, 13, 13, 14, 1, -13 },
  { 2241, 12, 13, 14, 1, -13 },
  { 2261, 12, 17, 14, 2, -17 },
  { 2287, 13, 13, 14, 1, -13 },
  { 2309, 12, 13, 14, 2, -13 },
  { 2329, 14, 13, 14, 1, -13 },
  { 2352, 15, 13, 14, -1, -13 },
  { 2377, 16, 18, 14, -2, -13 },
  { 2413, 14, 13, 14, 0, -13 },
  { 2436, 13, 25, 14, 2, -20 },
  { 2477, 9, 25, 14, 3, -20 },
  { 2506, 13, 25, 14, -1, -20 },
  { 2547, 13, 5, 14, 1, -10 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic25pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic25pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic25pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC25PT7B_H_
