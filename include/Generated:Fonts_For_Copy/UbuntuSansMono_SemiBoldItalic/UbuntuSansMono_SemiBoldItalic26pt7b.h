#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC26PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38,
  0x30, 0x00, 0x00, 0xF0, 0xF0, 0xF0, 0xF0, 0x73, 0xDC, 0xEF, 0x3B, 0x8E,
  0xE3, 0x39, 0xCC, 0x73, 0x18, 0x01, 0xCE, 0x03, 0x1C, 0x0E, 0x30, 0x1C,
  0xE3, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x87, 0x18, 0x0E, 0x70, 0x38, 0xC0,
  0x73, 0x87, 0xFF, 0xEF, 0xFF, 0x86, 0x38, 0x1C, 0x60, 0x39, 0xC0, 0x63,
  0x81, 0xCE, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x1F, 0xF0, 0xFF,
  0xC1, 0xE1, 0x87, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x60, 0xF0, 0xFF,
  0xE3, 0xFF, 0x80, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x07,
  0x81, 0xC3, 0xE0, 0xC1, 0x98, 0x70, 0x66, 0x38, 0x19, 0x9C, 0x06, 0x66,
  0x01, 0xB3, 0x00, 0x7D, 0x80, 0x04, 0xC0, 0x00, 0x72, 0x00, 0x3B, 0xE0,
  0x1D, 0xF8, 0x06, 0x66, 0x03, 0x39, 0x81, 0x8C, 0x60, 0xE3, 0x30, 0x70,
  0xFC, 0x38, 0x1E, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xE3, 0x83, 0x8E, 0x0C,
  0x30, 0x31, 0xC0, 0xEE, 0x03, 0xF0, 0x0F, 0x98, 0x7C, 0x73, 0xB9, 0x9C,
  0x7E, 0x61, 0xF3, 0x83, 0xCE, 0x0F, 0x3C, 0xFC, 0x7F, 0xF0, 0xFC, 0xE0,
  0x7B, 0xDC, 0xE7, 0x33, 0x9C, 0xC0, 0x00, 0x20, 0x1C, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0,
  0x1E, 0x01, 0xE0, 0x1C, 0x01, 0x00, 0x01, 0x00, 0x38, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x80, 0x70, 0x04, 0x00, 0x0E, 0x01, 0xC2,
  0x38, 0xF7, 0x7F, 0xFF, 0xFF, 0xC3, 0x81, 0xDC, 0x3B, 0x8E, 0x38, 0x46,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x3F, 0xFF, 0xFF,
  0xDF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x00, 0x08,
  0x78, 0xF9, 0xF3, 0xC3, 0x8E, 0x7C, 0xE0, 0x7F, 0xBF, 0xBF, 0xC0, 0x27,
  0xBF, 0xEF, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x7F,
  0x87, 0x9E, 0x78, 0x73, 0x83, 0xBC, 0x1D, 0xC0, 0xEE, 0x67, 0x77, 0xBF,
  0x39, 0xF8, 0x8F, 0xC0, 0xEE, 0x07, 0x70, 0x7B, 0x87, 0x8E, 0x78, 0x7F,
  0x81, 0xF8, 0x00, 0x00, 0xE0, 0x3C, 0x1F, 0x8F, 0xF3, 0xFC, 0x33, 0x80,
  0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x3F, 0xF0, 0xF3, 0xC2, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0xFC, 0x7F, 0xF3, 0xFF, 0xC0,
  0x07, 0xF0, 0x3F, 0xE0, 0x63, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x07,
  0x81, 0xFC, 0x07, 0xC0, 0x1F, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x18, 0x7C, 0xFF, 0xE1, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0xF0,
  0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x1E, 0xE0, 0x73, 0x83, 0x8E, 0x1C, 0x70,
  0xE1, 0xC7, 0x07, 0x1F, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x38, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x39, 0xF8, 0xFF, 0xE0,
  0xFF, 0x80, 0x00, 0x7C, 0x0F, 0xF0, 0x7F, 0xC3, 0xC0, 0x1E, 0x00, 0xF0,
  0x03, 0x80, 0x1D, 0xF8, 0x7F, 0xF1, 0xE3, 0xCF, 0x07, 0x38, 0x1E, 0xE0,
  0x73, 0x81, 0xC7, 0x0F, 0x1E, 0x78, 0x7F, 0xE0, 0x7E, 0x00, 0x7F, 0xFB,
  0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xE3, 0x87, 0x0F, 0x38,
  0x1C, 0xE0, 0xE1, 0xC7, 0x87, 0xBC, 0x0F, 0xE0, 0xFF, 0x87, 0x9E, 0x1C,
  0x3C, 0xE0, 0x73, 0x81, 0xCE, 0x0F, 0x3C, 0x78, 0x7F, 0xC0, 0xFE, 0x00,
  0x0F, 0xE0, 0xFF, 0x8F, 0x9E, 0x70, 0x77, 0x83, 0xB8, 0x1D, 0xC0, 0xEF,
  0x07, 0x3C, 0xF9, 0xFF, 0xC7, 0xFE, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x1F,
  0x1F, 0xF0, 0xFE, 0x07, 0xC0, 0x00, 0x08, 0x7C, 0xF9, 0xF3, 0xC0, 0x00,
  0x00, 0x00, 0x43, 0xC7, 0xCF, 0x1E, 0x00, 0x02, 0x07, 0xC3, 0xE1, 0xF0,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x0F, 0x07, 0xC3, 0xE1, 0xE0, 0x70,
  0x70, 0xF8, 0x70, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x0F, 0xF3, 0xFC,
  0x3F, 0x03, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xC0,
  0x02, 0x00, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x9F, 0xFE, 0xFF, 0xF0, 0x10, 0x00, 0x70, 0x03, 0xF0, 0x07,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0x80, 0x7E, 0x0F, 0xE3, 0xFE, 0x07,
  0xC0, 0x1C, 0x00, 0x80, 0x00, 0x3F, 0xC7, 0xFC, 0xC7, 0x80, 0x70, 0x0E,
  0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x00, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0xF8, 0x0E, 0x00, 0x03, 0xF8, 0x3F, 0xF1, 0xE1, 0xCF,
  0x07, 0x38, 0x1D, 0xC3, 0xF7, 0x3F, 0xD9, 0xFF, 0xE7, 0x1B, 0xB8, 0xEC,
  0xE3, 0xB3, 0x8E, 0xCE, 0x33, 0x39, 0xCC, 0xFF, 0x31, 0xFC, 0xE3, 0xE3,
  0x80, 0x07, 0x00, 0x1F, 0xB0, 0x3F, 0xC0, 0x3E, 0x00, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x7E, 0x03, 0xB8, 0x0E, 0xE0, 0x73, 0x81, 0xCE, 0x0E,
  0x18, 0x38, 0x61, 0xC1, 0xC7, 0xFF, 0x3F, 0xFC, 0xFF, 0xF7, 0x03, 0xDC,
  0x0F, 0xF0, 0x3F, 0x80, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC7, 0x87,
  0x1C, 0x1C, 0x70, 0x71, 0xC3, 0xC7, 0xFE, 0x3F, 0xE0, 0xFF, 0xE3, 0x83,
  0x8E, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x07, 0x9F, 0xFC, 0xFF, 0xE3, 0xFE,
  0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x3E, 0xF0, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F,
  0xE0, 0x3F, 0xE0, 0xFF, 0x87, 0x8F, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xCF,
  0x07, 0x38, 0x1C, 0xE0, 0x73, 0x83, 0xDE, 0x0E, 0x70, 0x79, 0xC1, 0xE7,
  0x0F, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF,
  0xC7, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF,
  0x87, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3F, 0xF8, 0xFF,
  0xE3, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xF8, 0x7F, 0xF0, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0x03, 0xFC, 0x1F, 0xF0, 0xF9, 0xC7, 0x80, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0xC1, 0xEF, 0x07, 0x38, 0x1C, 0xE0, 0x73,
  0xC3, 0xCF, 0x0E, 0x1F, 0x78, 0x7F, 0xE0, 0xFF, 0x80, 0x0E, 0x07, 0x0E,
  0x0F, 0x1E, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x1E, 0x3C, 0x1C, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x38, 0x38, 0x78, 0x38, 0x70, 0x38, 0x70,
  0x78, 0x70, 0x70, 0xF0, 0x70, 0xE0, 0x70, 0xE0, 0xF0, 0x0F, 0xFE, 0x1F,
  0xFC, 0x3F, 0xF8, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC0, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x1F,
  0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x10, 0x38, 0x3D,
  0xF0, 0xFF, 0xC0, 0x7F, 0x00, 0x0E, 0x0F, 0x0E, 0x1E, 0x0E, 0x1C, 0x1E,
  0x38, 0x1C, 0x70, 0x1C, 0xF0, 0x1D, 0xE0, 0x3F, 0xC0, 0x3F, 0x00, 0x3F,
  0x80, 0x3B, 0xC0, 0x79, 0xC0, 0x71, 0xE0, 0x70, 0xE0, 0x70, 0xF0, 0x70,
  0x70, 0xF0, 0x70, 0xE0, 0x78, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x70, 0x07, 0xFF, 0x7F, 0xFF, 0xFE, 0x07, 0x07, 0x83, 0x83,
  0x81, 0xE3, 0xC1, 0xF1, 0xE0, 0xD9, 0xB0, 0x6C, 0xF8, 0x76, 0xDC, 0x3B,
  0x6C, 0x19, 0xE6, 0x0C, 0xF7, 0x0E, 0x73, 0x87, 0x39, 0xC3, 0x80, 0xC3,
  0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x70, 0x1C, 0x00, 0x0E,
  0x07, 0x0E, 0x07, 0x1F, 0x0E, 0x1F, 0x0E, 0x1F, 0x0E, 0x1F, 0x8E, 0x1B,
  0x9C, 0x39, 0x9C, 0x39, 0x9C, 0x39, 0xDC, 0x31, 0xD8, 0x70, 0xF8, 0x70,
  0xF8, 0x70, 0xF8, 0x70, 0xF0, 0xE0, 0xF0, 0xE0, 0x70, 0xE0, 0x70, 0x07,
  0xF0, 0x3F, 0xE1, 0xF7, 0x8F, 0x0E, 0x38, 0x3D, 0xE0, 0xF7, 0x03, 0xDC,
  0x0E, 0xF0, 0x3B, 0xC0, 0xEE, 0x03, 0xB8, 0x1E, 0xE0, 0x73, 0x83, 0xCF,
  0x0E, 0x3E, 0xF8, 0x7F, 0xC0, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF8, 0x70, 0xF1, 0xE0, 0xE3, 0x81, 0xC7, 0x07, 0x8E, 0x0E, 0x3C, 0x7C,
  0x7F, 0xF0, 0xFF, 0xC1, 0xFC, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xF7, 0x8F, 0x0E,
  0x38, 0x3D, 0xE0, 0xF7, 0x03, 0xDC, 0x0E, 0xF0, 0x3B, 0xC0, 0xEE, 0x03,
  0xB8, 0x1E, 0xE0, 0x73, 0x83, 0xCF, 0x0E, 0x3E, 0xF8, 0x7F, 0xC0, 0xFC,
  0x01, 0xC0, 0x07, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x18, 0x00, 0x0F, 0xF0,
  0x3F, 0xE0, 0xFF, 0xC7, 0x87, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xCF, 0x0F,
  0x39, 0xF8, 0xFF, 0xC3, 0xFC, 0x0E, 0x70, 0x78, 0xE1, 0xC3, 0x87, 0x0F,
  0x1C, 0x1C, 0xF0, 0x73, 0x81, 0xC0, 0x03, 0xFC, 0x0F, 0xFC, 0x3C, 0x70,
  0xF0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x10, 0x1C, 0x3C, 0xF8,
  0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x00, 0x1C, 0x1E,
  0x38, 0x38, 0xF0, 0x71, 0xC0, 0xE3, 0x83, 0xC7, 0x07, 0x1E, 0x0E, 0x38,
  0x1C, 0x70, 0x78, 0xE0, 0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x0F, 0x1C, 0x1C,
  0x38, 0x38, 0x7D, 0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0xE0, 0x3F, 0x80, 0xEE,
  0x07, 0xB8, 0x1C, 0xE0, 0xF3, 0x83, 0x8E, 0x0E, 0x38, 0x70, 0xE1, 0xC3,
  0x8E, 0x0E, 0x38, 0x39, 0xC0, 0xE7, 0x03, 0xB8, 0x06, 0xE0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x8E, 0x03, 0x87, 0x01, 0xC3, 0x80,
  0xE1, 0x80, 0xE1, 0xC0, 0x70, 0xE7, 0x38, 0x73, 0x98, 0x33, 0xCC, 0x19,
  0xEE, 0x1D, 0xB7, 0x0F, 0xDB, 0x06, 0xCD, 0x83, 0xE7, 0xC1, 0xE3, 0xC0,
  0xF1, 0xE0, 0xF0, 0xF0, 0x70, 0x70, 0x00, 0x07, 0x03, 0xC1, 0xC1, 0xE0,
  0x78, 0xF0, 0x0E, 0x38, 0x03, 0x9C, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0x70,
  0x03, 0x8E, 0x01, 0xC3, 0x80, 0xF0, 0xE0, 0x78, 0x38, 0x3C, 0x0F, 0x00,
  0xE0, 0x3F, 0x80, 0xEF, 0x07, 0x1C, 0x3C, 0x70, 0xE1, 0xC7, 0x07, 0x3C,
  0x0E, 0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0x0F, 0xFE,
  0x0F, 0xFE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xF8, 0x3F, 0xC1,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0xFC, 0x1F, 0xE0, 0xFE,
  0x00, 0xE7, 0x39, 0xCF, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCF, 0x79,
  0xCE, 0x73, 0x9C, 0xE7, 0x38, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x07, 0xF8, 0x1F, 0xE0, 0xFF,
  0x00, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xE0, 0xE7, 0x0F, 0x38, 0xF1,
  0xEF, 0x07, 0xF0, 0x39, 0x01, 0x80, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0x80,
  0x61, 0xCF, 0x8F, 0x08, 0x03, 0xF0, 0x7F, 0xCF, 0xFE, 0x78, 0xF7, 0x87,
  0x78, 0x3B, 0x81, 0xDC, 0x1E, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xFF, 0xC7,
  0xFE, 0x1F, 0x78, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x01, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x70, 0xE3, 0xC3, 0xCE, 0x0F,
  0x38, 0x38, 0xE0, 0xE7, 0x83, 0x9C, 0x1E, 0x70, 0xF1, 0xCF, 0x87, 0xFC,
  0x3F, 0xE0, 0x03, 0xF8, 0x7F, 0xC7, 0xFC, 0x78, 0x07, 0x80, 0x38, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xFF, 0xC7, 0xFE, 0x0F,
  0xF0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x78, 0xF1, 0xE1, 0xC3, 0x83, 0x8F,
  0x07, 0x1C, 0x1E, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xE1, 0xFF, 0xC1, 0xFF,
  0x81, 0xF7, 0x80, 0x03, 0xE0, 0x7F, 0x8F, 0xFE, 0x70, 0x77, 0x03, 0xB8,
  0x3F, 0x8F, 0xDF, 0xFC, 0xFF, 0x07, 0x00, 0x3C, 0x00, 0xF8, 0xC7, 0xFE,
  0x1F, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x78, 0x71, 0xE1, 0xE3, 0x83, 0x8F, 0x07,
  0x1C, 0x0E, 0x38, 0x3C, 0x78, 0x70, 0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0x80,
  0x0E, 0x00, 0x1C, 0x20, 0x78, 0x7F, 0xE1, 0xFF, 0x80, 0xFC, 0x00, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x7F, 0x83, 0xFE,
  0x1F, 0xF8, 0xE3, 0xCF, 0x0E, 0x78, 0x73, 0x83, 0x9C, 0x3D, 0xE1, 0xCF,
  0x0E, 0x70, 0x73, 0x87, 0x9C, 0x39, 0xE1, 0xC0, 0x07, 0x81, 0xE0, 0x78,
  0x1C, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0xFF, 0x03, 0x80, 0xE0, 0x38, 0x1E,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0xF1, 0xFC, 0x3F, 0x00, 0x1C, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x03, 0xFC,
  0x0F, 0xF8, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x08, 0x78, 0x1F, 0xE0, 0x7F, 0xC0, 0x3E, 0x00, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC3, 0xC7, 0x1E, 0x3C, 0xF0,
  0xE7, 0x83, 0xBC, 0x0F, 0xE0, 0x7F, 0x01, 0xDC, 0x07, 0x78, 0x1C, 0xE0,
  0xF1, 0xC3, 0x87, 0x8E, 0x1E, 0x38, 0x3C, 0x7F, 0x3F, 0xBF, 0xC1, 0xC0,
  0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0,
  0xE0, 0x70, 0x3F, 0xCF, 0xE7, 0xF0, 0x0F, 0x38, 0x7F, 0xF3, 0xFF, 0xCE,
  0x67, 0x39, 0x9C, 0xCE, 0x77, 0x39, 0xDC, 0xE6, 0x73, 0x39, 0x80, 0xEE,
  0x03, 0xB8, 0x0C, 0xE0, 0x73, 0x01, 0xC0, 0x07, 0xE0, 0xFF, 0xC7, 0xFE,
  0x38, 0x71, 0xC3, 0x9E, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x7B, 0xC3, 0x9C,
  0x1C, 0xE0, 0xE7, 0x0F, 0x78, 0x70, 0x07, 0xC0, 0xFF, 0x8F, 0xFC, 0x70,
  0xE7, 0x07, 0xB8, 0x3F, 0xC1, 0xFC, 0x0E, 0xE0, 0x77, 0x07, 0xBC, 0x39,
  0xF7, 0xC7, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x70,
  0xE1, 0xE1, 0xE3, 0x83, 0xC7, 0x07, 0x8E, 0x0E, 0x1C, 0x1C, 0x78, 0x78,
  0xE1, 0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0x80, 0x00, 0x03, 0xF0, 0x7F, 0xC7, 0xFE, 0x78, 0xF7,
  0x87, 0xB8, 0x3B, 0xC1, 0xDC, 0x0E, 0xE0, 0xF7, 0x07, 0x3C, 0x39, 0xF7,
  0xC7, 0xFE, 0x1F, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x03, 0xF8, 0xFF, 0xC7, 0xFE, 0x38, 0x13, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x00, 0x07,
  0xF8, 0xFF, 0x87, 0xFC, 0x78, 0x03, 0x80, 0x1E, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0x00, 0x39, 0xE7, 0xCF, 0xFC, 0x7F, 0xC0, 0x01, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x7F, 0xF7, 0xFF, 0xFF, 0xF1, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xFC, 0x3F, 0xC1,
  0xFC, 0x38, 0x39, 0xC1, 0xCE, 0x1E, 0xF0, 0xE7, 0x07, 0x38, 0x39, 0xC3,
  0xCE, 0x1C, 0xF0, 0xE7, 0x07, 0x3C, 0x79, 0xFF, 0xC7, 0xFE, 0x3F, 0x70,
  0xF0, 0x7F, 0x83, 0xBC, 0x1D, 0xE1, 0xE7, 0x0E, 0x38, 0xF1, 0xC7, 0x0E,
  0x78, 0x73, 0x83, 0xB8, 0x1F, 0xC0, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0x70,
  0x0E, 0xE0, 0x19, 0x80, 0x73, 0x18, 0xEE, 0x31, 0x9C, 0xE7, 0x39, 0xCE,
  0x77, 0xD8, 0xFD, 0xF1, 0xB3, 0xE3, 0xE7, 0x87, 0x8F, 0x0E, 0x1C, 0x1C,
  0x38, 0x00, 0x1E, 0x0F, 0x0E, 0x0E, 0x0F, 0x1C, 0x07, 0x38, 0x07, 0xF8,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x1E, 0x70,
  0x1C, 0x70, 0x38, 0x78, 0xF0, 0x38, 0x0F, 0x07, 0x87, 0x83, 0x81, 0xC1,
  0xC0, 0xE1, 0xE0, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x70, 0x0E, 0x38, 0x07,
  0xB8, 0x01, 0xDC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xFC, 0x3F, 0xF1, 0xFF, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xFC, 0x7F, 0xE3, 0xFF, 0x80,
  0x01, 0xFC, 0x0F, 0xE0, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x3F, 0x00, 0xF0, 0x03, 0xE0,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x01, 0xE0, 0x07, 0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0x03, 0x83, 0xC1, 0xC0,
  0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0,
  0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xC0, 0xE0,
  0x00, 0x03, 0xE0, 0x1F, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1F, 0x00, 0x7C,
  0x03, 0xE0, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x07, 0xF0, 0x3F, 0x80, 0xF8, 0x00, 0x3C, 0x1B, 0xF9,
  0xFF, 0xFD, 0xCF, 0xE4, 0x1C, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 8, 18, 15, 4, -18 },
  { 19, 10, 8, 15, 5, -20 },
  { 29, 15, 18, 15, 0, -18 },
  { 63, 15, 23, 15, 0, -20 },
  { 107, 18, 18, 15, -1, -18 },
  { 148, 14, 18, 15, 0, -18 },
  { 180, 5, 9, 15, 7, -20 },
  { 186, 11, 26, 15, 3, -21 },
  { 222, 12, 26, 15, 0, -21 },
  { 261, 11, 11, 15, 3, -18 },
  { 277, 13, 13, 15, 1, -14 },
  { 299, 7, 9, 15, 2, -5 },
  { 307, 9, 3, 15, 3, -9 },
  { 311, 5, 5, 15, 4, -5 },
  { 315, 17, 25, 15, -1, -20 },
  { 369, 13, 18, 15, 1, -18 },
  { 399, 11, 18, 15, 1, -18 },
  { 424, 14, 18, 15, 0, -18 },
  { 456, 14, 18, 15, 0, -18 },
  { 488, 14, 18, 15, 0, -18 },
  { 520, 15, 18, 15, 0, -18 },
  { 554, 14, 18, 15, 1, -18 },
  { 586, 13, 18, 15, 3, -18 },
  { 616, 14, 18, 15, 1, -18 },
  { 648, 13, 18, 15, 1, -18 },
  { 678, 7, 14, 15, 4, -14 },
  { 691, 9, 18, 15, 2, -14 },
  { 712, 13, 13, 15, 1, -14 },
  { 734, 14, 9, 15, 0, -12 },
  { 750, 14, 13, 15, 0, -14 },
  { 773, 11, 18, 15, 3, -18 },
  { 798, 14, 22, 15, 1, -18 },
  { 837, 14, 18, 15, -1, -18 },
  { 869, 14, 18, 15, 0, -18 },
  { 901, 15, 18, 15, 1, -18 },
  { 935, 14, 18, 15, 0, -18 },
  { 967, 14, 18, 15, 1, -18 },
  { 999, 15, 18, 15, 1, -18 },
  { 1033, 14, 18, 15, 1, -18 },
  { 1065, 16, 18, 15, 0, -18 },
  { 1101, 15, 18, 15, 0, -18 },
  { 1135, 15, 18, 15, 0, -18 },
  { 1169, 16, 18, 15, 0, -18 },
  { 1205, 12, 18, 15, 0, -18 },
  { 1232, 17, 18, 15, -1, -18 },
  { 1271, 16, 18, 15, 0, -18 },
  { 1307, 14, 18, 15, 1, -18 },
  { 1339, 15, 18, 15, 0, -18 },
  { 1373, 14, 23, 15, 1, -18 },
  { 1414, 14, 18, 15, 0, -18 },
  { 1446, 15, 18, 15, 0, -18 },
  { 1480, 13, 18, 15, 3, -18 },
  { 1510, 15, 18, 15, 1, -18 },
  { 1544, 14, 18, 15, 3, -18 },
  { 1576, 17, 18, 15, 0, -18 },
  { 1615, 18, 18, 15, -1, -18 },
  { 1656, 14, 18, 15, 3, -18 },
  { 1688, 16, 18, 15, 0, -18 },
  { 1724, 13, 25, 15, 2, -20 },
  { 1765, 5, 25, 15, 5, -20 },
  { 1781, 14, 25, 15, -1, -20 },
  { 1825, 13, 10, 15, 1, -18 },
  { 1842, 14, 3, 15, -2, 2 },
  { 1848, 6, 5, 15, 6, -20 },
  { 1852, 13, 14, 15, 1, -14 },
  { 1875, 14, 20, 15, 0, -20 },
  { 1910, 13, 14, 15, 1, -14 },
  { 1933, 15, 20, 15, 1, -20 },
  { 1971, 13, 14, 15, 1, -14 },
  { 1994, 18, 25, 15, -2, -20 },
  { 2051, 15, 19, 15, -1, -14 },
  { 2087, 13, 20, 15, 0, -20 },
  { 2120, 10, 20, 15, 2, -20 },
  { 2145, 15, 25, 15, -1, -20 },
  { 2192, 14, 20, 15, 1, -20 },
  { 2227, 9, 20, 15, 3, -20 },
  { 2250, 14, 14, 15, 0, -14 },
  { 2275, 13, 14, 15, 0, -14 },
  { 2298, 13, 14, 15, 1, -14 },
  { 2321, 15, 19, 15, -1, -14 },
  { 2357, 13, 19, 15, 1, -14 },
  { 2388, 13, 14, 15, 1, -14 },
  { 2411, 13, 14, 15, 1, -14 },
  { 2434, 12, 18, 15, 2, -18 },
  { 2461, 13, 14, 15, 1, -14 },
  { 2484, 13, 14, 15, 2, -14 },
  { 2507, 15, 14, 15, 1, -14 },
  { 2534, 16, 14, 15, -1, -14 },
  { 2562, 17, 19, 15, -2, -14 },
  { 2603, 14, 14, 15, 0, -14 },
  { 2628, 14, 25, 15, 2, -20 },
  { 2672, 9, 25, 15, 3, -20 },
  { 2701, 14, 25, 15, -1, -20 },
  { 2745, 13, 5, 15, 1, -10 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic26pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic26pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic26pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC26PT7B_H_
