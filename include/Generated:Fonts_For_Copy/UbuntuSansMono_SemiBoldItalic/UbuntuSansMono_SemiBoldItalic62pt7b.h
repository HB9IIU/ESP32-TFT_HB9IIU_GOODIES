#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC62PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xE0,
  0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1,
  0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83,
  0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03,
  0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0,
  0x03, 0x80, 0x1F, 0xF0, 0x00, 0x20, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x01, 0x00, 0x00, 0xFF, 0x80,
  0x70, 0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0x01, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x3F, 0x00, 0x3F, 0x00, 0x0F, 0x87, 0xC0, 0x1F, 0x80, 0x07, 0xC1, 0xF0,
  0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x01, 0xF8,
  0x00, 0x3E, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0x81, 0xF0, 0x7E, 0x00, 0x03,
  0xE0, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x0F,
  0x87, 0xC0, 0x00, 0x0F, 0x87, 0xC3, 0xF0, 0x00, 0x03, 0xF3, 0xF1, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x7E, 0x00, 0x00,
  0x07, 0xFF, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x1F, 0x80, 0x00, 0x00, 0x0E,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x18, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0x8F, 0xFF, 0x80, 0x00,
  0x07, 0xE3, 0xF7, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0xF8, 0x00, 0x01, 0xF8,
  0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x3E, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0x83,
  0xE0, 0x00, 0x1F, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x3E, 0x00,
  0x07, 0xE0, 0x7C, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x07, 0xE0, 0x01, 0xF8,
  0x07, 0xC1, 0xF0, 0x00, 0xFC, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x00, 0x7E,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xC0, 0x03, 0xFF, 0xC0,
  0x07, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFE, 0x01,
  0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x3F,
  0xC0, 0x00, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x3E, 0x01, 0xFF, 0xC0,
  0x3F, 0x03, 0xFF, 0xE0, 0x7F, 0x07, 0xFF, 0xF0, 0x7E, 0x0F, 0xF7, 0xF0,
  0x7E, 0x1F, 0xC7, 0xF8, 0xFE, 0x3F, 0x83, 0xFC, 0xFC, 0x7F, 0x01, 0xFD,
  0xFC, 0x7F, 0x01, 0xFF, 0xF8, 0x7E, 0x00, 0xFF, 0xF8, 0xFE, 0x00, 0x7F,
  0xF0, 0xFE, 0x00, 0x7F, 0xE0, 0xFE, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF7,
  0xF8, 0x3F, 0xFF, 0xE3, 0xF8, 0x1F, 0xFF, 0xC3, 0xF8, 0x0F, 0xFE, 0x03,
  0xFC, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x9F, 0xF3, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x38, 0x1F,
  0x80, 0xC3, 0xE1, 0xF8, 0x3E, 0x3F, 0x8F, 0x8F, 0xE7, 0xFC, 0xFB, 0xFE,
  0x7F, 0xFF, 0x7F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x07,
  0xF8, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0x80, 0x7E, 0x07,
  0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x40, 0x10, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF,
  0xF0, 0x7F, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0x80, 0x00, 0x3F, 0xFF,
  0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xE7, 0xFC, 0x7F, 0x81, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x0F,
  0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF0, 0xFF,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x9F, 0xE0,
  0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFE, 0x7F, 0x03, 0x81, 0xFC, 0xFE, 0x1F,
  0x83, 0xFB, 0xFC, 0x7F, 0x87, 0xF7, 0xF0, 0xFF, 0x1F, 0xEF, 0xE1, 0xFE,
  0x3F, 0xDF, 0xC3, 0xF8, 0x7F, 0x7F, 0x87, 0xF0, 0xFE, 0xFE, 0x0F, 0xC1,
  0xFD, 0xFC, 0x0F, 0x07, 0xFB, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC,
  0x7F, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xE7,
  0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0x07, 0xF0, 0x01, 0x80, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0x7C, 0x00, 0x7F, 0x80, 0x38, 0x00, 0x3F, 0xC0, 0x08, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x9F, 0xFE, 0x00, 0x3C, 0x01,
  0xFF, 0x00, 0x18, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x81, 0x00, 0x00, 0xFF,
  0x81, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xDF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF3,
  0xFC, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x01,
  0xFC, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x01, 0x00, 0x00, 0xFF, 0x80, 0x3E, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x1F, 0xE7, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x1F, 0xE0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0x7F,
  0x80, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x0F, 0xFC,
  0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x07,
  0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF8, 0x01,
  0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFD,
  0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xF8,
  0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0x7F,
  0x00, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x0F,
  0xF0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFC, 0x7F, 0x00, 0x00, 0x60, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0x3F, 0xFC, 0x3C, 0x01, 0xFF,
  0x08, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0xFC,
  0x1F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x27,
  0xF1, 0xFC, 0x01, 0xFF, 0xFC, 0x7E, 0x01, 0xFF, 0xFF, 0x1F, 0x80, 0xFF,
  0xFF, 0xCF, 0xE0, 0x7F, 0xFF, 0xE3, 0xF0, 0x3F, 0xFF, 0xF8, 0xFC, 0x1F,
  0xFF, 0xFE, 0x7E, 0x07, 0xF8, 0x3F, 0x9F, 0x83, 0xF8, 0x0F, 0xC7, 0xE0,
  0xFE, 0x07, 0xF1, 0xF8, 0x7F, 0x01, 0xFC, 0xFC, 0x1F, 0xC0, 0x7F, 0x3F,
  0x07, 0xE0, 0x1F, 0x8F, 0xC3, 0xF8, 0x0F, 0xE3, 0xF0, 0xFE, 0x03, 0xF8,
  0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC3, 0xF8, 0x1F,
  0xC3, 0xF0, 0xFE, 0x07, 0xF0, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x0F, 0xE0,
  0x7E, 0x0F, 0xC3, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0xFF, 0xE0, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3F, 0x03, 0xFF, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0x03, 0xF0,
  0x0F, 0xFF, 0xC0, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x78,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE3,
  0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x01, 0xFC,
  0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F,
  0xBF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07,
  0xF0, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x03,
  0xF8, 0x07, 0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03,
  0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x3F, 0xE0, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0x80, 0x3F, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x80,
  0x7C, 0x03, 0xFF, 0x00, 0x04, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x10,
  0x03, 0xFF, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xF0, 0x7F, 0xF0, 0x03, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F,
  0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x01,
  0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xFC, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xF8,
  0x03, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0x87, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x08, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x06, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF0,
  0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF8, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xC0, 0x1F, 0xF8,
  0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x40, 0x00,
  0xFF, 0x00, 0x1E, 0x00, 0x3F, 0xE0, 0x03, 0xF0, 0x1F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x3F, 0xC7,
  0xFC, 0x00, 0x00, 0x7F, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00,
  0x03, 0xFD, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFB,
  0xFE, 0x00, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00,
  0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xF0,
  0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F,
  0xE0, 0x3F, 0xF8, 0x01, 0xFB, 0xC0, 0xFB, 0xF0, 0x03, 0xF7, 0xC1, 0xF7,
  0xC0, 0x07, 0xEF, 0x87, 0xCF, 0x80, 0x1F, 0x9F, 0x0F, 0xBF, 0x00, 0x3F,
  0x3E, 0x3E, 0x7E, 0x00, 0x7E, 0x7C, 0x7C, 0xFC, 0x00, 0xFC, 0xF9, 0xF1,
  0xF8, 0x03, 0xF1, 0xF3, 0xE7, 0xE0, 0x07, 0xE3, 0xEF, 0x8F, 0xC0, 0x0F,
  0xC7, 0xDF, 0x1F, 0x80, 0x3F, 0x8F, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0xF8,
  0xFE, 0x00, 0xFC, 0x3F, 0xE1, 0xF8, 0x03, 0xF8, 0x7F, 0xC3, 0xF0, 0x07,
  0xF0, 0x7F, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0, 0x1F, 0x81, 0xF8,
  0x3F, 0x80, 0x7F, 0x03, 0xE0, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x01,
  0xFF, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xFC, 0x00,
  0x3F, 0x80, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0xE0,
  0x0F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0x00,
  0x1F, 0x9F, 0x80, 0xFE, 0x00, 0x7F, 0x3F, 0x01, 0xF8, 0x00, 0xFE, 0x7E,
  0x07, 0xF0, 0x01, 0xFC, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x1F, 0xC0,
  0x0F, 0xE1, 0xF8, 0x3F, 0x00, 0x1F, 0xC3, 0xF0, 0xFE, 0x00, 0x3F, 0x87,
  0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xC3, 0xF8, 0x01, 0xFC, 0x0F, 0xC7, 0xF0,
  0x03, 0xF8, 0x1F, 0x9F, 0xC0, 0x07, 0xF0, 0x3F, 0x3F, 0x80, 0x0F, 0xE0,
  0x3E, 0x7F, 0x00, 0x3F, 0x80, 0x7E, 0xFE, 0x00, 0x7F, 0x00, 0xFD, 0xF8,
  0x00, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xFE,
  0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x01, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC,
  0x3F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F,
  0x8F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0x80, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xC0,
  0x07, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFE,
  0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0x81, 0xFF, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x0F, 0xFC, 0x03, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0,
  0xFF, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFE,
  0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07,
  0xF3, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x7F, 0x8F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xFC, 0x0F, 0xF0,
  0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x1F, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFC,
  0x07, 0xF8, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x0F,
  0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0x80,
  0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFE, 0x00, 0x3C, 0x00, 0xFF, 0x80, 0x01, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x08, 0x00, 0x03, 0xFC, 0x01, 0xC0, 0x00, 0xFF, 0x80, 0x7E, 0x00,
  0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xE0,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x0F,
  0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03,
  0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xE0,
  0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F,
  0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F,
  0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x03, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7F,
  0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0, 0x1F,
  0x83, 0xF8, 0x3F, 0x80, 0x3F, 0x0F, 0xF0, 0x7E, 0x00, 0xFE, 0x1F, 0xE0,
  0xFC, 0x01, 0xFC, 0x7F, 0xC3, 0xF8, 0x03, 0xF0, 0xFF, 0x87, 0xF0, 0x07,
  0xE3, 0xFF, 0x0F, 0xC0, 0x0F, 0xC7, 0xDE, 0x1F, 0x80, 0x3F, 0x9F, 0x3C,
  0x7F, 0x00, 0x7E, 0x3E, 0x78, 0xFC, 0x00, 0xFC, 0xF8, 0xF9, 0xF8, 0x01,
  0xF9, 0xF1, 0xF3, 0xF0, 0x03, 0xF7, 0xC3, 0xEF, 0xC0, 0x07, 0xCF, 0x87,
  0xDF, 0x80, 0x1F, 0xBE, 0x0F, 0xBF, 0x00, 0x3F, 0x7C, 0x1F, 0x7E, 0x00,
  0x7F, 0xF0, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0x80,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x7F,
  0xDF, 0xC0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x3F,
  0xE3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0x9F, 0xC0,
  0x01, 0xFF, 0x3F, 0xC0, 0x07, 0xFC, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x0F,
  0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF1, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xC7, 0xC0,
  0x00, 0x3E, 0x03, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF0, 0x08,
  0x00, 0x38, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC,
  0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xF8, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xC3, 0xFE, 0x07, 0xFE, 0x01, 0xFC, 0x0F, 0xF8, 0x03, 0xFC,
  0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8,
  0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8,
  0x7F, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xCF, 0xF0, 0x07, 0xFF, 0x07, 0xE0,
  0x00, 0xF8, 0x04, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0x83, 0xFC, 0x00,
  0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x03,
  0xF8, 0x7F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE,
  0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xFE, 0x3F,
  0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x01, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xF8, 0x7E, 0x07, 0xFF, 0x00, 0x08, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x01, 0x01, 0xFF, 0xC0, 0x1E, 0x03, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x5F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFC, 0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F,
  0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xCF, 0xF0, 0x00, 0x7F, 0xF8,
  0x7E, 0x00, 0x00, 0xF8, 0x04, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xC3, 0xFE, 0x00,
  0xFF, 0x1F, 0xE0, 0x01, 0xFC, 0xFF, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x1F,
  0xDF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFD, 0xFC, 0x00, 0x3F, 0xEF,
  0xF0, 0x07, 0xFF, 0x3F, 0x83, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x38,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF7, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x08, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xE0, 0x07, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x80,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x30, 0x00, 0x3F, 0xE0,
  0x03, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xDF, 0xFE, 0x01, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x01,
  0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01,
  0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x03,
  0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x07,
  0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F,
  0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x0F,
  0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xFC, 0x1C, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xC0,
  0x07, 0xF8, 0x00, 0x3E, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x03, 0xF8, 0x1F,
  0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x03, 0xFC,
  0x7F, 0xC0, 0x00, 0x7F, 0x1F, 0xF0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x03,
  0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x0F, 0xF1,
  0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07,
  0xF0, 0x3F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xC0,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0x8F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x1F, 0xFF, 0x3F,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x1F, 0xC3, 0xF8, 0x1F,
  0xC3, 0xF8, 0x7F, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xF8, 0x3F, 0x03, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0,
  0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xF0, 0x3F,
  0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF0,
  0x3F, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03,
  0xF0, 0x3F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x81, 0xFE, 0x01, 0xFF,
  0x03, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8,
  0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F,
  0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xE0,
  0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x03,
  0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFB, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x7F,
  0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x3F, 0xC0,
  0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0x7F, 0x7F, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xE1, 0xFE,
  0x00, 0xFF, 0x87, 0xFC, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xF0, 0x3F, 0xF0, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0xF8, 0x0F, 0xF0, 0x07, 0xFE, 0x01, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFB, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xE0,
  0xFF, 0x07, 0xFE, 0x01, 0xFE, 0x1F, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x07,
  0xF0, 0xFF, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8,
  0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x87,
  0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x3F,
  0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x00, 0x01, 0xC1, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x0C, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x3E,
  0x00, 0xFF, 0x00, 0x04, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x30, 0x00,
  0x3F, 0xC0, 0x78, 0x00, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x02, 0x01,
  0xFF, 0x01, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8,
  0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x1F,
  0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xE0,
  0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03,
  0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F,
  0xC0, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFB, 0xF8,
  0x0F, 0xFF, 0xE7, 0xF0, 0x07, 0xFF, 0x0F, 0xF0, 0x01, 0xF0, 0x10, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xE3,
  0xF8, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F,
  0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x1F, 0xC0,
  0xFF, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x1F,
  0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x80,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x01, 0xF0, 0x1F, 0x83,
  0xF0, 0x1F, 0x03, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0x03,
  0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F,
  0xF8, 0x7E, 0x07, 0xE0, 0xFF, 0x87, 0xE0, 0x7E, 0x1F, 0xF8, 0xFC, 0x07,
  0xE1, 0xFF, 0x8F, 0xC0, 0x7E, 0x3E, 0xF8, 0xFC, 0x07, 0xE7, 0xEF, 0x9F,
  0x80, 0x7E, 0x7C, 0xF9, 0xF8, 0x07, 0xCF, 0xCF, 0x9F, 0x80, 0x7C, 0xF8,
  0xFB, 0xF0, 0x07, 0xDF, 0x8F, 0xBF, 0x00, 0xFD, 0xF0, 0xFB, 0xE0, 0x0F,
  0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x03,
  0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F,
  0xBF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFE,
  0x3F, 0xC0, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x07,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x03,
  0xFB, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x20, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x1C, 0x01, 0xFF, 0xC0, 0x0F, 0xC1, 0xFF, 0xF0,
  0x0F, 0xE1, 0xFF, 0xFE, 0x0F, 0xE1, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xFF, 0xF8, 0x7E, 0x03,
  0xFF, 0xF8, 0x7F, 0x00, 0x7F, 0xF8, 0x0F, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xC0, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 19, 44, 35, 9, -43 },
  { 106, 24, 19, 35, 11, -47 },
  { 163, 37, 43, 35, 0, -43 },
  { 362, 34, 55, 35, 1, -48 },
  { 596, 42, 45, 35, -2, -44 },
  { 833, 32, 45, 35, 1, -44 },
  { 1013, 11, 20, 35, 17, -47 },
  { 1041, 27, 61, 35, 7, -49 },
  { 1247, 27, 61, 35, 1, -49 },
  { 1453, 28, 27, 35, 6, -43 },
  { 1548, 31, 31, 35, 2, -34 },
  { 1669, 17, 21, 35, 4, -11 },
  { 1714, 20, 8, 35, 8, -22 },
  { 1734, 12, 12, 35, 9, -11 },
  { 1752, 40, 60, 35, -3, -49 },
  { 2052, 31, 45, 35, 3, -44 },
  { 2227, 28, 43, 35, 2, -43 },
  { 2378, 33, 44, 35, 1, -44 },
  { 2560, 33, 45, 35, 0, -44 },
  { 2746, 34, 43, 35, 0, -43 },
  { 2929, 36, 44, 35, 0, -43 },
  { 3127, 33, 44, 35, 3, -43 },
  { 3309, 33, 43, 35, 6, -43 },
  { 3487, 33, 45, 35, 2, -44 },
  { 3673, 33, 44, 35, 2, -44 },
  { 3855, 17, 33, 35, 9, -32 },
  { 3926, 22, 42, 35, 4, -32 },
  { 4042, 31, 29, 35, 3, -32 },
  { 4155, 33, 20, 35, 1, -28 },
  { 4238, 32, 29, 35, 1, -32 },
  { 4354, 26, 45, 35, 8, -44 },
  { 4501, 34, 53, 35, 2, -44 },
  { 4727, 33, 43, 35, -3, -43 },
  { 4905, 34, 44, 35, 0, -43 },
  { 5092, 33, 45, 35, 4, -44 },
  { 5278, 34, 44, 35, 0, -43 },
  { 5465, 36, 43, 35, 1, -43 },
  { 5659, 36, 43, 35, 2, -43 },
  { 5853, 34, 45, 35, 3, -44 },
  { 6045, 39, 43, 35, -1, -43 },
  { 6255, 36, 43, 35, 1, -43 },
  { 6449, 35, 44, 35, 1, -43 },
  { 6642, 39, 43, 35, 0, -43 },
  { 6852, 27, 43, 35, 1, -43 },
  { 6998, 39, 43, 35, -2, -43 },
  { 7208, 39, 43, 35, -1, -43 },
  { 7418, 33, 45, 35, 2, -44 },
  { 7604, 36, 43, 35, 0, -43 },
  { 7798, 33, 56, 35, 2, -44 },
  { 8029, 34, 43, 35, 0, -43 },
  { 8212, 35, 45, 35, 0, -44 },
  { 8409, 32, 43, 35, 7, -43 },
  { 8581, 35, 44, 35, 2, -43 },
  { 8774, 33, 43, 35, 7, -43 },
  { 8952, 39, 43, 35, 1, -43 },
  { 9162, 42, 43, 35, -2, -43 },
  { 9388, 33, 43, 35, 7, -43 },
  { 9566, 38, 43, 35, -1, -43 },
  { 9771, 33, 60, 35, 4, -49 },
  { 10019, 13, 60, 35, 12, -49 },
  { 10117, 33, 60, 35, -1, -49 },
  { 10365, 31, 25, 35, 3, -43 },
  { 10462, 33, 6, 35, -5, 5 },
  { 10487, 15, 13, 35, 14, -48 },
  { 10512, 32, 34, 35, 2, -33 },
  { 10648, 31, 49, 35, 1, -48 },
  { 10838, 31, 34, 35, 3, -33 },
  { 10970, 36, 49, 35, 2, -48 },
  { 11191, 30, 34, 35, 3, -33 },
  { 11319, 43, 60, 35, -4, -48 },
  { 11642, 36, 45, 35, -2, -33 },
  { 11845, 32, 48, 35, 0, -48 },
  { 12037, 23, 49, 35, 6, -48 },
  { 12178, 34, 60, 35, -2, -48 },
  { 12433, 35, 48, 35, 1, -48 },
  { 12643, 21, 49, 35, 8, -48 },
  { 12772, 35, 33, 35, -1, -33 },
  { 12917, 31, 33, 35, 1, -33 },
  { 13045, 30, 34, 35, 2, -33 },
  { 13173, 35, 44, 35, -2, -33 },
  { 13366, 31, 44, 35, 3, -33 },
  { 13537, 31, 33, 35, 3, -33 },
  { 13665, 31, 34, 35, 1, -33 },
  { 13797, 28, 43, 35, 6, -42 },
  { 13948, 31, 33, 35, 3, -32 },
  { 14076, 31, 32, 35, 5, -32 },
  { 14200, 36, 32, 35, 2, -32 },
  { 14344, 37, 32, 35, -2, -32 },
  { 14492, 40, 44, 35, -5, -32 },
  { 14712, 33, 32, 35, 1, -32 },
  { 14844, 33, 60, 35, 4, -49 },
  { 15092, 22, 60, 35, 7, -49 },
  { 15257, 33, 60, 35, -2, -49 },
  { 15505, 33, 12, 35, 1, -24 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic62pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic62pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic62pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC62PT7B_H_
