#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC7PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x54, 0x80, 0xB4, 0x3F, 0x6F, 0xC0, 0x34, 0x62, 0xE4, 0x5D, 0x27,
  0xB0, 0x66, 0x5A, 0xE0, 0xC0, 0x2A, 0x49, 0x20, 0x64, 0x92, 0xB0, 0x5F,
  0x80, 0x2B, 0x44, 0x70, 0xC0, 0x80, 0x12, 0x24, 0x48, 0x75, 0xB9, 0xE0,
  0x2C, 0x9E, 0x71, 0x24, 0xE0, 0x71, 0x62, 0xE0, 0x13, 0x6F, 0x20, 0x74,
  0x62, 0xE0, 0x34, 0xE9, 0x60, 0xE5, 0x48, 0x75, 0x69, 0xE0, 0x75, 0x72,
  0xC0, 0x48, 0x21, 0x60, 0x16, 0xC2, 0xFE, 0x43, 0x68, 0xE5, 0x48, 0x75,
  0xFD, 0xA6, 0x2D, 0xFA, 0x75, 0x69, 0xE0, 0x34, 0x88, 0x60, 0x65, 0x99,
  0xE0, 0x74, 0x68, 0xE0, 0x74, 0x78, 0x80, 0x34, 0x89, 0x60, 0x55, 0x79,
  0xA0, 0x72, 0x24, 0xE0, 0x71, 0x12, 0xE0, 0x56, 0x4A, 0xA0, 0x49, 0x4E,
  0x55, 0xB9, 0xA0, 0x55, 0xBA, 0xA0, 0x75, 0x99, 0xE0, 0x75, 0x78, 0x80,
  0x75, 0x99, 0xE6, 0x75, 0x6A, 0xA0, 0x74, 0x62, 0xE0, 0xE9, 0x48, 0x55,
  0x9A, 0xE0, 0xBA, 0xCC, 0x80, 0x55, 0xBF, 0xA0, 0x55, 0x26, 0xA0, 0xBA,
  0xC8, 0x80, 0x72, 0x24, 0xE0, 0x34, 0x44, 0x4E, 0xA5, 0x50, 0x72, 0x22,
  0x4C, 0x25, 0x90, 0xF0, 0x80, 0x79, 0xAE, 0x46, 0x59, 0xE0, 0x34, 0x86,
  0x17, 0x9A, 0xE0, 0x69, 0xE6, 0x37, 0x44, 0x4C, 0x35, 0xA6, 0xE0, 0x46,
  0x5A, 0xA0, 0x7A, 0xC0, 0x36, 0x22, 0x2C, 0x45, 0x6A, 0xA0, 0xDA, 0xC0,
  0x7B, 0xDA, 0x65, 0xAA, 0x69, 0x9E, 0x65, 0x9E, 0x80, 0x35, 0xAE, 0x20,
  0x74, 0x48, 0x74, 0x2E, 0x5E, 0x4C, 0x55, 0xAE, 0xB7, 0x40, 0x9B, 0xEA,
  0x56, 0x6A, 0x29, 0x4C, 0x4E, 0x00, 0x72, 0x4E, 0x32, 0x4C, 0x46, 0x56,
  0xA0, 0x62, 0x32, 0x4C, 0x5A,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 3, 2, 4, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 6, 4, 0, -5 },
  { 10, 4, 5, 4, 0, -5 },
  { 13, 4, 5, 4, 0, -5 },
  { 16, 1, 2, 4, 2, -5 },
  { 17, 3, 7, 4, 1, -6 },
  { 20, 3, 7, 4, 0, -6 },
  { 23, 3, 3, 4, 1, -5 },
  { 25, 4, 4, 4, 0, -4 },
  { 27, 2, 2, 4, 0, -1 },
  { 28, 2, 1, 4, 1, -3 },
  { 29, 1, 1, 4, 1, -1 },
  { 30, 4, 6, 4, 0, -5 },
  { 33, 4, 5, 4, 0, -5 },
  { 36, 3, 5, 4, 0, -5 },
  { 38, 4, 5, 4, 0, -5 },
  { 41, 4, 5, 4, 0, -5 },
  { 44, 4, 5, 4, 0, -5 },
  { 47, 4, 5, 4, 0, -5 },
  { 50, 4, 5, 4, 0, -5 },
  { 53, 3, 5, 4, 1, -5 },
  { 55, 4, 5, 4, 0, -5 },
  { 58, 4, 5, 4, 0, -5 },
  { 61, 2, 3, 4, 1, -3 },
  { 62, 3, 4, 4, 0, -3 },
  { 64, 4, 4, 4, 0, -4 },
  { 66, 4, 2, 4, 0, -3 },
  { 67, 4, 4, 4, 0, -4 },
  { 69, 3, 5, 4, 1, -5 },
  { 71, 4, 6, 4, 0, -5 },
  { 74, 3, 5, 4, 0, -5 },
  { 76, 4, 5, 4, 0, -5 },
  { 79, 4, 5, 4, 0, -5 },
  { 82, 4, 5, 4, 0, -5 },
  { 85, 4, 5, 4, 0, -5 },
  { 88, 4, 5, 4, 0, -5 },
  { 91, 4, 5, 4, 0, -5 },
  { 94, 4, 5, 4, 0, -5 },
  { 97, 4, 5, 4, 0, -5 },
  { 100, 4, 5, 4, 0, -5 },
  { 103, 4, 5, 4, 0, -5 },
  { 106, 3, 5, 4, 0, -5 },
  { 108, 4, 5, 4, 0, -5 },
  { 111, 4, 5, 4, 0, -5 },
  { 114, 4, 5, 4, 0, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 4, 6, 4, 0, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 4, 5, 4, 0, -5 },
  { 129, 3, 5, 4, 1, -5 },
  { 131, 4, 5, 4, 0, -5 },
  { 134, 4, 5, 4, 1, -5 },
  { 137, 4, 5, 4, 0, -5 },
  { 140, 4, 5, 4, 0, -5 },
  { 143, 4, 5, 4, 1, -5 },
  { 146, 4, 5, 4, 0, -5 },
  { 149, 4, 6, 4, 0, -5 },
  { 152, 2, 6, 4, 1, -5 },
  { 154, 4, 6, 4, 0, -5 },
  { 157, 4, 3, 4, 0, -5 },
  { 159, 4, 1, 4, -1, 0 },
  { 160, 1, 1, 4, 2, -5 },
  { 161, 4, 4, 4, 0, -4 },
  { 163, 4, 5, 4, 0, -5 },
  { 166, 4, 4, 4, 0, -4 },
  { 168, 4, 5, 4, 0, -5 },
  { 171, 4, 4, 4, 0, -4 },
  { 173, 4, 6, 4, 0, -5 },
  { 176, 4, 5, 4, 0, -4 },
  { 179, 4, 5, 4, 0, -5 },
  { 182, 2, 5, 4, 1, -5 },
  { 184, 4, 6, 4, 0, -5 },
  { 187, 4, 5, 4, 0, -5 },
  { 190, 2, 5, 4, 1, -5 },
  { 192, 4, 4, 4, 0, -4 },
  { 194, 4, 4, 4, 0, -4 },
  { 196, 4, 4, 4, 0, -4 },
  { 198, 4, 5, 4, 0, -4 },
  { 201, 4, 5, 4, 0, -4 },
  { 204, 4, 4, 4, 0, -4 },
  { 206, 4, 4, 4, 0, -4 },
  { 208, 3, 5, 4, 1, -5 },
  { 210, 4, 4, 4, 0, -4 },
  { 212, 3, 4, 4, 1, -4 },
  { 214, 4, 4, 4, 0, -4 },
  { 216, 4, 4, 4, 0, -4 },
  { 218, 5, 5, 4, -1, -4 },
  { 222, 4, 4, 4, 0, -4 },
  { 224, 4, 6, 4, 0, -5 },
  { 227, 2, 6, 4, 1, -5 },
  { 229, 4, 6, 4, 0, -5 },
  { 232, 4, 2, 4, 0, -3 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic7pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic7pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic7pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC7PT7B_H_
