#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC37PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xE0, 0x7E, 0x0F,
  0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x7D, 0xF1, 0xE7, 0x8F, 0x9E, 0x3E, 0xF8,
  0xFB, 0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xE0, 0xE3, 0x83, 0x8E, 0x0C, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0x87, 0x80, 0x1E, 0x1E, 0x00,
  0x78, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0E, 0x07, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0xF1, 0xE0, 0x07, 0x87, 0x80,
  0x1E, 0x1C, 0x00, 0x70, 0xF0, 0x03, 0xC3, 0xC0, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x3C, 0x3C, 0x00, 0xF1, 0xE0,
  0x07, 0x87, 0x80, 0x1E, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC7, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3F,
  0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xC0, 0xC0, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x84, 0x00, 0xF8,
  0x78, 0x3F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x07, 0x81, 0xF8, 0x07, 0x81, 0xFE, 0x07, 0x81, 0xE7, 0x03, 0x80,
  0xE3, 0x83, 0x80, 0x71, 0xC3, 0x80, 0x70, 0xE3, 0xC0, 0x38, 0xE3, 0xC0,
  0x1C, 0x73, 0xC0, 0x0F, 0x7B, 0xC0, 0x03, 0xF9, 0xC0, 0x01, 0xF9, 0xC0,
  0x00, 0x31, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE7, 0xC0, 0x01, 0xE7,
  0xE0, 0x00, 0xE7, 0xF8, 0x00, 0xE7, 0x9C, 0x00, 0xE3, 0x8E, 0x00, 0xF1,
  0xC7, 0x00, 0xF1, 0xC3, 0x80, 0xF0, 0xE3, 0x80, 0x70, 0x71, 0xC0, 0x70,
  0x3D, 0xE0, 0x70, 0x0F, 0xE0, 0x78, 0x07, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3E, 0x3C, 0x03, 0xC3,
  0xC0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0xE0, 0xFF, 0x0F, 0x1F,
  0xF1, 0xE3, 0xE7, 0x9E, 0x3C, 0x7D, 0xC7, 0x83, 0xFC, 0x78, 0x3F, 0x8F,
  0x81, 0xF8, 0xF8, 0x0F, 0x0F, 0x81, 0xF8, 0x7C, 0x7F, 0x87, 0xFF, 0xF8,
  0x3F, 0xF7, 0xC1, 0xFC, 0x3C, 0x3E, 0x7D, 0xF3, 0xE7, 0xCF, 0x1E, 0x3C,
  0x71, 0xE3, 0xC7, 0x00, 0x00, 0x06, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x04,
  0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x63, 0xC6,
  0x79, 0xDF, 0xFD, 0xBF, 0xFF, 0xFF, 0x3F, 0xFE, 0x03, 0xE0, 0x0F, 0xF0,
  0x1F, 0x78, 0x3E, 0x7C, 0x3E, 0x7E, 0x1C, 0x38, 0x0C, 0x30, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x02, 0x0F, 0xC7, 0xE7, 0xF3, 0xF8, 0xFC,
  0x7E, 0x0F, 0x0F, 0x1F, 0x3F, 0x1F, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x08, 0xFD, 0xFF, 0xFF, 0xEF, 0xDF, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xF8, 0x7C, 0x3E, 0x07,
  0x8F, 0x80, 0xF1, 0xE0, 0x1F, 0x7C, 0x03, 0xCF, 0x80, 0x79, 0xE3, 0x8F,
  0x3C, 0xF1, 0xEF, 0x9F, 0x3D, 0xE3, 0xCF, 0xBC, 0x79, 0xF7, 0x80, 0x3C,
  0xF0, 0x07, 0x9E, 0x01, 0xF3, 0xC0, 0x3C, 0x78, 0x0F, 0x8F, 0x03, 0xE1,
  0xF0, 0x7C, 0x3F, 0x3F, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x0F, 0xC0, 0x1F, 0xE0,
  0x3F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0x7C, 0x0E, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x81, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0x81, 0xF0,
  0x30, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC4, 0x00, 0xF8, 0x78,
  0x3F, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xF7, 0x80, 0x1F, 0x3C, 0x00, 0xF3, 0xE0,
  0x0F, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x07, 0x80, 0xF0, 0x7C, 0x0F, 0x03,
  0xC0, 0xF8, 0x1E, 0x07, 0x80, 0xF0, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x10, 0x07, 0xC1, 0xF1, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x01, 0xE0, 0x03,
  0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF7, 0xF0, 0x3F, 0xFF,
  0x07, 0xFF, 0xF1, 0xFF, 0xFF, 0x3E, 0x03, 0xE7, 0xC0, 0x3C, 0xF0, 0x07,
  0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3E,
  0x1F, 0x9F, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x04, 0x00,
  0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x0F,
  0x01, 0xE0, 0xF8, 0x3E, 0x07, 0xC7, 0xC0, 0x7F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0xE0, 0x1F, 0x3F, 0x03, 0xE1, 0xF8, 0x7C, 0x0F, 0x87, 0x80, 0x78,
  0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x80, 0xF8, 0x7C, 0x3F,
  0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x83, 0xE1,
  0xF0, 0x1E, 0x1E, 0x01, 0xE3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F,
  0x3E, 0x01, 0xE3, 0xE0, 0x1E, 0x1F, 0x8F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x7F, 0xBC, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xC0, 0x0F, 0xE0, 0x00, 0x01, 0x01, 0xF0, 0xFC, 0x7F, 0x1F, 0xC3, 0xF0,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x07, 0xE1, 0xF8,
  0xFE, 0x3F, 0x87, 0xE1, 0xF0, 0x00, 0x40, 0x1F, 0x03, 0xF0, 0x7F, 0x07,
  0xF0, 0x3F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xF8, 0x07,
  0x80, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x01,
  0xF0, 0x01, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x03,
  0xFC, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x04, 0x00, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x0C, 0x00, 0x07, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0,
  0x0F, 0xE0, 0x03, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xF8,
  0xFF, 0xF9, 0xFF, 0xF3, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xC3, 0xE0, 0x78, 0x0F, 0x07, 0x80,
  0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x3C, 0x1F, 0xF1, 0xE1, 0xFF, 0x9E,
  0x1F, 0xFC, 0xF1, 0xFB, 0xE7, 0x1F, 0x1F, 0x38, 0xF0, 0xF3, 0xC7, 0x87,
  0x9E, 0x78, 0x3C, 0xF3, 0xC1, 0xE7, 0x9E, 0x1E, 0x3C, 0xF0, 0xF1, 0xE7,
  0x87, 0x8F, 0x3E, 0x3C, 0x78, 0xFF, 0xC3, 0xC7, 0xFE, 0x1E, 0x0F, 0xF0,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x3D, 0xE0, 0x07, 0xDE, 0x00, 0x79, 0xE0, 0x0F, 0x1E, 0x00, 0xF1,
  0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C,
  0x0F, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1E,
  0x00, 0xF3, 0xE0, 0x0F, 0x3C, 0x01, 0xF7, 0xC0, 0x1F, 0x78, 0x01, 0xFF,
  0x80, 0x1F, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7C, 0x1F, 0x03, 0xC0, 0x7C, 0x1E, 0x03, 0xC1, 0xF0, 0x1E, 0x0F,
  0x80, 0xF0, 0x7C, 0x0F, 0x83, 0xC3, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0,
  0x0F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x07, 0xE1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xC0, 0x60,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x20, 0x7F, 0xBE, 0x03, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0x87, 0xE0, 0x78, 0x1F, 0x0F, 0x81,
  0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0xF1, 0xF0,
  0x0F, 0x1F, 0x01, 0xF1, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1E, 0x3E,
  0x03, 0xE3, 0xC0, 0x3E, 0x3C, 0x07, 0xC7, 0xC0, 0xFC, 0x7C, 0x1F, 0x87,
  0x83, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xC0, 0x61, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0xF8, 0x07, 0x8F, 0x00,
  0xF8, 0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x0F, 0xC1, 0xF0, 0x7F, 0x7E, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01,
  0xFF, 0xC0, 0x01, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0x78, 0x1F,
  0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x78, 0x07, 0xC0, 0xF0, 0x0F, 0x03, 0xE0,
  0x1E, 0x07, 0xC0, 0x7C, 0x0F, 0x00, 0xF8, 0x1E, 0x01, 0xE0, 0x7C, 0x03,
  0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x78, 0x07, 0x81, 0xF0, 0x0F, 0x03,
  0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x00, 0xF8, 0x3E, 0x01, 0xE0, 0x7C,
  0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xE0, 0x1F, 0x00, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x20, 0x0F, 0x00, 0xC0, 0x7C, 0x07, 0xEF, 0xF0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x03,
  0xE0, 0x3E, 0x07, 0x80, 0xF8, 0x0F, 0x03, 0xE0, 0x3E, 0x0F, 0xC0, 0x7C,
  0x1F, 0x00, 0xF0, 0x7C, 0x01, 0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x9F,
  0x00, 0x1E, 0x7C, 0x00, 0x3D, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xBE, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F,
  0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0xF8, 0x07, 0xC1, 0xF0,
  0x0F, 0x80, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x80, 0x01, 0xE0,
  0x1E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07,
  0xE0, 0x7E, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF8, 0xEE, 0x07, 0x71, 0xFC,
  0x1E, 0xE7, 0x78, 0x3D, 0xDE, 0xF0, 0x7B, 0xB9, 0xC0, 0xE3, 0xE7, 0x83,
  0xC7, 0xCF, 0x07, 0x8F, 0x1E, 0x0F, 0x1E, 0x3C, 0x3C, 0x38, 0xF0, 0x78,
  0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x87, 0x80, 0x1F, 0x0F, 0x00,
  0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xE1, 0xE0, 0x07,
  0xC0, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0x78, 0x1F, 0x80, 0xF0, 0x3F, 0x01,
  0xE0, 0x7E, 0x03, 0xC0, 0xFC, 0x0F, 0x03, 0xFC, 0x1E, 0x07, 0xB8, 0x3C,
  0x0F, 0x70, 0x78, 0x1E, 0xF1, 0xE0, 0x7D, 0xE3, 0xC0, 0xF1, 0xC7, 0x81,
  0xE3, 0x8F, 0x03, 0xC7, 0x3C, 0x0F, 0x8F, 0x78, 0x1E, 0x0E, 0xF0, 0x3C,
  0x1D, 0xE0, 0x78, 0x3F, 0xC1, 0xF0, 0x7F, 0x03, 0xC0, 0xFE, 0x07, 0x80,
  0xFC, 0x0F, 0x01, 0xF8, 0x1E, 0x03, 0xE0, 0x78, 0x07, 0xC0, 0xF0, 0x0F,
  0x81, 0xE0, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC0,
  0x7F, 0xFE, 0x0F, 0xC3, 0xE0, 0xF8, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F,
  0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01,
  0xE7, 0x80, 0x1E, 0x78, 0x03, 0xE7, 0x80, 0x3E, 0xF8, 0x03, 0xCF, 0x80,
  0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0x78, 0x0F, 0x87, 0xC1, 0xF0, 0x7F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x01, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7C,
  0x1F, 0x83, 0xE0, 0x7C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x80, 0x78,
  0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1E, 0x03, 0xE1, 0xF0, 0x7F, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xC3, 0xE0, 0xF8, 0x1F,
  0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3C, 0x01,
  0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x03, 0xE7, 0x80,
  0x3E, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0x78,
  0x0F, 0x87, 0xC1, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0xFF, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xA0,
  0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x18, 0x00, 0x01, 0xFF, 0x00, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xC1, 0xF0, 0x78, 0x0F, 0x07,
  0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xF1,
  0xF0, 0x3E, 0x1F, 0x3F, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0,
  0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xF0, 0x7C, 0x0F,
  0x07, 0xC0, 0xF8, 0x78, 0x0F, 0x87, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x80,
  0x7C, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x7C, 0x02, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x10, 0x07, 0xC1, 0xF9,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x70, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x78, 0x7C, 0x03, 0xC3, 0xE0, 0x3E, 0x1F, 0x01,
  0xF0, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1E,
  0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xC0, 0x3C,
  0x1E, 0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x78, 0x07, 0xC3, 0xC0,
  0x3C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF0, 0x3E, 0x0F, 0x81,
  0xFD, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x40,
  0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8,
  0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x87, 0xC0,
  0x78, 0x78, 0x07, 0x8F, 0x80, 0x78, 0xF0, 0x07, 0x9F, 0x00, 0x79, 0xE0,
  0x07, 0xBC, 0x00, 0x7B, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1E,
  0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C,
  0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78,
  0x1E, 0x3C, 0x78, 0x1E, 0x7C, 0x70, 0x3C, 0x7C, 0xF0, 0x3C, 0xFC, 0xF0,
  0x3C, 0xFC, 0xF0, 0x3D, 0xDC, 0xE0, 0x39, 0xDD, 0xE0, 0x3B, 0x9D, 0xE0,
  0x7F, 0x9D, 0xC0, 0x7F, 0x1D, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x0F, 0x80,
  0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF8, 0x0F, 0x00,
  0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x3E, 0x07,
  0x80, 0x0F, 0x07, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xE7, 0xC0, 0x00, 0xF3,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xF3, 0xC0, 0x01, 0xF1, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x1E, 0x00, 0xFC, 0x0F, 0x00,
  0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x01,
  0xF7, 0x80, 0x3E, 0x78, 0x03, 0xE7, 0x80, 0x7C, 0x78, 0x07, 0xC7, 0xC0,
  0xF8, 0x7C, 0x1F, 0x03, 0xC1, 0xE0, 0x3C, 0x3E, 0x03, 0xC7, 0xC0, 0x3E,
  0x78, 0x01, 0xEF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xF8, 0xF8, 0xF8,
  0xF8, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7C, 0xF0, 0x3F, 0x3E, 0x0F, 0x8F, 0x87,
  0xC1, 0xE3, 0xE0, 0x7D, 0xF0, 0x1F, 0xF8, 0x03, 0xDE, 0x00, 0xF1, 0x00,
  0x30, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x20,
  0x60, 0xF8, 0xFC, 0x7E, 0x3F, 0x0E, 0x06, 0x00, 0x3F, 0x00, 0x3F, 0xFC,
  0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFC, 0x3C, 0x7E, 0x0F, 0x8F, 0x81, 0xF3,
  0xE0, 0x3E, 0x7C, 0x07, 0x8F, 0x00, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF,
  0x80, 0xF1, 0xF0, 0x1E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0x7E, 0xFF, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xE7, 0xC0, 0x00, 0x30, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFB, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x1F, 0x8F, 0xC3, 0xC0, 0xF8, 0xF8, 0x0F, 0x1F, 0x01, 0xE3,
  0xE0, 0x3C, 0x78, 0x07, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0x8F,
  0x01, 0xF1, 0xE0, 0x7E, 0x7C, 0x1F, 0x8F, 0xDF, 0xE1, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0F, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xF0,
  0x7F, 0xFC, 0x7F, 0xFE, 0x3F, 0xC1, 0x8F, 0xC0, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x08, 0xFF, 0xFE, 0x1F, 0xFF, 0x83,
  0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0x0F, 0x01, 0xF0, 0x3C, 0x0F, 0x81, 0xF0,
  0x7C, 0x07, 0xC1, 0xF0, 0x1E, 0x07, 0x80, 0x78, 0x3E, 0x03, 0xE0, 0xF8,
  0x0F, 0x83, 0xE0, 0x3C, 0x0F, 0x80, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x1F,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xC7, 0x80,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0x07, 0xDF,
  0x01, 0xF7, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xBC, 0xFF, 0xCF, 0xFF,
  0xE3, 0xFF, 0xE0, 0xFF, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0xFF, 0x1E, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFE,
  0x30, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x8F, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF,
  0xFE, 0x07, 0xF0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xC0, 0x7C,
  0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xE0, 0x1E, 0x07, 0x80, 0xF8, 0x1E,
  0x03, 0xE0, 0x78, 0x0F, 0x81, 0xF0, 0x7C, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x06, 0x03, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0x0F, 0xC3, 0xC0, 0xF8, 0x78, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C,
  0x78, 0x0F, 0x0F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x01, 0xE1,
  0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xE0, 0x3C, 0x3C, 0x07, 0x8F,
  0x81, 0xF0, 0x00, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0xFE, 0x01, 0xF0, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE2, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0xF0,
  0xFF, 0xC1, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x06, 0x0F,
  0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00,
  0x20, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x43, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x7C, 0x07, 0x8F, 0xC0,
  0x7C, 0xFC, 0x03, 0xEF, 0xC0, 0x1E, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x03, 0xDF, 0x80, 0x1E, 0x7C, 0x01, 0xF1, 0xF0, 0x0F,
  0x8F, 0x80, 0x7C, 0x3E, 0x03, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E,
  0x0F, 0x80, 0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0xFF, 0xCF, 0xFC, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xFF, 0x7F, 0xF3, 0xFF, 0x1F, 0xE0,
  0x00, 0xE0, 0x60, 0x3F, 0xDF, 0x81, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xF1,
  0xE7, 0x87, 0x8E, 0x3C, 0x38, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE7, 0x87, 0x8E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x00,
  0xF0, 0xF0, 0x07, 0x87, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0E, 0x1E,
  0x00, 0xF1, 0xE0, 0x07, 0x80, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x7F, 0xFF, 0x1F, 0x0F, 0xC7, 0xC1, 0xF1, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E,
  0x07, 0xCF, 0x81, 0xF3, 0xC0, 0x78, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03,
  0xE7, 0x80, 0xF1, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x01, 0xE3,
  0xC0, 0xF8, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F,
  0x8F, 0xCF, 0xC1, 0xF3, 0xE0, 0x3D, 0xF0, 0x0F, 0x7C, 0x03, 0xDE, 0x00,
  0xF7, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xEF, 0x80, 0xF9,
  0xF0, 0x7C, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xC0, 0x01,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x07, 0xC1, 0xF0, 0x78, 0x1F, 0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x80,
  0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xE1, 0xE0,
  0x3E, 0x1E, 0x07, 0xE3, 0xE0, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F,
  0xFE, 0x07, 0xFF, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x7F, 0xFF, 0x3F, 0x87, 0xCF, 0x81, 0xE7,
  0xC0, 0x79, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x00, 0xF3, 0xC0,
  0x7C, 0xF0, 0x1F, 0x3C, 0x07, 0xCF, 0x01, 0xE3, 0xE0, 0xF8, 0xFF, 0xFE,
  0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00,
  0x7F, 0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xF7, 0x87, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0xFF,
  0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0x81, 0x83, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF1, 0x00, 0x7C, 0x78, 0xFF, 0x3F, 0xFF,
  0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x01, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0xFF, 0xFE, 0xFF,
  0xFF, 0x7F, 0xFF, 0xC7, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x21, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F,
  0xFC, 0x00, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x78, 0xF0, 0x1E, 0x7C,
  0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF1, 0xE0, 0x3C, 0xF8, 0x1F, 0x3E, 0x07,
  0xCF, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x3E, 0x3C, 0x0F, 0x8F, 0x87, 0xE3,
  0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xF9, 0xF0, 0xF8, 0x07, 0xFE,
  0x01, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x1F, 0x1E, 0x07, 0xC7, 0x83,
  0xE1, 0xE0, 0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xCF, 0x81, 0xF3, 0xC0,
  0x3D, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xDE, 0x00, 0x3C,
  0xF0, 0x01, 0xE7, 0x87, 0x0F, 0x3C, 0x78, 0x71, 0xE3, 0xC7, 0x8F, 0x3E,
  0x3C, 0x71, 0xF9, 0xC3, 0x9D, 0xDE, 0x1C, 0xEE, 0xF0, 0xEE, 0x77, 0x07,
  0x73, 0xF8, 0x7F, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3E,
  0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x00, 0x0F, 0xC0, 0x7C, 0x1F, 0x03, 0xE0,
  0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x01, 0xE7, 0xC0, 0x07, 0xDE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0x3C, 0x00, 0xF8, 0xF8, 0x07,
  0xC3, 0xE0, 0x3E, 0x07, 0xC1, 0xF0, 0x1F, 0x0F, 0xC0, 0x3E, 0x00, 0x03,
  0xE0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x3E, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF1, 0xE0, 0x00, 0xF3, 0xE0, 0x00,
  0xFB, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x41, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x02, 0x00,
  0x03, 0xF8, 0x1C, 0xFF, 0x87, 0xBF, 0xFF, 0xE7, 0xFF, 0xFD, 0xE1, 0xFF,
  0x3C, 0x1F, 0xC1, 0x00, 0xE0,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 12, 26, 21, 5, -26 },
  { 40, 14, 11, 21, 7, -28 },
  { 60, 22, 26, 21, 0, -26 },
  { 132, 20, 33, 21, 1, -29 },
  { 215, 25, 27, 21, -1, -26 },
  { 300, 20, 26, 21, 0, -26 },
  { 365, 7, 12, 21, 10, -28 },
  { 376, 17, 36, 21, 4, -29 },
  { 453, 17, 36, 21, 0, -29 },
  { 530, 16, 16, 21, 4, -26 },
  { 562, 19, 18, 21, 1, -20 },
  { 605, 9, 13, 21, 3, -7 },
  { 620, 11, 5, 21, 5, -13 },
  { 627, 7, 7, 21, 5, -7 },
  { 634, 24, 36, 21, -2, -29 },
  { 742, 19, 27, 21, 2, -26 },
  { 807, 17, 26, 21, 1, -26 },
  { 863, 20, 26, 21, 0, -26 },
  { 928, 20, 27, 21, 0, -26 },
  { 996, 21, 26, 21, 0, -26 },
  { 1065, 21, 27, 21, 0, -26 },
  { 1136, 19, 27, 21, 2, -26 },
  { 1201, 19, 26, 21, 4, -26 },
  { 1263, 20, 27, 21, 1, -26 },
  { 1331, 20, 26, 21, 1, -26 },
  { 1396, 10, 20, 21, 5, -20 },
  { 1421, 12, 26, 21, 3, -20 },
  { 1460, 18, 17, 21, 2, -19 },
  { 1499, 20, 12, 21, 1, -17 },
  { 1529, 18, 17, 21, 1, -19 },
  { 1568, 15, 26, 21, 5, -26 },
  { 1617, 21, 32, 21, 1, -26 },
  { 1701, 20, 26, 21, -2, -26 },
  { 1766, 21, 26, 21, 0, -26 },
  { 1835, 20, 27, 21, 2, -26 },
  { 1903, 20, 26, 21, 0, -26 },
  { 1968, 21, 26, 21, 1, -26 },
  { 2037, 22, 26, 21, 1, -26 },
  { 2109, 20, 27, 21, 2, -26 },
  { 2177, 23, 26, 21, 0, -26 },
  { 2252, 22, 26, 21, 0, -26 },
  { 2324, 22, 27, 21, 0, -26 },
  { 2399, 23, 26, 21, 0, -26 },
  { 2474, 17, 26, 21, 0, -26 },
  { 2530, 23, 26, 21, -1, -26 },
  { 2605, 23, 26, 21, 0, -26 },
  { 2680, 20, 27, 21, 1, -26 },
  { 2748, 21, 26, 21, 0, -26 },
  { 2817, 20, 33, 21, 1, -26 },
  { 2900, 20, 26, 21, 0, -26 },
  { 2965, 21, 27, 21, 0, -26 },
  { 3036, 19, 26, 21, 4, -26 },
  { 3098, 21, 27, 21, 1, -26 },
  { 3169, 20, 26, 21, 4, -26 },
  { 3234, 24, 26, 21, 0, -26 },
  { 3312, 25, 26, 21, -1, -26 },
  { 3394, 20, 26, 21, 4, -26 },
  { 3459, 22, 26, 21, 0, -26 },
  { 3531, 20, 36, 21, 2, -29 },
  { 3621, 8, 36, 21, 7, -29 },
  { 3657, 20, 36, 21, -1, -29 },
  { 3747, 18, 15, 21, 2, -26 },
  { 3781, 20, 4, 21, -3, 3 },
  { 3791, 8, 8, 21, 9, -29 },
  { 3799, 19, 20, 21, 1, -20 },
  { 3847, 19, 30, 21, 0, -29 },
  { 3919, 18, 20, 21, 2, -20 },
  { 3964, 22, 29, 21, 1, -29 },
  { 4044, 18, 20, 21, 2, -20 },
  { 4089, 25, 36, 21, -2, -29 },
  { 4202, 22, 27, 21, -1, -20 },
  { 4277, 19, 29, 21, 0, -29 },
  { 4346, 14, 29, 21, 3, -29 },
  { 4397, 20, 36, 21, -1, -29 },
  { 4487, 21, 29, 21, 1, -29 },
  { 4564, 12, 29, 21, 5, -29 },
  { 4608, 21, 20, 21, -1, -20 },
  { 4661, 18, 20, 21, 1, -20 },
  { 4706, 18, 21, 21, 1, -20 },
  { 4754, 20, 27, 21, -1, -20 },
  { 4822, 18, 27, 21, 2, -20 },
  { 4883, 18, 20, 21, 2, -20 },
  { 4928, 18, 21, 21, 1, -20 },
  { 4976, 17, 25, 21, 3, -25 },
  { 5030, 18, 19, 21, 2, -19 },
  { 5073, 18, 19, 21, 3, -19 },
  { 5116, 21, 19, 21, 1, -19 },
  { 5166, 22, 19, 21, -1, -19 },
  { 5219, 24, 26, 21, -3, -19 },
  { 5297, 19, 19, 21, 1, -19 },
  { 5343, 20, 36, 21, 2, -29 },
  { 5433, 13, 36, 21, 4, -29 },
  { 5492, 19, 36, 21, -1, -29 },
  { 5578, 19, 8, 21, 1, -15 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic37pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic37pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic37pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC37PT7B_H_
