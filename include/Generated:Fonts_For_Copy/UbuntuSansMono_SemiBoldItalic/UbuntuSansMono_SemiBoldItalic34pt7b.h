#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC34PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F,
  0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x00, 0x00, 0x03,
  0x01, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x3C, 0x7B, 0xE3, 0xDE, 0x3E,
  0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xC3, 0x9E, 0x1C, 0xE1, 0xE7, 0x0E, 0x00,
  0x00, 0x38, 0x70, 0x07, 0x8F, 0x00, 0x70, 0xE0, 0x0F, 0x1E, 0x00, 0xE1,
  0xC0, 0x1E, 0x3C, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x0E, 0x00, 0xF1, 0xE0, 0x0E,
  0x1C, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x3C, 0x78, 0x03,
  0x87, 0x00, 0x78, 0xF0, 0x07, 0x0E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xF8, 0x03, 0xFF, 0x81,
  0xFF, 0xF0, 0xFF, 0xF8, 0x3C, 0x02, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0x7E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x18,
  0x0F, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF0, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x1E, 0x0F,
  0xE0, 0x38, 0x1F, 0xC0, 0xE0, 0x73, 0x83, 0x80, 0xC7, 0x0E, 0x03, 0x8E,
  0x3C, 0x07, 0x1C, 0xF0, 0x0E, 0x31, 0xC0, 0x1C, 0xE7, 0x00, 0x3F, 0x9C,
  0x00, 0x3F, 0x70, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0xF8,
  0x00, 0x3B, 0xF8, 0x00, 0xE7, 0x70, 0x03, 0x9C, 0x60, 0x0E, 0x38, 0xC0,
  0x3C, 0x63, 0x80, 0x70, 0xC7, 0x01, 0xC3, 0x8E, 0x07, 0x03, 0xB8, 0x1C,
  0x07, 0xF0, 0x70, 0x0F, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x0F, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x70, 0x70,
  0x1C, 0x3C, 0x07, 0x9E, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC4, 0x0F,
  0xE1, 0xC7, 0xF8, 0xF3, 0xCF, 0x39, 0xE1, 0xFE, 0x78, 0x7F, 0x1C, 0x0F,
  0xCF, 0x03, 0xE3, 0xC0, 0xF8, 0x78, 0x7F, 0x1F, 0xFF, 0xC7, 0xFE, 0xF0,
  0x7F, 0x1E, 0x3E, 0x78, 0xF3, 0xE7, 0x8F, 0x1E, 0x38, 0x70, 0xE3, 0x80,
  0x00, 0x04, 0x00, 0x38, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x01, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x71, 0xCE, 0x7D, 0x9E, 0x7F, 0xFE, 0xFF, 0xFF, 0x03, 0xC0, 0x07, 0xE0,
  0x0F, 0xF0, 0x1E, 0x78, 0x3E, 0x7C, 0x1C, 0x38, 0x04, 0x30, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x80, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xBF, 0xFF, 0xC0, 0x78, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x07, 0xC7, 0xE3, 0xF1, 0xF8, 0x7C, 0x1E, 0x1E, 0x3E, 0x7E, 0x1E, 0x08,
  0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0xFF, 0xE0, 0x39, 0xFF, 0xFF, 0xFD, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xC0,
  0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0x87, 0xC7, 0xC0, 0xF1, 0xE0, 0x3C, 0xF8,
  0x0F, 0x3C, 0x03, 0xCF, 0x18, 0xF7, 0x8E, 0x3D, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x80, 0x7B, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0xCF,
  0x81, 0xE1, 0xE0, 0xF8, 0x7C, 0x7C, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F,
  0x80, 0x02, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xE0,
  0x7F, 0xC3, 0xFF, 0x83, 0xFF, 0x07, 0x3E, 0x08, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x70,
  0x3E, 0x04, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0x00, 0xFE,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0x3F, 0x02, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x1F, 0xE0, 0x07,
  0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x70, 0x3F, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x3D, 0xE0,
  0x0F, 0x3C, 0x03, 0xC7, 0x80, 0x70, 0xF0, 0x1C, 0x3E, 0x07, 0x87, 0x81,
  0xE0, 0xF0, 0x78, 0x1E, 0x1E, 0x03, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0xFE, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x70, 0x7F, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x07, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x0F, 0xFE, 0x07, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1E, 0x3C, 0x07, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x3C, 0x07, 0x8F, 0x01, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0x8F,
  0x01, 0xE3, 0xC0, 0xF8, 0xF8, 0x7C, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F,
  0x80, 0x02, 0x00, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFD, 0xFF,
  0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0x3F, 0x0F, 0x03, 0xC3, 0xC0, 0xF1,
  0xE0, 0x3C, 0x78, 0x0F, 0x0F, 0x07, 0x83, 0xE3, 0xE0, 0x7F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x07, 0xDF, 0x83, 0xC3, 0xE1, 0xE0, 0x7C, 0x78, 0x0F,
  0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x7C, 0xF8, 0x3E, 0x1F, 0xFF, 0x87,
  0xFF, 0xC0, 0x7F, 0xC0, 0x01, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x80,
  0xFF, 0xF0, 0x7F, 0x7E, 0x1F, 0x07, 0x8F, 0x81, 0xF3, 0xC0, 0x3C, 0xF0,
  0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x7C, 0xFC, 0x3F, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x7E, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xF0,
  0x00, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x83, 0xE3, 0xF1, 0xF8, 0xFC, 0x3C, 0x00, 0x01, 0xE0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x80,
  0xF8, 0x07, 0x80, 0xF0, 0x3E, 0x0F, 0xC0, 0x78, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x03, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFF,
  0x01, 0xFC, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x30, 0x1F, 0xFF, 0xE3, 0xFF,
  0xF8, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF0, 0x10, 0x00, 0x0E, 0x00,
  0x0F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x7F, 0x81, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x07,
  0xF0, 0x03, 0xC0, 0x01, 0x80, 0x00, 0x0F, 0xE1, 0xFF, 0xC7, 0xFF, 0x8F,
  0x7F, 0x20, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xE1, 0xF0, 0xF0, 0x1E,
  0x3C, 0x03, 0xC7, 0x00, 0x79, 0xE0, 0xFF, 0x38, 0x7F, 0xEF, 0x1F, 0xF9,
  0xC7, 0xFF, 0x38, 0xF1, 0xEF, 0x3C, 0x3D, 0xE7, 0x87, 0x38, 0xE1, 0xE7,
  0x1C, 0x3C, 0xE3, 0x87, 0x9C, 0x70, 0xE3, 0x8F, 0x3C, 0x71, 0xFF, 0x8E,
  0x1F, 0xF1, 0xE1, 0xFC, 0x3C, 0x0E, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x77, 0x80,
  0x1E, 0xF0, 0x03, 0x9E, 0x00, 0xF3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x01,
  0xE1, 0xE0, 0x3C, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x78, 0x0F, 0x9F, 0x01, 0xF3, 0xC0, 0x3E, 0xF8,
  0x07, 0xDE, 0x00, 0xFF, 0xC0, 0x1F, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF0, 0x78, 0x3E, 0x1F, 0x03, 0xC3, 0xC0, 0x78, 0x78,
  0x0F, 0x0F, 0x03, 0xC3, 0xE1, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF,
  0xF0, 0x3C, 0x7F, 0x0F, 0x01, 0xE1, 0xE0, 0x3E, 0x3C, 0x07, 0xC7, 0x80,
  0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0xC7, 0x87, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFE,
  0x0F, 0x80, 0x87, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x10,
  0x7E, 0x3C, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xF8, 0x7C,
  0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1F, 0x1F, 0x03, 0xE3, 0xC0, 0x7C,
  0x78, 0x0F, 0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xF1,
  0xE0, 0x3E, 0x3C, 0x0F, 0x8F, 0x81, 0xF1, 0xE0, 0x7C, 0x3C, 0x1F, 0x07,
  0x9F, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFC, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x7F,
  0xFC, 0x3F, 0xFE, 0x1F, 0x80, 0x87, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x3C,
  0x07, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x03,
  0xC3, 0xE0, 0xF0, 0xFC, 0x3C, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x03, 0x00, 0x00, 0x07, 0xC0, 0x78, 0x3C, 0x07, 0xC1, 0xE0, 0x3C, 0x0F,
  0x01, 0xE0, 0xF8, 0x0F, 0x07, 0x80, 0xF8, 0x3C, 0x07, 0x81, 0xE0, 0x3C,
  0x1F, 0x01, 0xE0, 0xF0, 0x1F, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF,
  0xFC, 0x1E, 0x03, 0xE0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x7C, 0x07, 0x83,
  0xC0, 0x7C, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x0F, 0x80, 0xF0, 0x78, 0x0F,
  0x83, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x02, 0x03, 0xE0, 0x78, 0x7C, 0x0F, 0xFF,
  0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0xF8,
  0x3E, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x07, 0xC0, 0x78, 0x7C, 0x07, 0xC7,
  0xC0, 0x3C, 0x7C, 0x01, 0xE7, 0xC0, 0x0F, 0x7C, 0x00, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xF3, 0xE0,
  0x07, 0x8F, 0x00, 0x3C, 0x7C, 0x03, 0xE1, 0xE0, 0x1E, 0x0F, 0x80, 0xF0,
  0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x78,
  0x0F, 0x03, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x1F, 0x83, 0xF0,
  0xFC, 0x1F, 0x8F, 0xC0, 0xEC, 0x6E, 0x0F, 0x67, 0x70, 0x73, 0x33, 0x83,
  0x9B, 0xBC, 0x3C, 0xD9, 0xE1, 0xE7, 0xCE, 0x0E, 0x3C, 0x70, 0x71, 0xE7,
  0x87, 0x8E, 0x3C, 0x3C, 0x01, 0xE1, 0xC0, 0x0E, 0x1E, 0x00, 0xF0, 0xF0,
  0x07, 0x87, 0x80, 0x3C, 0x38, 0x01, 0xE3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0xFC,
  0x0F, 0x07, 0xF0, 0x78, 0x3F, 0x83, 0x81, 0xDC, 0x3C, 0x1E, 0xE1, 0xE0,
  0xF7, 0x8F, 0x07, 0x9C, 0x70, 0x38, 0xE7, 0x83, 0xC7, 0x3C, 0x1E, 0x3D,
  0xE0, 0xF0, 0xEE, 0x07, 0x87, 0xF0, 0x38, 0x3F, 0x83, 0xC1, 0xFC, 0x1E,
  0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x01, 0xF0, 0x78, 0x0F, 0x83, 0xC0, 0x7C,
  0x1E, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE,
  0x0F, 0x87, 0xC7, 0xC0, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xDF,
  0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x07, 0xDE, 0x01, 0xEF, 0x80,
  0x7B, 0xE0, 0x3E, 0xF8, 0x0F, 0x3E, 0x03, 0xCF, 0x81, 0xF1, 0xE0, 0xF8,
  0x7C, 0x7C, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0x83,
  0xE0, 0x78, 0x1E, 0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xE0, 0xF0,
  0x1E, 0x1F, 0x03, 0xE1, 0xE0, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFE, 0x03, 0xFE, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0x87, 0xC7,
  0xC0, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xDF, 0x00, 0xF7, 0x80,
  0x3D, 0xE0, 0x0F, 0x78, 0x07, 0xDE, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x3E,
  0xF8, 0x0F, 0x3E, 0x03, 0xCF, 0x81, 0xE1, 0xE0, 0xF8, 0x7C, 0x7C, 0x1F,
  0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x78, 0x3E, 0x1F, 0x07, 0xC3, 0xC0,
  0x78, 0x78, 0x0F, 0x0F, 0x03, 0xE3, 0xE0, 0x78, 0x78, 0x1F, 0x0F, 0x1F,
  0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xE3, 0xE0, 0x3C, 0x3C,
  0x07, 0x87, 0x81, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x1E,
  0x3E, 0x03, 0xC7, 0x80, 0x78, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF,
  0x83, 0xFB, 0xE0, 0x78, 0x04, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x10, 0x07, 0x87, 0x83, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x01,
  0xFF, 0x80, 0x01, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x01, 0xF0, 0xF0,
  0x1E, 0x0F, 0x01, 0xE1, 0xF0, 0x1E, 0x1E, 0x03, 0xE1, 0xE0, 0x3C, 0x1E,
  0x03, 0xC1, 0xE0, 0x3C, 0x3E, 0x07, 0xC3, 0xC0, 0x78, 0x3C, 0x07, 0x83,
  0xC0, 0x78, 0x7C, 0x0F, 0x87, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0,
  0xF8, 0x1F, 0x0F, 0x81, 0xE0, 0xF8, 0x1E, 0x0F, 0x83, 0xE0, 0x7C, 0x7C,
  0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x02, 0x00, 0x00, 0xF0,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7B, 0xC0, 0x3E, 0xF0, 0x0F, 0x3C, 0x07,
  0xCF, 0x01, 0xE3, 0xC0, 0xF8, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF3,
  0xC0, 0x3C, 0xF0, 0x07, 0x78, 0x01, 0xDC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x3C, 0x3C, 0x01, 0xE0, 0xF0,
  0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x78, 0x01, 0xC1, 0xE0, 0x0F,
  0x07, 0x80, 0x3C, 0x1E, 0x00, 0xE0, 0x71, 0xE3, 0x83, 0xC7, 0x9E, 0x0F,
  0x3E, 0x78, 0x3D, 0xF9, 0xC0, 0xE7, 0xE7, 0x03, 0xBB, 0xBC, 0x0E, 0xEE,
  0xE0, 0x7F, 0x3B, 0x81, 0xDC, 0xEE, 0x07, 0xE3, 0xF8, 0x1F, 0x87, 0xC0,
  0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0x03,
  0xC0, 0x3E, 0x07, 0x80, 0x78, 0x0F, 0x81, 0xE0, 0x0F, 0x07, 0xC0, 0x1E,
  0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xCF, 0x00,
  0x0F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0xF8, 0x3C, 0x03, 0xE0, 0x78, 0x07,
  0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x7C, 0x03, 0xE0, 0xF0, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0xF9, 0xE0, 0x3C, 0x78, 0x1F, 0x1E, 0x0F, 0x87, 0x83, 0xC1,
  0xE1, 0xF0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xDE, 0x00, 0xFF, 0x80, 0x1F,
  0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3E, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x3F, 0xF0, 0x3E, 0x78, 0x3E, 0x3C, 0x1E, 0x1F, 0x1F, 0x07, 0x9F, 0x03,
  0xDF, 0x01, 0xF7, 0x00, 0x71, 0x00, 0x20, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x20, 0x70, 0xFC, 0x7E, 0x1F, 0x0E, 0x04, 0x01, 0xFF, 0x03,
  0xFF, 0xC3, 0xFF, 0xE3, 0xF9, 0xF3, 0xE0, 0xF9, 0xE0, 0x79, 0xF0, 0x3C,
  0xF0, 0x1E, 0xF8, 0x1F, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01,
  0xE7, 0xC1, 0xF3, 0xF1, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xEF, 0x00,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF,
  0xF8, 0x3F, 0x7E, 0x1F, 0x07, 0xC7, 0x81, 0xF1, 0xE0, 0x3C, 0x78, 0x1F,
  0x3E, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3E, 0x3C, 0x0F, 0x1E,
  0x07, 0xC7, 0x87, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0x9C, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFE, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x81, 0xFC, 0xF8, 0x3F, 0x0F,
  0x83, 0xC0, 0xF0, 0x7C, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x1F, 0x0F, 0x81,
  0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x83, 0xE0, 0x7C,
  0x7E, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFD, 0xE0, 0x01, 0xFE, 0x03,
  0xFF, 0x83, 0xFF, 0xE3, 0xF1, 0xF3, 0xE0, 0x79, 0xE0, 0x3D, 0xE0, 0x1E,
  0xF0, 0x3E, 0x7F, 0xFF, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x30, 0x7F, 0xF8, 0x3F, 0xFE, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7C, 0x20,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x04, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0x1E, 0x0F, 0xC1, 0xE0, 0xF8, 0x3E, 0x1F,
  0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x07, 0xC1,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xFB, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF0,
  0x03, 0xEF, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x70, 0x7C,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xFB, 0xF1, 0xF0, 0x78,
  0xF8, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x9F, 0x07, 0xCF, 0x03,
  0xC7, 0x81, 0xE3, 0xC0, 0xF3, 0xE0, 0xF9, 0xE0, 0x78, 0xF0, 0x3C, 0x78,
  0x1E, 0x7C, 0x1F, 0x00, 0x00, 0x80, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0xF1, 0xFF, 0x8F,
  0xF8, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE3, 0x1F, 0xF8, 0x7F, 0xC1, 0xFE,
  0x00, 0x00, 0x80, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x04, 0x0F, 0x80, 0xE3, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x03, 0xE1, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x0F, 0x81,
  0xE3, 0xE0, 0x3D, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xFC, 0x00, 0xF7, 0xC0, 0x3E, 0x78, 0x07, 0x8F, 0x80, 0xF0, 0xF0, 0x1E,
  0x1F, 0x07, 0xC1, 0xE0, 0xF0, 0x3E, 0x1E, 0x03, 0xC0, 0x7F, 0xE7, 0xFC,
  0x7F, 0xC8, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x33, 0xFF, 0x3F, 0xF1, 0xFE,
  0x03, 0xF3, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xE3, 0xCF, 0x0E, 0x38,
  0xF1, 0xE3, 0x8E, 0x1E, 0x78, 0xE1, 0xE7, 0x9E, 0x1C, 0x71, 0xE1, 0xC7,
  0x1C, 0x3C, 0xF1, 0xC3, 0xC0, 0x3C, 0x38, 0x03, 0xC3, 0x80, 0x3C, 0x78,
  0x03, 0x87, 0x80, 0x78, 0x70, 0x07, 0x8F, 0x00, 0x78, 0x03, 0xFE, 0x07,
  0xFF, 0x83, 0xFF, 0xE1, 0xFB, 0xF0, 0xF0, 0x78, 0xF8, 0x3C, 0x78, 0x1E,
  0x3C, 0x0F, 0x1E, 0x07, 0x9F, 0x07, 0xCF, 0x83, 0xC7, 0x81, 0xE3, 0xC0,
  0xF1, 0xE0, 0x79, 0xF0, 0x7C, 0xF0, 0x3C, 0x78, 0x1E, 0x7C, 0x1F, 0x00,
  0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xF7, 0xE3, 0xE0, 0xF9, 0xE0,
  0x7D, 0xF0, 0x3E, 0xF0, 0x0F, 0x78, 0x0F, 0xFC, 0x07, 0xBC, 0x03, 0xDE,
  0x01, 0xEF, 0x81, 0xE7, 0xC1, 0xF1, 0xF1, 0xF0, 0xFF, 0xF8, 0x3F, 0xF0,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xC7,
  0xE0, 0xF8, 0x3E, 0x1F, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x03,
  0xE3, 0xE0, 0x78, 0x78, 0x0F, 0x0F, 0x03, 0xE1, 0xE0, 0x78, 0x7C, 0x3F,
  0x0F, 0x1F, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0x1E, 0x1F, 0x07, 0x8F,
  0x83, 0xE7, 0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0xCF, 0x81,
  0xE3, 0xE0, 0x78, 0xF8, 0x1E, 0x1E, 0x0F, 0x87, 0xC7, 0xE1, 0xFF, 0xF0,
  0x3F, 0xFC, 0x07, 0xEF, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC1, 0xF0, 0xE1, 0xF0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF1, 0xC1, 0xF1, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F,
  0xF8, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x18, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0,
  0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x7C, 0x1F, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0xF8, 0x3E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x7C, 0xF0, 0x7C, 0xF9, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0x3C,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF8, 0x3E, 0xF8, 0x3C,
  0xF8, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0x78, 0xF0, 0x79, 0xE0, 0x79, 0xE0,
  0x7B, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x38, 0x00, 0xF7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1C, 0x78, 0xE1,
  0xC7, 0x0E, 0x3C, 0x71, 0xE3, 0x87, 0x1E, 0x38, 0x73, 0xE7, 0x87, 0x3E,
  0x70, 0xF7, 0x77, 0x0F, 0xE7, 0xF0, 0xEE, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC,
  0x7C, 0x0F, 0x87, 0xC0, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0x0F, 0x80, 0xF0,
  0x78, 0x1E, 0x07, 0xC3, 0xE0, 0x3C, 0x7C, 0x03, 0xE7, 0x80, 0x1E, 0xF0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xF9, 0xE0, 0x1F, 0x1F, 0x03, 0xE0,
  0xF0, 0x7C, 0x0F, 0x8F, 0x80, 0x78, 0x03, 0xE0, 0x3C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xE0, 0xF8, 0x07, 0x83, 0xC0, 0x1E,
  0x0F, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x1F, 0x3C,
  0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x43, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x83, 0xCF, 0xF0, 0xE7, 0xFF, 0xFB,
  0xFF, 0xFC, 0xF1, 0xFE, 0x18, 0x1F, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 10, 24, 19, 5, -24 },
  { 31, 13, 10, 19, 6, -26 },
  { 48, 20, 24, 19, 0, -24 },
  { 108, 18, 30, 19, 1, -26 },
  { 176, 23, 25, 19, -1, -24 },
  { 248, 18, 24, 19, 0, -24 },
  { 302, 7, 11, 19, 9, -26 },
  { 312, 15, 33, 19, 4, -27 },
  { 374, 15, 33, 19, 0, -27 },
  { 436, 16, 15, 19, 3, -24 },
  { 466, 17, 17, 19, 1, -19 },
  { 503, 9, 12, 19, 2, -6 },
  { 517, 11, 4, 19, 4, -12 },
  { 523, 6, 6, 19, 5, -6 },
  { 528, 22, 33, 19, -2, -27 },
  { 619, 18, 25, 19, 1, -24 },
  { 676, 15, 24, 19, 1, -24 },
  { 721, 19, 24, 19, 0, -24 },
  { 778, 18, 25, 19, 0, -24 },
  { 835, 19, 24, 19, 0, -24 },
  { 892, 20, 25, 19, 0, -24 },
  { 955, 18, 25, 19, 2, -24 },
  { 1012, 18, 24, 19, 3, -24 },
  { 1066, 18, 25, 19, 1, -24 },
  { 1123, 18, 24, 19, 1, -24 },
  { 1177, 9, 18, 19, 5, -18 },
  { 1198, 12, 24, 19, 2, -18 },
  { 1234, 17, 16, 19, 2, -18 },
  { 1268, 19, 10, 19, 0, -15 },
  { 1292, 17, 16, 19, 1, -18 },
  { 1326, 14, 24, 19, 5, -24 },
  { 1368, 19, 29, 19, 1, -24 },
  { 1437, 19, 24, 19, -2, -24 },
  { 1494, 19, 24, 19, 0, -24 },
  { 1551, 18, 25, 19, 2, -24 },
  { 1608, 19, 24, 19, 0, -24 },
  { 1665, 19, 24, 19, 1, -24 },
  { 1722, 20, 24, 19, 1, -24 },
  { 1782, 18, 25, 19, 2, -24 },
  { 1839, 21, 24, 19, 0, -24 },
  { 1902, 20, 24, 19, 0, -24 },
  { 1962, 20, 25, 19, 0, -24 },
  { 2025, 21, 24, 19, 0, -24 },
  { 2088, 15, 24, 19, 0, -24 },
  { 2133, 21, 24, 19, -1, -24 },
  { 2196, 21, 24, 19, 0, -24 },
  { 2259, 18, 25, 19, 1, -24 },
  { 2316, 20, 24, 19, 0, -24 },
  { 2376, 18, 30, 19, 1, -24 },
  { 2444, 19, 24, 19, 0, -24 },
  { 2501, 19, 25, 19, 0, -24 },
  { 2561, 17, 24, 19, 4, -24 },
  { 2612, 20, 25, 19, 1, -24 },
  { 2675, 18, 24, 19, 4, -24 },
  { 2729, 22, 24, 19, 0, -24 },
  { 2795, 23, 24, 19, -1, -24 },
  { 2864, 18, 24, 19, 4, -24 },
  { 2918, 20, 24, 19, 0, -24 },
  { 2978, 18, 33, 19, 2, -27 },
  { 3053, 7, 33, 19, 7, -27 },
  { 3082, 18, 33, 19, -1, -27 },
  { 3157, 17, 14, 19, 2, -24 },
  { 3187, 18, 3, 19, -3, 3 },
  { 3194, 8, 7, 19, 8, -26 },
  { 3201, 17, 18, 19, 1, -18 },
  { 3240, 18, 26, 19, 0, -26 },
  { 3299, 18, 18, 19, 1, -18 },
  { 3340, 20, 26, 19, 1, -26 },
  { 3405, 17, 18, 19, 1, -18 },
  { 3444, 23, 32, 19, -2, -26 },
  { 3536, 20, 24, 19, -1, -18 },
  { 3596, 17, 26, 19, 0, -26 },
  { 3652, 13, 27, 19, 3, -27 },
  { 3696, 19, 33, 19, -1, -27 },
  { 3775, 19, 26, 19, 1, -26 },
  { 3837, 12, 26, 19, 4, -26 },
  { 3876, 20, 18, 19, -1, -18 },
  { 3921, 17, 18, 19, 0, -18 },
  { 3960, 17, 18, 19, 1, -18 },
  { 3999, 19, 24, 19, -1, -18 },
  { 4056, 18, 24, 19, 1, -18 },
  { 4110, 18, 18, 19, 1, -18 },
  { 4151, 17, 18, 19, 1, -18 },
  { 4190, 16, 23, 19, 3, -23 },
  { 4236, 16, 18, 19, 2, -18 },
  { 4272, 16, 18, 19, 3, -18 },
  { 4308, 20, 18, 19, 1, -18 },
  { 4353, 20, 18, 19, -1, -18 },
  { 4398, 22, 24, 19, -3, -18 },
  { 4464, 18, 18, 19, 1, -18 },
  { 4505, 19, 33, 19, 2, -27 },
  { 4584, 12, 33, 19, 4, -27 },
  { 4634, 18, 33, 19, -1, -27 },
  { 4709, 18, 6, 19, 1, -13 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic34pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic34pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic34pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC34PT7B_H_
