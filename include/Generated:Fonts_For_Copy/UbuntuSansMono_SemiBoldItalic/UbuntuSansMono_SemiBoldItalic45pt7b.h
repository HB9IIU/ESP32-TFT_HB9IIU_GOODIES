#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC45PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF0, 0x02, 0x00, 0x3F, 0x1F, 0x9F, 0x0F, 0xCF, 0x87, 0xEF,
  0xC3, 0xF7, 0xE1, 0xF3, 0xE1, 0xF9, 0xF0, 0xFC, 0xF8, 0x7C, 0x78, 0x3E,
  0x3C, 0x1E, 0x3E, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0x80, 0x00, 0x0F, 0x83,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x01,
  0xE0, 0xF8, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xE0, 0xF1,
  0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0x07, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x78, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x0F,
  0x80, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x80, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF0,
  0x78, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFC, 0x7E,
  0x07, 0xE0, 0x04, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x20, 0x03, 0xF0, 0x7C, 0x0F, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x02, 0x01, 0xFC,
  0x00, 0x78, 0x07, 0xFC, 0x01, 0xE0, 0x0F, 0xF8, 0x07, 0xC0, 0x3C, 0x78,
  0x1F, 0x00, 0x78, 0xF0, 0x3C, 0x01, 0xE1, 0xE0, 0xF0, 0x03, 0xC3, 0x83,
  0xC0, 0x07, 0x87, 0x0F, 0x00, 0x0F, 0x1E, 0x3E, 0x00, 0x1C, 0x3C, 0xF8,
  0x00, 0x3C, 0xF1, 0xE0, 0x00, 0x7F, 0xE7, 0x80, 0x00, 0xFF, 0x9E, 0x00,
  0x00, 0xFE, 0x78, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0xFE, 0x00, 0x00, 0xF3, 0xFE, 0x00,
  0x03, 0xCF, 0xFC, 0x00, 0x0F, 0x1E, 0x78, 0x00, 0x3E, 0x78, 0x70, 0x00,
  0xF8, 0xF0, 0xE0, 0x01, 0xE1, 0xC3, 0xC0, 0x07, 0x83, 0x87, 0x80, 0x1E,
  0x07, 0x0F, 0x00, 0x78, 0x0E, 0x1C, 0x01, 0xF0, 0x1C, 0x78, 0x07, 0xC0,
  0x3F, 0xE0, 0x0F, 0x00, 0x7F, 0xC0, 0x7C, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x1F, 0x9F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xE0,
  0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F,
  0x00, 0x3E, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x0C,
  0x07, 0xF8, 0x3E, 0x1F, 0xF8, 0x7C, 0x7D, 0xF0, 0xF1, 0xF1, 0xF3, 0xE7,
  0xC3, 0xF7, 0x9F, 0x03, 0xFF, 0x3E, 0x07, 0xFC, 0x7C, 0x07, 0xF8, 0xF8,
  0x07, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x3F, 0x87, 0xE1, 0xFF, 0x8F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xBE, 0x1F, 0xFE, 0x3E, 0x0F, 0xF0, 0x7C, 0x7F, 0x7E,
  0x7E, 0x7E, 0x7C, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8, 0xF0, 0xF0, 0xF0, 0xE0,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x1E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x60, 0xF0, 0x47, 0x8F,
  0x1E, 0xFC, 0xE7, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFE, 0x01,
  0xF0, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0xFB, 0xF0, 0x1F, 0x9F, 0x83,
  0xF1, 0xFC, 0x3F, 0x0F, 0x80, 0xE0, 0xF0, 0x06, 0x04, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x01,
  0xE0, 0x3E, 0x07, 0xC7, 0xF8, 0xFF, 0x0F, 0xE0, 0xF8, 0x08, 0x00, 0x7F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE0, 0x3C, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x10, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0xFE, 0x1F, 0x83, 0xF0, 0x1F, 0x87, 0xE0, 0x3F,
  0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF0, 0x01, 0xF3,
  0xE0, 0x03, 0xEF, 0xC7, 0x8F, 0xDF, 0x1F, 0x1F, 0xBE, 0x3E, 0x3E, 0x7C,
  0x7C, 0x7D, 0xF8, 0xF8, 0xFB, 0xE1, 0xE3, 0xF7, 0xC0, 0x07, 0xCF, 0x80,
  0x0F, 0x9F, 0x00, 0x3F, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF8, 0xF8, 0x03,
  0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x03, 0xF0, 0xFE, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xFC,
  0x07, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xCF, 0x80, 0xE3, 0xF0,
  0x10, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xE0, 0x7F, 0x03, 0x80, 0x3F, 0x01,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xE0, 0x7F, 0x00, 0x80, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x20, 0x01, 0xF8, 0x78,
  0x07, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x3F,
  0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x07,
  0xE0, 0x1F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80,
  0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x08, 0x00, 0xFE, 0x03, 0xC0, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x04, 0x00, 0x3E, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x7E, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0xFC,
  0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC,
  0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07,
  0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x3E, 0x07,
  0xE0, 0x7E, 0x03, 0xF9, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xC7, 0xF0, 0x1F, 0x03, 0xF8, 0x3E,
  0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0xFC,
  0x00, 0xF8, 0xFC, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7E, 0x07, 0xF0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F,
  0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x1F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0xE1, 0xFF, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01,
  0xFE, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xC0, 0xFE, 0x0F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFE, 0x0F,
  0xE0, 0xFC, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x07, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE,
  0x0F, 0xC0, 0x10, 0x00, 0x00, 0x3C, 0x00, 0xFE, 0x00, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x7F, 0x80,
  0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x08, 0x00,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x38, 0x1F,
  0xC4, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03,
  0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xC1, 0xF8, 0x1F, 0x80, 0x7C,
  0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x07, 0x8F, 0x80, 0x07,
  0xC7, 0xC0, 0xFF, 0xE3, 0xC0, 0xFF, 0xF3, 0xE1, 0xFF, 0xF9, 0xE1, 0xFF,
  0xF9, 0xF0, 0xFC, 0x7C, 0xF8, 0xFC, 0x3E, 0x78, 0x7C, 0x1F, 0x3C, 0x7C,
  0x0F, 0x1E, 0x3E, 0x0F, 0x9F, 0x1F, 0x07, 0xCF, 0x8F, 0x83, 0xE7, 0xC7,
  0xC1, 0xE3, 0xE3, 0xE1, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C,
  0x7E, 0x3E, 0x3E, 0x1F, 0xFE, 0x1F, 0x0F, 0xFF, 0x0F, 0x83, 0xFF, 0x83,
  0xC0, 0x7F, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF8, 0x60, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x3E, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xF8,
  0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0,
  0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x3F, 0x00,
  0x3F, 0x3E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0x83, 0xFC, 0x0F,
  0xC0, 0x7E, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0xC1,
  0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x07, 0xE0, 0x3F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01,
  0xF0, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x1F, 0x00,
  0x7E, 0x1F, 0x80, 0x7F, 0x0F, 0xE3, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0xF8, 0x1C, 0x0F, 0xE0, 0x04, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0xC0, 0x7F, 0x83, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x1F, 0x8F, 0xF0, 0x0F, 0x81, 0xFC, 0x07, 0xC0, 0x7E,
  0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03,
  0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x1F, 0x00,
  0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0,
  0x07, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0x7C,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0x83, 0xFC, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xE0, 0x70, 0x1F, 0xC0, 0x08, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0x3E,
  0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07,
  0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x1F, 0x80,
  0xF8, 0x0F, 0xF0, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x1F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03,
  0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00,
  0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x80,
  0xFC, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xF0, 0x03, 0xE0,
  0x1F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0,
  0x07, 0xC0, 0x3E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC,
  0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC,
  0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x10, 0x03, 0xF0, 0x0E, 0x01, 0xFC, 0x03, 0xE1, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xE0,
  0x03, 0xE0, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0x7E,
  0x7F, 0x00, 0x07, 0xCF, 0xE0, 0x00, 0x7D, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF1, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xE0, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x01,
  0xF8, 0x07, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x7E,
  0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x3D,
  0xC1, 0xDE, 0x03, 0xDC, 0x3F, 0xE0, 0x3D, 0xE3, 0xBC, 0x07, 0xDE, 0x7B,
  0xC0, 0x79, 0xE7, 0x3C, 0x07, 0x9E, 0xF3, 0xC0, 0xF9, 0xFE, 0x7C, 0x0F,
  0x9F, 0xE7, 0xC0, 0xF9, 0xFC, 0x78, 0x0F, 0x1F, 0xC7, 0x81, 0xF0, 0xF8,
  0xF8, 0x1F, 0x0F, 0x0F, 0x81, 0xF0, 0xF0, 0xF8, 0x3E, 0x00, 0x0F, 0x03,
  0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xF8, 0x03, 0xE0, 0x3F, 0x80,
  0x3E, 0x03, 0xF8, 0x07, 0xC0, 0x3F, 0xC0, 0x7C, 0x07, 0xFC, 0x07, 0xC0,
  0x7F, 0xC0, 0x7C, 0x07, 0xFE, 0x0F, 0x80, 0x7D, 0xE0, 0xF8, 0x07, 0xDE,
  0x0F, 0x80, 0xF9, 0xE0, 0xF8, 0x0F, 0x9F, 0x0F, 0x00, 0xF8, 0xF1, 0xF0,
  0x0F, 0x8F, 0x1F, 0x01, 0xF0, 0xF1, 0xF0, 0x1F, 0x0F, 0x9F, 0x01, 0xF0,
  0x7B, 0xE0, 0x1F, 0x07, 0xBE, 0x03, 0xE0, 0x7B, 0xE0, 0x3E, 0x07, 0xBE,
  0x03, 0xE0, 0x7F, 0xC0, 0x3E, 0x03, 0xFC, 0x07, 0xC0, 0x3F, 0xC0, 0x7C,
  0x03, 0xFC, 0x07, 0xC0, 0x3F, 0x80, 0x7C, 0x03, 0xF8, 0x0F, 0x80, 0x1F,
  0x80, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0xFE, 0x1F, 0xC3, 0xF8, 0x1F, 0x8F, 0xE0, 0x3F, 0x1F,
  0x80, 0x3E, 0x3E, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF0, 0x01, 0xF7, 0xE0,
  0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0xBE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F,
  0xDF, 0x00, 0x1F, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF1,
  0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x87, 0xF0, 0xFE, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x7C, 0x3F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0,
  0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF8,
  0x3F, 0x03, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x1F, 0x8F, 0xE0, 0x3F, 0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x7C,
  0xFC, 0x00, 0xF9, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xDF,
  0x00, 0x1F, 0xBE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFB, 0xF0,
  0x01, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0x3E, 0x00,
  0x7E, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F,
  0x87, 0xF0, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xC0, 0xFE,
  0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07,
  0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x03,
  0xF8, 0x1F, 0x0F, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0xFC,
  0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x1F,
  0x80, 0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0xC3,
  0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFE,
  0x01, 0xC0, 0x3F, 0x00, 0x10, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0x00, 0x1F, 0x81, 0xF8, 0x1F,
  0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03,
  0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0,
  0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC,
  0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0xC1,
  0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0xC7, 0xF0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07,
  0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x7D, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7C,
  0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00,
  0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1E, 0x1F, 0x0F, 0x01, 0xF0, 0xF8, 0xF8,
  0x0F, 0x8F, 0xC7, 0xC0, 0x7C, 0x7E, 0x3E, 0x03, 0xC7, 0xF1, 0xE0, 0x1E,
  0x7F, 0x9F, 0x01, 0xF3, 0xFC, 0xF8, 0x0F, 0xBC, 0xE7, 0x80, 0x79, 0xE7,
  0x3C, 0x03, 0xDE, 0x3B, 0xE0, 0x1E, 0xF1, 0xDF, 0x00, 0xFF, 0x0E, 0xF0,
  0x0F, 0x78, 0x77, 0x80, 0x7F, 0x83, 0xBC, 0x03, 0xF8, 0x1F, 0xC0, 0x1F,
  0xC0, 0xFE, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0,
  0x3E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x0F, 0xEF, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x01,
  0xF8, 0x3E, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xE0,
  0x07, 0xE0, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x7C, 0x00,
  0x7E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0x7E, 0x01,
  0xF8, 0x7E, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x0F,
  0xC0, 0x3F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x3F, 0x00, 0x1F, 0x7E,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x20, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xF1, 0xF8, 0xFC, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7E, 0x3F, 0x1F, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x40, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFC, 0xF8, 0x03, 0xF1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x3F, 0x03, 0xE0, 0xFE, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xE0, 0x0F,
  0xBF, 0x80, 0x1F, 0xBE, 0x00, 0x3F, 0x18, 0x00, 0x38, 0x10, 0x00, 0x40,
  0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x10, 0x07, 0x00, 0xF0, 0x3F, 0x0F, 0xF8, 0x7F, 0x83,
  0xF8, 0x3E, 0x01, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFC, 0x0F, 0x87, 0xF0, 0x1F,
  0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0xFC, 0x01, 0xF1, 0xF8, 0x03, 0xE3,
  0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x7E,
  0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xF8, 0x07, 0xE1, 0xF8, 0x1F, 0xC3, 0xF8,
  0x7F, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0x7C, 0x07, 0xFC,
  0xFC, 0x01, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xBF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xF8, 0x7E,
  0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0xC0,
  0x1F, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xFC, 0xFC, 0x03, 0xF1, 0xF8, 0x07,
  0xE3, 0xE0, 0x1F, 0x87, 0xC0, 0x7F, 0x1F, 0x87, 0xFC, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x83, 0xFC, 0x01, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x83, 0xFE, 0x1E, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x28, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3E, 0x03, 0xF0,
  0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x0F,
  0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xF8,
  0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x3F, 0x03,
  0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFE, 0xF8, 0x01, 0xFF, 0x3F, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xF3, 0xFC, 0x7F,
  0x03, 0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x7E, 0x00, 0xFD, 0xF0, 0x07,
  0xEF, 0xC0, 0x7F, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x70, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0x81, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xF8,
  0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x0F, 0x80,
  0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x01,
  0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F,
  0xC0, 0x3E, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x04, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x80, 0x0F, 0xC0,
  0x1F, 0x0F, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x07, 0xC0, 0xFE, 0x0F, 0x80, 0xFC, 0x3F, 0x01, 0xF8,
  0x7E, 0x03, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF0, 0xFC, 0x03, 0xE1, 0xF8,
  0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xC0, 0x3F, 0x1F, 0x80, 0x7C, 0x3F, 0x01,
  0xF8, 0x7E, 0x03, 0xF0, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0xCE, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0x80, 0xFE, 0x00,
  0xF1, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x7E, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE3, 0xF0, 0x03, 0xF3, 0xF0, 0x01, 0xF7, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E,
  0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE0,
  0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C,
  0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0xF8, 0xFF,
  0xF3, 0xFF, 0xE7, 0xFF, 0x8F, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC7, 0xBF, 0xFF, 0x3F, 0xFE, 0x7F,
  0xFC, 0x3F, 0xF0, 0x06, 0x00, 0x00, 0x7E, 0x1E, 0x00, 0xFF, 0xDF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xCF, 0xCF, 0xC1, 0xE1, 0xE1,
  0xF0, 0x78, 0x78, 0x7C, 0x3E, 0x1E, 0x1E, 0x0F, 0x8F, 0x8F, 0x83, 0xC3,
  0xE3, 0xE0, 0xF0, 0xF0, 0xF8, 0x7C, 0x3C, 0x3C, 0x1F, 0x1F, 0x1F, 0x07,
  0x87, 0xC7, 0xC1, 0xE1, 0xE1, 0xF0, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x1E,
  0x0F, 0x80, 0x0F, 0x83, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x3C, 0x1F, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x00,
  0x7F, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x3F, 0x07, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F, 0x1F, 0x80, 0xFC,
  0x7E, 0x03, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xFC,
  0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF8, 0x0F,
  0xC7, 0xE0, 0x3F, 0x1F, 0x00, 0xFC, 0xFC, 0x03, 0xE3, 0xF0, 0x1F, 0x8F,
  0xC0, 0x7E, 0x3E, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F,
  0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x1F,
  0x8F, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xBF,
  0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x1F, 0xBE, 0x00,
  0x7C, 0xF8, 0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFE, 0x3F, 0xCF, 0xF0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7C, 0x07, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x3E,
  0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xE0,
  0x7C, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x7F, 0x03, 0xE0, 0x3F,
  0x80, 0xF8, 0x1F, 0xE0, 0x7E, 0x3F, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0x20, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC3, 0xFC, 0x1F, 0x8F, 0xE0, 0x3F, 0x1F, 0x80, 0x7C, 0x7E, 0x00, 0xF8,
  0xFC, 0x03, 0xF1, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x1F,
  0x80, 0x7E, 0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF0, 0xFC, 0x03, 0xE1, 0xF8,
  0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xF8, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x01, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFC, 0x03, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x80, 0x20, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC2, 0x00, 0x3F, 0x1F, 0x03, 0xF8, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xF0, 0x00,
  0x00, 0x08, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF1, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x08, 0x00,
  0x0F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3F, 0x1F,
  0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xF0, 0x1F, 0x8F, 0x80, 0x7E, 0x3E, 0x01,
  0xF9, 0xF8, 0x07, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xF3,
  0xF0, 0x0F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0,
  0x1F, 0x8F, 0xC0, 0xFE, 0x3F, 0xCF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0x83, 0xFF, 0xBE, 0x07, 0xF8, 0xF8, 0x01, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x03, 0xF3, 0xF0,
  0x0F, 0xCF, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xC1, 0xF0, 0x3F,
  0x07, 0xC1, 0xF8, 0x1F, 0x07, 0xE0, 0x7C, 0x3F, 0x01, 0xF8, 0xF8, 0x07,
  0xE7, 0xE0, 0x1F, 0x9F, 0x00, 0x3E, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03,
  0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE1, 0xE0, 0xF9, 0xE0, 0xF0,
  0x78, 0xF0, 0xF8, 0x7C, 0xF8, 0x7C, 0x3E, 0x7C, 0x7E, 0x1E, 0x3E, 0x3F,
  0x1F, 0x1F, 0x3F, 0x8F, 0x0F, 0x1F, 0xC7, 0x87, 0x9E, 0xF7, 0xC3, 0xCF,
  0x7B, 0xC1, 0xEF, 0x3D, 0xE0, 0xF7, 0x9F, 0xF0, 0x7F, 0x8F, 0xF0, 0x3F,
  0x87, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7C, 0x03,
  0xE0, 0x3E, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x01,
  0xF0, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE0,
  0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF0,
  0x0F, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7E, 0x07,
  0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE3, 0xF0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0C, 0x7F, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xC0, 0x10, 0x0F, 0xF0, 0x1F, 0x1F, 0xF8, 0x1E, 0x3F, 0xFE, 0x3E, 0x3F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xF8, 0x3F, 0xF8, 0xF8, 0x1F, 0xF0, 0x30,
  0x07, 0xC0,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 13, 32, 25, 7, -31 },
  { 53, 17, 13, 25, 8, -34 },
  { 81, 27, 31, 25, 0, -31 },
  { 186, 24, 40, 25, 1, -35 },
  { 306, 31, 33, 25, -2, -32 },
  { 434, 23, 32, 25, 1, -32 },
  { 526, 8, 14, 25, 13, -34 },
  { 540, 20, 45, 25, 5, -36 },
  { 653, 20, 45, 25, 0, -36 },
  { 766, 20, 19, 25, 5, -31 },
  { 814, 22, 22, 25, 2, -24 },
  { 875, 12, 16, 25, 3, -8 },
  { 899, 14, 6, 25, 6, -16 },
  { 910, 8, 9, 25, 7, -8 },
  { 919, 30, 43, 25, -3, -35 },
  { 1081, 23, 33, 25, 2, -32 },
  { 1176, 19, 31, 25, 2, -31 },
  { 1250, 24, 32, 25, 1, -32 },
  { 1346, 24, 33, 25, 0, -32 },
  { 1445, 25, 31, 25, 0, -31 },
  { 1542, 26, 32, 25, 0, -31 },
  { 1646, 24, 32, 25, 2, -31 },
  { 1742, 24, 31, 25, 4, -31 },
  { 1835, 24, 33, 25, 1, -32 },
  { 1934, 24, 32, 25, 1, -32 },
  { 2030, 12, 25, 25, 7, -24 },
  { 2068, 16, 32, 25, 3, -24 },
  { 2132, 23, 22, 25, 2, -24 },
  { 2196, 24, 14, 25, 1, -20 },
  { 2238, 23, 22, 25, 1, -24 },
  { 2302, 19, 33, 25, 6, -32 },
  { 2381, 25, 39, 25, 1, -32 },
  { 2503, 24, 31, 25, -2, -31 },
  { 2596, 25, 32, 25, 0, -32 },
  { 2696, 24, 33, 25, 3, -32 },
  { 2795, 25, 32, 25, 0, -32 },
  { 2895, 26, 31, 25, 1, -31 },
  { 2996, 26, 31, 25, 1, -31 },
  { 3097, 25, 33, 25, 2, -32 },
  { 3201, 28, 31, 25, 0, -31 },
  { 3310, 27, 31, 25, 0, -31 },
  { 3415, 26, 32, 25, 0, -31 },
  { 3519, 28, 31, 25, 0, -31 },
  { 3628, 20, 31, 25, 0, -31 },
  { 3706, 28, 31, 25, -1, -31 },
  { 3815, 28, 31, 25, 0, -31 },
  { 3924, 23, 33, 25, 2, -32 },
  { 4019, 26, 32, 25, 0, -32 },
  { 4123, 23, 40, 25, 2, -32 },
  { 4238, 25, 32, 25, 0, -32 },
  { 4338, 26, 33, 25, 0, -32 },
  { 4446, 23, 31, 25, 5, -31 },
  { 4536, 25, 32, 25, 2, -31 },
  { 4636, 24, 31, 25, 5, -31 },
  { 4729, 29, 31, 25, 0, -31 },
  { 4842, 31, 31, 25, -2, -31 },
  { 4963, 24, 31, 25, 5, -31 },
  { 5056, 27, 31, 25, 0, -31 },
  { 5161, 24, 43, 25, 3, -35 },
  { 5290, 9, 43, 25, 9, -35 },
  { 5339, 24, 43, 25, -1, -35 },
  { 5468, 23, 18, 25, 2, -31 },
  { 5520, 24, 5, 25, -4, 3 },
  { 5535, 11, 9, 25, 10, -35 },
  { 5548, 23, 25, 25, 1, -24 },
  { 5620, 23, 36, 25, 0, -35 },
  { 5724, 23, 25, 25, 2, -24 },
  { 5796, 26, 36, 25, 2, -35 },
  { 5913, 22, 25, 25, 2, -24 },
  { 5982, 31, 43, 25, -3, -35 },
  { 6149, 27, 32, 25, -2, -24 },
  { 6257, 23, 35, 25, 0, -35 },
  { 6358, 17, 35, 25, 4, -35 },
  { 6433, 25, 44, 25, -2, -35 },
  { 6571, 25, 35, 25, 1, -35 },
  { 6681, 15, 36, 25, 6, -35 },
  { 6749, 26, 24, 25, -1, -24 },
  { 6827, 22, 24, 25, 1, -24 },
  { 6893, 22, 25, 25, 2, -24 },
  { 6962, 26, 32, 25, -2, -24 },
  { 7066, 23, 32, 25, 2, -24 },
  { 7158, 23, 24, 25, 2, -24 },
  { 7227, 22, 25, 25, 1, -24 },
  { 7296, 21, 32, 25, 4, -31 },
  { 7380, 22, 25, 25, 2, -24 },
  { 7449, 22, 24, 25, 4, -24 },
  { 7515, 25, 24, 25, 2, -24 },
  { 7590, 27, 24, 25, -1, -24 },
  { 7671, 30, 32, 25, -4, -24 },
  { 7791, 24, 24, 25, 1, -24 },
  { 7863, 24, 43, 25, 3, -35 },
  { 7992, 16, 43, 25, 5, -35 },
  { 8078, 24, 43, 25, -2, -35 },
  { 8207, 24, 9, 25, 1, -18 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic45pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic45pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic45pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC45PT7B_H_
