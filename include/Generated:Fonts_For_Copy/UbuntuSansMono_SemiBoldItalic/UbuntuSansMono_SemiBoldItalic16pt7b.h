#ifndef _UBUNTUSANSMONO_SEMIBOLDITALIC16PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLDITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBoldItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBoldItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x19, 0xCE, 0x63, 0x19, 0x80, 0x47, 0x38, 0xEF, 0x3D, 0xB6, 0x90,
  0x0C, 0x86, 0xC6, 0x4F, 0xF1, 0x31, 0x90, 0x9B, 0xFE, 0x6C, 0x26, 0x36,
  0x00, 0x06, 0x07, 0x87, 0xE6, 0x03, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x21,
  0xBF, 0x87, 0x81, 0x01, 0x80, 0x1C, 0x66, 0x98, 0x92, 0x16, 0x83, 0xA0,
  0x0C, 0x03, 0xE0, 0xD6, 0x12, 0xC4, 0xD3, 0x0E, 0x00, 0x1F, 0x0D, 0x8C,
  0xC6, 0xC1, 0xC1, 0xCD, 0xB5, 0x9E, 0xC6, 0x77, 0x1E, 0xC0, 0x6D, 0xAC,
  0x02, 0x1C, 0x71, 0xC3, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x0C,
  0x1C, 0x10, 0x08, 0x38, 0x30, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x30,
  0xE1, 0x86, 0x38, 0x20, 0x31, 0x67, 0x7B, 0xE7, 0x9D, 0x92, 0x00, 0x08,
  0x30, 0x67, 0xFF, 0xE6, 0x0C, 0x18, 0x37, 0x73, 0xE8, 0xFF, 0xC0, 0x7F,
  0x80, 0x00, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30,
  0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x00, 0x3E,
  0x37, 0x63, 0xC3, 0xDB, 0xDB, 0xC6, 0xC6, 0xC6, 0xDC, 0x78, 0x0E, 0x39,
  0xF2, 0x60, 0xC3, 0x06, 0x0C, 0x19, 0xFF, 0xF0, 0x1F, 0x1D, 0xC0, 0x60,
  0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0x3F, 0xBF, 0x80, 0x3F, 0x09, 0xC0,
  0x60, 0x61, 0xE0, 0xF0, 0x0C, 0x06, 0x03, 0x67, 0x3F, 0x00, 0x03, 0x83,
  0xC3, 0xC3, 0x63, 0x33, 0x19, 0x19, 0xFE, 0x06, 0x03, 0x03, 0x00, 0x1F,
  0x8F, 0xC6, 0x02, 0x03, 0xC1, 0xF0, 0x1C, 0x06, 0x03, 0x27, 0x3F, 0x00,
  0x0F, 0x1E, 0x30, 0x60, 0xDC, 0xFE, 0xC6, 0xC6, 0xC6, 0xEE, 0x7C, 0xFF,
  0xFF, 0x0E, 0x0C, 0x18, 0x30, 0x30, 0x60, 0xE0, 0xC0, 0xC0, 0x3E, 0x73,
  0x63, 0x63, 0x36, 0x3C, 0xCE, 0xC6, 0x86, 0xCE, 0xFC, 0x1F, 0x19, 0xCC,
  0x6C, 0x36, 0x19, 0xFC, 0x7C, 0x06, 0x06, 0x3E, 0x3C, 0x00, 0x31, 0xCC,
  0x00, 0x01, 0x9C, 0xE0, 0x18, 0x71, 0x80, 0x00, 0x03, 0x1C, 0x70, 0xCE,
  0x20, 0x07, 0x1F, 0xF8, 0xC0, 0xF0, 0x1E, 0x04, 0x7F, 0x80, 0x00, 0x0F,
  0xEF, 0xF0, 0x30, 0x7C, 0x0F, 0x03, 0x1E, 0xF8, 0xC0, 0x7C, 0x9C, 0x18,
  0x61, 0x86, 0x18, 0x00, 0x41, 0xC3, 0x80, 0x0F, 0x8C, 0xCC, 0x2C, 0xF6,
  0xFA, 0xCD, 0x67, 0xB2, 0xDB, 0x67, 0x90, 0x0C, 0x03, 0xE0, 0x03, 0x03,
  0x83, 0x41, 0xB1, 0x98, 0xCC, 0xC6, 0x7F, 0x61, 0xB0, 0xF0, 0x60, 0x1F,
  0x1D, 0xCC, 0x66, 0x33, 0xF3, 0xF1, 0x8C, 0xC6, 0x63, 0x7F, 0xBF, 0x00,
  0x1F, 0x9C, 0x98, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x7E, 0x1F,
  0x80, 0x3E, 0x1F, 0x8C, 0x66, 0x36, 0x1B, 0x0D, 0x8C, 0xC6, 0xC7, 0x7F,
  0x3E, 0x00, 0x1F, 0xC7, 0xE3, 0x00, 0xC0, 0x3F, 0x0F, 0xC6, 0x01, 0x80,
  0x60, 0x1F, 0xCF, 0xE0, 0x1F, 0xC7, 0xE3, 0x00, 0xC0, 0x3F, 0x0F, 0xC2,
  0x01, 0x80, 0x60, 0x18, 0x0E, 0x00, 0x1F, 0x39, 0x60, 0x60, 0xC0, 0xC6,
  0xC6, 0xC6, 0xC6, 0xEC, 0x7C, 0x38, 0xCC, 0x63, 0x18, 0xC6, 0x7F, 0x9F,
  0xC6, 0x31, 0x8C, 0xC3, 0x31, 0x8C, 0x60, 0x1F, 0x9F, 0xC1, 0x81, 0x80,
  0xC0, 0x60, 0x30, 0x30, 0x18, 0x3F, 0x3F, 0x80, 0x0F, 0x8F, 0xC0, 0x60,
  0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x7F, 0x1F, 0x00, 0x39, 0xCC, 0xE3,
  0x30, 0xD8, 0x3C, 0x1E, 0x06, 0xC1, 0xB8, 0x66, 0x31, 0x8C, 0x30, 0x18,
  0x60, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0xF8, 0x0C, 0xE3, 0x98,
  0x77, 0x0A, 0xA3, 0x7C, 0x6D, 0x89, 0xA3, 0x04, 0x61, 0x8C, 0x33, 0x06,
  0x00, 0x30, 0xCE, 0x23, 0x98, 0xA6, 0x6D, 0x9B, 0x46, 0x71, 0x1C, 0xC7,
  0x31, 0x8C, 0x60, 0x3E, 0x77, 0x63, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xC6,
  0xFC, 0x78, 0x1F, 0x1F, 0xCC, 0x66, 0x33, 0x1B, 0xF9, 0xF8, 0xC0, 0x60,
  0x60, 0x30, 0x00, 0x3E, 0x77, 0x63, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xC6,
  0xFC, 0x78, 0x20, 0x3C, 0x18, 0x3F, 0x19, 0xCC, 0x66, 0x33, 0x33, 0xF9,
  0xF0, 0xCC, 0x66, 0x63, 0x30, 0xC0, 0x1F, 0x9C, 0xCC, 0x06, 0x03, 0x80,
  0xF0, 0x1C, 0x06, 0x03, 0x77, 0x3F, 0x00, 0xFF, 0xFF, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x60, 0x60, 0x60, 0xE0, 0x61, 0xB1, 0x98, 0xCC, 0x6C, 0x36,
  0x33, 0x19, 0x8C, 0xCE, 0x7E, 0x3E, 0x00, 0xC3, 0xC3, 0xC6, 0xC6, 0xCC,
  0xCC, 0xD8, 0xD8, 0xF0, 0xE0, 0xE0, 0x30, 0xCC, 0x32, 0x09, 0x86, 0x6D,
  0x9B, 0x65, 0x51, 0x54, 0xE7, 0x39, 0x8C, 0x60, 0x18, 0x61, 0x98, 0x36,
  0x03, 0xC0, 0x70, 0x0C, 0x03, 0xC0, 0xD8, 0x3B, 0x06, 0x33, 0x86, 0x00,
  0xC3, 0xC6, 0xC6, 0x4C, 0x78, 0x78, 0x70, 0x60, 0x60, 0x60, 0x60, 0x1F,
  0xCF, 0xE0, 0x30, 0x18, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0xCF,
  0xE0, 0x0F, 0x1F, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60,
  0x60, 0x60, 0x40, 0xF8, 0xF8, 0xDB, 0x6C, 0x9B, 0x6D, 0xB6, 0xDB, 0x1F,
  0x1F, 0x03, 0x02, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x18,
  0x18, 0xF8, 0xF8, 0x0C, 0x1E, 0x36, 0x76, 0x63, 0xC3, 0xFF, 0xFF, 0xDC,
  0x80, 0x0C, 0x3F, 0x66, 0xC6, 0xC6, 0x86, 0xCC, 0xFC, 0xF6, 0x18, 0x18,
  0x30, 0x34, 0x3F, 0x33, 0x63, 0x63, 0x63, 0x67, 0xFE, 0xFC, 0x0E, 0x3F,
  0x70, 0xC0, 0xC0, 0xC0, 0xC0, 0xFC, 0x7C, 0x01, 0x81, 0x80, 0xC1, 0xE3,
  0xF3, 0x33, 0x19, 0x8C, 0xC6, 0x66, 0x3F, 0x1E, 0xC0, 0x0C, 0x3E, 0x63,
  0xC6, 0xFE, 0xF8, 0xC0, 0xE4, 0x7C, 0x03, 0xE0, 0xE4, 0x18, 0x03, 0x01,
  0xFC, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x81,
  0xF0, 0x3C, 0x00, 0x03, 0x03, 0xF1, 0x98, 0xC6, 0x31, 0x8C, 0x63, 0x38,
  0xFC, 0x03, 0x00, 0xC7, 0xE3, 0xF0, 0x18, 0x18, 0x30, 0x34, 0x3F, 0x33,
  0x63, 0x63, 0x63, 0x66, 0xC6, 0xC6, 0x08, 0x71, 0xC0, 0x01, 0xE9, 0x8E,
  0x30, 0xC3, 0x0F, 0x3C, 0x00, 0x80, 0xC0, 0x60, 0x00, 0x00, 0xFC, 0x0C,
  0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x31, 0xF1, 0xF0, 0x18, 0x0C,
  0x06, 0x06, 0x03, 0x39, 0xB8, 0xF0, 0xF0, 0x6C, 0x37, 0x19, 0x98, 0xE0,
  0xF9, 0x8C, 0x63, 0x31, 0x8C, 0x63, 0x1E, 0xF0, 0x11, 0x1F, 0xDB, 0x6D,
  0xB4, 0x92, 0xDB, 0x0D, 0x86, 0xC2, 0x00, 0x0C, 0x3F, 0x33, 0x33, 0x63,
  0x63, 0x63, 0x66, 0xC6, 0x18, 0xFD, 0x9E, 0x3C, 0x78, 0xF1, 0xFE, 0xF8,
  0x06, 0x0F, 0xC6, 0x66, 0x33, 0x19, 0x8C, 0xCE, 0xFE, 0x7E, 0x30, 0x18,
  0x18, 0x00, 0x0C, 0x3F, 0x66, 0xC6, 0xC6, 0xC6, 0xCC, 0xFC, 0xFC, 0x0C,
  0x0C, 0x18, 0x0E, 0x7F, 0x61, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0x0E,
  0x1F, 0x31, 0x30, 0x3C, 0x0E, 0x06, 0x6E, 0xFC, 0x18, 0x18, 0x18, 0x7F,
  0xB0, 0x30, 0x30, 0x60, 0x60, 0x7C, 0x3C, 0x67, 0x66, 0xC6, 0xC6, 0xC6,
  0xCC, 0xFC, 0xF6, 0xC3, 0x66, 0x66, 0x6C, 0x6C, 0x78, 0x70, 0x70, 0xC1,
  0xED, 0xA6, 0xD7, 0x4A, 0xE7, 0x73, 0x31, 0x18, 0x73, 0x99, 0x87, 0x83,
  0x81, 0xC1, 0xB1, 0x99, 0x8E, 0x38, 0xC6, 0x61, 0x98, 0x66, 0x1B, 0x07,
  0x81, 0xE0, 0x30, 0x18, 0x3E, 0x0E, 0x00, 0x3F, 0x81, 0x83, 0x83, 0x81,
  0x81, 0x81, 0xF9, 0xFC, 0x03, 0x87, 0x83, 0x03, 0x01, 0x80, 0xC0, 0x41,
  0xE0, 0xE0, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0xE0, 0x70, 0x18, 0xC6,
  0x33, 0x18, 0xC6, 0x23, 0x18, 0xC6, 0x63, 0x18, 0x0C, 0x07, 0x80, 0xC0,
  0x60, 0x30, 0x10, 0x18, 0x07, 0x03, 0x83, 0x03, 0x01, 0x80, 0xC0, 0x41,
  0xE1, 0xE0, 0x79, 0xBF, 0xB1, 0x80,
};

const GFXglyph UbuntuSansMono_SemiBoldItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 11, 9, 2, -11 },
  { 8, 6, 5, 9, 3, -12 },
  { 12, 9, 11, 9, 0, -11 },
  { 25, 9, 14, 9, 0, -12 },
  { 41, 11, 11, 9, -1, -11 },
  { 57, 9, 11, 9, 0, -11 },
  { 70, 3, 5, 9, 4, -12 },
  { 72, 7, 16, 9, 2, -13 },
  { 86, 7, 16, 9, 0, -13 },
  { 100, 7, 7, 9, 2, -11 },
  { 107, 7, 8, 9, 1, -9 },
  { 114, 4, 6, 9, 1, -3 },
  { 117, 5, 2, 9, 2, -6 },
  { 119, 3, 3, 9, 2, -3 },
  { 121, 11, 16, 9, -1, -13 },
  { 143, 8, 11, 9, 1, -11 },
  { 154, 7, 11, 9, 1, -11 },
  { 164, 9, 11, 9, 0, -11 },
  { 177, 9, 11, 9, 0, -11 },
  { 190, 9, 11, 9, 0, -11 },
  { 203, 9, 11, 9, 0, -11 },
  { 216, 8, 11, 9, 1, -11 },
  { 227, 8, 11, 9, 2, -11 },
  { 238, 8, 11, 9, 1, -11 },
  { 249, 9, 11, 9, 0, -11 },
  { 262, 5, 9, 9, 2, -9 },
  { 268, 6, 12, 9, 1, -9 },
  { 277, 8, 7, 9, 1, -8 },
  { 284, 9, 5, 9, 0, -7 },
  { 290, 8, 7, 9, 0, -8 },
  { 297, 7, 11, 9, 2, -11 },
  { 307, 9, 13, 9, 0, -11 },
  { 322, 9, 11, 9, -1, -11 },
  { 335, 9, 11, 9, 0, -11 },
  { 348, 9, 11, 9, 1, -11 },
  { 361, 9, 11, 9, 0, -11 },
  { 374, 10, 11, 9, 0, -11 },
  { 388, 10, 11, 9, 0, -11 },
  { 402, 8, 11, 9, 1, -11 },
  { 413, 10, 11, 9, 0, -11 },
  { 427, 9, 11, 9, 0, -11 },
  { 440, 9, 11, 9, 0, -11 },
  { 453, 10, 11, 9, 0, -11 },
  { 467, 7, 11, 9, 0, -11 },
  { 477, 11, 11, 9, -1, -11 },
  { 493, 10, 11, 9, 0, -11 },
  { 507, 8, 11, 9, 1, -11 },
  { 518, 9, 11, 9, 0, -11 },
  { 531, 8, 14, 9, 1, -11 },
  { 545, 9, 11, 9, 0, -11 },
  { 558, 9, 11, 9, 0, -11 },
  { 571, 8, 11, 9, 2, -11 },
  { 582, 9, 11, 9, 1, -11 },
  { 595, 8, 11, 9, 2, -11 },
  { 606, 10, 11, 9, 0, -11 },
  { 620, 11, 11, 9, -1, -11 },
  { 636, 8, 11, 9, 2, -11 },
  { 647, 10, 11, 9, 0, -11 },
  { 661, 8, 16, 9, 1, -13 },
  { 677, 3, 16, 9, 3, -13 },
  { 683, 8, 16, 9, 0, -13 },
  { 699, 8, 6, 9, 1, -11 },
  { 705, 8, 2, 9, -1, 1 },
  { 707, 3, 3, 9, 4, -12 },
  { 709, 8, 9, 9, 1, -9 },
  { 718, 8, 12, 9, 0, -12 },
  { 730, 8, 9, 9, 1, -9 },
  { 739, 9, 12, 9, 1, -12 },
  { 753, 8, 9, 9, 1, -9 },
  { 762, 11, 15, 9, -1, -12 },
  { 783, 10, 12, 9, -1, -9 },
  { 798, 8, 12, 9, 0, -12 },
  { 810, 6, 13, 9, 1, -13 },
  { 820, 9, 16, 9, -1, -13 },
  { 838, 9, 12, 9, 0, -12 },
  { 852, 5, 12, 9, 2, -12 },
  { 860, 9, 9, 9, 0, -9 },
  { 871, 8, 9, 9, 0, -9 },
  { 880, 7, 9, 9, 1, -9 },
  { 888, 9, 12, 9, -1, -9 },
  { 902, 8, 12, 9, 1, -9 },
  { 914, 8, 9, 9, 1, -9 },
  { 923, 8, 9, 9, 0, -9 },
  { 932, 8, 11, 9, 1, -11 },
  { 943, 8, 8, 9, 1, -8 },
  { 951, 8, 8, 9, 1, -8 },
  { 959, 9, 8, 9, 1, -8 },
  { 968, 9, 8, 9, 0, -8 },
  { 977, 10, 11, 9, -1, -8 },
  { 991, 9, 8, 9, 0, -8 },
  { 1000, 9, 16, 9, 1, -13 },
  { 1018, 5, 16, 9, 2, -13 },
  { 1028, 9, 16, 9, -1, -13 },
  { 1046, 9, 3, 9, 0, -6 },
};

const GFXfont UbuntuSansMono_SemiBoldItalic16pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBoldItalic16pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBoldItalic16pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _UBUNTUSANSMONO_SEMIBOLDITALIC16PT7B_H_
