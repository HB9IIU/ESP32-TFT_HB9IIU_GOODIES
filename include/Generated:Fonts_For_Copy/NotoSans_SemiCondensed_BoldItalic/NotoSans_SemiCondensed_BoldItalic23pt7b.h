#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC23PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x70, 0xE1, 0xC7, 0x8E, 0x1C, 0x38, 0x71, 0xC0, 0x02,
  0x0E, 0x3C, 0x78, 0x77, 0xBB, 0x99, 0xCC, 0xCE, 0x66, 0x30, 0x03, 0x38,
  0x0C, 0xC0, 0x73, 0x01, 0x9C, 0x3F, 0xFC, 0xFF, 0xF0, 0xCE, 0x03, 0x30,
  0x1C, 0xC1, 0xFF, 0xCF, 0xFF, 0x06, 0x60, 0x39, 0x80, 0xCE, 0x03, 0x30,
  0x1C, 0xC0, 0x01, 0x80, 0x3C, 0x0F, 0xF1, 0xFE, 0x3D, 0x23, 0xB0, 0x3E,
  0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x5E, 0x85, 0xEF, 0xFC, 0xFF,
  0xC7, 0xF0, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x1F, 0x07, 0x1F, 0xC7, 0x0E,
  0xE3, 0x06, 0x73, 0x87, 0x3B, 0x83, 0x99, 0x81, 0xDD, 0xDE, 0xFD, 0xDF,
  0x3E, 0xDD, 0xCC, 0xEC, 0xE0, 0xEE, 0x70, 0x67, 0x30, 0x73, 0x98, 0x71,
  0xDC, 0x30, 0xFC, 0x38, 0x3C, 0x00, 0x01, 0x80, 0x1F, 0x80, 0xFF, 0x03,
  0x9C, 0x0C, 0x70, 0x3B, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x1C, 0xFE, 0x77,
  0xBB, 0xDC, 0xFE, 0x71, 0xF3, 0xC7, 0xC7, 0xFF, 0x1F, 0xFC, 0x3F, 0x78,
  0x77, 0x66, 0xEE, 0x0F, 0x0C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0x60, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x70, 0x06,
  0x03, 0x81, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0,
  0xE0, 0x70, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x0E, 0x00, 0x08,
  0x03, 0x88, 0xE3, 0xB0, 0xFF, 0xCF, 0xF1, 0xFC, 0xF8, 0xF6, 0x09, 0xC0,
  0x20, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xF8, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x00, 0x39, 0xDC, 0xEE, 0x70, 0x7E, 0xFB, 0xF0,
  0x2F, 0xFF, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70,
  0x07, 0x00, 0xE0, 0x00, 0x07, 0x03, 0xF8, 0xFF, 0x1C, 0xE7, 0x9E, 0xE3,
  0xFC, 0x7F, 0x8E, 0xE1, 0xDC, 0x3B, 0x87, 0x71, 0xEE, 0x39, 0xCF, 0x3F,
  0xC7, 0xF0, 0x7C, 0x00, 0x07, 0x8F, 0x8F, 0xDF, 0xE6, 0xF2, 0x70, 0x38,
  0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x01, 0xC0,
  0x3F, 0x07, 0xFC, 0x18, 0xE0, 0x87, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xFF, 0x8F, 0xFC,
  0xFF, 0xC0, 0x03, 0x81, 0xFE, 0x1F, 0xE1, 0x8F, 0x00, 0xF0, 0x0E, 0x01,
  0xE0, 0xFC, 0x0F, 0x01, 0xFC, 0x01, 0xC0, 0x1C, 0x01, 0xC8, 0x1C, 0xEF,
  0xCF, 0xF8, 0xFE, 0x00, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x7E, 0x06, 0xE0,
  0xDC, 0x1D, 0xC3, 0x9C, 0x71, 0xC6, 0x38, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0,
  0x38, 0x07, 0x00, 0x70, 0x0F, 0xF1, 0xFE, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x3F, 0x83, 0xFC, 0x23, 0xC0, 0x1E, 0x01, 0xC0, 0x1C, 0x83, 0xCF,
  0xFC, 0xFF, 0x8F, 0xE0, 0x01, 0xE0, 0xFC, 0x7F, 0x8E, 0x03, 0x80, 0xE0,
  0x1D, 0xC3, 0xFC, 0xFF, 0xDE, 0x7B, 0x87, 0x70, 0xEE, 0x3D, 0xC7, 0x3F,
  0xE3, 0xF8, 0x3E, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0xE0, 0x1C, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0x03, 0x80, 0xFE, 0x1F, 0xF1, 0xCF, 0x3C, 0x73,
  0xCF, 0x1D, 0xE1, 0xFC, 0x0F, 0x03, 0xFC, 0x79, 0xC7, 0x1E, 0xF1, 0xEF,
  0x1C, 0x73, 0xC7, 0xF8, 0x3F, 0x00, 0x07, 0x07, 0xE3, 0xFD, 0xE7, 0x71,
  0xDC, 0x7F, 0x1F, 0xC7, 0xF3, 0xDF, 0xF3, 0xDC, 0x0E, 0x03, 0x81, 0xCD,
  0xF3, 0xF8, 0xF8, 0x00, 0x18, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x8F,
  0x3C, 0xF0, 0x0C, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3,
  0xC7, 0x0E, 0x38, 0x70, 0x00, 0x60, 0x3C, 0x1F, 0x8F, 0xC7, 0xC1, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0x80, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x80, 0x1C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0xF8, 0xFC, 0x7E, 0x1F, 0x03, 0x00, 0x40, 0x00,
  0x0E, 0x3F, 0xDF, 0xE4, 0x70, 0x38, 0x1C, 0x1C, 0x1E, 0x1C, 0x1C, 0x0E,
  0x0E, 0x00, 0x00, 0x01, 0xC1, 0xE0, 0xF0, 0x00, 0x03, 0xFC, 0x07, 0xFF,
  0x07, 0x01, 0xC7, 0x00, 0x63, 0x1F, 0xBB, 0x1F, 0x9D, 0x9C, 0xCF, 0xCC,
  0x67, 0xCE, 0x73, 0x66, 0x39, 0xB3, 0x19, 0xD9, 0xDD, 0xCC, 0xFB, 0xC7,
  0x10, 0x81, 0x80, 0x00, 0xF0, 0x60, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x77, 0x03, 0xB8, 0x39, 0xC1, 0xCE,
  0x1C, 0x70, 0xFF, 0x8F, 0xFC, 0x7F, 0xE7, 0x87, 0x38, 0x3F, 0xC1, 0xFC,
  0x0F, 0x0F, 0xF0, 0xFF, 0xC7, 0x1E, 0x38, 0x71, 0xC3, 0x8E, 0x38, 0xFF,
  0xC7, 0xF8, 0x3F, 0xE1, 0xC7, 0x8E, 0x1C, 0xF1, 0xE7, 0x0F, 0x3F, 0xF1,
  0xFF, 0x1F, 0xF0, 0x01, 0xC0, 0x3F, 0xC7, 0xFC, 0x7C, 0x63, 0xC0, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x01, 0xFF, 0x0F, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0xE1, 0xEF,
  0x87, 0x0E, 0x1C, 0x3C, 0x70, 0xF3, 0xC3, 0xCE, 0x0F, 0x38, 0x38, 0xE0,
  0xE3, 0x87, 0x9E, 0x3C, 0x71, 0xF1, 0xFF, 0x87, 0xFC, 0x3F, 0xC0, 0x0F,
  0xF1, 0xFF, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3F, 0xC3, 0xFC, 0x3F,
  0xC3, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0xF8, 0x7F, 0x8F, 0xF8, 0x0F,
  0xF1, 0xFF, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xFC, 0x3F,
  0xC3, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0x01,
  0xE0, 0x1F, 0xF1, 0xFF, 0x87, 0x86, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xF1, 0xFB, 0xC7, 0xCF, 0x27, 0x3C, 0x1C, 0xF0, 0xF3, 0xC3, 0x87,
  0xFE, 0x1F, 0xF8, 0x1F, 0xC0, 0x0E, 0x0E, 0x3C, 0x3C, 0x78, 0x70, 0xE0,
  0xE1, 0xC1, 0xC3, 0x87, 0x8F, 0xFF, 0x1F, 0xFC, 0x3F, 0xF8, 0x70, 0x70,
  0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x78, 0x78, 0x1F,
  0xE1, 0xF8, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x1F, 0xC7, 0xF0, 0x00, 0xE0, 0x1C,
  0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC1, 0xF8, 0x7E,
  0x0F, 0x80, 0x0E, 0x1E, 0x3C, 0x70, 0x71, 0xE0, 0xE7, 0x81, 0xDE, 0x03,
  0xB8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xEF, 0x03, 0xCE,
  0x07, 0x1C, 0x0E, 0x3C, 0x1C, 0x38, 0x78, 0x78, 0x0E, 0x0F, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0xFD,
  0xFF, 0xFF, 0x0F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x0F, 0x83, 0xE1,
  0xF0, 0xFC, 0x36, 0x1B, 0x8E, 0xC7, 0x71, 0xD8, 0xDC, 0x3B, 0xBB, 0x87,
  0x76, 0x70, 0xCF, 0xCE, 0x39, 0xF3, 0x87, 0x3E, 0x70, 0xE7, 0x8E, 0x1C,
  0xF1, 0xC7, 0x1E, 0x38, 0x0F, 0x07, 0x1F, 0x07, 0x1F, 0x0E, 0x1F, 0x8E,
  0x1F, 0x8E, 0x1B, 0x8E, 0x3B, 0x8E, 0x39, 0xDC, 0x39, 0xDC, 0x39, 0xDC,
  0x31, 0xFC, 0x70, 0xFC, 0x70, 0xF8, 0x70, 0xF8, 0x70, 0x78, 0xE0, 0x78,
  0x01, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0x9E, 0x3C, 0x3D, 0xE0, 0xF7, 0x83,
  0xDC, 0x0F, 0xF0, 0x3F, 0xC0, 0xEF, 0x03, 0xBC, 0x1E, 0xF0, 0x73, 0xC3,
  0xC7, 0xFE, 0x1F, 0xF0, 0x1F, 0x80, 0x0F, 0xF0, 0xFF, 0xC7, 0x9E, 0x38,
  0x71, 0xC3, 0x8E, 0x1C, 0xF1, 0xE7, 0xFE, 0x3F, 0xE1, 0xFE, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0x01, 0xC0, 0x3F, 0xC1,
  0xFF, 0x8F, 0x9E, 0x3C, 0x3D, 0xE0, 0xF7, 0x83, 0xDC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xEF, 0x03, 0xBC, 0x1E, 0xF0, 0x73, 0xC3, 0xC7, 0xFE, 0x1F, 0xF0,
  0x1F, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x0F, 0xE0, 0xFF,
  0x87, 0x1C, 0x38, 0xF1, 0xC7, 0x8E, 0x38, 0xF3, 0xC7, 0xFC, 0x3F, 0xC1,
  0xFC, 0x0E, 0xF0, 0xF3, 0x87, 0x1C, 0x38, 0xF1, 0xC3, 0x9E, 0x1E, 0x03,
  0x80, 0xFF, 0x1F, 0xE1, 0xE6, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xC8, 0x3C, 0xFF, 0x8F, 0xF8, 0x7E,
  0x00, 0xFF, 0xFF, 0xF8, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0x1C,
  0x3C, 0xF0, 0xE3, 0x83, 0x8E, 0x0E, 0x38, 0x79, 0xE1, 0xE7, 0x87, 0x1C,
  0x1C, 0x70, 0x71, 0xC3, 0xCF, 0x0F, 0x3C, 0x38, 0xF1, 0xE1, 0xFF, 0x07,
  0xFC, 0x0F, 0xC0, 0xE0, 0x7F, 0x07, 0xB8, 0x39, 0xC3, 0xCE, 0x1C, 0x71,
  0xE3, 0x8E, 0x0E, 0x70, 0x77, 0x03, 0xB8, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xE0, 0xE1, 0xFC, 0x3C, 0x3B, 0x87, 0x87,
  0x71, 0xF1, 0xCE, 0x3E, 0x39, 0xC7, 0xCF, 0x39, 0xF9, 0xC7, 0x37, 0x38,
  0xEE, 0xEE, 0x1D, 0xDD, 0xC3, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0x8F, 0xC1,
  0xF1, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x1C, 0x78, 0x3C,
  0xE0, 0x3B, 0xC0, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x7F, 0x80, 0xE7, 0x03, 0xCE, 0x0F, 0x1C, 0x1C, 0x3C, 0x78,
  0x38, 0xF0, 0xFF, 0x1E, 0x71, 0xC7, 0x38, 0x77, 0x87, 0x70, 0x3E, 0x03,
  0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07,
  0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3F, 0xF1,
  0xFF, 0x1F, 0xF8, 0x0F, 0xC3, 0xE0, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70,
  0x1F, 0x07, 0xC3, 0xF0, 0xE1, 0x86, 0x1C, 0x71, 0xC7, 0x1C, 0x30, 0xE3,
  0x8E, 0x38, 0xE3, 0x86, 0x1C, 0x0F, 0xC3, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x30, 0x1C, 0x1F, 0x07, 0xC3, 0xF0, 0x03, 0x80, 0x70, 0x1E, 0x07, 0xE0,
  0xDC, 0x39, 0x8E, 0x31, 0x87, 0x70, 0xFC, 0x0C, 0xFF, 0xFF, 0x80, 0xF3,
  0x8C, 0x70, 0x0E, 0x67, 0xFC, 0xFF, 0xBC, 0xF7, 0x1F, 0xE3, 0xB8, 0x77,
  0x0E, 0xE3, 0xDC, 0x73, 0xDE, 0x7F, 0xC7, 0xB8, 0x0E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x1D, 0xC1, 0xFE, 0x3F, 0xF3, 0xCF, 0x38, 0x73, 0x8F, 0x38,
  0xF7, 0x0E, 0x70, 0xE7, 0x1E, 0x7B, 0xC7, 0xF8, 0xEF, 0x00, 0x0F, 0x07,
  0xF3, 0xF9, 0xE2, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x71,
  0xFC, 0x7E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x0E, 0xE3, 0xFE,
  0x3F, 0xE7, 0x9E, 0x71, 0xCF, 0x1C, 0xE1, 0xCE, 0x1C, 0xE3, 0xCE, 0x38,
  0xF7, 0x8F, 0xF8, 0x7B, 0x80, 0x07, 0x07, 0xF3, 0xFD, 0xC7, 0x71, 0xF8,
  0xFF, 0xFB, 0xF8, 0xE0, 0x38, 0x0F, 0x11, 0xFC, 0x3F, 0x00, 0x00, 0x30,
  0x07, 0xC0, 0x7E, 0x03, 0x80, 0x1C, 0x01, 0xF8, 0x3F, 0xC1, 0xFC, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x7E, 0x03, 0xE0, 0x04,
  0x00, 0x07, 0x31, 0xFF, 0x1F, 0xF3, 0xCF, 0x38, 0xF7, 0x8E, 0x70, 0xE7,
  0x0E, 0x71, 0xE7, 0x1C, 0x7F, 0xC7, 0xFC, 0x3D, 0xC0, 0x3C, 0x03, 0x88,
  0x78, 0xFF, 0x0F, 0xE0, 0x10, 0x00, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0x1D, 0xC1, 0xFE, 0x3F, 0xF3, 0xCF, 0x3C, 0xF3, 0x8E, 0x38, 0xE7, 0x8E,
  0x70, 0xE7, 0x1E, 0x71, 0xC7, 0x1C, 0xF1, 0xC0, 0x04, 0x1C, 0x78, 0x60,
  0x03, 0x87, 0x1E, 0x38, 0x70, 0xE1, 0xC7, 0x8E, 0x1C, 0x38, 0x71, 0xE0,
  0x00, 0x80, 0x70, 0x3C, 0x06, 0x00, 0x00, 0xE0, 0x38, 0x1E, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0,
  0x70, 0x3C, 0x3E, 0x0F, 0x81, 0x00, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x01, 0xC7, 0x8E, 0x38, 0xF3, 0x87, 0x38, 0x3B, 0x81, 0xF8, 0x0F, 0xC0,
  0xFF, 0x07, 0xB8, 0x39, 0xC1, 0xCF, 0x0E, 0x38, 0xE1, 0xE0, 0x0E, 0x3C,
  0x78, 0xE1, 0xC3, 0x8F, 0x1C, 0x38, 0x70, 0xE3, 0xC7, 0x0E, 0x1C, 0x38,
  0xF0, 0x19, 0xC3, 0x06, 0xFB, 0xE3, 0xFF, 0xFC, 0xF3, 0xC7, 0x38, 0xF1,
  0xCE, 0x38, 0xF3, 0x8E, 0x39, 0xE3, 0x8E, 0x70, 0xE3, 0x9C, 0x70, 0xE7,
  0x1C, 0x79, 0xC7, 0x1C, 0xE1, 0xC7, 0x00, 0x19, 0xC1, 0xBE, 0x3F, 0xF3,
  0xCF, 0x3C, 0xF3, 0x8E, 0x38, 0xE7, 0x8E, 0x70, 0xE7, 0x1E, 0x71, 0xC7,
  0x1C, 0xF1, 0xC0, 0x0F, 0x07, 0xE3, 0xFD, 0xE7, 0x71, 0xFC, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0xFF, 0x79, 0xFC, 0x3E, 0x00, 0x0C, 0xE0, 0x6F, 0x87,
  0xFE, 0x3C, 0xF1, 0xC3, 0x8E, 0x3C, 0x71, 0xE7, 0x0E, 0x38, 0x71, 0xC7,
  0x8F, 0x78, 0x7F, 0x87, 0x78, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x38, 0x00, 0x0E, 0x67, 0xFC, 0xFF, 0xBC, 0xF7, 0x1D, 0xE3, 0xB8,
  0x77, 0x0E, 0xE1, 0xDC, 0x73, 0xDE, 0x7F, 0xC7, 0xB8, 0x0F, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x3C, 0x00, 0x19, 0xC6, 0xF3, 0xF8, 0xFA, 0x3C,
  0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x00, 0x0F,
  0x0F, 0xF3, 0xF9, 0xE2, 0x78, 0x0F, 0x03, 0xF0, 0x3C, 0x07, 0x81, 0xEC,
  0xF3, 0xFC, 0xFE, 0x00, 0x1C, 0x18, 0x3F, 0xFF, 0xFF, 0x78, 0x70, 0x70,
  0x70, 0x70, 0xF0, 0xE0, 0xF4, 0xFC, 0x7C, 0x38, 0xE7, 0x1D, 0xC3, 0xB8,
  0x77, 0x1E, 0xE3, 0xBC, 0x77, 0x0E, 0xE3, 0xDC, 0x73, 0xDE, 0x7F, 0xC7,
  0xB8, 0xE0, 0xFC, 0x3F, 0x87, 0x31, 0xE7, 0x38, 0xEF, 0x1D, 0xC3, 0xF8,
  0x7E, 0x0F, 0xC1, 0xF0, 0x3C, 0x07, 0x80, 0xE1, 0xC3, 0xF1, 0xE3, 0xB8,
  0xF1, 0xDC, 0x79, 0xC6, 0x7C, 0xE3, 0x36, 0x71, 0xBB, 0x70, 0xD9, 0xB8,
  0x6C, 0xF8, 0x3E, 0x7C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x0E, 0x00, 0x1C,
  0x38, 0xE3, 0x87, 0xBC, 0x1D, 0xC0, 0xFC, 0x07, 0xC0, 0x1E, 0x01, 0xF0,
  0x1F, 0x81, 0xFE, 0x0E, 0x70, 0xE3, 0x8F, 0x1E, 0x00, 0x1C, 0x1C, 0x70,
  0xF1, 0xE3, 0x83, 0x9E, 0x0E, 0x70, 0x3B, 0xC0, 0xEE, 0x03, 0xB8, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0xFC, 0x03, 0xE0, 0x04, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x81,
  0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xFE, 0x3F, 0xCF,
  0xF8, 0x07, 0xC1, 0xE0, 0xF0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x78,
  0x3C, 0x0F, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1F, 0x03,
  0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E,
  0x0F, 0x83, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x81, 0xC3, 0xE3,
  0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x78, 0x3C, 0x18, 0x00, 0x78, 0x3F,
  0xFF, 0x7F, 0xC1, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 16, 6, 0, -16 },
  { 15, 9, 6, 10, 2, -16 },
  { 22, 14, 16, 13, 0, -16 },
  { 50, 12, 18, 12, 0, -17 },
  { 77, 17, 17, 18, 1, -17 },
  { 114, 14, 17, 15, 0, -17 },
  { 144, 4, 6, 6, 2, -16 },
  { 147, 8, 20, 7, 1, -16 },
  { 167, 9, 21, 7, -2, -17 },
  { 191, 10, 11, 11, 2, -18 },
  { 205, 11, 11, 12, 1, -14 },
  { 221, 5, 6, 6, -1, -3 },
  { 225, 7, 3, 7, 0, -8 },
  { 228, 4, 4, 6, 0, -4 },
  { 230, 12, 17, 9, -1, -17 },
  { 256, 11, 17, 12, 1, -17 },
  { 280, 9, 16, 12, 2, -16 },
  { 298, 13, 17, 12, -1, -17 },
  { 326, 12, 17, 12, 0, -17 },
  { 352, 12, 16, 12, 0, -16 },
  { 376, 12, 16, 12, 0, -16 },
  { 400, 11, 17, 12, 1, -17 },
  { 424, 12, 16, 12, 1, -16 },
  { 448, 12, 17, 12, 0, -17 },
  { 474, 10, 17, 12, 1, -17 },
  { 496, 6, 13, 6, 0, -13 },
  { 506, 7, 16, 6, -1, -13 },
  { 520, 11, 12, 12, 1, -14 },
  { 537, 11, 7, 12, 1, -12 },
  { 547, 11, 12, 12, 1, -14 },
  { 564, 9, 17, 10, 1, -17 },
  { 584, 17, 18, 18, 1, -16 },
  { 623, 13, 16, 13, -1, -16 },
  { 649, 13, 16, 13, 0, -16 },
  { 675, 13, 17, 13, 1, -17 },
  { 703, 14, 16, 14, 0, -16 },
  { 731, 12, 16, 11, 0, -16 },
  { 755, 12, 16, 11, 0, -16 },
  { 779, 14, 17, 14, 1, -17 },
  { 809, 15, 16, 15, 0, -16 },
  { 839, 11, 16, 8, -1, -16 },
  { 861, 11, 21, 7, -4, -16 },
  { 890, 15, 16, 13, 0, -16 },
  { 920, 9, 16, 11, 0, -16 },
  { 938, 19, 16, 19, 0, -16 },
  { 976, 16, 16, 16, 0, -16 },
  { 1008, 14, 17, 15, 1, -17 },
  { 1038, 13, 16, 13, 0, -16 },
  { 1064, 14, 21, 15, 1, -17 },
  { 1101, 13, 16, 13, 0, -16 },
  { 1127, 12, 17, 11, 0, -17 },
  { 1153, 11, 16, 11, 2, -16 },
  { 1175, 14, 16, 14, 1, -16 },
  { 1203, 13, 16, 13, 2, -16 },
  { 1229, 19, 16, 19, 2, -16 },
  { 1267, 15, 16, 13, -1, -16 },
  { 1297, 12, 16, 12, 2, -16 },
  { 1321, 13, 16, 11, -1, -16 },
  { 1347, 10, 20, 7, -1, -16 },
  { 1372, 6, 17, 9, 2, -17 },
  { 1385, 10, 20, 7, -2, -16 },
  { 1410, 11, 10, 12, 0, -16 },
  { 1424, 9, 2, 9, -2, 2 },
  { 1427, 5, 4, 7, 3, -18 },
  { 1430, 11, 13, 13, 1, -13 },
  { 1448, 12, 17, 13, 0, -17 },
  { 1474, 10, 13, 10, 1, -13 },
  { 1491, 12, 17, 13, 1, -17 },
  { 1517, 10, 13, 12, 1, -13 },
  { 1534, 13, 24, 8, -3, -18 },
  { 1573, 12, 19, 13, 0, -13 },
  { 1602, 12, 17, 13, 0, -17 },
  { 1628, 7, 18, 6, 0, -18 },
  { 1644, 10, 24, 6, -3, -18 },
  { 1674, 13, 17, 12, 0, -17 },
  { 1702, 7, 17, 6, 0, -17 },
  { 1717, 18, 13, 19, 0, -13 },
  { 1747, 12, 13, 13, 0, -13 },
  { 1767, 10, 13, 12, 1, -13 },
  { 1784, 13, 19, 13, -1, -13 },
  { 1815, 11, 19, 13, 1, -13 },
  { 1842, 10, 13, 9, 0, -13 },
  { 1859, 10, 13, 10, 0, -13 },
  { 1876, 8, 15, 8, 1, -15 },
  { 1891, 11, 13, 13, 1, -13 },
  { 1909, 11, 13, 11, 1, -13 },
  { 1927, 17, 13, 17, 1, -13 },
  { 1955, 13, 13, 11, -1, -13 },
  { 1977, 14, 19, 11, -2, -13 },
  { 2011, 11, 13, 10, -1, -13 },
  { 2029, 10, 20, 8, 0, -16 },
  { 2054, 3, 23, 11, 4, -18 },
  { 2063, 9, 20, 8, -1, -16 },
  { 2086, 11, 4, 12, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC23PT7B_H_
