#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC17PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0x63, 0x19, 0xCC, 0x02, 0x39, 0xC0, 0xFF, 0x6D, 0xB6,
  0x0C, 0x83, 0x60, 0x99, 0xFF, 0x7F, 0xC6, 0xC1, 0x23, 0xFE, 0xFF, 0x89,
  0x86, 0x41, 0xB0, 0x02, 0x07, 0x07, 0xE7, 0xA3, 0x41, 0xC0, 0xF8, 0x1E,
  0x0F, 0x47, 0xBF, 0x9F, 0xC1, 0x00, 0x80, 0x78, 0x67, 0x8C, 0xC9, 0x8D,
  0x98, 0xDB, 0x0D, 0xEF, 0xF7, 0xB0, 0xDB, 0x19, 0xB1, 0x13, 0x31, 0xE6,
  0x1C, 0x0F, 0x03, 0xF0, 0x66, 0x0D, 0x81, 0xF0, 0x38, 0x4F, 0x33, 0x7E,
  0xE7, 0x9C, 0x61, 0xFE, 0x3E, 0xE0, 0xFB, 0x60, 0x0E, 0x30, 0x61, 0x83,
  0x0C, 0x18, 0x30, 0x61, 0xC3, 0x83, 0x06, 0x0C, 0x18, 0x00, 0x18, 0x70,
  0xC3, 0x0C, 0x30, 0xC7, 0x18, 0x63, 0x8C, 0x71, 0x8C, 0x00, 0x0C, 0x48,
  0x68, 0xFF, 0x3F, 0x7C, 0x6E, 0x08, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18,
  0x18, 0x18, 0x37, 0x6C, 0x7F, 0xFC, 0x5F, 0x80, 0x01, 0x81, 0x81, 0xC0,
  0xC0, 0xE0, 0x60, 0x70, 0x30, 0x30, 0x18, 0x18, 0x1C, 0x00, 0x1F, 0x1F,
  0x8C, 0xCE, 0x76, 0x33, 0x19, 0x8D, 0xCE, 0xE7, 0x33, 0x1F, 0x8F, 0x80,
  0x1C, 0xEF, 0xB6, 0x98, 0xE3, 0x0C, 0x31, 0xC7, 0x18, 0x0F, 0x87, 0xE1,
  0x1C, 0x06, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x18, 0x0C, 0x07, 0xF3, 0xFC,
  0x3F, 0x1F, 0x88, 0xE0, 0x60, 0x70, 0xE0, 0xF8, 0x0E, 0x07, 0x43, 0x3F,
  0x9F, 0x80, 0x03, 0x83, 0x83, 0xC3, 0x61, 0xF1, 0xB1, 0x99, 0x8C, 0xFF,
  0x07, 0x03, 0x01, 0x80, 0x1F, 0x9F, 0x8C, 0x06, 0x03, 0xC3, 0xF0, 0x9C,
  0x0E, 0x07, 0x43, 0x3F, 0x9F, 0x80, 0x1F, 0x3F, 0x70, 0x60, 0xFC, 0xFE,
  0xE6, 0xC6, 0xCE, 0xCE, 0xFC, 0x78, 0x7F, 0x7F, 0x07, 0x0E, 0x0C, 0x1C,
  0x18, 0x38, 0x30, 0x70, 0xE0, 0xC0, 0x1F, 0x1F, 0xCC, 0xE6, 0x73, 0xF0,
  0xF0, 0xF8, 0xCE, 0xE3, 0x73, 0x9F, 0x8F, 0x80, 0x1F, 0x3F, 0x73, 0x63,
  0x63, 0x77, 0x7F, 0x3F, 0x06, 0x0E, 0xFC, 0xF8, 0x33, 0x00, 0x00, 0x4E,
  0xE0, 0x18, 0xC0, 0x00, 0x00, 0x0E, 0x63, 0x30, 0x03, 0x0F, 0x3C, 0xE0,
  0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xF0,
  0x3C, 0x0F, 0x0F, 0x7C, 0xE0, 0x80, 0xFC, 0xFC, 0x38, 0x61, 0xC7, 0x1C,
  0x30, 0x00, 0x83, 0x86, 0x00, 0x0F, 0xC1, 0x86, 0x30, 0x36, 0x7B, 0xCD,
  0xBD, 0x9B, 0x99, 0x39, 0x33, 0x9B, 0x69, 0xDC, 0xC0, 0x06, 0x08, 0x7F,
  0x00, 0x03, 0x81, 0xE0, 0x78, 0x36, 0x0D, 0x86, 0x61, 0x98, 0xFE, 0x3F,
  0x9C, 0x66, 0x1F, 0x87, 0x1F, 0x8F, 0xE3, 0x9C, 0xC6, 0x33, 0x8F, 0xC7,
  0xF1, 0xCE, 0x63, 0x98, 0xC7, 0xF3, 0xF8, 0x1F, 0x9F, 0xDC, 0x2C, 0x0E,
  0x07, 0x03, 0x01, 0x80, 0xC0, 0x71, 0x1F, 0x8F, 0xC0, 0x1F, 0x0F, 0xE3,
  0x9C, 0xE3, 0x30, 0xCC, 0x37, 0x1D, 0xC7, 0x63, 0x99, 0xE7, 0xF3, 0xF0,
  0x1F, 0x9F, 0xCE, 0x07, 0x03, 0x01, 0xF9, 0xF8, 0xE0, 0x60, 0x30, 0x1F,
  0x9F, 0xC0, 0x1F, 0x9F, 0xCE, 0x07, 0x03, 0x01, 0xF9, 0xF8, 0xE0, 0x60,
  0x30, 0x18, 0x1C, 0x00, 0x1F, 0xCF, 0xE7, 0x09, 0xC0, 0xE0, 0x39, 0xEC,
  0x7B, 0x2E, 0xC3, 0x38, 0xC7, 0xF0, 0xFC, 0x18, 0x67, 0x1C, 0xE3, 0x9C,
  0x63, 0x0C, 0x7F, 0x9F, 0xF3, 0x8E, 0x61, 0x8C, 0x31, 0x8E, 0x71, 0xC0,
  0x1F, 0x1E, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x7C, 0xFC,
  0x03, 0x03, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C,
  0x1C, 0xF8, 0xF8, 0x60, 0x18, 0xE7, 0x38, 0xEE, 0x1B, 0x83, 0x60, 0x7C,
  0x1F, 0x83, 0xB0, 0x66, 0x0C, 0xE1, 0x9C, 0x71, 0xC0, 0x18, 0x70, 0xE1,
  0x83, 0x06, 0x1C, 0x38, 0x60, 0xC1, 0xFF, 0xF0, 0x1C, 0x3C, 0xF0, 0xF3,
  0xC7, 0xCF, 0x1E, 0x3C, 0x58, 0xF3, 0x67, 0xCF, 0x9B, 0x6C, 0x65, 0xB1,
  0x9C, 0xC6, 0x73, 0x39, 0x9C, 0x1C, 0x33, 0xC7, 0x3C, 0x63, 0xE6, 0x36,
  0x63, 0x6E, 0x76, 0xC6, 0x7C, 0x63, 0xC6, 0x3C, 0x63, 0xCE, 0x38, 0x1F,
  0x8F, 0xE7, 0x1D, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x06, 0xC3, 0xB9, 0xCF,
  0xF1, 0xF0, 0x1F, 0x8F, 0xE3, 0x9C, 0xC7, 0x31, 0xCC, 0xE7, 0xF1, 0xF0,
  0x60, 0x18, 0x06, 0x03, 0x80, 0x1F, 0x8F, 0xE7, 0x1D, 0x87, 0xE1, 0xF8,
  0x7C, 0x1F, 0x06, 0xC3, 0xB9, 0xC7, 0xF1, 0xF0, 0x0E, 0x03, 0x80, 0x70,
  0x1F, 0x1F, 0xCE, 0x66, 0x33, 0x19, 0xFD, 0xF8, 0xEC, 0x66, 0x33, 0x98,
  0xDC, 0x70, 0x1F, 0x9F, 0x8C, 0x06, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x06,
  0x47, 0x3F, 0x9F, 0x80, 0x7F, 0xFF, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30,
  0x30, 0x70, 0x70, 0x60, 0x31, 0xDC, 0x77, 0x19, 0x86, 0x61, 0x98, 0xEE,
  0x3B, 0x8C, 0xC3, 0x39, 0xCF, 0xE1, 0xF0, 0xC3, 0xE1, 0xB1, 0x98, 0xCC,
  0xE6, 0x63, 0x71, 0xB0, 0xF8, 0x78, 0x3C, 0x1C, 0x00, 0xC7, 0x1F, 0x1C,
  0xEC, 0xF3, 0x33, 0xCC, 0xDB, 0x73, 0x6D, 0x8D, 0xBE, 0x3C, 0xF0, 0xF3,
  0xC3, 0x8E, 0x0E, 0x38, 0x30, 0xE0, 0x18, 0xF1, 0xCC, 0x0D, 0xC0, 0xD8,
  0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x3B, 0x03, 0x38, 0x73, 0x8E, 0x18,
  0xC7, 0xC6, 0xCE, 0xEC, 0x78, 0x78, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xE0,
  0x1F, 0xC7, 0xF0, 0x38, 0x0C, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x1C,
  0x07, 0xF3, 0xFC, 0x1E, 0x78, 0xC1, 0x83, 0x06, 0x18, 0x30, 0x60, 0xC3,
  0x86, 0x0C, 0x1E, 0x38, 0x00, 0xCC, 0xCC, 0xE6, 0x66, 0x66, 0x67, 0x1E,
  0x38, 0x30, 0x60, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0xE1, 0x83, 0x1E, 0x3C,
  0x00, 0x04, 0x0E, 0x1E, 0x1E, 0x33, 0x63, 0x63, 0xC1, 0xFE, 0xE6, 0x30,
  0x3B, 0x7F, 0xE7, 0xC6, 0xC6, 0xC6, 0xCE, 0xFC, 0xFC, 0x18, 0x0C, 0x0E,
  0x06, 0x03, 0xF1, 0xFC, 0xCE, 0xE7, 0x63, 0xB1, 0x99, 0xDF, 0xCD, 0xC0,
  0x3E, 0xFB, 0x86, 0x0C, 0x18, 0x30, 0x7C, 0x78, 0x03, 0x81, 0xC0, 0xC0,
  0x63, 0xB3, 0xFB, 0x9D, 0x8C, 0xC6, 0x63, 0x33, 0x9F, 0x8F, 0xC0, 0x3E,
  0xEF, 0x9E, 0x7F, 0xD8, 0x30, 0x7E, 0x7C, 0x03, 0xC1, 0xE0, 0x60, 0x1A,
  0x1F, 0x07, 0xC0, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E,
  0x03, 0x83, 0xC0, 0xE0, 0x00, 0x1D, 0x9F, 0xDC, 0xEC, 0x66, 0x33, 0x39,
  0x9C, 0xFC, 0x76, 0x03, 0x23, 0x9F, 0x8F, 0x80, 0x18, 0x0C, 0x0E, 0x06,
  0x03, 0xF1, 0xFC, 0xCE, 0xE6, 0x63, 0x31, 0x99, 0xDC, 0xEE, 0x60, 0x19,
  0xC4, 0x13, 0x18, 0xCE, 0x73, 0x19, 0xCE, 0x00, 0x06, 0x0C, 0x10, 0x10,
  0xC1, 0x83, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x78, 0xE0, 0x18,
  0x06, 0x03, 0x80, 0xC1, 0x33, 0x8D, 0xC3, 0x61, 0xF0, 0x7C, 0x1F, 0x86,
  0xE3, 0x98, 0xE7, 0x00, 0x18, 0xCE, 0x73, 0x18, 0xCE, 0x63, 0x19, 0xCE,
  0x00, 0x3F, 0x79, 0xFF, 0xCC, 0xE6, 0xE6, 0x36, 0x33, 0xB1, 0x9D, 0x9C,
  0xDC, 0xE6, 0xE6, 0x30, 0x3F, 0x1F, 0xCC, 0xEE, 0x66, 0x33, 0x19, 0x8D,
  0xCE, 0xE6, 0x00, 0x3E, 0xFF, 0x9E, 0x3C, 0x78, 0xF3, 0xFE, 0x78, 0x1F,
  0x87, 0x71, 0x9C, 0xE7, 0x31, 0x8C, 0x63, 0x39, 0xFC, 0x7E, 0x18, 0x06,
  0x01, 0x80, 0xE0, 0x00, 0x3F, 0x7F, 0xE7, 0xC6, 0xC6, 0xC6, 0xCE, 0xFC,
  0xFC, 0x0C, 0x1C, 0x1C, 0x18, 0x3E, 0x7C, 0xC3, 0x86, 0x0C, 0x18, 0x70,
  0xE0, 0x3E, 0xED, 0xC3, 0xC3, 0xC3, 0x83, 0x7E, 0xF8, 0x30, 0xCF, 0xFE,
  0x63, 0x8E, 0x30, 0xC3, 0xCF, 0x00, 0x63, 0x67, 0xE7, 0xE6, 0xC6, 0xC6,
  0xCE, 0xFE, 0xFC, 0xC7, 0xC6, 0xCE, 0xCC, 0xDC, 0xD8, 0x78, 0x70, 0x60,
  0xCE, 0x7C, 0xE6, 0xCA, 0x6D, 0xAC, 0xDE, 0xCF, 0x7C, 0xF7, 0x8E, 0x78,
  0xE7, 0x00, 0x39, 0xC6, 0xE1, 0xB0, 0x38, 0x0E, 0x07, 0x83, 0xE1, 0xDC,
  0xE3, 0x00, 0x31, 0xCC, 0x63, 0x38, 0xCC, 0x3F, 0x07, 0x81, 0xE0, 0x70,
  0x1C, 0x06, 0x03, 0x83, 0xC0, 0xE0, 0x00, 0x3E, 0xFC, 0x30, 0xC3, 0x8E,
  0x18, 0x7E, 0xFC, 0x0E, 0x3C, 0x60, 0xC1, 0x87, 0x3C, 0x70, 0x70, 0x61,
  0x83, 0x06, 0x0E, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x38,
  0x30, 0x61, 0x83, 0x07, 0x87, 0x18, 0x60, 0xC1, 0x87, 0x1C, 0x30, 0x00,
  0xFB, 0xBF,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 12, 5, 0, -12 },
  { 9, 6, 4, 7, 2, -12 },
  { 12, 10, 12, 10, 0, -12 },
  { 27, 9, 14, 9, 0, -13 },
  { 43, 12, 12, 14, 1, -12 },
  { 61, 11, 12, 11, 0, -12 },
  { 78, 3, 4, 4, 2, -12 },
  { 80, 7, 15, 5, 0, -12 },
  { 94, 6, 15, 5, -1, -12 },
  { 106, 8, 8, 8, 1, -13 },
  { 114, 8, 8, 9, 1, -10 },
  { 122, 4, 4, 5, -1, -2 },
  { 124, 5, 3, 5, 0, -6 },
  { 126, 3, 3, 5, 0, -3 },
  { 128, 9, 12, 7, -1, -12 },
  { 142, 9, 12, 9, 0, -12 },
  { 156, 6, 12, 9, 2, -12 },
  { 165, 10, 12, 9, -1, -12 },
  { 180, 9, 12, 9, 0, -12 },
  { 194, 9, 12, 9, 0, -12 },
  { 208, 9, 12, 9, 0, -12 },
  { 222, 8, 12, 9, 1, -12 },
  { 234, 8, 12, 9, 1, -12 },
  { 246, 9, 12, 9, 0, -12 },
  { 260, 8, 12, 9, 0, -12 },
  { 272, 4, 9, 5, 0, -9 },
  { 277, 5, 11, 5, -1, -9 },
  { 284, 8, 8, 9, 1, -10 },
  { 292, 8, 6, 9, 1, -9 },
  { 298, 8, 8, 9, 1, -10 },
  { 306, 7, 12, 7, 1, -12 },
  { 317, 12, 13, 13, 1, -12 },
  { 337, 10, 12, 10, -1, -12 },
  { 352, 10, 12, 10, 0, -12 },
  { 367, 9, 12, 9, 1, -12 },
  { 381, 10, 12, 10, 0, -12 },
  { 396, 9, 12, 8, 0, -12 },
  { 410, 9, 12, 8, 0, -12 },
  { 424, 10, 12, 11, 1, -12 },
  { 439, 11, 12, 11, 0, -12 },
  { 456, 8, 12, 6, -1, -12 },
  { 468, 8, 16, 5, -3, -12 },
  { 484, 11, 12, 9, 0, -12 },
  { 501, 7, 12, 8, 0, -12 },
  { 512, 14, 12, 14, 0, -12 },
  { 533, 12, 12, 12, 0, -12 },
  { 551, 10, 12, 11, 1, -12 },
  { 566, 10, 12, 9, 0, -12 },
  { 581, 10, 15, 11, 1, -12 },
  { 600, 9, 12, 10, 0, -12 },
  { 614, 9, 12, 8, 0, -12 },
  { 628, 8, 12, 8, 1, -12 },
  { 640, 10, 12, 11, 1, -12 },
  { 655, 9, 12, 9, 2, -12 },
  { 669, 14, 12, 14, 2, -12 },
  { 690, 12, 12, 9, -1, -12 },
  { 708, 8, 12, 9, 2, -12 },
  { 720, 10, 12, 8, -1, -12 },
  { 735, 7, 15, 5, 0, -12 },
  { 749, 4, 12, 7, 2, -12 },
  { 755, 7, 15, 5, -1, -12 },
  { 769, 8, 8, 9, 0, -12 },
  { 777, 7, 1, 6, -2, 2 },
  { 778, 4, 3, 5, 2, -13 },
  { 780, 8, 9, 9, 1, -9 },
  { 789, 9, 13, 9, 0, -13 },
  { 804, 7, 9, 8, 1, -9 },
  { 812, 9, 13, 9, 1, -13 },
  { 827, 7, 9, 9, 1, -9 },
  { 835, 10, 17, 6, -2, -13 },
  { 857, 9, 13, 9, 0, -9 },
  { 872, 9, 13, 9, 0, -13 },
  { 887, 5, 13, 5, 0, -13 },
  { 896, 7, 17, 5, -2, -13 },
  { 911, 10, 13, 9, 0, -13 },
  { 928, 5, 13, 5, 0, -13 },
  { 937, 13, 9, 14, 0, -9 },
  { 952, 9, 9, 9, 0, -9 },
  { 963, 7, 9, 9, 1, -9 },
  { 971, 10, 13, 9, -1, -9 },
  { 988, 8, 13, 9, 1, -9 },
  { 1001, 7, 9, 7, 0, -9 },
  { 1009, 7, 9, 7, 0, -9 },
  { 1017, 6, 11, 6, 1, -11 },
  { 1026, 8, 9, 9, 1, -9 },
  { 1035, 8, 9, 8, 1, -9 },
  { 1044, 12, 9, 12, 1, -9 },
  { 1058, 10, 9, 8, -1, -9 },
  { 1070, 10, 13, 8, -1, -9 },
  { 1087, 7, 9, 7, 0, -9 },
  { 1095, 7, 15, 6, 0, -12 },
  { 1109, 2, 17, 8, 3, -13 },
  { 1114, 7, 15, 6, -1, -12 },
  { 1128, 8, 2, 9, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC17PT7B_H_
