#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC24PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xE1, 0xC3, 0x8F, 0x1C, 0x38, 0x70, 0xE0, 0x00,
  0x04, 0x3C, 0x78, 0xF0, 0x73, 0xB9, 0xDD, 0xCC, 0xE6, 0x77, 0x30, 0x03,
  0x98, 0x0C, 0xE0, 0x33, 0x81, 0xCC, 0x06, 0x30, 0xFF, 0xF3, 0xFF, 0xC3,
  0x98, 0x0C, 0xE0, 0x33, 0x0F, 0xFF, 0xBF, 0xFE, 0x19, 0xC0, 0xE6, 0x03,
  0x18, 0x0C, 0xE0, 0x73, 0x00, 0x00, 0x80, 0x08, 0x0F, 0xF1, 0xFF, 0x1F,
  0x63, 0xD0, 0x3D, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x7E, 0x06,
  0xE4, 0x4E, 0xFF, 0xEF, 0xFC, 0x7F, 0x00, 0xC0, 0x08, 0x00, 0x1E, 0x07,
  0x1F, 0x87, 0x1D, 0xC7, 0x0E, 0xE3, 0x06, 0x73, 0x87, 0x3B, 0x83, 0x9D,
  0x89, 0xDD, 0xDF, 0x7F, 0xDF, 0xBE, 0xDC, 0xC0, 0xEE, 0x60, 0xE7, 0x30,
  0x63, 0x38, 0x71, 0x9C, 0x70, 0xCC, 0x30, 0x7E, 0x38, 0x1E, 0x00, 0x03,
  0xE0, 0x0F, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xDE, 0x03, 0xF8,
  0x07, 0xC0, 0x1F, 0x8E, 0x7F, 0x39, 0xEF, 0x73, 0x8F, 0xCF, 0x1F, 0x9E,
  0x1E, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0x3C, 0x77, 0x76, 0x6E, 0x07, 0x0E,
  0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x70, 0x07, 0x03, 0x80, 0xC0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x38,
  0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x0E, 0x00, 0x07, 0x01, 0x84, 0x63, 0xF9,
  0xFF, 0xC7, 0xF3, 0xE1, 0xFC, 0x77, 0x08, 0xE0, 0x20, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x00, 0x39, 0xDC, 0xEE, 0x70, 0x7E, 0xFF, 0xF0, 0x2F, 0xFF, 0x00, 0x78,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x00, 0x0F, 0xC3, 0xF8, 0xFF, 0x9C, 0x77, 0x8E, 0xE1, 0xFC, 0x3F,
  0x8F, 0xE1, 0xFC, 0x3F, 0x87, 0x71, 0xEE, 0x3D, 0xCF, 0x3F, 0xE7, 0xF8,
  0x7E, 0x00, 0x07, 0x87, 0xC7, 0xEF, 0xEF, 0x73, 0x38, 0x3C, 0x1C, 0x0E,
  0x07, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x00, 0x07, 0xF0,
  0x7F, 0x87, 0xFE, 0x18, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xFF, 0x8F, 0xFC,
  0xFF, 0xE0, 0x0F, 0xE1, 0xFF, 0x1F, 0xF1, 0x07, 0x00, 0xF0, 0x0F, 0x01,
  0xE0, 0xFC, 0x0F, 0x81, 0xFC, 0x01, 0xE0, 0x1E, 0x01, 0xE8, 0x1E, 0xFF,
  0xCF, 0xF8, 0xFF, 0x00, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xE0,
  0xEE, 0x0D, 0xE1, 0xDC, 0x39, 0xC7, 0x1C, 0x61, 0xCF, 0xFF, 0xFF, 0xE0,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x0F, 0xF0, 0xFF, 0x1F, 0xF1, 0xC0,
  0x1C, 0x01, 0xC0, 0x3F, 0x03, 0xFC, 0x3F, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE8, 0x3C, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0xFE, 0x1F,
  0x23, 0xC0, 0x38, 0x07, 0x00, 0x77, 0x8F, 0xFC, 0xFF, 0xCF, 0x1C, 0xE1,
  0xCE, 0x1C, 0xE1, 0xCE, 0x3C, 0xFF, 0x87, 0xF0, 0x3E, 0x00, 0x3F, 0xF7,
  0xFF, 0x7F, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xF0, 0x00,
  0x07, 0xE0, 0xFF, 0x1E, 0xF1, 0xC7, 0x1C, 0x71, 0xCF, 0x1F, 0xE0, 0xFC,
  0x1F, 0x83, 0xFC, 0x79, 0xE7, 0x0E, 0xF0, 0xEF, 0x1E, 0x7B, 0xC7, 0xFC,
  0x3F, 0x80, 0x1F, 0x87, 0xF9, 0xFF, 0xB8, 0xF7, 0x0F, 0xE3, 0xFC, 0x7F,
  0x8F, 0x7F, 0xEF, 0xF8, 0xF7, 0x01, 0xE0, 0x38, 0x0F, 0x3F, 0xC7, 0xF0,
  0xFC, 0x00, 0x1C, 0xF3, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x8F, 0x3C, 0xF0,
  0x0E, 0x3C, 0x78, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0xC7, 0x0E,
  0x38, 0x70, 0x00, 0x20, 0x0C, 0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x3C, 0x07,
  0xE0, 0x3F, 0x80, 0xFC, 0x07, 0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x80, 0x1C, 0x03, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x78, 0x3F, 0x1F, 0x9F, 0xC3, 0xC0, 0x60, 0x00, 0x3F, 0x9F,
  0xE3, 0xFD, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x78, 0x1C, 0x0E, 0x03, 0x80,
  0x00, 0x00, 0x08, 0x07, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xFC, 0x01, 0xFF,
  0xC0, 0xE0, 0x70, 0x70, 0x0E, 0x38, 0x61, 0x9C, 0x7E, 0x66, 0x39, 0x9D,
  0x9C, 0xE6, 0xE6, 0x31, 0xB3, 0x8C, 0x6C, 0xE7, 0x3B, 0x39, 0xCC, 0xCF,
  0xFF, 0x39, 0xEF, 0x8E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x10, 0x0F, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x03,
  0x98, 0x1C, 0xE1, 0xC7, 0x0E, 0x38, 0xF1, 0xC7, 0xFE, 0x7F, 0xF3, 0xFF,
  0xBC, 0x1D, 0xC0, 0xFE, 0x07, 0xE0, 0x38, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF,
  0x87, 0x8F, 0x1C, 0x38, 0x70, 0xE1, 0xCF, 0x8F, 0xF8, 0x3F, 0xE0, 0xE7,
  0xC3, 0x87, 0x0E, 0x1C, 0x78, 0x71, 0xC3, 0xC7, 0xFE, 0x1F, 0xF8, 0xFF,
  0x80, 0x07, 0xF8, 0x7F, 0xC7, 0xFC, 0x7C, 0x23, 0xC0, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x21,
  0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0xE1, 0xFF, 0x87, 0x8F,
  0x1E, 0x3C, 0x70, 0x71, 0xC1, 0xCF, 0x07, 0x3C, 0x3C, 0xE0, 0xF3, 0x83,
  0xCE, 0x1E, 0x78, 0x79, 0xE7, 0xC7, 0xFE, 0x1F, 0xF0, 0xFF, 0x00, 0x0F,
  0xF8, 0x7F, 0x87, 0xFC, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0xFC,
  0x3F, 0xE1, 0xFE, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xFF, 0x0F,
  0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0x87, 0xFC, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0xFC, 0x3F, 0xC1, 0xFE, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xF1, 0xFF,
  0x8F, 0x82, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x7E, 0xF1, 0xFB, 0xC7,
  0xEF, 0x07, 0xBC, 0x1C, 0xF0, 0x71, 0xE3, 0xC7, 0xFF, 0x0F, 0xF8, 0x1F,
  0xE0, 0x0E, 0x0F, 0x0E, 0x0E, 0x1E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C,
  0x1E, 0x1C, 0x1C, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x38, 0x38, 0x38,
  0x38, 0x78, 0x38, 0x78, 0x78, 0x70, 0x78, 0x70, 0x70, 0xF0, 0x70, 0x0F,
  0xE3, 0xFC, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01,
  0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x87, 0xF8, 0xFF, 0x00, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07,
  0x00, 0xF0, 0x0F, 0x0F, 0xE0, 0xFC, 0x0F, 0x80, 0x0E, 0x1F, 0x0E, 0x3C,
  0x1E, 0x3C, 0x1E, 0x78, 0x1C, 0xF0, 0x1D, 0xE0, 0x1D, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x39, 0xC0, 0x79, 0xE0, 0x71, 0xE0,
  0x70, 0xE0, 0x70, 0xF0, 0xF0, 0xF0, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C,
  0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07,
  0xFD, 0xFE, 0xFF, 0x80, 0x0F, 0x01, 0xF0, 0xF8, 0x3F, 0x1F, 0x83, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xEE, 0x1F, 0x8F, 0xC3, 0xB9, 0xDC,
  0x3B, 0x9D, 0xC3, 0xB9, 0x9C, 0x3B, 0xBB, 0xC3, 0xBB, 0x38, 0x73, 0xF3,
  0x87, 0x3E, 0x38, 0x71, 0xE3, 0x87, 0x1C, 0x78, 0xF1, 0xC7, 0x00, 0x0F,
  0x03, 0x87, 0x83, 0x87, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x78,
  0x77, 0x38, 0x73, 0x9C, 0x39, 0xCE, 0x1C, 0xE7, 0x0E, 0x3F, 0x87, 0x1F,
  0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC1, 0xF0, 0xE0, 0xF0, 0xF0, 0x78, 0x00,
  0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0x0F, 0x3C, 0x1D, 0xE0, 0x77, 0x81,
  0xDC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x79, 0xC3,
  0xC7, 0xFF, 0x0F, 0xF8, 0x1F, 0x80, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0x87,
  0x8F, 0x1C, 0x3C, 0x70, 0xF1, 0xC3, 0x8F, 0x1E, 0x3F, 0xF0, 0xFF, 0x83,
  0xFC, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0x0F, 0x3C, 0x1D, 0xE0, 0x77, 0x81,
  0xDC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x79, 0xC3,
  0xC7, 0xFF, 0x0F, 0xF8, 0x1F, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x0F, 0xE0, 0x7F, 0x87, 0xFE, 0x3C, 0x71, 0xC3, 0x8E, 0x1C, 0x71,
  0xE7, 0x9E, 0x3F, 0xF1, 0xFE, 0x0E, 0x70, 0x73, 0x87, 0x9E, 0x3C, 0xF1,
  0xC3, 0x8E, 0x1E, 0xF0, 0xF0, 0x07, 0xF1, 0xFF, 0x1F, 0xE3, 0xC2, 0x3C,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1C, 0x01,
  0xC8, 0x3C, 0xFF, 0xCF, 0xF8, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x1E, 0x38, 0x38, 0xF0,
  0xF1, 0xE1, 0xE3, 0x83, 0xC7, 0x07, 0x1E, 0x0E, 0x3C, 0x3C, 0x78, 0x78,
  0xE0, 0xE1, 0xC1, 0xC7, 0x83, 0x8F, 0x0F, 0x1E, 0x1C, 0x1F, 0xF8, 0x3F,
  0xE0, 0x3F, 0x80, 0xE0, 0x7F, 0x83, 0xBC, 0x3D, 0xE1, 0xCF, 0x0E, 0x78,
  0xE1, 0xC7, 0x0E, 0x78, 0x73, 0x83, 0xBC, 0x1D, 0xC0, 0xFE, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x00, 0xE0, 0xE0, 0xFE, 0x0E, 0x0E,
  0xE1, 0xE1, 0xEE, 0x1E, 0x1C, 0xE1, 0xF1, 0xCE, 0x3F, 0x3C, 0xE3, 0x73,
  0x8E, 0x77, 0x78, 0xE7, 0x77, 0x0E, 0xE7, 0x70, 0xEE, 0x7E, 0x0E, 0xC6,
  0xE0, 0xFC, 0x6E, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0x80, 0xF0,
  0x78, 0x00, 0x0E, 0x0F, 0x0F, 0x1E, 0x0F, 0x3C, 0x07, 0x38, 0x07, 0x78,
  0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xE0,
  0x1E, 0xE0, 0x1C, 0xE0, 0x3C, 0xF0, 0x78, 0xF0, 0x70, 0x70, 0xF0, 0x78,
  0xF0, 0xFB, 0x87, 0x1C, 0x78, 0xE3, 0x87, 0x3C, 0x3F, 0xC0, 0xFC, 0x07,
  0xE0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x00, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0x80, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x07, 0xFE, 0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0xC3,
  0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0xC1, 0xF0, 0xFC,
  0x00, 0xE7, 0x39, 0xCE, 0x73, 0x8E, 0x73, 0x9C, 0xE7, 0x18, 0xE7, 0x38,
  0x07, 0xC3, 0xF0, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x07, 0xC1,
  0xF0, 0xFC, 0x00, 0x01, 0x80, 0x38, 0x07, 0xC0, 0x7C, 0x0E, 0xC1, 0xCC,
  0x1C, 0xE3, 0x8E, 0x30, 0x67, 0x07, 0xE0, 0x70, 0xFF, 0xFF, 0xC0, 0xF3,
  0xCE, 0x1F, 0x73, 0xF7, 0x7F, 0xE7, 0x9E, 0x70, 0xEF, 0x1E, 0xF1, 0xEE,
  0x1C, 0xE1, 0xCE, 0x3C, 0xFF, 0xCF, 0xD8, 0x7B, 0x80, 0x0E, 0x00, 0xE0,
  0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xDE, 0x1F, 0xF3, 0xEF, 0x3C, 0x73, 0x87,
  0x38, 0x73, 0x87, 0x78, 0xF7, 0x8F, 0x79, 0xE7, 0xFE, 0xEF, 0xCE, 0xF8,
  0x1F, 0xCF, 0xF7, 0xD9, 0xE0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x3C,
  0x4F, 0xF1, 0xFC, 0x3F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x0F, 0xF8, 0xFF, 0xCF, 0xBC, 0x79, 0xE3, 0x87, 0x3C, 0x79, 0xC3,
  0x8E, 0x1C, 0x70, 0xE3, 0x8F, 0x1F, 0xF8, 0xFF, 0x83, 0xCC, 0x00, 0x0F,
  0xC7, 0xF8, 0xE7, 0xB8, 0xF7, 0x1D, 0xFF, 0xBF, 0xE7, 0xC0, 0xE0, 0x1C,
  0x03, 0xC6, 0x3F, 0xC3, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x1E, 0x80, 0x70,
  0x01, 0xC0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x03, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0x0F,
  0xB8, 0xFD, 0xCF, 0xFC, 0x79, 0xE3, 0x87, 0x3C, 0x79, 0xE3, 0xCE, 0x1C,
  0x70, 0xE3, 0x8F, 0x1F, 0xF8, 0xFF, 0x83, 0xDC, 0x00, 0xE0, 0x0F, 0x10,
  0x70, 0xFF, 0x87, 0xF8, 0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x1C, 0x01, 0xDE, 0x1F, 0xF3, 0xFF, 0x3C, 0x73, 0xC7, 0x38, 0x73, 0x8F,
  0x78, 0xF7, 0x8E, 0x70, 0xE7, 0x0E, 0x71, 0xEF, 0x1C, 0x0E, 0x1C, 0x38,
  0x00, 0x03, 0x87, 0x1E, 0x3C, 0x70, 0xE1, 0xC7, 0x8F, 0x1C, 0x38, 0xF1,
  0xE0, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x1E, 0x07,
  0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81,
  0xE0, 0x70, 0x3C, 0x3F, 0x0F, 0x83, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x04, 0x71, 0xE1, 0xCF, 0x0F, 0x38, 0x3D, 0xC0, 0xEE,
  0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x81, 0xEE, 0x07, 0x3C, 0x1C, 0x70, 0x71,
  0xE3, 0xC7, 0x80, 0x0E, 0x1C, 0x78, 0xF1, 0xC3, 0x87, 0x1E, 0x3C, 0x70,
  0xE1, 0xC7, 0x8F, 0x1C, 0x38, 0xF1, 0xE0, 0x1D, 0xE7, 0xC3, 0x7F, 0xF8,
  0xFF, 0xFF, 0x9E, 0x3C, 0xF3, 0xC7, 0x1E, 0x71, 0xE3, 0x8E, 0x3C, 0x73,
  0xC7, 0x0E, 0x70, 0xE3, 0xCE, 0x1C, 0x79, 0xC7, 0x8E, 0x38, 0xE1, 0xCF,
  0x1C, 0x78, 0x1D, 0xE1, 0xBF, 0x3F, 0xF3, 0xC7, 0x3C, 0x73, 0x87, 0x38,
  0xF7, 0x8E, 0x78, 0xE7, 0x0E, 0x70, 0xE7, 0x1E, 0xF1, 0xC0, 0x1F, 0x87,
  0xF9, 0xFF, 0xBC, 0xFF, 0x0F, 0xE1, 0xF8, 0x7F, 0x0F, 0xE1, 0xDC, 0x7B,
  0xFE, 0x3F, 0xC3, 0xE0, 0x0E, 0xF0, 0x6F, 0xC7, 0xDE, 0x3C, 0x71, 0xC3,
  0x8E, 0x1C, 0x70, 0xE7, 0x8F, 0x3C, 0x71, 0xE7, 0x8F, 0xFC, 0x7F, 0xC7,
  0xBC, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x00, 0x1F,
  0x73, 0xFF, 0x7F, 0xE7, 0x9E, 0x70, 0xEF, 0x1E, 0xE1, 0xEE, 0x1C, 0xE1,
  0xCE, 0x3C, 0xFF, 0xCF, 0xF8, 0x7B, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x1D, 0xC7, 0xF3, 0xFC, 0xF8, 0x3C, 0x0E, 0x03,
  0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x00, 0x1F, 0xCF, 0xF3,
  0x88, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x81, 0xEE, 0xFB, 0xFC,
  0xFE, 0x00, 0x0C, 0x1C, 0x1C, 0x7F, 0xFF, 0x38, 0x78, 0x78, 0x70, 0x70,
  0x70, 0xF0, 0xF0, 0xFC, 0xFC, 0x7C, 0x38, 0x73, 0x8F, 0x78, 0xE7, 0x0E,
  0x70, 0xE7, 0x1E, 0xF1, 0xEF, 0x1C, 0xE1, 0xCE, 0x3C, 0xFF, 0xCF, 0xDC,
  0x79, 0x80, 0xF0, 0xFF, 0x1E, 0x71, 0xC7, 0x3C, 0x73, 0x87, 0x78, 0x77,
  0x07, 0x70, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x00, 0xF1, 0xE3,
  0xDC, 0xF8, 0xE7, 0x3E, 0x71, 0xCF, 0x9C, 0x77, 0xEF, 0x1D, 0xBB, 0x87,
  0xEE, 0xE1, 0xFB, 0xF0, 0x6C, 0xFC, 0x1F, 0x3E, 0x07, 0x8F, 0x81, 0xE3,
  0xC0, 0x78, 0xF0, 0x00, 0x1C, 0x3C, 0x79, 0xE0, 0xEF, 0x03, 0xB8, 0x0F,
  0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0xC0, 0xF7, 0x03, 0x9C, 0x1E,
  0x78, 0xF1, 0xE0, 0x1E, 0x1E, 0x3C, 0x78, 0x38, 0xE0, 0x73, 0xC0, 0xE7,
  0x01, 0xCE, 0x03, 0xB8, 0x07, 0x70, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0x80, 0x00, 0x1F, 0xF1, 0xFE, 0x1F, 0xE0, 0x3C, 0x03, 0x80, 0x78,
  0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x7F, 0xC7, 0xF8, 0xFF, 0x80, 0x03,
  0xC1, 0xF0, 0x78, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x3C, 0x3E, 0x0F,
  0x03, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xF0,
  0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0E,
  0x0F, 0x87, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x03, 0xC0, 0xE1,
  0xF1, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x3E, 0x1E, 0x0C, 0x00, 0xFE,
  0x3F, 0xFF, 0x1F, 0xC0, 0x40,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 17, 7, 0, -17 },
  { 16, 9, 6, 10, 2, -17 },
  { 23, 14, 17, 14, 0, -17 },
  { 53, 12, 19, 12, 0, -18 },
  { 82, 17, 17, 19, 1, -17 },
  { 119, 15, 17, 15, 0, -17 },
  { 151, 4, 6, 6, 2, -17 },
  { 154, 8, 21, 8, 1, -17 },
  { 175, 9, 21, 8, -2, -17 },
  { 199, 10, 11, 12, 2, -18 },
  { 213, 11, 11, 13, 1, -14 },
  { 229, 5, 6, 6, -1, -3 },
  { 233, 7, 3, 7, 0, -8 },
  { 236, 4, 4, 6, 0, -4 },
  { 238, 13, 17, 10, -1, -17 },
  { 266, 11, 17, 12, 1, -17 },
  { 290, 9, 17, 12, 2, -17 },
  { 310, 13, 17, 12, -1, -17 },
  { 338, 12, 17, 12, 0, -17 },
  { 364, 12, 17, 12, 0, -17 },
  { 390, 12, 17, 12, 0, -17 },
  { 416, 12, 17, 12, 1, -17 },
  { 442, 12, 17, 12, 1, -17 },
  { 468, 12, 17, 12, 0, -17 },
  { 494, 11, 17, 12, 1, -17 },
  { 518, 6, 13, 6, 0, -13 },
  { 528, 7, 16, 6, -1, -13 },
  { 542, 11, 12, 13, 1, -15 },
  { 559, 11, 7, 13, 1, -12 },
  { 569, 11, 12, 13, 1, -15 },
  { 586, 10, 17, 10, 1, -17 },
  { 608, 18, 19, 19, 1, -17 },
  { 651, 13, 17, 14, -1, -17 },
  { 679, 14, 17, 14, 0, -17 },
  { 709, 13, 17, 13, 1, -17 },
  { 737, 14, 17, 15, 0, -17 },
  { 767, 13, 17, 12, 0, -17 },
  { 795, 13, 17, 11, 0, -17 },
  { 823, 14, 17, 15, 1, -17 },
  { 853, 16, 17, 15, 0, -17 },
  { 887, 11, 17, 9, -1, -17 },
  { 911, 12, 22, 7, -4, -17 },
  { 944, 16, 17, 13, 0, -17 },
  { 978, 10, 17, 11, 0, -17 },
  { 1000, 20, 17, 20, 0, -17 },
  { 1043, 17, 17, 16, 0, -17 },
  { 1080, 14, 17, 16, 1, -17 },
  { 1110, 14, 17, 13, 0, -17 },
  { 1140, 14, 21, 16, 1, -17 },
  { 1177, 13, 17, 13, 0, -17 },
  { 1205, 12, 17, 12, 0, -17 },
  { 1231, 11, 17, 12, 2, -17 },
  { 1255, 15, 17, 15, 1, -17 },
  { 1287, 13, 17, 13, 2, -17 },
  { 1315, 20, 17, 20, 2, -17 },
  { 1358, 16, 17, 13, -1, -17 },
  { 1392, 13, 17, 12, 2, -17 },
  { 1420, 14, 17, 12, -1, -17 },
  { 1450, 10, 21, 8, -1, -17 },
  { 1477, 5, 17, 10, 3, -17 },
  { 1488, 10, 21, 8, -2, -17 },
  { 1515, 12, 11, 12, 0, -17 },
  { 1532, 9, 2, 9, -2, 2 },
  { 1535, 5, 3, 8, 3, -18 },
  { 1537, 12, 13, 13, 1, -13 },
  { 1557, 12, 18, 13, 0, -18 },
  { 1584, 10, 13, 11, 1, -13 },
  { 1601, 13, 18, 13, 1, -18 },
  { 1631, 11, 13, 12, 1, -13 },
  { 1649, 14, 24, 8, -3, -18 },
  { 1691, 13, 19, 13, 0, -13 },
  { 1722, 12, 18, 13, 0, -18 },
  { 1749, 7, 18, 7, 0, -18 },
  { 1765, 10, 24, 7, -3, -18 },
  { 1795, 14, 18, 12, 0, -18 },
  { 1827, 7, 18, 7, 0, -18 },
  { 1843, 19, 13, 20, 0, -13 },
  { 1874, 12, 13, 13, 0, -13 },
  { 1894, 11, 13, 13, 1, -13 },
  { 1912, 13, 19, 13, -1, -13 },
  { 1943, 12, 19, 13, 1, -13 },
  { 1972, 10, 13, 9, 0, -13 },
  { 1989, 10, 13, 10, 0, -13 },
  { 2006, 8, 16, 9, 1, -16 },
  { 2022, 12, 13, 13, 1, -13 },
  { 2042, 12, 13, 11, 1, -13 },
  { 2062, 18, 13, 17, 1, -13 },
  { 2092, 14, 13, 12, -1, -13 },
  { 2115, 15, 19, 11, -2, -13 },
  { 2151, 12, 13, 10, -1, -13 },
  { 2171, 10, 21, 8, 0, -17 },
  { 2198, 3, 23, 12, 4, -18 },
  { 2207, 9, 21, 8, -1, -17 },
  { 2231, 11, 4, 13, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC24PT7B_H_
