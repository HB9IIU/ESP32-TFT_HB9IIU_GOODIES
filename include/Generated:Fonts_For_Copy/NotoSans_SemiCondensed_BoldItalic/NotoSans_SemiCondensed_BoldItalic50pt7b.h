#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC50PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x07, 0xE0, 0x1F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x03, 0xF0, 0x01, 0x00, 0x00, 0x3F,
  0x1F, 0xDF, 0xC7, 0xF7, 0xF1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0x8F, 0x83, 0xE3,
  0xE0, 0xF8, 0xF8, 0x7C, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3E,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0xFC, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E,
  0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x7F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8,
  0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03,
  0xFD, 0xC3, 0x01, 0xFC, 0xE0, 0x80, 0xFE, 0x70, 0x00, 0x7F, 0x38, 0x00,
  0x3F, 0x98, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3B, 0xFC, 0x00, 0x1C,
  0xFE, 0x00, 0x0E, 0x7F, 0x10, 0x07, 0x3F, 0x8C, 0x03, 0x1F, 0xC7, 0xC3,
  0x9F, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0xFF, 0x80, 0x07, 0xC0, 0x3F, 0xF8,
  0x01, 0xF8, 0x0F, 0xFF, 0x00, 0x3E, 0x03, 0xFF, 0xF0, 0x0F, 0x80, 0x7E,
  0x7E, 0x03, 0xF0, 0x1F, 0x8F, 0xC0, 0x7C, 0x03, 0xF1, 0xF8, 0x1F, 0x00,
  0x7C, 0x3F, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0xF8, 0x03, 0xF0, 0xFC, 0x3E,
  0x00, 0x7E, 0x1F, 0x0F, 0xC0, 0x0F, 0x83, 0xE1, 0xF0, 0x01, 0xF0, 0xFC,
  0x7C, 0x00, 0x3E, 0x1F, 0x9F, 0x8F, 0xC7, 0xC3, 0xE3, 0xE3, 0xFC, 0xF8,
  0xFC, 0xF9, 0xFF, 0xDF, 0xFF, 0x3F, 0x3F, 0xFF, 0xFF, 0xE7, 0xCF, 0xFF,
  0xBF, 0xF9, 0xF3, 0xF1, 0xF3, 0xFE, 0x7E, 0x7E, 0x3E, 0x3F, 0x0F, 0x8F,
  0x87, 0xC0, 0x03, 0xE3, 0xF0, 0xF8, 0x00, 0xFC, 0x7E, 0x1F, 0x00, 0x3F,
  0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x1F, 0x80,
  0x7E, 0x0F, 0xC3, 0xF0, 0x0F, 0x81, 0xF8, 0x7C, 0x03, 0xF0, 0x3F, 0x1F,
  0x80, 0xFC, 0x07, 0xE3, 0xE0, 0x1F, 0x00, 0xFC, 0xFC, 0x07, 0xE0, 0x0F,
  0xFF, 0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x3E, 0x00, 0x1F, 0xF8, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xCF, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF8,
  0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x03,
  0xFC, 0x1F, 0xFE, 0x07, 0xF0, 0x7F, 0xFE, 0x0F, 0xC1, 0xFF, 0xFC, 0x3F,
  0x87, 0xFB, 0xFC, 0x7F, 0x1F, 0xE3, 0xFD, 0xFC, 0x3F, 0x87, 0xFF, 0xF0,
  0xFF, 0x07, 0xFF, 0xE1, 0xFC, 0x07, 0xFF, 0x83, 0xF8, 0x0F, 0xFF, 0x07,
  0xF0, 0x0F, 0xFC, 0x0F, 0xE0, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0xE0, 0x3F,
  0xF7, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x7F, 0x80, 0x7F, 0xF0, 0xFF, 0x80, 0x04,
  0x00, 0x00, 0x00, 0x3F, 0x3F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C,
  0xFC, 0xFC, 0xF8, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x20, 0x3E, 0x00,
  0xE0, 0xF8, 0x07, 0xE3, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFD, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xF8,
  0x10, 0xFF, 0xE0, 0x07, 0xF7, 0xC0, 0x3F, 0x9F, 0x01, 0xFE, 0x7E, 0x01,
  0xF1, 0xF8, 0x03, 0x83, 0xF0, 0x06, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F,
  0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0xFD, 0xFF, 0xE7, 0xFF,
  0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0xFF, 0x00, 0x0E, 0x1F, 0x9F, 0xEF,
  0xFF, 0xFF, 0xFB, 0xFC, 0xFC, 0x10, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xF8,
  0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0,
  0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80,
  0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0xFE, 0x01,
  0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03,
  0xF8, 0xFE, 0x07, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF0,
  0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF,
  0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0xCF, 0xF7, 0xF1, 0xF1, 0xFC, 0x38, 0x7E,
  0x08, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x3F, 0x87, 0xFC, 0x07, 0x80, 0xFF, 0x00, 0xC0, 0x1F, 0xC0, 0x20, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0x81, 0xFE, 0x01,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x88, 0x00, 0x3F, 0xC6, 0x00, 0x3F, 0xE3, 0xF9,
  0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xFC,
  0x00, 0x3F, 0x7F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xE0, 0x07, 0xE3,
  0xF8, 0x01, 0xF8, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F,
  0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x81,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1C, 0x1F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x80, 0x03, 0xFC, 0x38, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x9F,
  0xC0, 0x3F, 0x3F, 0xE0, 0x7F, 0x7F, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0x83, 0xFC, 0xFF, 0x01, 0xFC, 0xFF, 0x01,
  0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x03,
  0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0xBF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xC7, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87,
  0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0,
  0x3F, 0xCF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x01, 0xFE, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0xFE, 0x01,
  0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0,
  0x1F, 0xC7, 0xF0, 0x1F, 0xC3, 0xFE, 0x1F, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0xFE,
  0x1F, 0xE0, 0xFF, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F,
  0x3F, 0x80, 0x7F, 0x3F, 0x80, 0xFF, 0x3F, 0x80, 0xFF, 0x3F, 0x80, 0xFF,
  0x3F, 0x81, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0xE7, 0xFE, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFE, 0xFC, 0x0F, 0xFD, 0xFC, 0x07, 0xF9, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0xF9, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0x81, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x1F, 0x81, 0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xF8,
  0x3F, 0xC0, 0xFC, 0x01, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1C, 0x0F, 0xE1,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xBF, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x7F, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00,
  0x0F, 0x83, 0xE0, 0x1F, 0xF8, 0x7C, 0x3F, 0x03, 0xFF, 0xE3, 0xE1, 0xF0,
  0x3F, 0xFF, 0x0F, 0x9F, 0x83, 0xFF, 0xF0, 0x7C, 0xF8, 0x3F, 0x0F, 0x83,
  0xEF, 0xC3, 0xF0, 0x7C, 0x1F, 0x7C, 0x1F, 0x07, 0xE1, 0xF3, 0xE1, 0xF0,
  0x3E, 0x0F, 0x9F, 0x0F, 0x81, 0xF0, 0x7D, 0xF0, 0xFC, 0x0F, 0x83, 0xEF,
  0x87, 0xC0, 0xFC, 0x1F, 0x7C, 0x3E, 0x07, 0xC1, 0xF3, 0xE1, 0xF0, 0x3E,
  0x0F, 0x9F, 0x0F, 0x83, 0xF0, 0xFC, 0xF8, 0x7C, 0x1F, 0x87, 0xC7, 0xC3,
  0xE1, 0xFC, 0x7E, 0x3E, 0x1F, 0xFF, 0xFF, 0xE1, 0xF0, 0xFF, 0xEF, 0xFE,
  0x0F, 0x83, 0xFE, 0x7F, 0xE0, 0x7E, 0x0F, 0xE1, 0xFE, 0x01, 0xF0, 0x1E,
  0x07, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x20, 0x00, 0x3F, 0xE0, 0x0F,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7E,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0xFC, 0x7E, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x87,
  0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00,
  0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0x7F,
  0x3F, 0x80, 0x07, 0xF7, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFE,
  0x0F, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xE0,
  0x7F, 0x83, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFC, 0x1F,
  0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x03, 0xFC, 0x3F,
  0x80, 0x7F, 0x87, 0xF0, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F,
  0x87, 0xF0, 0x0F, 0xF0, 0xFE, 0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0x03, 0xC0, 0x7F, 0xC0, 0x08, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x08, 0x07, 0xFE, 0x03,
  0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xE3, 0xFF, 0x80, 0x7F, 0x03, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F,
  0xC0, 0x3F, 0x81, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00,
  0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFC, 0x00, 0xFF,
  0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x0F, 0xE1, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00,
  0x3F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xE1, 0xFC, 0x01, 0xFE,
  0x0F, 0xE0, 0x1F, 0xF0, 0x7F, 0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x3F,
  0x83, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F,
  0x81, 0xFF, 0x80, 0x08, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x03, 0xFF,
  0xE7, 0xF8, 0x1F, 0xFE, 0x3F, 0x80, 0xFF, 0xF1, 0xFC, 0x0F, 0xFF, 0x8F,
  0xE0, 0x7F, 0xFC, 0x7F, 0x03, 0xFF, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x1F,
  0xC1, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0xE0, 0x3F, 0x81,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8,
  0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8,
  0x01, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x07, 0xF0,
  0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x03, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80,
  0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0xFF, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x03,
  0xF8, 0x07, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F,
  0x80, 0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFC,
  0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xC7,
  0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFE, 0xFF,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00,
  0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F,
  0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x7F,
  0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xF0,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0x80,
  0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xEF, 0x80, 0x3F, 0xFC,
  0x07, 0xEF, 0x80, 0x7E, 0xFC, 0x07, 0xEF, 0x80, 0x7F, 0xFC, 0x07, 0xEF,
  0x80, 0xFD, 0xFC, 0x0F, 0xEF, 0x80, 0xFD, 0xF8, 0x0F, 0xCF, 0x81, 0xF9,
  0xF8, 0x0F, 0xCF, 0x81, 0xFB, 0xF8, 0x0F, 0xCF, 0x83, 0xF3, 0xF8, 0x1F,
  0xCF, 0xC3, 0xF3, 0xF8, 0x1F, 0xCF, 0xC7, 0xE3, 0xF0, 0x1F, 0x8F, 0xC7,
  0xE7, 0xF0, 0x1F, 0x8F, 0xCF, 0xC7, 0xF0, 0x1F, 0x8F, 0xCF, 0xC7, 0xF0,
  0x3F, 0x8F, 0xDF, 0x87, 0xE0, 0x3F, 0x8F, 0xDF, 0x87, 0xE0, 0x3F, 0x0F,
  0xFF, 0x0F, 0xE0, 0x3F, 0x0F, 0xFF, 0x0F, 0xE0, 0x3F, 0x0F, 0xFE, 0x0F,
  0xE0, 0x7F, 0x0F, 0xFE, 0x0F, 0xC0, 0x7F, 0x0F, 0xFC, 0x0F, 0xC0, 0x7E,
  0x07, 0xFC, 0x1F, 0xC0, 0x7E, 0x07, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0xC0,
  0x07, 0xF0, 0x1F, 0xF0, 0x01, 0xFC, 0x07, 0xFC, 0x00, 0x7E, 0x03, 0xFF,
  0x00, 0x1F, 0x80, 0xFF, 0xE0, 0x0F, 0xE0, 0x3F, 0xF8, 0x03, 0xF8, 0x0F,
  0xFE, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x01, 0xFF, 0xF0, 0x0F, 0xC0,
  0x7E, 0xFC, 0x07, 0xF0, 0x1F, 0xBF, 0x01, 0xFC, 0x07, 0xEF, 0xE0, 0x7E,
  0x03, 0xFB, 0xF8, 0x1F, 0x80, 0xFE, 0x7E, 0x0F, 0xE0, 0x3F, 0x1F, 0xC3,
  0xF8, 0x0F, 0xC7, 0xF0, 0xFE, 0x03, 0xF1, 0xFC, 0x3F, 0x01, 0xFC, 0x3F,
  0x0F, 0xC0, 0x7F, 0x0F, 0xE7, 0xF0, 0x1F, 0xC3, 0xF9, 0xFC, 0x07, 0xE0,
  0x7E, 0x7F, 0x01, 0xF8, 0x1F, 0x9F, 0x80, 0xFE, 0x07, 0xF7, 0xE0, 0x3F,
  0x81, 0xFD, 0xF8, 0x0F, 0xC0, 0x3F, 0x7E, 0x03, 0xF0, 0x0F, 0xFF, 0x00,
  0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0xF0, 0x1F, 0xC0, 0x1F, 0xFC,
  0x07, 0xE0, 0x07, 0xFF, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFE, 0x00, 0x3F,
  0xE0, 0x3F, 0x80, 0x0F, 0xF8, 0x0F, 0xE0, 0x03, 0xFE, 0x03, 0xF0, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFC,
  0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x3F,
  0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xF1,
  0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F,
  0x80, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xF8, 0x7F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xF0,
  0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0,
  0x1F, 0xE0, 0xFE, 0x03, 0xFE, 0x0F, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x03,
  0xFC, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F,
  0x3F, 0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xF7, 0xF0,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF9, 0xFC, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x0F,
  0xF1, 0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x80, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x3F, 0x87, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x07,
  0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC,
  0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x81, 0xFE, 0x0F, 0xE7, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F,
  0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF8,
  0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xF3, 0xF8, 0x03,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xE1, 0xE0,
  0x1F, 0xE0, 0x08, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x40, 0x07, 0xF8, 0x1E,
  0x03, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00,
  0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8,
  0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFE,
  0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x01,
  0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8,
  0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE,
  0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x01,
  0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8,
  0x3F, 0x80, 0x3F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0xFE,
  0x7E, 0x00, 0x1F, 0xE7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0xC7, 0xF0,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x87, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x7F,
  0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x03,
  0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F,
  0x80, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0xDF, 0x80, 0x1F, 0xC0, 0x0F, 0xE7, 0xE0, 0x07,
  0xF0, 0x03, 0xF9, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFF, 0x00,
  0x7F, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xC7, 0xE0, 0x1F, 0xF0, 0x0F, 0xE1,
  0xF8, 0x07, 0xFC, 0x03, 0xF8, 0x7E, 0x03, 0xFF, 0x01, 0xFC, 0x1F, 0x80,
  0xFF, 0xC0, 0x7F, 0x07, 0xE0, 0x3F, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xFC,
  0x0F, 0xE0, 0x7E, 0x07, 0xDF, 0x03, 0xF8, 0x1F, 0x83, 0xF7, 0xC1, 0xFC,
  0x07, 0xE0, 0xFD, 0xF0, 0x7F, 0x01, 0xF8, 0x7E, 0x7C, 0x3F, 0x80, 0x7E,
  0x1F, 0x9F, 0x0F, 0xE0, 0x1F, 0x87, 0xE7, 0xC3, 0xF0, 0x07, 0xE3, 0xF1,
  0xF1, 0xFC, 0x01, 0xF8, 0xFC, 0x7C, 0x7F, 0x00, 0x7E, 0x7E, 0x1F, 0x3F,
  0x80, 0x1F, 0x9F, 0x87, 0xCF, 0xE0, 0x07, 0xEF, 0xC1, 0xF3, 0xF0, 0x01,
  0xFB, 0xF0, 0x7D, 0xFC, 0x00, 0x7E, 0xFC, 0x1F, 0x7E, 0x00, 0x1F, 0xFE,
  0x07, 0xDF, 0x80, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xF8,
  0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x07,
  0xF3, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x1F,
  0xC7, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xE7,
  0xF0, 0x07, 0xF9, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xFF, 0x0F, 0xE0, 0x7F,
  0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xE1,
  0xFC, 0x01, 0xF8, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xDF, 0xC0, 0x07,
  0xF7, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x1F,
  0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xE0,
  0x07, 0xE3, 0xF0, 0x01, 0xF3, 0xF0, 0x00, 0xFB, 0xF0, 0x00, 0x7E, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x1F, 0xC3,
  0xF8, 0xFE, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x00, 0x38, 0x00, 0x00, 0xFF,
  0x8F, 0xC0, 0xFF, 0xEF, 0xE0, 0xFF, 0xF7, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x7F, 0xCF, 0xFC, 0x7F, 0x83, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F,
  0xC0, 0x7F, 0x1F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xC7,
  0xF8, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC,
  0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xE0, 0x7F,
  0x87, 0xF8, 0x7F, 0x83, 0xFE, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFB,
  0xF0, 0x3F, 0xFD, 0xF8, 0x0F, 0xFC, 0xF8, 0x03, 0xF8, 0xFC, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x87, 0x80, 0x0F, 0xE7, 0xF8, 0x03, 0xFB, 0xFF, 0x00, 0xFD, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFC, 0x7F, 0x81, 0xFE, 0x0F,
  0xE0, 0x7F, 0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8,
  0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x7F,
  0x0F, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xE3,
  0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFB, 0xFF, 0xC0, 0x7C,
  0x7F, 0xE0, 0x3F, 0x0F, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F, 0x00,
  0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xC3, 0x87, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0xC3, 0xFE, 0x3E, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0xE0, 0xFE, 0x00, 0xFF, 0x9F, 0xC0, 0x3F, 0xFB, 0xF0, 0x0F, 0xFF,
  0x7E, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xE1, 0xFF, 0x07,
  0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F,
  0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE,
  0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xFC,
  0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0,
  0x7F, 0x80, 0xFF, 0x1F, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFD, 0xF8, 0x03, 0xFF, 0x3E, 0x00, 0x3F, 0xC7, 0xC0, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xEF, 0xF1, 0xFE, 0x0F, 0xCF, 0xF0, 0x3F,
  0x3F, 0x80, 0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC1, 0xFE, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xF0,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x01, 0x0F, 0xF0, 0x1C, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xCC, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xF8, 0xFC,
  0x03, 0xFF, 0xBF, 0x80, 0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0x81,
  0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03,
  0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F,
  0x80, 0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFF,
  0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x0F, 0xFB, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xBF, 0x80, 0x3F, 0xE7, 0xE0,
  0x03, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x80, 0x0F, 0xF0, 0x1C, 0x03, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x87, 0x80, 0x0F, 0xE7, 0xF8, 0x03,
  0xF3, 0xFF, 0x00, 0xFD, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x07, 0xFC, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC0,
  0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F,
  0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0,
  0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F,
  0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x07, 0xF0,
  0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x00,
  0x00, 0x7C, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0x03,
  0xFC, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x07, 0xF1, 0xFE, 0x00,
  0x7F, 0x1F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0,
  0x03, 0xF8, 0x7F, 0x80, 0x3F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F,
  0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x10, 0x78, 0x01, 0xC0, 0x07, 0xC3,
  0xFC, 0x1F, 0xF0, 0x0F, 0x9F, 0xFC, 0x7F, 0xF0, 0x1F, 0x7F, 0xF9, 0xFF,
  0xE0, 0x7E, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0x1F, 0xFC, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0xC0,
  0xFE, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x7F,
  0x01, 0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0xE0,
  0x3F, 0x87, 0xF0, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x1F,
  0xC0, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8,
  0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0x3F, 0x87,
  0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x0F, 0xC1,
  0xFC, 0x07, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x10,
  0x78, 0x00, 0xF8, 0x7F, 0x80, 0x3E, 0x3F, 0xF0, 0x0F, 0x9F, 0xFE, 0x07,
  0xEF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xC3, 0xF8, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0x80,
  0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F,
  0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0,
  0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F,
  0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0,
  0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xF8,
  0x7F, 0x1F, 0xE0, 0xFF, 0x3F, 0x80, 0xFE, 0xFF, 0x01, 0xFD, 0xFC, 0x03,
  0xFB, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xF7,
  0xF0, 0x1F, 0xCF, 0xE0, 0x7F, 0x9F, 0xC1, 0xFE, 0x3F, 0xE7, 0xFC, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x1E, 0x00, 0x0F, 0x87, 0xF8,
  0x00, 0xF9, 0xFF, 0xC0, 0x0F, 0xBF, 0xFC, 0x01, 0xFB, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0x1F, 0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFC, 0x0F,
  0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03,
  0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00,
  0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0,
  0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF9,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0x9F, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x81, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x8F, 0xC0, 0xFF, 0xE7, 0xC0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0x87, 0xFC, 0x7F,
  0x83, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F,
  0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF8, 0x07, 0xF1,
  0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0xFE,
  0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x7F, 0x83, 0xFE, 0x7F,
  0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFB, 0xF8, 0x0F, 0xF9,
  0xF8, 0x03, 0xF9, 0xFC, 0x00, 0x20, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x78, 0x1F, 0x8F, 0xC0,
  0xFC, 0xFE, 0x07, 0xEF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xC2, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x7F, 0x81, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x60, 0x0F, 0xE3, 0xC0, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x10, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x10, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xEF,
  0xFF, 0xF8, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xFC, 0x60, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF,
  0xE0, 0x1F, 0xF0, 0x00, 0x80, 0x00, 0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x1F,
  0xC7, 0xF0, 0x0F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03,
  0xF8, 0x7E, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0,
  0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x1F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF8,
  0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x7F,
  0x01, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xE0, 0xFF, 0x87,
  0xF9, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xF7, 0xE0, 0x7F, 0xFB, 0xF0,
  0x1F, 0xF9, 0xF8, 0x07, 0xF0, 0xF8, 0x00, 0x40, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F,
  0x9F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE0,
  0xFC, 0x3F, 0x81, 0xF8, 0x7F, 0x03, 0xF1, 0xFC, 0x07, 0xE3, 0xF8, 0x0F,
  0xC7, 0xE0, 0x1F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0xFE, 0x00, 0xFD,
  0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x80,
  0xFE, 0xFE, 0x07, 0xF8, 0x0F, 0xEF, 0xE0, 0xFF, 0x81, 0xFC, 0xFE, 0x0F,
  0xF8, 0x1F, 0xCF, 0xE0, 0xFF, 0x83, 0xF8, 0xFE, 0x1F, 0xF8, 0x3F, 0x8F,
  0xE1, 0xFF, 0x83, 0xF0, 0xFE, 0x3F, 0xF8, 0x7F, 0x0F, 0xE3, 0xEF, 0x87,
  0xE0, 0xFE, 0x7E, 0xF8, 0xFE, 0x0F, 0xE7, 0xCF, 0x8F, 0xC0, 0xFC, 0x7C,
  0xF9, 0xFC, 0x0F, 0xCF, 0xCF, 0x9F, 0xC0, 0xFC, 0xF8, 0xF9, 0xF8, 0x0F,
  0xDF, 0x8F, 0xBF, 0x80, 0xFD, 0xF0, 0xFB, 0xF0, 0x0F, 0xDF, 0x0F, 0xBF,
  0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xFC, 0x07, 0xF8,
  0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFE, 0x1F,
  0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF9, 0xFC,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0x80,
  0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x01, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F,
  0xC0, 0xFE, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF0,
  0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x7F,
  0x00, 0x03, 0xF1, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x80,
  0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x02, 0x7F,
  0xE0, 0x05, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFC, 0x80, 0x00, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 15, 37, 14, 0, -36 },
  { 71, 18, 13, 22, 5, -36 },
  { 101, 29, 36, 29, 1, -36 },
  { 232, 25, 41, 25, 1, -38 },
  { 361, 35, 36, 40, 3, -36 },
  { 519, 31, 37, 32, 1, -36 },
  { 663, 8, 13, 13, 5, -36 },
  { 676, 18, 44, 16, 1, -36 },
  { 775, 18, 44, 16, -4, -36 },
  { 874, 22, 23, 25, 4, -38 },
  { 938, 23, 24, 27, 2, -30 },
  { 1007, 12, 13, 13, -3, -6 },
  { 1027, 14, 7, 16, 1, -17 },
  { 1040, 9, 9, 13, 0, -8 },
  { 1051, 26, 36, 20, -2, -36 },
  { 1168, 24, 37, 25, 1, -36 },
  { 1279, 18, 36, 25, 5, -36 },
  { 1360, 26, 36, 25, -1, -36 },
  { 1477, 25, 37, 25, 0, -36 },
  { 1593, 26, 36, 25, -1, -36 },
  { 1710, 26, 37, 25, 0, -36 },
  { 1831, 24, 37, 25, 2, -36 },
  { 1942, 26, 36, 25, 2, -36 },
  { 2059, 25, 37, 25, 1, -36 },
  { 2175, 24, 37, 25, 1, -36 },
  { 2286, 13, 29, 14, 0, -28 },
  { 2334, 16, 35, 14, -3, -28 },
  { 2404, 23, 26, 27, 2, -31 },
  { 2479, 23, 15, 27, 2, -25 },
  { 2523, 23, 26, 27, 2, -31 },
  { 2598, 20, 37, 21, 3, -36 },
  { 2691, 37, 40, 39, 2, -36 },
  { 2876, 28, 36, 29, -3, -36 },
  { 3002, 27, 36, 28, 1, -36 },
  { 3124, 28, 37, 27, 2, -36 },
  { 3254, 29, 36, 31, 1, -36 },
  { 3385, 25, 36, 25, 1, -36 },
  { 3498, 25, 36, 24, 1, -36 },
  { 3611, 29, 37, 32, 3, -36 },
  { 3746, 32, 36, 32, 1, -36 },
  { 3890, 23, 36, 18, -2, -36 },
  { 3994, 24, 47, 15, -8, -36 },
  { 4135, 31, 36, 28, 1, -36 },
  { 4275, 19, 36, 23, 1, -36 },
  { 4361, 40, 36, 41, 1, -36 },
  { 4541, 34, 36, 34, 1, -36 },
  { 4694, 30, 37, 33, 2, -36 },
  { 4833, 28, 36, 28, 1, -36 },
  { 4959, 30, 45, 33, 2, -36 },
  { 5128, 26, 36, 28, 1, -36 },
  { 5245, 26, 37, 24, 0, -36 },
  { 5366, 24, 36, 24, 4, -36 },
  { 5474, 29, 37, 31, 3, -36 },
  { 5609, 28, 36, 27, 4, -36 },
  { 5735, 42, 36, 41, 4, -36 },
  { 5924, 34, 36, 27, -3, -36 },
  { 6077, 26, 36, 26, 4, -36 },
  { 6194, 29, 36, 24, -2, -36 },
  { 6325, 20, 44, 16, -1, -36 },
  { 6435, 12, 36, 20, 5, -36 },
  { 6489, 20, 44, 16, -3, -36 },
  { 6599, 25, 23, 25, 0, -36 },
  { 6671, 20, 4, 19, -5, 4 },
  { 6681, 10, 8, 16, 7, -38 },
  { 6691, 25, 29, 27, 2, -28 },
  { 6782, 26, 39, 27, 0, -38 },
  { 6909, 21, 29, 22, 2, -28 },
  { 6986, 27, 39, 27, 2, -38 },
  { 7118, 22, 29, 25, 2, -28 },
  { 7198, 28, 50, 17, -5, -38 },
  { 7373, 27, 40, 27, 0, -28 },
  { 7508, 26, 38, 28, 0, -38 },
  { 7632, 15, 38, 14, 0, -38 },
  { 7704, 21, 50, 14, -6, -38 },
  { 7836, 28, 38, 26, 0, -38 },
  { 7969, 16, 38, 14, 0, -38 },
  { 8045, 39, 28, 41, 0, -28 },
  { 8182, 26, 28, 28, 0, -28 },
  { 8273, 23, 29, 27, 2, -28 },
  { 8357, 28, 40, 27, -2, -28 },
  { 8497, 25, 40, 27, 2, -28 },
  { 8622, 21, 28, 19, 0, -28 },
  { 8696, 21, 29, 22, 0, -28 },
  { 8773, 18, 34, 18, 2, -33 },
  { 8850, 25, 28, 27, 2, -27 },
  { 8938, 23, 27, 24, 3, -27 },
  { 9016, 36, 27, 36, 3, -27 },
  { 9138, 30, 27, 24, -3, -27 },
  { 9240, 30, 39, 24, -4, -27 },
  { 9387, 23, 27, 21, -1, -27 },
  { 9465, 21, 44, 17, 0, -36 },
  { 9581, 6, 49, 24, 9, -38 },
  { 9618, 20, 44, 17, -3, -36 },
  { 9728, 23, 9, 27, 2, -22 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC50PT7B_H_
