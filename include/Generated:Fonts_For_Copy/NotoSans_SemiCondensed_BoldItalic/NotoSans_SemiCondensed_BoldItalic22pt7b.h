#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC22PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0x70, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0x61, 0xC0, 0x00,
  0x0E, 0x3C, 0x70, 0x77, 0x77, 0x66, 0xE6, 0xE6, 0xCE, 0x03, 0x30, 0x39,
  0x81, 0x9C, 0x0C, 0xC0, 0x66, 0x1F, 0xFC, 0xFF, 0xE1, 0x98, 0x1C, 0xC3,
  0xFF, 0xBF, 0xFD, 0xFF, 0xE3, 0x38, 0x19, 0x80, 0xCC, 0x0E, 0xE0, 0x01,
  0x80, 0x20, 0x1F, 0x8F, 0xF3, 0xFC, 0x74, 0x0E, 0x81, 0xF0, 0x1F, 0x01,
  0xF8, 0x1F, 0x02, 0xE8, 0x5D, 0xCF, 0xBF, 0xE3, 0xF8, 0x08, 0x03, 0x00,
  0x1C, 0x0C, 0x3E, 0x1C, 0x76, 0x18, 0x66, 0x30, 0xE6, 0x70, 0xE6, 0x60,
  0xEE, 0xCC, 0xED, 0xDE, 0x7D, 0xBF, 0x7B, 0x77, 0x07, 0x77, 0x06, 0x67,
  0x0C, 0x66, 0x1C, 0x66, 0x18, 0x7E, 0x30, 0x3C, 0x03, 0xC0, 0x3F, 0x80,
  0xEE, 0x07, 0x38, 0x1C, 0xE0, 0x77, 0x80, 0xFC, 0x03, 0xC0, 0x3F, 0x1D,
  0xFE, 0xE7, 0x3F, 0x9C, 0xFC, 0xF1, 0xE1, 0xCF, 0x87, 0xFF, 0x0F, 0xDE,
  0x77, 0x66, 0xEC, 0x07, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0x70, 0x60, 0xE0,
  0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0xE0, 0x06, 0x07,
  0x07, 0x07, 0x07, 0x03, 0x03, 0x03, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E,
  0x0C, 0x1C, 0x18, 0x38, 0xF0, 0x0C, 0x07, 0x13, 0x1D, 0x8F, 0xF8, 0xFC,
  0xF1, 0xEC, 0x66, 0x13, 0x80, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF,
  0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x39, 0xDC, 0xEE, 0x70, 0x7F,
  0xF0, 0x7F, 0xE0, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38,
  0x07, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0x0F, 0x07, 0xE3, 0xFD, 0xE7, 0x71, 0xDC, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0xEE, 0x3B, 0x8E, 0xE7, 0x3B, 0xCF, 0xE1, 0xF0, 0x07,
  0x0F, 0x3F, 0x7E, 0xFE, 0x6E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x38, 0x38, 0x38, 0x03, 0xC0, 0xFE, 0x1F, 0xF0, 0x87, 0x00, 0x70, 0x07,
  0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xFC,
  0x7F, 0xCF, 0xFC, 0x0F, 0x87, 0xFC, 0x7F, 0x88, 0x70, 0x0E, 0x01, 0xC0,
  0xF0, 0xF8, 0x1F, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x3D, 0x8F, 0x3F, 0xE7,
  0xF0, 0x00, 0xE0, 0x3C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x87, 0x71, 0xCE,
  0x33, 0x8E, 0x73, 0xFF, 0xFF, 0xEF, 0xFC, 0x0E, 0x01, 0xC0, 0x38, 0x0F,
  0xE3, 0xFC, 0x7F, 0x8E, 0x01, 0xC0, 0x70, 0x0F, 0xC1, 0xFC, 0x3F, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x3D, 0xDF, 0x3F, 0xC7, 0xF0, 0x03, 0xE1, 0xF8,
  0x7F, 0x1C, 0x07, 0x80, 0xE0, 0x1F, 0xC7, 0xFC, 0xF3, 0x9C, 0x73, 0x8E,
  0x71, 0xCE, 0x39, 0xEE, 0x1F, 0xC3, 0xF0, 0x3F, 0xEF, 0xFD, 0xFF, 0x80,
  0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03,
  0x80, 0xF0, 0x1C, 0x07, 0x00, 0x07, 0x83, 0xFC, 0x77, 0x9C, 0x73, 0x8E,
  0x79, 0xC7, 0xF0, 0x7C, 0x3F, 0x8F, 0x79, 0xC7, 0x70, 0xEE, 0x1D, 0xE7,
  0x9F, 0xE1, 0xF8, 0x0F, 0x0F, 0xE7, 0xFD, 0xC7, 0x71, 0xF8, 0x7E, 0x3F,
  0xCF, 0x7F, 0x9F, 0xE0, 0x38, 0x1C, 0x07, 0x27, 0x8F, 0xC3, 0xE0, 0x1C,
  0xF3, 0x80, 0x00, 0x00, 0x00, 0x01, 0xCF, 0x38, 0x0E, 0x3C, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x71, 0xE3, 0x87, 0x1C, 0x30, 0x00, 0x00, 0x40,
  0x30, 0x3C, 0x3E, 0x3E, 0x3E, 0x0F, 0x01, 0xF0, 0x1F, 0x81, 0xF0, 0x0C,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x30,
  0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3C, 0x3E, 0x7E, 0x3E, 0x0E, 0x02,
  0x00, 0x1E, 0x3F, 0x9F, 0xE8, 0x70, 0x38, 0x38, 0x3C, 0x3C, 0x38, 0x18,
  0x1C, 0x00, 0x00, 0x03, 0x83, 0xC1, 0xC0, 0x01, 0xF0, 0x07, 0xFC, 0x0E,
  0x0E, 0x18, 0x06, 0x30, 0xC7, 0x73, 0xF3, 0x67, 0x33, 0xE6, 0x73, 0xCC,
  0x63, 0xCC, 0x67, 0xCC, 0xE6, 0xCC, 0xEE, 0xCF, 0xFC, 0xC6, 0x30, 0xE0,
  0x00, 0x70, 0x20, 0x3F, 0xE0, 0x0F, 0xC0, 0x01, 0xE0, 0x1E, 0x03, 0xE0,
  0x36, 0x07, 0x60, 0x76, 0x0E, 0x70, 0xE7, 0x1C, 0x71, 0xC7, 0x3F, 0xF3,
  0xFF, 0x78, 0x77, 0x07, 0xF0, 0x7E, 0x07, 0x0F, 0xC1, 0xFF, 0x1F, 0xF1,
  0xC7, 0x1C, 0x71, 0xC7, 0x38, 0xE3, 0xFC, 0x3F, 0xC3, 0x8E, 0x78, 0xE7,
  0x0E, 0x70, 0xE7, 0xFE, 0x7F, 0xCF, 0xF0, 0x03, 0xE0, 0xFF, 0x1F, 0xE3,
  0xC2, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0F,
  0x00, 0xF0, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x0F, 0x80, 0xFF, 0x07, 0xFC,
  0x38, 0xF1, 0xC3, 0x8E, 0x1C, 0xF0, 0xE7, 0x07, 0x38, 0x39, 0xC3, 0xDE,
  0x1C, 0xE1, 0xE7, 0x1E, 0x3F, 0xF1, 0xFE, 0x1F, 0xE0, 0x0F, 0xF1, 0xFE,
  0x1F, 0xE1, 0xC0, 0x1C, 0x01, 0xC0, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x07, 0xF8, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE,
  0x1F, 0xE1, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xFC, 0x3F, 0xC3, 0xF8,
  0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0x03, 0xF0, 0x7F,
  0xC7, 0xFC, 0x78, 0x23, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x3E, 0xF3, 0xF7,
  0x1F, 0xB8, 0x39, 0xE1, 0xCF, 0x0E, 0x3F, 0xF1, 0xFF, 0x03, 0xF8, 0x0E,
  0x1C, 0x78, 0x71, 0xC1, 0xC7, 0x07, 0x1C, 0x3C, 0x70, 0xE3, 0xFF, 0x8F,
  0xFE, 0x3F, 0xF8, 0xE1, 0xC7, 0x87, 0x1C, 0x1C, 0x70, 0x71, 0xC3, 0xC7,
  0x0E, 0x3C, 0x38, 0x0F, 0xC7, 0xF0, 0xF8, 0x1C, 0x0F, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x07, 0xE3, 0xF8, 0x01,
  0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x0F, 0xC3, 0xE0,
  0xE0, 0x00, 0x0E, 0x1C, 0x70, 0xE1, 0xC7, 0x87, 0x3C, 0x1D, 0xE0, 0x77,
  0x03, 0xB8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xB8, 0x1C, 0xF0, 0x71,
  0xC1, 0xC7, 0x07, 0x1E, 0x3C, 0x78, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x03, 0xFD, 0xFF, 0xFE,
  0x0F, 0x03, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x3F, 0x1B, 0x0D, 0x86,
  0xC7, 0xE3, 0xB1, 0xB8, 0xEC, 0xEE, 0x3B, 0x3B, 0x0E, 0xDD, 0xC3, 0x37,
  0x71, 0xCD, 0x9C, 0x73, 0xE7, 0x1C, 0xF1, 0x86, 0x3C, 0xE3, 0x8E, 0x38,
  0x0E, 0x06, 0x3E, 0x1C, 0x7C, 0x38, 0xF8, 0x71, 0xF0, 0xE3, 0x73, 0x8E,
  0xE7, 0x1D, 0xCE, 0x39, 0x9C, 0x73, 0xB1, 0xC7, 0xE3, 0x8F, 0xC7, 0x0F,
  0x8E, 0x1F, 0x1C, 0x3C, 0x70, 0x78, 0x07, 0xC0, 0x7F, 0x87, 0xFC, 0x78,
  0xF7, 0x83, 0xB8, 0x1D, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1D,
  0xC1, 0xEF, 0x0E, 0x3F, 0xF1, 0xFF, 0x07, 0xE0, 0x0F, 0xC0, 0xFF, 0x87,
  0xFC, 0x38, 0xE1, 0xC7, 0x8E, 0x3C, 0xE1, 0xC7, 0x1E, 0x3F, 0xE1, 0xFE,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0x07, 0xC0,
  0x7F, 0x87, 0xFC, 0x78, 0xF7, 0x83, 0xB8, 0x1D, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x03, 0xF8, 0x1D, 0xC1, 0xEF, 0x0E, 0x3F, 0xF1, 0xFF, 0x07, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x81, 0xFE, 0x1F, 0xF1,
  0xC7, 0x1C, 0x71, 0xC7, 0x38, 0xF3, 0xFE, 0x3F, 0xC3, 0xF8, 0x3B, 0x87,
  0x3C, 0x71, 0xC7, 0x1C, 0x71, 0xEF, 0x0E, 0x07, 0xC3, 0xFC, 0x7F, 0x9E,
  0x23, 0x80, 0x78, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x0E, 0x01, 0xC8,
  0x39, 0xFF, 0x3F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0x1C, 0x07,
  0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03,
  0xC0, 0x1C, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0xF3, 0x87, 0x3C, 0x39, 0xC1,
  0xCE, 0x0E, 0x70, 0xE3, 0x87, 0x3C, 0x39, 0xC1, 0xCF, 0x1C, 0x7F, 0xE1,
  0xFE, 0x07, 0xE0, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x1C, 0xE1, 0xCE, 0x38,
  0xE3, 0x8E, 0x70, 0xE7, 0x06, 0xE0, 0x6E, 0x06, 0xE0, 0x7C, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0xE0, 0xC1, 0xF8, 0x70, 0x7E, 0x1C, 0x3B, 0x8F, 0x0E,
  0xE3, 0xC7, 0x39, 0xF1, 0xCE, 0x7C, 0xE3, 0x9B, 0x38, 0xEE, 0xCE, 0x3B,
  0x37, 0x0F, 0xCD, 0xC3, 0xE3, 0x60, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x0F,
  0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x1C, 0x78, 0x38, 0xE0, 0x73, 0x80, 0x7F,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0xEE, 0x03, 0xDE, 0x0F, 0x1C, 0x1C, 0x38, 0x78, 0x78, 0xE0, 0xFC, 0x3F,
  0xC7, 0x39, 0xC7, 0x78, 0xEE, 0x1F, 0x81, 0xF0, 0x3C, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x0F, 0xF8, 0xFF, 0xC7, 0xFC,
  0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07,
  0x80, 0x78, 0x03, 0x80, 0x3F, 0xE1, 0xFF, 0x1F, 0xF8, 0x0F, 0x87, 0xC3,
  0xE1, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81,
  0x81, 0xC0, 0xE0, 0x70, 0x3E, 0x3F, 0x00, 0xE3, 0x18, 0xC7, 0x39, 0xCE,
  0x31, 0x8C, 0x73, 0x9C, 0xE3, 0x0F, 0x87, 0xC3, 0xE0, 0x70, 0x38, 0x18,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C,
  0x3E, 0x3F, 0x00, 0x03, 0x00, 0x60, 0x1E, 0x07, 0xC0, 0xD8, 0x3B, 0x86,
  0x71, 0x86, 0x70, 0xDC, 0x1C, 0xFF, 0xF3, 0x8C, 0x70, 0x1E, 0xE7, 0xFD,
  0xEF, 0x38, 0xEF, 0x1D, 0xC3, 0xB8, 0xE7, 0x1C, 0xE3, 0x9E, 0xF3, 0xFE,
  0x3D, 0x80, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0x8F, 0xF9,
  0xE7, 0x38, 0xE7, 0x1C, 0xC3, 0xB8, 0x77, 0x1E, 0xE3, 0x9E, 0xF7, 0xFC,
  0xEF, 0x00, 0x1F, 0x9F, 0xDE, 0x4E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x7B, 0x3F, 0x8F, 0xC0, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE1,
  0xEE, 0x3F, 0xC7, 0xBC, 0x71, 0xCF, 0x1C, 0xE1, 0xCE, 0x18, 0xE3, 0x8E,
  0x38, 0xE7, 0x8F, 0xF8, 0x7B, 0x00, 0x1F, 0x8F, 0xE7, 0x9D, 0xC7, 0xE3,
  0xBF, 0xEF, 0xE3, 0x80, 0xE0, 0x38, 0x4F, 0xF1, 0xFC, 0x00, 0xE0, 0x3F,
  0x03, 0xE0, 0x38, 0x07, 0x00, 0xFC, 0x1F, 0xC0, 0x70, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x38, 0x0B, 0x80, 0xF8, 0x0F, 0x00, 0x0F, 0x71, 0xFF, 0x3D, 0xE3, 0x8E,
  0x78, 0xE7, 0x0E, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0xBC, 0x7F, 0xC3, 0xF8,
  0x03, 0x80, 0x38, 0xC7, 0x8F, 0xF0, 0xFE, 0x00, 0x0E, 0x03, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x3F, 0x8F, 0xF9, 0xE7, 0x38, 0xE7, 0x1C, 0xE3, 0xB8,
  0x77, 0x1C, 0xE3, 0x9C, 0x73, 0x8E, 0xE3, 0xC0, 0x0C, 0x3C, 0x70, 0x00,
  0x03, 0x8F, 0x1C, 0x38, 0x70, 0xE3, 0x87, 0x0E, 0x1C, 0x78, 0xE0, 0x01,
  0x80, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC2, 0xF0,
  0xF8, 0x3C, 0x00, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC7,
  0x38, 0xE3, 0x9C, 0x3B, 0x83, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0x38,
  0x73, 0x87, 0x3C, 0xE1, 0xC0, 0x0E, 0x3C, 0x70, 0xE1, 0xC3, 0x8F, 0x1C,
  0x38, 0x70, 0xE3, 0x87, 0x0E, 0x1C, 0x78, 0xE0, 0x1B, 0xCF, 0x1F, 0xFF,
  0xCF, 0x3C, 0xE7, 0x1C, 0x73, 0x8E, 0x39, 0xC7, 0x1D, 0xC7, 0x0E, 0xE3,
  0x8E, 0x71, 0xC7, 0x38, 0xE3, 0x9C, 0x71, 0xDC, 0x71, 0xC0, 0x1B, 0xC7,
  0xFC, 0xF3, 0x9C, 0x73, 0x8E, 0x71, 0xDC, 0x3B, 0x8E, 0x71, 0xCE, 0x39,
  0xC7, 0x71, 0xE0, 0x1F, 0x0F, 0xE7, 0xBD, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F,
  0x8F, 0xE3, 0xBD, 0xE7, 0xF1, 0xF8, 0x0D, 0xE1, 0xFF, 0x1E, 0x71, 0xC7,
  0x1C, 0x71, 0x87, 0x38, 0x73, 0x8F, 0x38, 0xE3, 0xDE, 0x3F, 0xC7, 0x78,
  0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x00, 0x1E, 0xE7, 0xF9, 0xEF,
  0x38, 0xEF, 0x1D, 0xC3, 0xB8, 0x67, 0x1C, 0xE3, 0x9C, 0xF3, 0xFE, 0x3F,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x00, 0x1B, 0x9F, 0xCF, 0xE7,
  0x83, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x00, 0x1F, 0x9F,
  0xDE, 0x6F, 0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x67, 0xBF, 0x9F, 0x80,
  0x1C, 0x18, 0x38, 0x7F, 0xFE, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0,
  0xE4, 0xF8, 0x78, 0x38, 0xEE, 0x1D, 0xC7, 0x38, 0xE7, 0x1D, 0xE3, 0xB8,
  0xE7, 0x1C, 0xE3, 0x9C, 0xF3, 0xFE, 0x3D, 0x80, 0xE1, 0xFC, 0x3B, 0x8E,
  0x71, 0xC6, 0x70, 0xCE, 0x1B, 0x83, 0x70, 0x6C, 0x0F, 0x81, 0xE0, 0x3C,
  0x00, 0xE3, 0xC7, 0xE3, 0xCE, 0xE7, 0xCE, 0xE7, 0xCC, 0xE7, 0xDC, 0xEF,
  0xDC, 0x6D, 0xF8, 0x7D, 0xF8, 0x79, 0xF0, 0x79, 0xF0, 0x79, 0xE0, 0x71,
  0xE0, 0x1C, 0x78, 0xE7, 0x87, 0xB8, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3C,
  0x03, 0xF0, 0x1F, 0x81, 0xDC, 0x1C, 0x71, 0xE3, 0x80, 0x1C, 0x3C, 0x70,
  0xE1, 0xC7, 0x03, 0x1C, 0x0E, 0xE0, 0x3B, 0x80, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x1F,
  0x00, 0xF8, 0x00, 0x1F, 0xE3, 0xF8, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x03,
  0x80, 0xE0, 0x38, 0x0F, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0x83, 0xC3, 0xE1,
  0xC0, 0xE0, 0x60, 0x70, 0x38, 0x78, 0x78, 0x3C, 0x07, 0x03, 0x81, 0xC0,
  0xC0, 0xE0, 0x70, 0x3C, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x83, 0x83,
  0xC3, 0xC1, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x78, 0x3C, 0x00, 0x20, 0x7F,
  0x1F, 0xFE, 0x1E,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 16, 6, 0, -16 },
  { 15, 8, 6, 10, 2, -16 },
  { 21, 13, 16, 13, 0, -16 },
  { 47, 11, 18, 11, 0, -17 },
  { 72, 16, 16, 18, 1, -16 },
  { 104, 14, 16, 14, 0, -16 },
  { 132, 4, 6, 6, 2, -16 },
  { 135, 8, 19, 7, 1, -16 },
  { 154, 8, 19, 7, -2, -16 },
  { 173, 9, 10, 11, 2, -17 },
  { 185, 10, 11, 12, 1, -13 },
  { 199, 5, 6, 6, -1, -3 },
  { 203, 6, 2, 7, 0, -7 },
  { 205, 4, 3, 6, 0, -3 },
  { 207, 12, 16, 9, -1, -16 },
  { 231, 10, 16, 11, 1, -16 },
  { 251, 8, 16, 11, 2, -16 },
  { 267, 12, 16, 11, -1, -16 },
  { 291, 11, 16, 11, 0, -16 },
  { 313, 11, 16, 11, 0, -16 },
  { 335, 11, 16, 11, 0, -16 },
  { 357, 11, 16, 11, 1, -16 },
  { 379, 11, 16, 11, 1, -16 },
  { 401, 11, 16, 11, 0, -16 },
  { 423, 10, 16, 11, 1, -16 },
  { 443, 6, 12, 6, 0, -12 },
  { 452, 7, 15, 6, -1, -12 },
  { 466, 10, 12, 12, 1, -14 },
  { 481, 10, 7, 12, 1, -11 },
  { 490, 10, 12, 12, 1, -14 },
  { 505, 9, 16, 9, 1, -16 },
  { 523, 16, 18, 17, 1, -16 },
  { 559, 12, 16, 13, -1, -16 },
  { 583, 12, 16, 12, 0, -16 },
  { 607, 12, 16, 12, 1, -16 },
  { 631, 13, 16, 14, 0, -16 },
  { 657, 12, 16, 11, 0, -16 },
  { 681, 12, 16, 11, 0, -16 },
  { 705, 13, 16, 14, 1, -16 },
  { 731, 14, 16, 14, 0, -16 },
  { 759, 10, 16, 8, -1, -16 },
  { 779, 10, 21, 7, -3, -16 },
  { 806, 14, 16, 12, 0, -16 },
  { 834, 9, 16, 10, 0, -16 },
  { 852, 18, 16, 18, 0, -16 },
  { 888, 15, 16, 15, 0, -16 },
  { 918, 13, 16, 15, 1, -16 },
  { 944, 13, 16, 12, 0, -16 },
  { 970, 13, 20, 15, 1, -16 },
  { 1003, 12, 16, 12, 0, -16 },
  { 1027, 11, 16, 11, 0, -16 },
  { 1049, 10, 16, 11, 2, -16 },
  { 1069, 13, 16, 14, 1, -16 },
  { 1095, 12, 16, 12, 2, -16 },
  { 1119, 18, 16, 18, 2, -16 },
  { 1155, 15, 16, 12, -1, -16 },
  { 1185, 11, 16, 11, 2, -16 },
  { 1207, 13, 16, 11, -1, -16 },
  { 1233, 9, 19, 7, -1, -16 },
  { 1255, 5, 16, 9, 2, -16 },
  { 1265, 9, 19, 7, -2, -16 },
  { 1287, 11, 10, 11, 0, -16 },
  { 1301, 8, 1, 8, -2, 2 },
  { 1302, 5, 4, 7, 3, -17 },
  { 1305, 11, 12, 12, 1, -12 },
  { 1322, 11, 17, 12, 0, -17 },
  { 1346, 9, 12, 10, 1, -12 },
  { 1360, 12, 17, 12, 1, -17 },
  { 1386, 10, 12, 11, 1, -12 },
  { 1401, 12, 22, 7, -2, -17 },
  { 1434, 12, 17, 12, 0, -12 },
  { 1460, 11, 17, 12, 0, -17 },
  { 1484, 7, 17, 6, 0, -17 },
  { 1499, 10, 22, 6, -3, -17 },
  { 1527, 12, 17, 11, 0, -17 },
  { 1553, 7, 17, 6, 0, -17 },
  { 1568, 17, 12, 18, 0, -12 },
  { 1594, 11, 12, 12, 0, -12 },
  { 1611, 10, 12, 12, 1, -12 },
  { 1626, 12, 17, 12, -1, -12 },
  { 1652, 11, 17, 12, 1, -12 },
  { 1676, 9, 12, 8, 0, -12 },
  { 1690, 9, 12, 10, 0, -12 },
  { 1704, 8, 15, 8, 1, -15 },
  { 1719, 11, 12, 12, 1, -12 },
  { 1736, 11, 12, 10, 1, -12 },
  { 1753, 16, 12, 16, 1, -12 },
  { 1777, 13, 12, 11, -1, -12 },
  { 1797, 14, 17, 10, -2, -12 },
  { 1827, 11, 12, 9, -1, -12 },
  { 1844, 9, 19, 8, 0, -16 },
  { 1866, 2, 22, 11, 4, -17 },
  { 1872, 9, 19, 8, -1, -16 },
  { 1894, 10, 4, 12, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC22PT7B_H_
