#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC71PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0xF0, 0xFF, 0xCF, 0xFC, 0x3F, 0xE3, 0xFE, 0x0F, 0xF8, 0xFF, 0x83,
  0xFE, 0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0xC3, 0xFC, 0x1F, 0xF1, 0xFF,
  0x07, 0xFC, 0x7F, 0xC1, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F,
  0xC3, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xE7, 0xC7, 0xC0, 0x1F, 0xF8, 0xF0, 0x38, 0x03, 0xFF,
  0x1E, 0x01, 0x00, 0x7F, 0xE3, 0xC0, 0x00, 0x0F, 0xF8, 0x78, 0x00, 0x01,
  0xFF, 0x9F, 0x00, 0x00, 0x3F, 0xF3, 0xC0, 0x00, 0x07, 0xFF, 0x78, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xBF, 0xFC, 0x00, 0x00, 0xF3,
  0xFF, 0x80, 0x00, 0x1E, 0x3F, 0xF0, 0x00, 0x03, 0xC7, 0xFE, 0x00, 0x00,
  0xF8, 0xFF, 0xC2, 0x00, 0x1E, 0x1F, 0xF8, 0x70, 0x03, 0xC7, 0xFE, 0x0F,
  0x80, 0x78, 0xFF, 0xC1, 0xFE, 0x0F, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0,
  0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x83, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F,
  0x87, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF1, 0xFE, 0x1F, 0xFC, 0x3F, 0xC3,
  0xFC, 0x7F, 0x8F, 0xFF, 0xC7, 0xF8, 0xFF, 0x8F, 0xE3, 0xFF, 0xFC, 0xFF,
  0xBF, 0xE3, 0xFC, 0x7F, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0x1F, 0xFF, 0xF9,
  0xFF, 0xFF, 0x1F, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xF8, 0xFF, 0x1F,
  0xE3, 0xFF, 0xF1, 0xFE, 0x3F, 0xC1, 0xFC, 0x3F, 0xFC, 0x3F, 0x87, 0xF8,
  0x3F, 0xC3, 0xFE, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xE1,
  0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80,
  0x03, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00,
  0x03, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF,
  0x81, 0xFF, 0x87, 0xFF, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xFB, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xFF, 0xFE, 0x07, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x9F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x3F,
  0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xC7, 0xFC, 0x7F, 0xC7, 0xF8, 0x7F,
  0x87, 0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x04, 0x01, 0xFE, 0x00, 0x1E,
  0x03, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFF, 0x8F, 0xE0, 0x01, 0xFF,
  0x9F, 0xC0, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x7F,
  0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x7F, 0xF1, 0xFE, 0x00, 0x7F, 0xE1, 0xFE,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3E, 0x07, 0xFC, 0x00, 0x3C, 0x07, 0xFC,
  0x00, 0x30, 0x0F, 0xE0, 0x00, 0x20, 0x1F, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x00,
  0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x07, 0xC1, 0xFE, 0x3F,
  0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE7, 0xFE, 0x7F,
  0xC1, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC3, 0xFF,
  0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x1F,
  0xFC, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x0F, 0xFC,
  0xFF, 0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F,
  0xE7, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0, 0x01,
  0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0x80,
  0x0F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xCF, 0xFC,
  0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0x3F,
  0xF0, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF,
  0x83, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F,
  0xFC, 0x07, 0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFD, 0xFF, 0x87, 0xFE, 0x7F, 0xE1, 0xFF, 0x1F, 0xF8,
  0x3F, 0x07, 0xFC, 0x0F, 0x83, 0xFF, 0x01, 0xC0, 0xFF, 0xC0, 0x20, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0xFF,
  0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x07,
  0x80, 0x07, 0xFF, 0x00, 0x0C, 0x00, 0x1F, 0xF8, 0x00, 0x20, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x81,
  0xFF, 0xF0, 0x03, 0xE0, 0x0F, 0xFF, 0x00, 0x18, 0x00, 0x7F, 0xF0, 0x01,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x80, 0x00, 0x0F,
  0xFE, 0x0E, 0x00, 0x01, 0xFF, 0xE0, 0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x03, 0xFD, 0xFF,
  0x00, 0x00, 0x3F, 0xDF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xE3, 0xFF, 0x00,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x3F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x80, 0x00, 0x3F, 0xFC, 0x1C, 0x00,
  0x0F, 0xFF, 0x03, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0xC7, 0xFF, 0x00,
  0x3F, 0xF3, 0xFF, 0xE0, 0x0F, 0xF9, 0xFF, 0xFC, 0x07, 0xFE, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xF0,
  0x0F, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xE3, 0xFF,
  0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x0F, 0xFC,
  0x3F, 0xE0, 0x03, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x8F, 0xFF, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x0F, 0xFE, 0x00,
  0x7F, 0xF3, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0x7F, 0xF8, 0x07,
  0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xE0, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xF0,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x1F,
  0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x87,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80,
  0x3F, 0xF1, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xE0,
  0x07, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x9F, 0xF8,
  0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x7F, 0xF3, 0xFF,
  0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFE, 0x7F,
  0xF0, 0x1F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xBF, 0xE0,
  0x7F, 0xFF, 0xDF, 0xF0, 0x1F, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0x8F, 0xFC,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x20, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8,
  0x07, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x7F, 0xF0,
  0xF0, 0x03, 0xFF, 0x0C, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0xFF,
  0xE0, 0xFE, 0x0F, 0xF0, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x7F, 0x1F, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xF1, 0xFC, 0x07,
  0xFF, 0x7F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x81, 0xFC, 0x07, 0xF3, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x07, 0xF7,
  0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x0F,
  0xE7, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x7F, 0x03, 0xF8, 0x07, 0xF8,
  0x0F, 0xEF, 0xE0, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0xFE, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0xEF, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0xFE, 0x07, 0xF0,
  0x0F, 0xF0, 0x1F, 0xCF, 0xE0, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0xFE, 0x0F,
  0xF0, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0,
  0xFE, 0x07, 0xF0, 0x7F, 0xE1, 0xFE, 0x0F, 0xE0, 0x7F, 0xDF, 0xFF, 0x7F,
  0xE0, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0xFF, 0x7F,
  0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xE3, 0xFF, 0xF0, 0x0F, 0xF0, 0x1F, 0xFC,
  0x3F, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xF0, 0x01,
  0x80, 0x01, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF7, 0xF8,
  0x00, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F,
  0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x07,
  0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x03,
  0xFE, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8,
  0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF,
  0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F,
  0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x3F, 0xF0,
  0x07, 0xFF, 0xC0, 0x07, 0x80, 0x3F, 0xFE, 0x00, 0x06, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x08, 0x01, 0xFF, 0xE0, 0x00, 0xE0,
  0x07, 0xFF, 0xE0, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xF0, 0x3F, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x01,
  0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x0F,
  0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF,
  0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3E, 0x00,
  0xFF, 0xFC, 0x00, 0x06, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x7F, 0xF0, 0x07, 0xFF, 0xFC, 0x3F, 0xF8, 0x03,
  0xFF, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0xFF,
  0x87, 0xFE, 0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xFF, 0xC1, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x81, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x00,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x80, 0x7F, 0xF8, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x87,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE3, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF3, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE7,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xBF, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0x7F,
  0x80, 0x0F, 0xF7, 0xFC, 0x00, 0x7F, 0xDF, 0xE0, 0x03, 0xFD, 0xFF, 0x00,
  0x1F, 0xF7, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x07, 0xFD, 0xFE, 0x00, 0x7F,
  0xBF, 0xF0, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xCF, 0xF8, 0x00, 0xFF, 0x9F,
  0xE0, 0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0xE7, 0xF8, 0x07, 0xF8, 0xFF, 0x80,
  0x0F, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0x80, 0xFF,
  0x1F, 0xF8, 0x00, 0xFF, 0x9F, 0xE0, 0x3F, 0xC7, 0xFC, 0x00, 0x7F, 0xC7,
  0xF8, 0x1F, 0xF1, 0xFF, 0x00, 0x1F, 0xF0, 0xFE, 0x07, 0xF8, 0x7F, 0xC0,
  0x07, 0xFC, 0x3F, 0x83, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x0F, 0xE0, 0xFF,
  0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFC, 0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xE0,
  0xFF, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xCF, 0xF8, 0x3F, 0xE0,
  0x03, 0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x83, 0xFD, 0xFF,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xF0,
  0x01, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xFE,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8,
  0x0F, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xFE,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x1F,
  0xF0, 0x01, 0xFF, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x07,
  0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x03,
  0xFF, 0x00, 0x1F, 0xE3, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xF0,
  0x7F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF,
  0x87, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xE0, 0x3F,
  0xE3, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF1, 0xFF, 0x00, 0x1F, 0xF0, 0x0F,
  0xFC, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0x01,
  0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xDF, 0xE0, 0x03, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x3F, 0xFF, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x00, 0x1F, 0xFC,
  0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x00,
  0x7F, 0xE7, 0xFF, 0x00, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x00, 0x1F, 0xFB,
  0xFF, 0x80, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x00,
  0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x03, 0xFF, 0xC7, 0xFF, 0x00,
  0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFE,
  0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00,
  0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x00, 0x3F,
  0xF7, 0xFF, 0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00, 0x0F, 0xFD, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x7F, 0xF7, 0xFE,
  0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x8F, 0xFC,
  0x00, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x01,
  0xFF, 0xE1, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE3, 0xFF, 0xF8,
  0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFC, 0x01,
  0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x03, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x00,
  0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x78, 0x01, 0xFF, 0xE0, 0x01, 0x80, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x04, 0x00, 0x01, 0xFF, 0xC0, 0x70, 0x00, 0x1F, 0xFC,
  0x07, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFE,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x5F, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xF3, 0xFE, 0x00, 0x00,
  0xFF, 0xC7, 0xFC, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x07, 0xFE, 0x1F,
  0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00,
  0x7F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00,
  0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x7F,
  0xCF, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x00, 0xFF, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0xFF, 0xC0, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x07,
  0xFB, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFE, 0x1F, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xF8,
  0x7F, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0,
  0x07, 0xFF, 0xF0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFF,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x3F, 0xDF, 0xE0, 0x3F, 0xF0, 0x07, 0xFC, 0x0F, 0xFB, 0xFC, 0x07,
  0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x7F, 0x81, 0xFF, 0x80, 0x1F, 0xF0, 0x3F,
  0xCF, 0xF0, 0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xF9, 0xFE, 0x0F, 0xFC, 0x00,
  0x7F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC7, 0xF8,
  0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xE3,
  0xFE, 0x1F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC3, 0xFC, 0x7F, 0xE0,
  0x00, 0xFF, 0x8F, 0xF0, 0x7F, 0x8F, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x0F,
  0xF1, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0xE0, 0x00, 0x7F,
  0x9F, 0xF0, 0x3F, 0xCF, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x07, 0xF9, 0xFF,
  0x00, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xDF, 0xF0,
  0x1F, 0xEF, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x83,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x87,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xCF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xDF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x03, 0xFF, 0x9F,
  0xF8, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x1F,
  0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x01,
  0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0xE0, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFE,
  0x3F, 0x80, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F,
  0xC1, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0x7F, 0x9F, 0xF0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC1,
  0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFF,
  0xE0, 0xFF, 0x00, 0x3F, 0xFF, 0x1F, 0xF0, 0x07, 0xFF, 0xF9, 0xFF, 0x00,
  0xFF, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F,
  0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF,
  0x83, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x1F, 0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x7F,
  0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFE,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0xFF, 0x80, 0x1F,
  0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0xF8, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0xE0,
  0x07, 0xFE, 0xFF, 0xFE, 0x00, 0xFF, 0xBF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x1F,
  0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE,
  0x0F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xE0,
  0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x0F, 0xFC, 0x3F,
  0xF0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0x80, 0x0F, 0xFC,
  0x3F, 0xF0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F,
  0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFF, 0xDF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xF7, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0xFF, 0x80,
  0x7F, 0x8F, 0xFF, 0xE0, 0x0F, 0xF0, 0xFF, 0xF8, 0x01, 0xFC, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0xF0, 0x1F, 0xFE, 0x00, 0x40, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x20, 0x1F, 0xFE, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00,
  0x1F, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0xFE,
  0xFF, 0x80, 0x07, 0xFF, 0xFD, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC1,
  0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xEF, 0xF0, 0x00, 0x7F, 0xFF, 0x9F,
  0xE0, 0x00, 0xFF, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0xF8, 0xFF, 0x00, 0x00,
  0x7F, 0xC1, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0x87, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x0F, 0xFC,
  0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x3F, 0xF0,
  0x03, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xFE, 0x7F, 0xE0,
  0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x40, 0xFF, 0xE0,
  0x01, 0xC0, 0xFF, 0xF0, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x04, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xE7, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x1F, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0xFC, 0x7F, 0xC0,
  0x07, 0xFF, 0xF9, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xE1, 0xFF, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFD, 0xFF, 0x80,
  0x07, 0xFF, 0xE7, 0xFE, 0x00, 0x0F, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0xFF, 0xC0, 0x00, 0x0E, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x02, 0x00, 0x00, 0xFF, 0xC0, 0x0E,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x8F,
  0xFF, 0x00, 0x3F, 0xF3, 0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0xFF, 0x00, 0xFF,
  0xBF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x80,
  0x3F, 0xF0, 0x7F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x1F, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x7F,
  0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF8, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x31, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF,
  0x83, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xF8,
  0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x01, 0xFF, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x01,
  0xFF, 0x83, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03,
  0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xE3, 0xFF, 0xF8, 0x3F, 0xFF,
  0x00, 0x7F, 0x9F, 0xFF, 0xE1, 0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0x07, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xE0, 0xFF, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xF0,
  0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x3F, 0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x83,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xC1, 0xFF,
  0xE0, 0x07, 0xF8, 0x7F, 0xFE, 0x00, 0xFF, 0x1F, 0xFF, 0xE0, 0x1F, 0xE7,
  0xFF, 0xFC, 0x03, 0xFD, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0x07,
  0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0,
  0x03, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F,
  0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8,
  0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F,
  0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0,
  0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x1F,
  0xF8, 0x7F, 0xE0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0x1F,
  0xFC, 0x03, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x7F,
  0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF,
  0x80, 0x0F, 0xFE, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF,
  0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xC3, 0xFF, 0xC0, 0x00, 0x7F, 0x8F,
  0xFF, 0xC0, 0x00, 0xFF, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0xFF, 0xFF, 0xC0,
  0x03, 0xFD, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFC,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F,
  0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0xFB, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xEF, 0xFF, 0xF0, 0x00, 0xFF, 0xCF, 0xFF, 0xC0, 0x01,
  0xFF, 0x9F, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x07,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x0F,
  0xF0, 0x01, 0xFF, 0xF0, 0xFF, 0x00, 0x3F, 0xFF, 0x9F, 0xF0, 0x07, 0xFF,
  0xF9, 0xFE, 0x00, 0xFF, 0xFF, 0xDF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x83, 0xFF,
  0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xC0,
  0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F,
  0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xE0, 0x07, 0xFE,
  0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xDF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xEF, 0xF8, 0x03, 0xFF, 0xFD,
  0xFF, 0x80, 0x1F, 0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0xF1, 0xFF, 0x00, 0x07,
  0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x07, 0xF8,
  0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0xC7, 0xFE, 0x03, 0xFE, 0x7F, 0xE0, 0x1F,
  0xE7, 0xFF, 0x00, 0xFF, 0x7F, 0xF8, 0x0F, 0xFB, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE7, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0xFC,
  0x07, 0xFE, 0x00, 0xE0, 0x1F, 0xF8, 0x00, 0x80, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC3, 0x00, 0x03, 0xFF, 0x0F, 0x00,
  0x1F, 0xFC, 0x3F, 0xC3, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xE7, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0xFF,
  0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0,
  0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x00,
  0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC1,
  0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFE,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x83,
  0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFD, 0xFE, 0x01, 0xFF,
  0xFF, 0xBF, 0xC0, 0x3F, 0xFF, 0xE7, 0xF8, 0x03, 0xFF, 0xF8, 0xFF, 0x00,
  0x3F, 0xFE, 0x1F, 0xC0, 0x03, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xC0,
  0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8,
  0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x80, 0x3F,
  0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x07, 0xF8, 0x7F, 0xE0, 0x03,
  0xFC, 0x3F, 0xE0, 0x01, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0x1F, 0xF0, 0x00,
  0x7F, 0x9F, 0xF8, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x1F, 0xEF, 0xFC, 0x00,
  0x0F, 0xF7, 0xFC, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFB, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x03, 0xFF, 0xE0,
  0x1F, 0xF8, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0x1F, 0xF0, 0x1F, 0xFF,
  0x80, 0x7F, 0xC3, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xF8, 0x7F, 0xC0, 0x7F,
  0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xFF, 0x07, 0xFE, 0x07, 0xFC,
  0x1F, 0xDF, 0xE0, 0xFF, 0xC0, 0xFF, 0x83, 0xFB, 0xFC, 0x1F, 0xF0, 0x1F,
  0xF0, 0xFF, 0x7F, 0x87, 0xFE, 0x03, 0xFE, 0x1F, 0xCF, 0xF0, 0xFF, 0x80,
  0x7F, 0xC7, 0xF9, 0xFE, 0x3F, 0xF0, 0x0F, 0xF0, 0xFF, 0x3F, 0xC7, 0xFC,
  0x01, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x80, 0x3F, 0xC7, 0xF8, 0xFE, 0x3F,
  0xE0, 0x07, 0xF8, 0xFE, 0x1F, 0xC7, 0xFC, 0x00, 0xFF, 0x3F, 0xC3, 0xF9,
  0xFF, 0x80, 0x1F, 0xE7, 0xF8, 0x7F, 0x3F, 0xE0, 0x03, 0xFC, 0xFE, 0x0F,
  0xE7, 0xFC, 0x00, 0x7F, 0xBF, 0xC1, 0xFD, 0xFF, 0x00, 0x0F, 0xF7, 0xF0,
  0x3F, 0xBF, 0xE0, 0x01, 0xFE, 0xFE, 0x07, 0xF7, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x83, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xCF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x00, 0xFF, 0xE7, 0xFC, 0x00, 0x00,
  0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE7,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x9F, 0xF0,
  0x00, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x04, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x8F, 0xFF, 0x80, 0x00, 0xCF, 0xFF,
  0xF0, 0x00, 0xEF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x30, 0x00, 0x0F, 0xFF, 0x10,
  0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 22, 52, 19, 0, -51 },
  { 144, 26, 19, 31, 7, -51 },
  { 206, 41, 51, 41, 1, -51 },
  { 468, 35, 58, 36, 1, -54 },
  { 722, 51, 52, 57, 4, -51 },
  { 1054, 44, 52, 45, 1, -51 },
  { 1340, 12, 19, 18, 7, -51 },
  { 1369, 25, 62, 22, 2, -51 },
  { 1563, 25, 63, 22, -5, -52 },
  { 1760, 31, 32, 35, 6, -54 },
  { 1884, 33, 34, 38, 3, -42 },
  { 2025, 17, 18, 19, -4, -9 },
  { 2064, 20, 8, 22, 1, -23 },
  { 2084, 12, 12, 19, 0, -11 },
  { 2102, 37, 52, 29, -3, -51 },
  { 2343, 34, 52, 36, 2, -51 },
  { 2564, 26, 51, 36, 7, -51 },
  { 2730, 38, 51, 36, -2, -51 },
  { 2973, 36, 52, 36, 0, -51 },
  { 3207, 37, 51, 36, -1, -51 },
  { 3443, 35, 52, 36, 1, -51 },
  { 3671, 34, 52, 36, 3, -51 },
  { 3892, 37, 51, 36, 2, -51 },
  { 4128, 35, 52, 36, 1, -51 },
  { 4356, 33, 52, 36, 2, -51 },
  { 4571, 18, 40, 19, 0, -39 },
  { 4661, 23, 48, 19, -4, -39 },
  { 4799, 33, 36, 38, 3, -44 },
  { 4948, 33, 22, 38, 3, -36 },
  { 5039, 33, 36, 38, 3, -44 },
  { 5188, 28, 52, 29, 4, -51 },
  { 5370, 52, 57, 55, 3, -51 },
  { 5741, 40, 51, 40, -4, -51 },
  { 5996, 39, 51, 40, 1, -51 },
  { 6245, 38, 52, 39, 4, -51 },
  { 6492, 41, 51, 44, 1, -51 },
  { 6754, 37, 51, 35, 1, -51 },
  { 6990, 36, 51, 34, 1, -51 },
  { 7220, 41, 52, 45, 4, -51 },
  { 7487, 45, 51, 45, 1, -51 },
  { 7774, 32, 51, 25, -2, -51 },
  { 7978, 34, 66, 21, -11, -51 },
  { 8259, 45, 51, 40, 1, -51 },
  { 8546, 28, 51, 33, 1, -51 },
  { 8725, 58, 51, 58, 1, -51 },
  { 9095, 49, 51, 49, 1, -51 },
  { 9408, 41, 52, 47, 4, -51 },
  { 9675, 40, 51, 39, 1, -51 },
  { 9930, 41, 63, 47, 4, -51 },
  { 10253, 38, 51, 40, 1, -51 },
  { 10496, 36, 52, 35, 0, -51 },
  { 10730, 33, 51, 34, 6, -51 },
  { 10941, 42, 52, 45, 4, -51 },
  { 11214, 39, 51, 39, 6, -51 },
  { 11463, 59, 51, 58, 6, -51 },
  { 11840, 48, 51, 39, -4, -51 },
  { 12146, 37, 51, 36, 6, -51 },
  { 12382, 40, 51, 34, -2, -51 },
  { 12637, 29, 62, 22, -2, -51 },
  { 12862, 17, 52, 29, 7, -51 },
  { 12973, 29, 62, 22, -5, -51 },
  { 13198, 34, 32, 36, 1, -51 },
  { 13334, 28, 5, 26, -7, 6 },
  { 13352, 15, 11, 22, 10, -54 },
  { 13373, 36, 40, 39, 2, -39 },
  { 13553, 35, 55, 39, 1, -54 },
  { 13794, 31, 40, 31, 2, -39 },
  { 13949, 39, 55, 39, 2, -54 },
  { 14218, 32, 40, 36, 3, -39 },
  { 14378, 40, 71, 24, -8, -54 },
  { 14733, 38, 56, 39, 0, -39 },
  { 14999, 35, 54, 39, 1, -54 },
  { 15236, 21, 54, 19, 1, -54 },
  { 15378, 31, 71, 19, -9, -54 },
  { 15654, 39, 54, 37, 1, -54 },
  { 15918, 21, 54, 19, 1, -54 },
  { 16060, 54, 39, 58, 1, -39 },
  { 16324, 35, 39, 39, 1, -39 },
  { 16495, 32, 40, 38, 3, -39 },
  { 16655, 39, 56, 39, -3, -39 },
  { 16928, 36, 56, 39, 2, -39 },
  { 17180, 29, 39, 27, 1, -39 },
  { 17322, 30, 40, 31, 0, -39 },
  { 17472, 25, 48, 26, 3, -47 },
  { 17622, 35, 40, 39, 3, -39 },
  { 17797, 33, 39, 33, 4, -39 },
  { 17958, 51, 39, 51, 4, -39 },
  { 18207, 42, 39, 35, -4, -39 },
  { 18412, 43, 56, 34, -5, -39 },
  { 18713, 33, 39, 30, -2, -39 },
  { 18874, 29, 62, 25, 0, -51 },
  { 19099, 8, 70, 35, 13, -54 },
  { 19169, 29, 62, 25, -4, -51 },
  { 19394, 33, 12, 38, 3, -31 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic71pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC71PT7B_H_
