#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC19PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x73, 0x8E, 0x38, 0xE3, 0x0C, 0x71, 0xC0, 0x18, 0xE3, 0x80,
  0x6F, 0xDB, 0x36, 0x6D, 0xC0, 0x06, 0x60, 0xD8, 0x33, 0x06, 0x63, 0xFE,
  0xFF, 0xC6, 0x60, 0xC8, 0xFF, 0xDF, 0xF8, 0xCC, 0x1B, 0x06, 0x60, 0xCC,
  0x00, 0x02, 0x03, 0xF1, 0xF8, 0xFA, 0x34, 0x0F, 0x03, 0xE0, 0x7C, 0x0F,
  0x82, 0xEC, 0xBB, 0xFC, 0xFE, 0x04, 0x01, 0x00, 0x18, 0x31, 0xF0, 0xC6,
  0xC6, 0x3B, 0x30, 0xCC, 0xC3, 0x36, 0x0D, 0xB7, 0xBE, 0xFF, 0x76, 0xDC,
  0x33, 0x70, 0xCD, 0x86, 0x76, 0x30, 0xF9, 0xC3, 0xC0, 0x07, 0x00, 0xF8,
  0x1D, 0xC1, 0x9C, 0x19, 0x81, 0xF8, 0x0E, 0x03, 0xE7, 0x77, 0x66, 0x7E,
  0xE3, 0xCE, 0x38, 0x7F, 0xC3, 0xEE, 0x7F, 0xEC, 0x0C, 0x73, 0x8C, 0x71,
  0x8E, 0x38, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xE0, 0x18, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x31, 0xC6, 0x38, 0xC7, 0x18, 0xC0, 0x10, 0x1C,
  0x98, 0xF9, 0xFF, 0x3F, 0x68, 0xEC, 0x4C, 0x18, 0x0C, 0x06, 0x1F, 0xFF,
  0xF8, 0xC0, 0x60, 0x30, 0x18, 0x00, 0x37, 0x6E, 0xC0, 0x7F, 0xE0, 0x7F,
  0x80, 0x00, 0xC0, 0x70, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C,
  0x06, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x00, 0x0E, 0x1F, 0x8F, 0xCE, 0x6E,
  0x3F, 0x1B, 0x8D, 0x86, 0xC7, 0x63, 0xB1, 0x99, 0xCF, 0xC3, 0xC0, 0x0E,
  0x3C, 0xF7, 0xED, 0xD3, 0x86, 0x0C, 0x38, 0x70, 0xE1, 0x83, 0x0E, 0x00,
  0x07, 0x83, 0xF8, 0x7F, 0x08, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x1C, 0x07,
  0x01, 0xC0, 0xE0, 0x38, 0x07, 0xF9, 0xFF, 0x00, 0x0F, 0x0F, 0xE1, 0xFC,
  0x07, 0x01, 0x80, 0xE1, 0xF0, 0x7C, 0x07, 0x00, 0xE0, 0x3A, 0x1C, 0xFF,
  0x3F, 0x00, 0x01, 0xC0, 0xE0, 0x78, 0x1E, 0x0F, 0x86, 0xC3, 0x31, 0xCC,
  0x67, 0x3F, 0xEF, 0xF8, 0x18, 0x0E, 0x03, 0x80, 0x1F, 0xC7, 0xF1, 0xF8,
  0xE0, 0x38, 0x0D, 0x03, 0xF1, 0xFE, 0x03, 0x80, 0xE0, 0x32, 0x1C, 0xFE,
  0x3F, 0x00, 0x07, 0x8F, 0xCF, 0x6E, 0x07, 0x07, 0x73, 0xFD, 0xEE, 0xE7,
  0x63, 0xB1, 0xDD, 0xCF, 0xE3, 0xE0, 0x7F, 0xDF, 0xE7, 0xF8, 0x0C, 0x07,
  0x01, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x00,
  0x0F, 0x07, 0xE3, 0x9C, 0xE7, 0x39, 0xCE, 0xE1, 0xF0, 0xFC, 0x77, 0x18,
  0xEE, 0x3B, 0x8E, 0x7F, 0x0F, 0x80, 0x0E, 0x0F, 0xCE, 0xE6, 0x37, 0x1B,
  0x8D, 0xCE, 0xFF, 0x3F, 0x81, 0x81, 0xC1, 0xCF, 0xE7, 0xC0, 0x11, 0xCE,
  0x60, 0x00, 0x00, 0x67, 0x38, 0x08, 0x71, 0xC6, 0x00, 0x00, 0x00, 0x01,
  0xC7, 0x18, 0xE3, 0x00, 0x00, 0x81, 0xC3, 0xE7, 0xCF, 0x07, 0x01, 0xF0,
  0x3E, 0x07, 0x80, 0x40, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x80,
  0x60, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x79, 0xF0, 0xE0, 0x40, 0x00, 0x1C,
  0x7E, 0x6F, 0x07, 0x06, 0x0E, 0x3C, 0x30, 0x70, 0x60, 0x00, 0x60, 0xE0,
  0xE0, 0x01, 0xC0, 0x3F, 0xC1, 0xC3, 0x8C, 0x06, 0x63, 0xCD, 0x9F, 0x3C,
  0xCC, 0xF6, 0x32, 0xD9, 0x9B, 0x66, 0x6D, 0xFF, 0x33, 0xB8, 0xC0, 0x01,
  0x81, 0x03, 0xF8, 0x03, 0x80, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0x60, 0xEC,
  0x19, 0x83, 0x30, 0xE6, 0x1F, 0xC7, 0xF8, 0xFF, 0x38, 0x76, 0x0F, 0xC1,
  0xC0, 0x1F, 0x03, 0xF8, 0x7F, 0x8C, 0x73, 0x8E, 0x73, 0x8F, 0xE1, 0xFC,
  0x71, 0xCE, 0x39, 0xC7, 0x31, 0xC7, 0xF9, 0xFC, 0x00, 0x07, 0x87, 0xF3,
  0xFD, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC4,
  0x7F, 0x0F, 0xC0, 0x1E, 0x03, 0xF8, 0x7F, 0x8C, 0x73, 0x8E, 0x71, 0xCE,
  0x39, 0x87, 0x70, 0xEE, 0x1D, 0xC7, 0x3B, 0xC7, 0xF1, 0xFC, 0x00, 0x1F,
  0xC7, 0xF1, 0xFC, 0x60, 0x38, 0x0E, 0x03, 0xF8, 0xFC, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x7F, 0x3F, 0x80, 0x1F, 0xC7, 0xF1, 0xFC, 0x60, 0x38, 0x0E,
  0x03, 0xF8, 0xFC, 0x7F, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x00, 0x07,
  0xC3, 0xFC, 0xFF, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0xF7, 0x3E, 0xE7, 0xDC,
  0x3B, 0x86, 0x79, 0xC7, 0xF8, 0x7F, 0x00, 0x1C, 0x31, 0xC7, 0x18, 0x71,
  0x87, 0x38, 0x73, 0x86, 0x3F, 0xE3, 0xFE, 0x70, 0xE7, 0x0E, 0x70, 0xC7,
  0x1C, 0x61, 0xCE, 0x1C, 0x1F, 0x8F, 0xC3, 0x81, 0xC0, 0xE0, 0x60, 0x70,
  0x38, 0x1C, 0x0E, 0x06, 0x07, 0x07, 0xC7, 0xE0, 0x03, 0x81, 0xC0, 0xE0,
  0x60, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60,
  0x71, 0x78, 0xF8, 0x78, 0x00, 0x1C, 0x71, 0xCE, 0x18, 0xE1, 0x9C, 0x3B,
  0x83, 0xF0, 0x3F, 0x03, 0xE0, 0x7F, 0x07, 0x70, 0x73, 0x06, 0x38, 0x63,
  0x8E, 0x3C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70,
  0x70, 0x70, 0x7F, 0xFE, 0x1E, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x3E, 0x3E, 0x36, 0x3E, 0x36, 0x6C, 0x36, 0x6C, 0x76, 0xCC, 0x76, 0xDC,
  0x67, 0x9C, 0x67, 0x98, 0x67, 0x18, 0xE7, 0x38, 0x1C, 0x18, 0xF0, 0xC7,
  0x8E, 0x3C, 0x73, 0xE3, 0x1B, 0x98, 0xDC, 0xC6, 0x6E, 0x73, 0x73, 0x9F,
  0x18, 0xF8, 0xC3, 0xC6, 0x1E, 0x70, 0xF0, 0x07, 0x83, 0xF8, 0xFF, 0xBC,
  0x77, 0x0E, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3B, 0x87, 0x79, 0xC7,
  0xF8, 0x7C, 0x00, 0x1F, 0x03, 0xF8, 0x7F, 0x8C, 0x73, 0x8E, 0x71, 0xCE,
  0x71, 0xFE, 0x7F, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x00, 0x07,
  0x83, 0xF8, 0xFF, 0xBC, 0x77, 0x0E, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x3B, 0x87, 0x79, 0xC7, 0xF8, 0x7C, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x1E,
  0x07, 0xF1, 0xFC, 0x63, 0x38, 0xCE, 0x73, 0xBC, 0xFE, 0x7F, 0x1D, 0xC7,
  0x31, 0xCE, 0x63, 0xB8, 0x70, 0x07, 0x07, 0xF3, 0xF8, 0xE0, 0x38, 0x0E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x73, 0x1C, 0xFE, 0x3F, 0x00, 0xFF,
  0xFF, 0xBF, 0xC7, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C,
  0x0E, 0x07, 0x00, 0x38, 0x67, 0x1C, 0xC3, 0xB8, 0x77, 0x0C, 0xE3, 0x9C,
  0x73, 0x0E, 0xE1, 0xDC, 0x33, 0x8E, 0x73, 0xC7, 0xF0, 0xFC, 0x00, 0xC1,
  0xF0, 0x7C, 0x3B, 0x0E, 0xC7, 0x31, 0xCE, 0xE3, 0xB8, 0xEC, 0x3F, 0x0F,
  0x83, 0xE0, 0xF0, 0x1C, 0x00, 0xC3, 0x87, 0x87, 0x1F, 0x1E, 0x36, 0x3C,
  0xEC, 0x79, 0xD9, 0xB3, 0x33, 0x6E, 0x6E, 0xD8, 0xD9, 0xF1, 0xB3, 0xE3,
  0xC7, 0x87, 0x8F, 0x0E, 0x1C, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0xE3, 0x83,
  0x38, 0x1D, 0xC0, 0xFC, 0x07, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x80, 0xFC,
  0x0E, 0xE0, 0x73, 0x87, 0x1C, 0x70, 0xE0, 0xC3, 0xF1, 0xF9, 0xDC, 0xE6,
  0xE3, 0x61, 0xF0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x00, 0x1F,
  0xE3, 0xFC, 0x7F, 0x80, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x03,
  0x80, 0xE0, 0x38, 0x07, 0xF9, 0xFF, 0x00, 0x0F, 0x0F, 0x0C, 0x1C, 0x18,
  0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x70, 0x70, 0x60, 0x78, 0xF8,
  0xCC, 0xEE, 0x66, 0x66, 0x67, 0x73, 0x33, 0x1E, 0x3C, 0x18, 0x70, 0xE1,
  0x83, 0x06, 0x1C, 0x38, 0x60, 0xC1, 0x87, 0x0C, 0x78, 0xF0, 0x02, 0x03,
  0x03, 0xC1, 0xE1, 0xB1, 0xD8, 0xC6, 0xC3, 0xE1, 0x80, 0xFF, 0xEE, 0x70,
  0x08, 0x1E, 0xDF, 0xEE, 0x7E, 0x37, 0x1B, 0x1D, 0x8E, 0xEF, 0x7F, 0x1D,
  0x80, 0x1C, 0x06, 0x01, 0x80, 0xE4, 0x3F, 0x8F, 0xF3, 0x9C, 0xC7, 0x71,
  0xDC, 0x67, 0x39, 0xCE, 0xFF, 0x37, 0x80, 0x0C, 0x3F, 0x7E, 0x60, 0xE0,
  0xE0, 0xC0, 0xC0, 0xE4, 0xFC, 0x7C, 0x01, 0xC0, 0x70, 0x18, 0x26, 0x3F,
  0x9F, 0xE6, 0x3B, 0x8C, 0xE3, 0x31, 0xCC, 0x73, 0x9C, 0xFE, 0x1D, 0x80,
  0x0C, 0x3F, 0x77, 0x63, 0xE7, 0xFE, 0xF8, 0xC0, 0xE2, 0xFE, 0x7E, 0x00,
  0xA0, 0x78, 0x1F, 0x03, 0x80, 0x60, 0x3F, 0x07, 0xE0, 0x70, 0x0E, 0x01,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x1F, 0x03,
  0xC0, 0x20, 0x00, 0x04, 0x07, 0xB3, 0xFC, 0xC7, 0x71, 0x9C, 0x66, 0x39,
  0x8E, 0x77, 0x9F, 0xC3, 0xB0, 0x1C, 0x07, 0x3F, 0x8F, 0xC0, 0xC0, 0x1C,
  0x06, 0x01, 0x80, 0xE4, 0x3F, 0x8F, 0xF3, 0x9C, 0xC7, 0x71, 0x9C, 0xE7,
  0x39, 0x8E, 0xE3, 0xB8, 0xC0, 0x1C, 0x70, 0x00, 0x38, 0xE3, 0x0C, 0x71,
  0xC7, 0x18, 0xE3, 0x80, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x0C, 0x0C,
  0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x38, 0xF0, 0xF0, 0xC0, 0x1C,
  0x03, 0x00, 0x60, 0x1C, 0x13, 0x9C, 0x77, 0x0D, 0xC1, 0xF0, 0x7E, 0x0F,
  0xC1, 0xD8, 0x33, 0x8E, 0x71, 0xC7, 0x00, 0x1C, 0x61, 0x8E, 0x38, 0xE3,
  0x0C, 0x71, 0xC7, 0x18, 0xE3, 0x80, 0x01, 0x08, 0x6F, 0x78, 0xFF, 0xF9,
  0xCE, 0x73, 0x1C, 0xEE, 0x31, 0x9C, 0xE3, 0x39, 0xCE, 0x63, 0x9D, 0xC6,
  0x3B, 0x9C, 0x60, 0x01, 0x0D, 0xE3, 0xFC, 0xE7, 0x31, 0xDC, 0x67, 0x19,
  0xCE, 0x63, 0xB8, 0xEE, 0x30, 0x0C, 0x3F, 0x7F, 0xE3, 0xE3, 0xE3, 0xC3,
  0xC7, 0xE7, 0xFE, 0x7C, 0x00, 0x83, 0x78, 0x7F, 0x8E, 0x71, 0x8E, 0x71,
  0xCE, 0x31, 0xCE, 0x39, 0xCF, 0xF1, 0xDC, 0x38, 0x06, 0x00, 0xC0, 0x38,
  0x07, 0x00, 0x08, 0x1E, 0xDF, 0xEC, 0x7E, 0x37, 0x1B, 0x1D, 0x8E, 0xE7,
  0x7F, 0x1D, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x09, 0x37, 0x3F, 0x38,
  0x30, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0x0C, 0x3F, 0x7E, 0x70, 0x78,
  0x3C, 0x1E, 0x0E, 0x8E, 0xFE, 0xFC, 0x18, 0xC3, 0x3F, 0xFD, 0xC6, 0x18,
  0xE3, 0x8E, 0x3E, 0xF8, 0x73, 0xB1, 0xD8, 0xFC, 0x6E, 0x37, 0x3B, 0x1D,
  0xDE, 0xFE, 0x7B, 0x00, 0xE3, 0xF3, 0xB9, 0xDD, 0xCE, 0xE3, 0x61, 0xF0,
  0xF0, 0x70, 0x38, 0x00, 0xE7, 0x1F, 0x9C, 0xEE, 0xF3, 0x3B, 0xDC, 0xFB,
  0x73, 0xED, 0x8F, 0xBE, 0x3C, 0xF0, 0xF3, 0xC3, 0x8E, 0x00, 0x38, 0xE3,
  0xB8, 0x7E, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0xC1, 0xD8, 0x73, 0x9C, 0x70,
  0x38, 0xE7, 0x38, 0xE7, 0x1D, 0xC1, 0xB8, 0x36, 0x07, 0xC0, 0xF0, 0x1E,
  0x03, 0x80, 0x70, 0x1C, 0x0F, 0x01, 0xE0, 0x30, 0x00, 0x1F, 0x9F, 0xC1,
  0xC0, 0xC0, 0xE0, 0xE0, 0xE0, 0x60, 0x7F, 0x7F, 0x00, 0x03, 0x0F, 0x0E,
  0x1C, 0x1C, 0x18, 0x18, 0x78, 0xE0, 0xF0, 0x30, 0x30, 0x70, 0x70, 0x70,
  0x78, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x10, 0x1C, 0x1C, 0x0C, 0x0C,
  0x0C, 0x1C, 0x0D, 0x0E, 0x1E, 0x18, 0x38, 0x38, 0x30, 0x70, 0xF0, 0xE0,
  0xF8, 0xFF, 0xE1, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 14, 5, 0, -14 },
  { 12, 7, 5, 8, 2, -14 },
  { 17, 11, 14, 11, 0, -14 },
  { 37, 10, 15, 10, 0, -14 },
  { 56, 14, 14, 15, 1, -14 },
  { 81, 12, 14, 12, 0, -14 },
  { 102, 3, 5, 5, 2, -14 },
  { 104, 6, 17, 6, 1, -14 },
  { 117, 6, 17, 6, -1, -14 },
  { 130, 8, 9, 9, 2, -15 },
  { 139, 9, 9, 10, 1, -11 },
  { 150, 4, 5, 5, -1, -2 },
  { 153, 6, 2, 6, 0, -6 },
  { 155, 3, 3, 5, 0, -3 },
  { 157, 10, 14, 8, -1, -14 },
  { 175, 9, 14, 10, 1, -14 },
  { 191, 7, 14, 10, 2, -14 },
  { 204, 11, 14, 10, -1, -14 },
  { 224, 10, 14, 10, 0, -14 },
  { 242, 10, 14, 10, 0, -14 },
  { 260, 10, 14, 10, 0, -14 },
  { 278, 9, 14, 10, 1, -14 },
  { 294, 10, 14, 10, 1, -14 },
  { 312, 10, 14, 10, 0, -14 },
  { 330, 9, 14, 10, 0, -14 },
  { 346, 5, 11, 5, 0, -11 },
  { 353, 6, 14, 5, -1, -11 },
  { 364, 9, 10, 10, 1, -12 },
  { 376, 9, 6, 10, 1, -10 },
  { 383, 9, 10, 10, 1, -12 },
  { 395, 8, 14, 8, 1, -14 },
  { 409, 14, 16, 15, 1, -14 },
  { 437, 11, 14, 11, -1, -14 },
  { 457, 11, 14, 11, 0, -14 },
  { 477, 10, 14, 10, 1, -14 },
  { 495, 11, 14, 12, 0, -14 },
  { 515, 10, 14, 9, 0, -14 },
  { 533, 10, 14, 9, 0, -14 },
  { 551, 11, 14, 12, 1, -14 },
  { 571, 12, 14, 12, 0, -14 },
  { 592, 9, 14, 7, -1, -14 },
  { 608, 9, 18, 6, -3, -14 },
  { 629, 12, 14, 11, 0, -14 },
  { 650, 8, 14, 9, 0, -14 },
  { 664, 16, 14, 15, 0, -14 },
  { 692, 13, 14, 13, 0, -14 },
  { 715, 11, 14, 13, 1, -14 },
  { 735, 11, 14, 11, 0, -14 },
  { 755, 11, 17, 13, 1, -14 },
  { 779, 10, 14, 11, 0, -14 },
  { 797, 10, 14, 9, 0, -14 },
  { 815, 9, 14, 9, 2, -14 },
  { 831, 11, 14, 12, 1, -14 },
  { 851, 10, 14, 10, 2, -14 },
  { 869, 15, 14, 16, 2, -14 },
  { 896, 13, 14, 10, -1, -14 },
  { 919, 9, 14, 10, 2, -14 },
  { 935, 11, 14, 9, -1, -14 },
  { 955, 8, 17, 6, -1, -14 },
  { 972, 4, 14, 8, 2, -14 },
  { 979, 7, 17, 6, -1, -14 },
  { 994, 9, 9, 10, 0, -14 },
  { 1005, 8, 1, 7, -2, 2 },
  { 1006, 4, 3, 6, 3, -15 },
  { 1008, 9, 11, 10, 1, -11 },
  { 1021, 10, 14, 10, 0, -14 },
  { 1039, 8, 11, 8, 1, -11 },
  { 1050, 10, 14, 10, 1, -14 },
  { 1068, 8, 11, 10, 1, -11 },
  { 1079, 11, 20, 6, -2, -15 },
  { 1107, 10, 16, 10, 0, -11 },
  { 1127, 10, 14, 10, 0, -14 },
  { 1145, 6, 14, 5, 0, -14 },
  { 1156, 8, 19, 5, -2, -14 },
  { 1175, 11, 14, 10, 0, -14 },
  { 1195, 6, 14, 5, 0, -14 },
  { 1206, 15, 11, 16, 0, -11 },
  { 1227, 10, 11, 10, 0, -11 },
  { 1241, 8, 11, 10, 1, -11 },
  { 1252, 11, 16, 10, -1, -11 },
  { 1274, 9, 16, 10, 1, -11 },
  { 1292, 8, 11, 7, 0, -11 },
  { 1303, 8, 11, 8, 0, -11 },
  { 1314, 6, 13, 7, 1, -13 },
  { 1324, 9, 10, 10, 1, -10 },
  { 1336, 9, 10, 9, 1, -10 },
  { 1348, 14, 10, 14, 1, -10 },
  { 1366, 11, 10, 9, -1, -10 },
  { 1380, 11, 15, 9, -1, -10 },
  { 1401, 9, 10, 8, -1, -10 },
  { 1413, 8, 17, 7, 0, -14 },
  { 1430, 2, 18, 9, 4, -14 },
  { 1435, 8, 17, 7, -1, -14 },
  { 1452, 9, 3, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC19PT7B_H_
