#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC40PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7C, 0x00, 0x7E, 0x7D, 0xF1,
  0xF7, 0xC7, 0xDF, 0x1E, 0x7C, 0xF9, 0xE3, 0xEF, 0x8F, 0xBE, 0x3C, 0xF0,
  0xF3, 0xC3, 0xCF, 0x0E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0xF0, 0x01,
  0xE1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C,
  0x78, 0x00, 0x78, 0xF0, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF0, 0x3C, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xF1, 0xE0,
  0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x01, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F,
  0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xE0, 0x01, 0xE3,
  0xC0, 0x07, 0x87, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFE, 0xDE,
  0x1F, 0xB8, 0x83, 0xE6, 0x00, 0x7C, 0xC0, 0x0F, 0xD8, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x67, 0xC0, 0x0C, 0xFD, 0x01, 0x9F, 0x30, 0x73, 0xE7,
  0xCF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFC, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0x7F, 0x80, 0x3C, 0x07, 0xFC, 0x03, 0xE0, 0x7F, 0xF0, 0x1E, 0x03,
  0xE7, 0x81, 0xE0, 0x3E, 0x3C, 0x1F, 0x01, 0xF1, 0xE0, 0xF0, 0x0F, 0x0F,
  0x0F, 0x00, 0x78, 0xF8, 0xF8, 0x07, 0xC7, 0xC7, 0x80, 0x3E, 0x3E, 0x78,
  0x01, 0xF1, 0xE7, 0xC2, 0x0F, 0x9F, 0x3C, 0xFE, 0x7C, 0xF3, 0xCF, 0xFB,
  0xFF, 0xBE, 0xFF, 0xCF, 0xF9, 0xE7, 0xDF, 0x3F, 0x9E, 0x7C, 0xF8, 0xF9,
  0xF3, 0xC7, 0xC0, 0x0F, 0x3E, 0x3E, 0x00, 0xF1, 0xF1, 0xF0, 0x0F, 0x8F,
  0x0F, 0x00, 0x78, 0x78, 0x78, 0x07, 0x83, 0xC7, 0xC0, 0x7C, 0x1E, 0x3E,
  0x03, 0xC0, 0xF1, 0xE0, 0x3C, 0x07, 0xFF, 0x03, 0xE0, 0x3F, 0xF0, 0x1E,
  0x00, 0xFF, 0x01, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xF3, 0xE0, 0x07, 0xE3,
  0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC7,
  0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x3F, 0x1F, 0xFC, 0x3F, 0x3F, 0xFC, 0x3E, 0x7F, 0x7E,
  0x7E, 0x7E, 0x7F, 0x7C, 0xFC, 0x3F, 0xFC, 0xFC, 0x1F, 0xF8, 0xFC, 0x1F,
  0xF0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFF, 0x7F, 0xE0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFD, 0xF8, 0x1F, 0xF1, 0xFC, 0x7E, 0xF9,
  0xF3, 0xE7, 0xCF, 0x3E, 0x7C, 0xF1, 0xE3, 0xC0, 0x00, 0x3C, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80,
  0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x0F, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x20, 0xF0, 0x1E,
  0x3C, 0x07, 0xEF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F,
  0xFC, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xDE, 0x07, 0xE7, 0xC0, 0xF9, 0xF0,
  0x1C, 0x3E, 0x02, 0x0E, 0x00, 0x02, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x0F, 0x8F, 0xC7, 0xC3, 0xE3, 0xF1, 0xF1, 0xF8,
  0xF8, 0x78, 0x7C, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFC, 0x3C,
  0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x8F,
  0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x3F, 0x03, 0xE7, 0xE0, 0xFC, 0xF8, 0x1F,
  0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x01, 0xFF, 0xE0, 0x3E,
  0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xCF, 0xC1, 0xF9,
  0xF8, 0x3F, 0x3F, 0x0F, 0xC7, 0xE3, 0xF8, 0x7E, 0xFE, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x1F,
  0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0xE7, 0xFF, 0xBF, 0xBE, 0xFD, 0xF9, 0xE7,
  0xE2, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83,
  0xE1, 0xFC, 0x0E, 0x07, 0xE0, 0x20, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x38, 0x3F, 0x02, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC8, 0x01, 0xF8, 0xF8, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xBE,
  0x00, 0xFF, 0xC0, 0x0F, 0x7C, 0x01, 0xE7, 0xC0, 0x3E, 0xFC, 0x07, 0xCF,
  0xC0, 0xF8, 0xF8, 0x0F, 0x0F, 0x81, 0xF0, 0xF8, 0x3E, 0x1F, 0x87, 0xC1,
  0xF8, 0x78, 0x1F, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0xCC, 0x03, 0xF8, 0xFD, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x18, 0x03, 0xE7, 0xF0,
  0x3E, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xF0, 0xFC, 0x7E, 0x0F,
  0xC7, 0xE0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0,
  0xF8, 0x7C, 0x1F, 0x87, 0xC1, 0xF8, 0x7F, 0x7F, 0x07, 0xFF, 0xF0, 0x3F,
  0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xE7,
  0xE0, 0xF8, 0x3E, 0x1F, 0x83, 0xF1, 0xF8, 0x3E, 0x1F, 0x83, 0xE1, 0xF8,
  0x7E, 0x0F, 0xCF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xF3, 0xF8, 0x7C, 0x1F, 0x8F,
  0xC0, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0xC1, 0xF8,
  0xFC, 0x3F, 0x8F, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3E, 0x07, 0xEF, 0xC0,
  0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0xFE, 0xFC, 0x3F, 0x8F, 0xFF,
  0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFD, 0xF0, 0x1F, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0xC3, 0xFC,
  0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0x8F, 0xE3, 0xF8, 0xFC,
  0x1F, 0x00, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF0,
  0x00, 0x7C, 0x00, 0x03, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0x80, 0x0F, 0x80, 0x03, 0x80, 0x00, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x1F, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0x38, 0x3F, 0x20, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x1E, 0x0F, 0x03, 0xFC, 0x7C, 0x7C, 0x3F, 0xF8, 0xF1, 0xE1, 0xFF,
  0xE3, 0xCF, 0x0F, 0xCF, 0x0F, 0x3C, 0x3C, 0x3C, 0x3D, 0xF1, 0xE0, 0xF0,
  0xF7, 0x87, 0x87, 0xC3, 0xDE, 0x3C, 0x1E, 0x1E, 0x78, 0xF0, 0x78, 0x79,
  0xE3, 0xC1, 0xE1, 0xE7, 0x8F, 0x0F, 0x8F, 0xBC, 0x3C, 0x3C, 0x3C, 0xF0,
  0xF1, 0xF1, 0xF1, 0xE3, 0xFF, 0xFF, 0x87, 0x8F, 0xF7, 0xFC, 0x1E, 0x1F,
  0xCF, 0xE0, 0x78, 0x3C, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x02, 0x00, 0x1F, 0xC0, 0x78, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x01, 0xF3, 0xE0,
  0x07, 0xCF, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x1F,
  0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xE0, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xF8, 0x07, 0xCF,
  0xC0, 0x1F, 0x3F, 0x00, 0x7D, 0xF8, 0x01, 0xF7, 0xE0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7C, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF,
  0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x0F, 0xF0, 0xFC, 0x0F, 0xC3,
  0xF0, 0x3F, 0x0F, 0xC0, 0xF8, 0x3E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE1,
  0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x3F, 0x1F, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xFC, 0x7E,
  0x03, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x03, 0xF8, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x3F, 0xC1, 0xC1, 0xFE, 0x01, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x40, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xF8,
  0xFF, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0x80,
  0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F,
  0xC7, 0xC0, 0x1F, 0x9F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8,
  0xFC, 0x07, 0xF1, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x8F, 0xC0, 0xFE, 0x1F,
  0x83, 0xFC, 0x3F, 0x0F, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0x3F, 0xFF, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0x07, 0x83, 0xF8, 0x02, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC1, 0xFF, 0xBF, 0x07, 0xFE, 0x7E, 0x0F, 0xFC, 0xFC, 0x1F, 0xF9, 0xF8,
  0x3F, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80,
  0x7E, 0x3F, 0x80, 0xFC, 0x3F, 0x81, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xE0,
  0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E,
  0x01, 0xF0, 0x3E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F,
  0xC0, 0x3E, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x3F,
  0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07,
  0xE0, 0x7C, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0x7C, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8,
  0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x1F,
  0x80, 0xFC, 0x1F, 0xC0, 0x7C, 0x1F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xCF, 0xE0, 0x03, 0xE7,
  0xE0, 0x03, 0xF7, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xDF, 0x00, 0x0F,
  0xCF, 0xC0, 0x07, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0xFC, 0x01,
  0xF8, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0x80, 0x7E, 0x00, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x03,
  0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x07,
  0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F,
  0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0xFC, 0x1F, 0x7C, 0x3E,
  0xF8, 0x1F, 0x7C, 0x7C, 0xF8, 0x3F, 0x7C, 0x7C, 0xF8, 0x3E, 0x7C, 0x79,
  0xF8, 0x3E, 0x3C, 0xF9, 0xF0, 0x3E, 0x3C, 0xF1, 0xF0, 0x3E, 0x3D, 0xF1,
  0xF0, 0x7E, 0x3D, 0xE1, 0xF0, 0x7C, 0x3F, 0xE3, 0xF0, 0x7C, 0x3F, 0xC3,
  0xE0, 0x7C, 0x3F, 0xC3, 0xE0, 0x7C, 0x3F, 0x83, 0xE0, 0xFC, 0x3F, 0x83,
  0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3E, 0x07,
  0xC0, 0x03, 0xF0, 0x03, 0xE0, 0xFE, 0x00, 0x7C, 0x1F, 0xE0, 0x1F, 0x83,
  0xFC, 0x03, 0xE0, 0x7F, 0x80, 0x7C, 0x0F, 0xF0, 0x0F, 0x83, 0xFF, 0x03,
  0xF0, 0x7F, 0xE0, 0x7E, 0x0F, 0xFC, 0x0F, 0x81, 0xFF, 0xC1, 0xF0, 0x7C,
  0xF8, 0x3E, 0x0F, 0x9F, 0x0F, 0xC1, 0xF3, 0xE1, 0xF0, 0x3E, 0x7E, 0x3E,
  0x07, 0xC7, 0xC7, 0xC1, 0xF8, 0xF8, 0xF8, 0x3E, 0x1F, 0x3F, 0x07, 0xC3,
  0xF7, 0xC0, 0xF8, 0x3E, 0xF8, 0x1F, 0x07, 0xDF, 0x07, 0xE0, 0xFF, 0xE0,
  0xF8, 0x0F, 0xFC, 0x1F, 0x01, 0xFF, 0x03, 0xE0, 0x3F, 0xE0, 0x7C, 0x07,
  0xFC, 0x1F, 0x80, 0x7F, 0x83, 0xE0, 0x0F, 0xE0, 0x7C, 0x01, 0xFC, 0x0F,
  0x80, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xF0, 0xFE, 0x1F, 0xC0, 0x7E,
  0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x3E, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xF8,
  0x7E, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x0F, 0xF0, 0xFC,
  0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3E, 0x03, 0xF1, 0xF8, 0x0F,
  0xC7, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x1F, 0xE1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xF0, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F,
  0x80, 0x7E, 0x3F, 0x80, 0x3E, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0x7E,
  0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xE1, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7E, 0x3F, 0x07, 0xE1, 0xF8, 0x7F,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF0, 0x0F, 0x8F, 0xC0, 0x7C, 0x7E, 0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0xC1,
  0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03,
  0xF1, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF,
  0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFE, 0x0E, 0x0F, 0xC0,
  0x20, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x80, 0x1F, 0x8E, 0x03, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0xFC, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x7E,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x7C,
  0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xFC,
  0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0x80, 0x3E, 0x7C, 0x03, 0xF3,
  0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0xFC, 0x3E, 0x07,
  0xC1, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F,
  0x8F, 0x80, 0x7C, 0xFC, 0x03, 0xE7, 0xC0, 0x1F, 0x7E, 0x00, 0xFB, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xF8, 0x03, 0xC0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xBE, 0x01, 0xF0,
  0x0F, 0xDF, 0x01, 0xF8, 0x07, 0xCF, 0x80, 0xFE, 0x07, 0xE7, 0xC0, 0xFF,
  0x03, 0xE3, 0xE0, 0x7F, 0x83, 0xF1, 0xF0, 0x3F, 0xC1, 0xF8, 0xF8, 0x3F,
  0xE0, 0xF8, 0x7C, 0x1F, 0xF0, 0xFC, 0x3E, 0x1F, 0xF8, 0x7C, 0x1F, 0x0F,
  0x7C, 0x7E, 0x0F, 0x8F, 0xBE, 0x3E, 0x07, 0xC7, 0xDF, 0x1F, 0x03, 0xE3,
  0xCF, 0x9F, 0x81, 0xF3, 0xE7, 0xCF, 0x80, 0xF9, 0xE3, 0xEF, 0xC0, 0x7D,
  0xF1, 0xF7, 0xC0, 0x3E, 0xF8, 0xF3, 0xE0, 0x1F, 0xF8, 0x7B, 0xF0, 0x0F,
  0xFC, 0x3D, 0xF0, 0x07, 0xFC, 0x1E, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xC0, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x00,
  0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x1F,
  0x80, 0x07, 0xE7, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00,
  0x0F, 0xCF, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x83,
  0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x80, 0xF8, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0,
  0xFC, 0xFC, 0x0F, 0xC7, 0xC1, 0xF8, 0x7C, 0x3F, 0x07, 0xE3, 0xF0, 0x7E,
  0x7E, 0x03, 0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80,
  0xFF, 0x80, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x1E, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1E, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x1E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xE7,
  0x80, 0x3E, 0x78, 0x07, 0xC7, 0xC0, 0x78, 0x3C, 0x0F, 0x83, 0xC1, 0xF0,
  0x3C, 0x1E, 0x03, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xEF, 0xC0, 0x1F, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFC, 0xFC, 0x7C, 0x7E, 0x3E, 0x1F, 0x0F, 0x01, 0xF8,
  0xF8, 0x3F, 0xEF, 0x83, 0xFF, 0x7C, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F,
  0xC3, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F,
  0x1F, 0x81, 0xF0, 0xFC, 0x0F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0,
  0x3E, 0x1F, 0x83, 0xF0, 0xFC, 0x3F, 0x83, 0xF3, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xDE, 0x03, 0xFD, 0xF0, 0x0F, 0xCF, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x7D, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0xF7, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF1, 0xF8, 0x1F,
  0x1F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x03, 0xF1, 0xF0, 0x3F, 0x3F, 0x03,
  0xF3, 0xF0, 0x3E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x7F, 0x0F, 0xC7, 0xF9,
  0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x79, 0xFE, 0x0F, 0x8F, 0xC0, 0x00,
  0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE1, 0xFE, 0xF0, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x04, 0x3F,
  0x9E, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF9, 0xF0, 0x0F,
  0xF7, 0xC0, 0x7F, 0xDF, 0x03, 0xFF, 0xFC, 0x1F, 0xCF, 0xF0, 0x7E, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87,
  0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0xFE, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0x3F, 0xEF, 0x00, 0x7E, 0x3C, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFC, 0x7C, 0x3E, 0x0F, 0xCF,
  0xC1, 0xF1, 0xF0, 0x3E, 0x7E, 0x1F, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x0F, 0xFF, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFC, 0x7C, 0x07, 0xFB,
  0xE0, 0x3F, 0xEF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0,
  0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7C,
  0x1F, 0x83, 0xF0, 0x7F, 0x1F, 0xC0, 0xFC, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x1F, 0xEF, 0x80, 0x3F, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x02, 0x00, 0xFC, 0x0E, 0x07, 0xE0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x02, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x7D, 0xFE,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFE, 0x1F, 0x0F, 0xC1,
  0xF1, 0xF8, 0x1F, 0x1F, 0x81, 0xF1, 0xF8, 0x3F, 0x1F, 0x03, 0xF1, 0xF0,
  0x3E, 0x3F, 0x03, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xE0, 0x7E, 0x3E,
  0x07, 0xC7, 0xE0, 0x7C, 0x7E, 0x0F, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0xCF,
  0xC0, 0xF8, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x27,
  0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x70, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0xFE, 0x0F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC,
  0x7E, 0x01, 0xF1, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0xDF, 0x80, 0x1F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xCF, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x3F, 0x00,
  0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x1F,
  0x81, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0,
  0x07, 0x8F, 0xC1, 0xF8, 0x0F, 0x3F, 0xC7, 0xF8, 0x3E, 0xFF, 0xDF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0x7F, 0xEF, 0xE1, 0xFC, 0x7F, 0x8F, 0xC3,
  0xF0, 0x7E, 0x0F, 0x8F, 0xC1, 0xF8, 0x3F, 0x1F, 0x83, 0xF0, 0x7E, 0x3F,
  0x07, 0xE0, 0xFC, 0x7C, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x03, 0xE3, 0xF0,
  0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x1F, 0x8F, 0x81, 0xF8, 0x3F, 0x1F, 0x03,
  0xE0, 0x7C, 0x3E, 0x07, 0xC0, 0xF8, 0xFC, 0x1F, 0x83, 0xF1, 0xF8, 0x3F,
  0x07, 0xE3, 0xE0, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x1F, 0x1F, 0x83, 0xF0,
  0x7E, 0x00, 0x07, 0x8F, 0xC0, 0x79, 0xFE, 0x0F, 0xBF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFE, 0x1F, 0x0F, 0xC1, 0xF1, 0xF8, 0x1F, 0x1F, 0x81,
  0xF1, 0xF8, 0x3F, 0x1F, 0x03, 0xF1, 0xF0, 0x3E, 0x3F, 0x03, 0xE3, 0xF0,
  0x7E, 0x3F, 0x07, 0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xC7, 0xE0, 0x7C, 0x7E,
  0x0F, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0xCF, 0xC0, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0x0F, 0xCF,
  0xC1, 0xF9, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xFD, 0xF0, 0x1F, 0xBE,
  0x03, 0xFF, 0xC0, 0x7D, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0x7C,
  0x1F, 0x8F, 0xC7, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F,
  0xE0, 0x00, 0x01, 0xE3, 0xF0, 0x07, 0x9F, 0xE0, 0x3E, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFD, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xC1, 0xF8, 0x1F,
  0x07, 0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0xC1, 0xF0, 0x3F, 0x0F,
  0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3,
  0xF0, 0x7F, 0x9F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0x7F, 0x80,
  0xFC, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0xF0, 0x3F, 0xCF, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xCF, 0xF1, 0xF8, 0x7E, 0x3F, 0x07, 0xE3,
  0xF0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xC7, 0xC0, 0x7C,
  0x7C, 0x07, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F,
  0x87, 0xE3, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xDF, 0x01, 0xF9,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x07, 0x8F, 0x83, 0xCF, 0xC3, 0xEF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7F, 0xC8, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x00, 0x03, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE1, 0xF8, 0x70,
  0xF8, 0x08, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x80,
  0x7E, 0x70, 0x7E, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0xFD, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFE, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF1, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0x03,
  0xF1, 0xF0, 0x3E, 0x3F, 0x03, 0xE3, 0xF0, 0x7E, 0x3E, 0x07, 0xE3, 0xE0,
  0x7C, 0x7E, 0x07, 0xC7, 0xE0, 0x7C, 0x7E, 0x0F, 0xC7, 0xC0, 0xFC, 0x7C,
  0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xF8, 0x1F, 0x8F,
  0x83, 0xF0, 0xF8, 0x7F, 0x0F, 0xCF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFD, 0xE0,
  0x7F, 0x9E, 0x03, 0xF1, 0xE0, 0xFC, 0x07, 0xFF, 0x80, 0xFB, 0xF0, 0x3F,
  0x7E, 0x07, 0xC7, 0xC1, 0xF8, 0xF8, 0x3E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF0,
  0x7C, 0x7E, 0x0F, 0x8F, 0x81, 0xF3, 0xF0, 0x3E, 0x7C, 0x07, 0xDF, 0x80,
  0xFB, 0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x1F,
  0xC1, 0xFB, 0xE0, 0xFE, 0x0F, 0x9F, 0x07, 0xF0, 0xFC, 0xF8, 0x7F, 0x87,
  0xE7, 0xC3, 0xFC, 0x3E, 0x3E, 0x3F, 0xE3, 0xF1, 0xF1, 0xFF, 0x1F, 0x0F,
  0x9F, 0xF9, 0xF8, 0x7C, 0xF7, 0x8F, 0x83, 0xE7, 0xBC, 0x7C, 0x1F, 0x7D,
  0xE7, 0xC0, 0xFB, 0xCF, 0x3E, 0x07, 0xDE, 0x7B, 0xE0, 0x3D, 0xE3, 0xDF,
  0x01, 0xEF, 0x1E, 0xF8, 0x0F, 0x78, 0xFF, 0x80, 0x7F, 0x87, 0xFC, 0x03,
  0xFC, 0x3F, 0xC0, 0x1F, 0xC1, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0,
  0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x0F, 0x87, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0x3E, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x1F, 0x00, 0x7E, 0x3F,
  0x01, 0xF8, 0x7E, 0x07, 0xE0, 0x7C, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xE0,
  0x3F, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x7C, 0x03, 0xE0,
  0xFC, 0x03, 0xE0, 0xF8, 0x03, 0xE1, 0xF8, 0x03, 0xE1, 0xF0, 0x03, 0xE3,
  0xF0, 0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE7, 0xC0, 0x01, 0xE7,
  0xC0, 0x01, 0xEF, 0x80, 0x01, 0xEF, 0x80, 0x01, 0xEF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x03, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFE, 0x03,
  0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 12, 29, 11, 0, -29 },
  { 45, 14, 11, 17, 4, -29 },
  { 65, 23, 29, 23, 1, -29 },
  { 149, 19, 32, 20, 1, -30 },
  { 225, 29, 29, 32, 2, -29 },
  { 331, 24, 29, 26, 1, -29 },
  { 418, 7, 11, 10, 4, -29 },
  { 428, 14, 35, 13, 1, -29 },
  { 490, 14, 35, 13, -3, -29 },
  { 552, 18, 19, 20, 3, -31 },
  { 595, 18, 20, 21, 2, -24 },
  { 640, 9, 10, 11, -2, -5 },
  { 652, 11, 5, 12, 1, -13 },
  { 659, 7, 6, 11, 0, -6 },
  { 665, 21, 29, 16, -2, -29 },
  { 742, 19, 29, 20, 1, -29 },
  { 811, 14, 29, 20, 4, -29 },
  { 862, 21, 29, 20, -1, -29 },
  { 939, 20, 29, 20, 0, -29 },
  { 1012, 20, 29, 20, 0, -29 },
  { 1085, 20, 29, 20, 0, -29 },
  { 1158, 20, 29, 20, 1, -29 },
  { 1231, 21, 29, 20, 1, -29 },
  { 1308, 20, 29, 20, 1, -29 },
  { 1381, 19, 29, 20, 1, -29 },
  { 1450, 10, 22, 11, 0, -22 },
  { 1478, 12, 27, 11, -2, -22 },
  { 1519, 18, 21, 21, 2, -25 },
  { 1567, 18, 12, 21, 2, -20 },
  { 1594, 18, 21, 21, 2, -25 },
  { 1642, 16, 29, 17, 2, -29 },
  { 1700, 30, 32, 31, 1, -29 },
  { 1820, 22, 29, 23, -2, -29 },
  { 1900, 22, 29, 23, 1, -29 },
  { 1980, 22, 29, 22, 2, -29 },
  { 2060, 23, 29, 25, 1, -29 },
  { 2144, 20, 29, 20, 1, -29 },
  { 2217, 20, 29, 19, 1, -29 },
  { 2290, 23, 29, 25, 2, -29 },
  { 2374, 25, 29, 26, 1, -29 },
  { 2465, 18, 29, 14, -1, -29 },
  { 2531, 19, 37, 12, -6, -29 },
  { 2619, 25, 29, 22, 1, -29 },
  { 2710, 15, 29, 19, 1, -29 },
  { 2765, 32, 29, 33, 1, -29 },
  { 2881, 27, 29, 27, 1, -29 },
  { 2979, 24, 29, 26, 2, -29 },
  { 3066, 22, 29, 22, 1, -29 },
  { 3146, 24, 36, 26, 2, -29 },
  { 3254, 21, 29, 22, 1, -29 },
  { 3331, 20, 29, 19, 0, -29 },
  { 3404, 19, 29, 19, 3, -29 },
  { 3473, 24, 29, 25, 2, -29 },
  { 3560, 21, 29, 22, 4, -29 },
  { 3637, 33, 29, 33, 4, -29 },
  { 3757, 27, 29, 22, -2, -29 },
  { 3855, 20, 29, 21, 4, -29 },
  { 3928, 23, 29, 19, -1, -29 },
  { 4012, 16, 35, 13, -1, -29 },
  { 4082, 9, 29, 16, 4, -29 },
  { 4115, 17, 35, 13, -3, -29 },
  { 4190, 20, 18, 20, 0, -29 },
  { 4235, 16, 2, 15, -4, 4 },
  { 4239, 8, 7, 13, 6, -31 },
  { 4246, 21, 22, 22, 1, -22 },
  { 4304, 20, 30, 22, 0, -30 },
  { 4379, 17, 22, 18, 1, -22 },
  { 4426, 22, 30, 22, 1, -30 },
  { 4509, 19, 22, 20, 1, -22 },
  { 4562, 22, 41, 14, -4, -31 },
  { 4675, 22, 32, 22, 0, -22 },
  { 4763, 20, 30, 22, 0, -30 },
  { 4838, 12, 30, 11, 0, -30 },
  { 4883, 17, 40, 11, -5, -30 },
  { 4968, 23, 30, 21, 0, -30 },
  { 5055, 12, 30, 11, 0, -30 },
  { 5100, 31, 22, 33, 0, -22 },
  { 5186, 20, 22, 22, 0, -22 },
  { 5241, 19, 22, 21, 1, -22 },
  { 5294, 22, 32, 22, -2, -22 },
  { 5382, 20, 32, 22, 1, -22 },
  { 5462, 17, 22, 15, 0, -22 },
  { 5509, 17, 22, 17, 0, -22 },
  { 5556, 14, 26, 15, 2, -26 },
  { 5602, 20, 22, 22, 2, -22 },
  { 5657, 19, 22, 19, 2, -22 },
  { 5710, 29, 22, 29, 2, -22 },
  { 5790, 23, 22, 19, -2, -22 },
  { 5854, 24, 32, 19, -3, -22 },
  { 5950, 19, 22, 17, -1, -22 },
  { 6003, 17, 35, 14, 0, -29 },
  { 6078, 5, 39, 19, 7, -30 },
  { 6103, 16, 35, 14, -2, -29 },
  { 6173, 18, 6, 21, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC40PT7B_H_
