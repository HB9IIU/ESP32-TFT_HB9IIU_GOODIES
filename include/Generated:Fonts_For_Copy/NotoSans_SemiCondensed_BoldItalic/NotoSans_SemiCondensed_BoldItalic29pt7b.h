#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC29PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xC1, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x3E, 0x1F, 0x0F,
  0x00, 0x7B, 0xDC, 0xF7, 0x3F, 0xCE, 0xF3, 0xB8, 0xEE, 0x3B, 0x9C, 0x00,
  0xE7, 0x00, 0xE3, 0x80, 0x71, 0x80, 0x39, 0xC0, 0x38, 0xE0, 0x1C, 0x70,
  0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x83, 0x9C, 0x01, 0xCE, 0x01, 0xC7,
  0x07, 0xFF, 0xF3, 0xFF, 0xFB, 0xFF, 0xF8, 0x38, 0xE0, 0x1C, 0xE0, 0x0E,
  0x70, 0x0E, 0x38, 0x07, 0x38, 0x03, 0x9C, 0x00, 0x00, 0x20, 0x00, 0xC0,
  0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x87, 0xB1, 0x0F, 0x60, 0x1E,
  0x80, 0x3F, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x5E,
  0x01, 0xBC, 0x43, 0x78, 0xFF, 0xF1, 0xFF, 0xC7, 0xFF, 0x01, 0xF8, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x1E, 0x01, 0xC3, 0xF0, 0x3C, 0x7F, 0x83,
  0x87, 0x38, 0x70, 0xF3, 0x8F, 0x0E, 0x38, 0xE0, 0xE7, 0x9C, 0x0E, 0x7B,
  0xC0, 0xE7, 0x39, 0xCE, 0xF7, 0x3E, 0xFE, 0xF7, 0xFF, 0xEE, 0xF7, 0x79,
  0xCE, 0x70, 0x3D, 0xE7, 0x03, 0x9C, 0x70, 0x71, 0xC7, 0x0F, 0x1C, 0xF0,
  0xE1, 0xCE, 0x1C, 0x1F, 0xE3, 0xC1, 0xFC, 0x78, 0x0F, 0x80, 0x01, 0xF0,
  0x03, 0xFC, 0x03, 0xFF, 0x01, 0xE7, 0x80, 0xE3, 0xC0, 0xF1, 0xE0, 0x79,
  0xE0, 0x1D, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE1, 0xE7, 0xF8, 0xF7,
  0xBC, 0xF7, 0x8F, 0x7B, 0xC7, 0xF9, 0xE1, 0xF8, 0xF0, 0xFC, 0x7C, 0xFE,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xF9, 0xF0, 0x7B, 0x9D, 0xEF, 0x73, 0x9C,
  0x03, 0xC0, 0xE0, 0x70, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x38, 0x1E,
  0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x0E, 0x00, 0x07, 0x80, 0xE0,
  0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x07,
  0x83, 0xC0, 0xE0, 0x70, 0x38, 0x00, 0x03, 0xC0, 0x1C, 0x10, 0xE0, 0xE7,
  0x07, 0xF0, 0xFF, 0xFC, 0x3F, 0xE1, 0xFF, 0x1F, 0x81, 0xEE, 0x1E, 0x70,
  0x23, 0xC0, 0x18, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0xF3, 0xDE, 0x7B, 0xCF, 0x38, 0x7F,
  0x7F, 0x7F, 0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x1F, 0xC0, 0xFF, 0x87, 0xFE, 0x3E, 0x78, 0xF0, 0xF7, 0x83, 0xDE, 0x1F,
  0x78, 0x7B, 0xE1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC3, 0xEF, 0x0F,
  0x3C, 0x3C, 0xF1, 0xE3, 0xCF, 0x8F, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x01,
  0xC1, 0xF0, 0xFC, 0xFF, 0x7F, 0xBF, 0xEF, 0x79, 0x1E, 0x07, 0x83, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF0,
  0x3C, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x06, 0x1F,
  0x04, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x03, 0xF0, 0x1F, 0xF8,
  0x7F, 0xF0, 0x7F, 0xF0, 0x83, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x80, 0xF9, 0x83, 0xE3, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x80,
  0xFE, 0x03, 0xBC, 0x0F, 0x78, 0x3C, 0xF0, 0x71, 0xC1, 0xC7, 0x87, 0x8F,
  0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xF8, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0xFF,
  0xE0, 0x87, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x80, 0xF9,
  0xC7, 0xE3, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xF0,
  0x7F, 0xC3, 0xF3, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x7B, 0xE1,
  0xFF, 0xC7, 0xFF, 0x3E, 0x3E, 0xF8, 0x7B, 0xC1, 0xEF, 0x0F, 0xBC, 0x3C,
  0xF0, 0xF3, 0xE7, 0xC7, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0x3F, 0xFE, 0x7F,
  0xFC, 0xFF, 0xF9, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x79, 0xF1, 0xE1, 0xE3, 0xC3,
  0xC7, 0x87, 0x8F, 0x9E, 0x0F, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x83,
  0xEF, 0x8F, 0x0F, 0x1E, 0x1E, 0x7C, 0x3C, 0xF8, 0x78, 0xF1, 0xF1, 0xFF,
  0xC1, 0xFF, 0x81, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x7D, 0xF7,
  0xC7, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0x7B, 0xC7, 0xDF, 0xFE, 0xFF,
  0xF3, 0xF7, 0x0E, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xE4, 0x3E, 0x3F, 0xE1,
  0xFE, 0x0F, 0xE0, 0x00, 0x0E, 0x1F, 0x1E, 0x1E, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF0, 0x03, 0x81, 0xF0, 0x78,
  0x1E, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x07, 0x83, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0x00, 0x04, 0x00,
  0x70, 0x07, 0xC0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3E, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x70, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x01, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F,
  0xC0, 0xFC, 0x03, 0x80, 0x08, 0x00, 0x00, 0x1F, 0x9F, 0xF9, 0xFF, 0xBD,
  0xF4, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x1E, 0x03,
  0x80, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00,
  0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0xE0,
  0x07, 0x8E, 0x00, 0x1C, 0xE1, 0xFC, 0xE7, 0x1F, 0xE7, 0x71, 0xE7, 0x1B,
  0x9E, 0x39, 0xDC, 0xE3, 0x8F, 0xC7, 0x1C, 0x7E, 0x70, 0xE3, 0xF3, 0x8F,
  0x3B, 0x9C, 0x71, 0xDC, 0xFF, 0xFC, 0xE3, 0xFF, 0xC7, 0x0E, 0x3C, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x60, 0x0F, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x18, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xCF, 0x01, 0xE7,
  0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0x3F,
  0xFE, 0x3E, 0x07, 0x1E, 0x03, 0xDF, 0x01, 0xEF, 0x00, 0xFF, 0x80, 0x78,
  0x07, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F,
  0x1F, 0x0F, 0x1E, 0x0F, 0x1E, 0x7E, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xFC,
  0x3C, 0x3E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x78, 0x3E, 0x78, 0xFC,
  0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC0, 0x00, 0xFC, 0x03, 0xFF, 0x07, 0xFF,
  0x0F, 0xFE, 0x1F, 0x02, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x7E, 0x70, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0,
  0x07, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0, 0xF8, 0x78,
  0x7C, 0x7C, 0x1E, 0x3E, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE7,
  0xC1, 0xF3, 0xC0, 0xF9, 0xE0, 0x78, 0xF0, 0x7C, 0x78, 0x3C, 0x7C, 0x7E,
  0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x0F,
  0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC3, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x0F, 0xFE,
  0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xF0, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC3,
  0xFF, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xE1,
  0xFF, 0xE1, 0xF8, 0x11, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x3F, 0x9E, 0x1F, 0xCF, 0x0F, 0xEF, 0x8F, 0xF7, 0xC0, 0xF3, 0xE0,
  0x78, 0xF0, 0x3C, 0x7C, 0x1E, 0x3F, 0x1E, 0x0F, 0xFF, 0x07, 0xFF, 0x80,
  0xFF, 0x80, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x3E, 0x0F, 0x87, 0x81, 0xE0,
  0xF0, 0x3C, 0x1E, 0x07, 0x87, 0xC1, 0xF0, 0xF8, 0x3C, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xC0, 0xF0, 0x78, 0x1E, 0x0F,
  0x03, 0xC1, 0xE0, 0x78, 0x7C, 0x1F, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C,
  0x0F, 0x0F, 0x83, 0xE0, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x1F, 0xE1, 0xFF,
  0x0F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x17, 0xE0, 0x7F, 0x01, 0xFC,
  0x0F, 0xC0, 0x00, 0x07, 0x83, 0xE0, 0xF0, 0xF8, 0x3C, 0x3E, 0x07, 0x87,
  0x80, 0xF1, 0xF0, 0x1E, 0x7C, 0x03, 0xDF, 0x00, 0xF3, 0xC0, 0x1E, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x79, 0xE0,
  0x0F, 0x3C, 0x01, 0xE7, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xF0,
  0x3C, 0x1E, 0x0F, 0x83, 0xE0, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xFF, 0x7F, 0xF7, 0xFE, 0xFF,
  0xE0, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xE1,
  0xDC, 0x1F, 0xE3, 0xFC, 0x1F, 0xE3, 0xBC, 0x1C, 0xE7, 0xBC, 0x3C, 0xE7,
  0x3C, 0x3C, 0xEF, 0x38, 0x3C, 0xEE, 0x78, 0x3C, 0xFE, 0x78, 0x38, 0xFC,
  0x78, 0x78, 0xFC, 0x78, 0x78, 0xF8, 0x70, 0x78, 0xF8, 0xF0, 0x70, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0x07, 0xC0, 0xF0, 0x7C, 0x0F, 0x0F, 0xC0, 0xF0,
  0xFC, 0x0F, 0x0F, 0xE0, 0xE0, 0xFE, 0x1E, 0x1F, 0xE1, 0xE1, 0xEE, 0x1E,
  0x1E, 0xF1, 0xE1, 0xEF, 0x1C, 0x1C, 0xF3, 0xC3, 0xC7, 0xBC, 0x3C, 0x7B,
  0xC3, 0xC7, 0xBC, 0x3C, 0x3B, 0x83, 0x83, 0xF8, 0x78, 0x3F, 0x87, 0x83,
  0xF8, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0x0F, 0x8F, 0x81, 0xE3, 0xE0,
  0x7C, 0xF0, 0x1F, 0x7C, 0x07, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E,
  0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xF1, 0xE0, 0x7C, 0x78, 0x3E, 0x1F,
  0xBF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x03,
  0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0, 0xF0, 0x78, 0x7C, 0x7C, 0x3E,
  0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x0F, 0x87, 0xFF, 0x87, 0xFF, 0x83, 0xFF,
  0x81, 0xFE, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F,
  0xF0, 0x3F, 0xFE, 0x1F, 0x0F, 0x8F, 0x81, 0xE3, 0xE0, 0x7C, 0xF0, 0x1F,
  0x7C, 0x07, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0xF8, 0x0F, 0xBE,
  0x03, 0xEF, 0x80, 0xF1, 0xE0, 0x7C, 0x78, 0x3E, 0x1F, 0xBF, 0x83, 0xFF,
  0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x0F, 0xFE, 0x0F,
  0xFF, 0x0F, 0x1F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x1F, 0x1E, 0x1E, 0x1E,
  0x7E, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C,
  0x78, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x78, 0x3C, 0xF8, 0x3C, 0x01,
  0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE1, 0xF0, 0x43, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x80, 0xF1, 0xE7, 0xE3, 0xFF, 0x87, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x07, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x00, 0x1E, 0x07, 0x9F, 0x07, 0x8F, 0x03, 0xC7, 0x81,
  0xE3, 0xC0, 0xF1, 0xE0, 0xF9, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C,
  0x0F, 0x1E, 0x0F, 0x9F, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xF1,
  0xE0, 0xF0, 0xF0, 0x78, 0x7C, 0xFC, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xFC,
  0x00, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xF7, 0x81, 0xEF, 0x07, 0x9E, 0x0F,
  0x3C, 0x3C, 0x78, 0x78, 0xF1, 0xE1, 0xE3, 0xC3, 0xCF, 0x07, 0x9E, 0x0F,
  0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0xE0, 0x38, 0x1F, 0xE0, 0x78, 0x1E, 0xE0,
  0x78, 0x3E, 0xE0, 0xF8, 0x3C, 0xE0, 0xF8, 0x3C, 0xE1, 0xF8, 0x78, 0xE1,
  0xF8, 0x78, 0xE1, 0xF8, 0xF0, 0xE3, 0xF8, 0xF0, 0xE3, 0xB8, 0xF0, 0xE7,
  0xB9, 0xE0, 0xE7, 0x39, 0xE0, 0xEF, 0x3B, 0xC0, 0xEF, 0x3B, 0xC0, 0xEE,
  0x3B, 0xC0, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xF8,
  0x3F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0x81, 0xF0, 0x7C,
  0x1E, 0x03, 0xC3, 0xE0, 0x3C, 0x7C, 0x03, 0xC7, 0x80, 0x1E, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xBC, 0x00, 0xFB, 0xC0,
  0x1F, 0x1E, 0x01, 0xE1, 0xE0, 0x3E, 0x1E, 0x07, 0xC1, 0xF0, 0xF8, 0x0F,
  0x00, 0xF0, 0x3F, 0xE0, 0xFB, 0xC1, 0xE7, 0x87, 0x87, 0x0F, 0x0F, 0x3C,
  0x1E, 0xF8, 0x3D, 0xE0, 0x7F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F,
  0xFF, 0x80, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x78, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xF1, 0xE3, 0xC3, 0x87, 0x0E, 0x1C, 0x3C,
  0x78, 0xF0, 0xE1, 0xC3, 0x87, 0x0F, 0x1E, 0x3C, 0x38, 0x70, 0xE1, 0xE0,
  0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x7C, 0x03, 0xF0,
  0x1F, 0xC0, 0x77, 0x03, 0x8E, 0x1E, 0x38, 0x70, 0xE3, 0x83, 0xDE, 0x07,
  0xF0, 0x1C, 0x7F, 0xFF, 0xFE, 0xF9, 0xE3, 0x8F, 0x07, 0x9E, 0x3F, 0xB8,
  0xFF, 0xF1, 0xF7, 0xE7, 0xC7, 0xCF, 0x0F, 0x1E, 0x1E, 0x7C, 0x3C, 0xF0,
  0x79, 0xE0, 0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0x9F, 0x1F, 0xFE, 0x1F, 0xFC,
  0x1E, 0x70, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x9E, 0x0F, 0x7E, 0x1F, 0xFC, 0x3E, 0x7C, 0x78, 0xF9, 0xF0,
  0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x1E, 0x1E, 0x78, 0x3C, 0xF8, 0xF9,
  0xF3, 0xE3, 0xFF, 0x87, 0xFF, 0x1E, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x1F,
  0xF3, 0xE2, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF8, 0xC7, 0xFC, 0x7F, 0xC3, 0xF8, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x07, 0x9E, 0x1F, 0xFC,
  0x1F, 0xFC, 0x3E, 0xFC, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0xF8, 0x78,
  0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF9, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x3E, 0xE0, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x78, 0xF7, 0xC7,
  0xBC, 0x3D, 0xE7, 0xDF, 0xFE, 0xFF, 0xC7, 0xC0, 0x3C, 0x01, 0xE0, 0x0F,
  0x82, 0x3F, 0xF1, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xFC, 0x07, 0xFC, 0x0F, 0xFC,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0xBE, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xF0, 0x00, 0x03, 0xCF, 0x0F, 0xEE, 0x1F, 0xFE, 0x1F, 0x3E,
  0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x3C,
  0x78, 0x78, 0x78, 0x78, 0x7C, 0xF8, 0x7F, 0xF8, 0x3F, 0x78, 0x1E, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x81, 0xF0, 0xE3, 0xE0, 0xFF, 0xC0, 0xFF, 0x80,
  0x7F, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x9E, 0x0F, 0x7E, 0x1F, 0xFE, 0x3E, 0x7C, 0x78, 0x79, 0xF0,
  0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x78, 0x3C, 0xF0, 0xF1,
  0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x9E, 0x1F, 0x00, 0x07, 0x07, 0xC3, 0xE0,
  0xE0, 0x00, 0x00, 0x3C, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xC1, 0xE0,
  0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x80, 0x00, 0x70, 0x07,
  0xC0, 0x3E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x05, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x0F, 0x1E,
  0x1E, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0xF0, 0x3D, 0xF0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7D, 0xE0, 0x79, 0xF0, 0x78, 0xF0, 0x78,
  0xF0, 0x78, 0xF8, 0xF0, 0x78, 0x07, 0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x7C,
  0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x80, 0x0E, 0x78, 0x78, 0x3F, 0xFB, 0xF8,
  0x77, 0xF7, 0xF0, 0xFD, 0xFD, 0xF1, 0xE1, 0xE1, 0xE7, 0xC7, 0xC7, 0x8F,
  0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x79, 0xE1,
  0xE1, 0xE3, 0xC3, 0xC3, 0xC7, 0x87, 0x87, 0x8F, 0x0F, 0x0F, 0x1E, 0x1E,
  0x1E, 0x78, 0x78, 0x78, 0x0E, 0x78, 0x3D, 0xF8, 0x77, 0xF8, 0xF9, 0xF1,
  0xE1, 0xE7, 0xC3, 0xCF, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x79, 0xE0,
  0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x78, 0x7C, 0x07, 0xE0,
  0xFF, 0x8F, 0xFE, 0x7D, 0xF7, 0xC7, 0xBC, 0x3D, 0xE1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xEF, 0x9F, 0x3F, 0xF1, 0xFF, 0x07, 0xF0,
  0x07, 0x3C, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x9F, 0x0F, 0x0F, 0x1F, 0x0F,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x1E, 0x3E, 0x3E,
  0x3E, 0x7C, 0x3F, 0xF8, 0x3B, 0xF8, 0x79, 0xE0, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x9E,
  0x3F, 0xB8, 0x7F, 0xF1, 0xF7, 0xE7, 0xC7, 0xCF, 0x0F, 0x1E, 0x1E, 0x7C,
  0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0x9F, 0x1F, 0xFE,
  0x1F, 0xBC, 0x1E, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x0E, 0x71, 0xEF, 0x1F, 0xF1, 0xFF,
  0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x0F, 0xE1, 0xFF, 0x3F, 0xF3, 0xC2,
  0x3C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1E,
  0xC3, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0, 0x07, 0x03, 0x80, 0xE0, 0x7F, 0x7F,
  0xFF, 0xF3, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F,
  0x83, 0xE0, 0xFF, 0x1F, 0xC7, 0xF0, 0x3C, 0x1E, 0x78, 0x78, 0xF0, 0xF1,
  0xE1, 0xE3, 0xC3, 0xCF, 0x07, 0x9E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0,
  0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0x9F, 0x1F, 0xFE, 0x1F, 0xFC, 0x3E, 0x70,
  0xF0, 0x7F, 0x87, 0xFC, 0x3D, 0xE3, 0xEF, 0x1E, 0x78, 0xF3, 0xCF, 0x1E,
  0x78, 0xF7, 0x87, 0xBC, 0x3F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF0,
  0x0F, 0x00, 0xF0, 0xF0, 0xFF, 0x1F, 0x0F, 0xF1, 0xF1, 0xEF, 0x3F, 0x1E,
  0xF3, 0xF1, 0xEF, 0x3F, 0x3C, 0xF7, 0x73, 0xCF, 0x77, 0x78, 0xEF, 0x77,
  0x8E, 0xE7, 0x70, 0xEE, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0x87,
  0xE0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x0F, 0x1E, 0x0F, 0x3E,
  0x0F, 0x3C, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x1E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0x78,
  0xF8, 0x78, 0x0F, 0x07, 0x87, 0x87, 0xC3, 0xC3, 0xC1, 0xE1, 0xE0, 0xF1,
  0xE0, 0x78, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x07, 0x78, 0x03, 0xBC, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x17, 0xE0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xC0, 0x00, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x80, 0x3E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80,
  0x3C, 0x01, 0xFF, 0x87, 0xFE, 0x3F, 0xF8, 0x00, 0x30, 0x1F, 0x03, 0xF0,
  0x7E, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x1F, 0x07,
  0xE0, 0xF8, 0x0F, 0x80, 0xFC, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x06, 0x00, 0x7C, 0x07, 0xC0, 0x7C, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x3F, 0x01, 0xF0, 0x3F, 0x07, 0xE0,
  0xF8, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0xFE, 0x0F,
  0xC0, 0xF8, 0x08, 0x00, 0x18, 0x05, 0xFC, 0x3F, 0xFF, 0xFB, 0xFF, 0x81,
  0xF8,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 21, 8, 0, -21 },
  { 25, 10, 8, 13, 3, -21 },
  { 35, 17, 21, 17, 0, -21 },
  { 80, 15, 24, 15, 0, -22 },
  { 125, 20, 21, 23, 2, -21 },
  { 178, 17, 21, 19, 1, -21 },
  { 223, 5, 8, 7, 3, -21 },
  { 228, 10, 26, 9, 1, -21 },
  { 261, 10, 26, 9, -2, -21 },
  { 294, 13, 13, 14, 2, -22 },
  { 316, 14, 14, 15, 1, -17 },
  { 341, 6, 8, 8, -1, -4 },
  { 347, 8, 4, 9, 0, -10 },
  { 351, 5, 4, 8, 0, -4 },
  { 354, 15, 21, 12, -1, -21 },
  { 394, 14, 21, 15, 1, -21 },
  { 431, 10, 21, 15, 3, -21 },
  { 458, 16, 21, 15, -1, -21 },
  { 500, 15, 21, 15, 0, -21 },
  { 540, 15, 21, 15, 0, -21 },
  { 580, 15, 21, 15, 0, -21 },
  { 620, 14, 21, 15, 1, -21 },
  { 657, 15, 21, 15, 1, -21 },
  { 697, 15, 21, 15, 0, -21 },
  { 737, 13, 21, 15, 1, -21 },
  { 772, 8, 16, 8, 0, -16 },
  { 788, 10, 20, 8, -2, -16 },
  { 813, 14, 15, 15, 1, -18 },
  { 840, 14, 9, 15, 1, -15 },
  { 856, 14, 15, 15, 1, -18 },
  { 883, 11, 21, 12, 2, -21 },
  { 912, 21, 24, 23, 1, -21 },
  { 975, 17, 21, 17, -2, -21 },
  { 1020, 16, 21, 16, 0, -21 },
  { 1062, 16, 21, 16, 1, -21 },
  { 1104, 17, 21, 18, 0, -21 },
  { 1149, 15, 21, 14, 0, -21 },
  { 1189, 15, 21, 14, 0, -21 },
  { 1229, 17, 21, 18, 1, -21 },
  { 1274, 19, 21, 19, 0, -21 },
  { 1324, 13, 21, 10, -1, -21 },
  { 1359, 14, 27, 9, -5, -21 },
  { 1407, 19, 21, 16, 0, -21 },
  { 1457, 12, 21, 14, 0, -21 },
  { 1489, 24, 21, 24, 0, -21 },
  { 1552, 20, 21, 20, 0, -21 },
  { 1605, 18, 21, 19, 1, -21 },
  { 1653, 17, 21, 16, 0, -21 },
  { 1698, 18, 26, 19, 1, -21 },
  { 1757, 16, 21, 16, 0, -21 },
  { 1799, 15, 21, 14, 0, -21 },
  { 1839, 14, 21, 14, 2, -21 },
  { 1876, 17, 21, 18, 2, -21 },
  { 1921, 15, 21, 16, 3, -21 },
  { 1961, 24, 21, 24, 3, -21 },
  { 2024, 20, 21, 16, -2, -21 },
  { 2077, 15, 21, 15, 3, -21 },
  { 2117, 17, 21, 14, -1, -21 },
  { 2162, 12, 26, 9, -1, -21 },
  { 2201, 7, 21, 12, 3, -21 },
  { 2220, 12, 26, 9, -2, -21 },
  { 2259, 14, 13, 15, 0, -21 },
  { 2282, 12, 2, 11, -3, 3 },
  { 2285, 6, 4, 9, 4, -22 },
  { 2288, 15, 16, 16, 1, -16 },
  { 2318, 15, 22, 16, 0, -22 },
  { 2360, 12, 16, 13, 1, -16 },
  { 2384, 16, 22, 16, 1, -22 },
  { 2428, 13, 16, 15, 1, -16 },
  { 2454, 16, 29, 10, -3, -22 },
  { 2512, 16, 23, 16, 0, -16 },
  { 2558, 15, 22, 16, 0, -22 },
  { 2600, 9, 22, 8, 0, -22 },
  { 2625, 13, 29, 8, -4, -22 },
  { 2673, 16, 22, 15, 0, -22 },
  { 2717, 9, 22, 8, 0, -22 },
  { 2742, 23, 16, 24, 0, -16 },
  { 2788, 15, 16, 16, 0, -16 },
  { 2818, 13, 16, 15, 1, -16 },
  { 2844, 16, 23, 16, -1, -16 },
  { 2890, 15, 23, 16, 1, -16 },
  { 2934, 12, 16, 11, 0, -16 },
  { 2958, 12, 16, 13, 0, -16 },
  { 2982, 10, 19, 11, 1, -19 },
  { 3006, 15, 16, 16, 1, -16 },
  { 3036, 13, 16, 14, 2, -16 },
  { 3062, 20, 16, 21, 2, -16 },
  { 3102, 16, 16, 14, -1, -16 },
  { 3134, 17, 23, 14, -2, -16 },
  { 3183, 14, 16, 12, -1, -16 },
  { 3211, 12, 26, 10, 0, -21 },
  { 3250, 4, 29, 14, 5, -22 },
  { 3265, 12, 26, 10, -2, -21 },
  { 3304, 14, 5, 15, 1, -13 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC29PT7B_H_
