#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC42PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x3E, 0x00, 0x40, 0x00, 0x3E, 0x3E, 0xFC, 0xFD, 0xF1, 0xFB, 0xE3, 0xE7,
  0xC7, 0xCF, 0x8F, 0x9E, 0x1E, 0x3C, 0x3C, 0xF8, 0xF9, 0xF1, 0xF3, 0xC3,
  0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF8, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0xF0, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x01, 0xE3, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3,
  0xC0, 0x07, 0xC7, 0x80, 0x07, 0x87, 0x80, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x1F, 0x1F, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xDD, 0xE0, 0xFC, 0xC2, 0x07, 0xE6, 0x00,
  0x3F, 0x30, 0x01, 0xFB, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x06, 0xFC, 0x00, 0x77, 0xE0, 0x03, 0x9F, 0x10, 0x19, 0xF8, 0xE0, 0xCF,
  0xC7, 0xF7, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0xF0, 0x01, 0xE0, 0x3F, 0xE0, 0x0F, 0x81, 0xFF, 0x80, 0x7C,
  0x0F, 0xFF, 0x01, 0xE0, 0x3E, 0x7C, 0x0F, 0x00, 0xF1, 0xF0, 0x7C, 0x07,
  0xC7, 0xC1, 0xE0, 0x1F, 0x1F, 0x0F, 0x00, 0x78, 0x7C, 0x7C, 0x03, 0xE1,
  0xE1, 0xE0, 0x0F, 0x87, 0x8F, 0x00, 0x3E, 0x3E, 0x7C, 0x00, 0xF8, 0xF9,
  0xE3, 0xF3, 0xE7, 0xCF, 0x3F, 0xE7, 0xFF, 0x7D, 0xFF, 0xDF, 0xF9, 0xE7,
  0xFF, 0x7F, 0xCF, 0x3E, 0x3C, 0xFE, 0x7C, 0xF8, 0xF0, 0x01, 0xE3, 0xC3,
  0xC0, 0x0F, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x7C, 0x01, 0xE1, 0xF1, 0xF0,
  0x0F, 0x07, 0x87, 0xC0, 0x7C, 0x1E, 0x1E, 0x01, 0xE0, 0x78, 0xF8, 0x0F,
  0x01, 0xE3, 0xE0, 0x7C, 0x07, 0xFF, 0x01, 0xE0, 0x1F, 0xF8, 0x0F, 0x00,
  0x3F, 0xC0, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x0F,
  0xC0, 0x0F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF3,
  0xF0, 0x00, 0xFB, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x7E, 0x1F, 0xF8, 0x3F, 0x1F, 0xFE, 0x1F, 0x1F,
  0xBF, 0x9F, 0x9F, 0x8F, 0xCF, 0x8F, 0xC7, 0xFF, 0xCF, 0xC1, 0xFF, 0xC7,
  0xE0, 0xFF, 0xE3, 0xF0, 0x3F, 0xE1, 0xF8, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xCF,
  0xC0, 0xFF, 0xC7, 0xF0, 0x3E, 0xFD, 0xFB, 0xE7, 0xCF, 0x9E, 0x3C, 0xF9,
  0xF3, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x03, 0x0F, 0x80,
  0xF9, 0xE0, 0x1F, 0xFC, 0x0B, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x83, 0xFC, 0x10, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xCF, 0x01,
  0xF1, 0xF0, 0x0C, 0x3E, 0x00, 0x83, 0xE0, 0x00, 0x60, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xC7,
  0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFC, 0x3E, 0xFF, 0xFF, 0xFF, 0xEF,
  0x84, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xF0, 0xFC, 0x3F, 0x1F, 0xC3, 0xF1, 0xF8, 0x3F, 0x3F, 0x83, 0xF3,
  0xF0, 0x3F, 0x3F, 0x03, 0xF7, 0xF0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F,
  0x7E, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07,
  0xEF, 0xC0, 0xFE, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x1F, 0x8F, 0xC1,
  0xF8, 0xFC, 0x3F, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F,
  0xF8, 0x01, 0xFF, 0x00, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x3F, 0xF0,
  0xFF, 0xC3, 0xFF, 0x9F, 0xFF, 0x7F, 0xFE, 0x7E, 0xFC, 0xF1, 0xF0, 0xC7,
  0xE1, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x0F, 0x87, 0xF0, 0x38, 0x0F, 0xC0, 0x40, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x81, 0xC1, 0xFC, 0x08, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x90, 0x01, 0xFC, 0xC0, 0x1F, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3D, 0xF0, 0x01, 0xF7, 0xC0, 0x0F,
  0xBF, 0x00, 0x7C, 0xFC, 0x01, 0xF3, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7E,
  0x03, 0xE1, 0xF8, 0x0F, 0x87, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x1F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFC, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x04, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x20, 0x03, 0xF0,
  0xE0, 0x3F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xEF, 0xE0, 0x7D,
  0xFF, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xF9, 0xFC, 0xFE, 0x0F, 0xCF,
  0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xF8, 0x0F, 0xCF, 0x81, 0xF8,
  0xF8, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE,
  0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFE, 0x3F, 0x07, 0xE0, 0xFC, 0x3E,
  0x07, 0xE3, 0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0x7C, 0x1F, 0x83, 0xF1, 0xF8,
  0x1F, 0xDF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0x81, 0xFC, 0xFC, 0x1F, 0x87, 0xF1, 0xF8, 0x1F, 0x8F,
  0xC0, 0xFC, 0x7E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F,
  0xC7, 0xF1, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE1, 0xF8, 0x7F, 0x3F, 0x83, 0xF3, 0xF0, 0x3F, 0x3F, 0x03,
  0xF3, 0xF0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xF7, 0xF0,
  0xFE, 0x3F, 0x9F, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0x7E, 0x0F,
  0xE7, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFC,
  0x1F, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F,
  0x00, 0x80, 0x01, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x01, 0xF8,
  0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xF0,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7,
  0xFF, 0xF3, 0xF7, 0xF8, 0xC0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0x40, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x03, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x1F, 0x1F, 0x03, 0xFC, 0x3C, 0xF8, 0x3F, 0xF8,
  0xF3, 0xC1, 0xFF, 0xE3, 0xDF, 0x0F, 0xCF, 0x0F, 0x78, 0x7C, 0x3C, 0x3D,
  0xE1, 0xE0, 0xF0, 0xFF, 0x8F, 0x87, 0xC3, 0xFC, 0x3C, 0x1E, 0x0F, 0xF0,
  0xF0, 0x78, 0x3F, 0xC7, 0xC1, 0xE1, 0xFF, 0x1E, 0x0F, 0x87, 0xBC, 0x78,
  0x3E, 0x3E, 0xF1, 0xE1, 0xF0, 0xF3, 0xC7, 0xCF, 0xE7, 0xCF, 0x1F, 0xFF,
  0xFE, 0x3C, 0x3F, 0xDF, 0xF0, 0xF0, 0x7E, 0x3F, 0x83, 0xE0, 0x60, 0x30,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x08, 0x00,
  0xFE, 0x01, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xBE, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x3E, 0x00, 0x3F,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0xFC,
  0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF0,
  0x3F, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80,
  0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x87, 0xE0, 0x3F,
  0x0F, 0xC0, 0xFE, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7C, 0x1F, 0xC1,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0,
  0x1F, 0x8F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x0F,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFE, 0x03, 0x03, 0xF8, 0x02,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x01, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xE1,
  0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80,
  0x7F, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x7E, 0x3F, 0x00,
  0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x01, 0xFC, 0x7F, 0x01,
  0xFC, 0x7E, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0x7E, 0x1F, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xC0, 0x70, 0x3F, 0x80,
  0x08, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x7F, 0xF1, 0xF8,
  0x3F, 0xF9, 0xFC, 0x1F, 0xF8, 0xFE, 0x0F, 0xFC, 0x7E, 0x0F, 0xFE, 0x3F,
  0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xC3,
  0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x03,
  0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xC0, 0x1F, 0x83,
  0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F,
  0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80,
  0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x3F,
  0x00, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x01, 0xFF,
  0xE0, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x04, 0x7F, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0,
  0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x7F,
  0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xF3,
  0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE,
  0x07, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xBC, 0x07, 0xDF, 0x03, 0xEF, 0x01,
  0xFF, 0xC0, 0xFB, 0xC0, 0xFB, 0xF0, 0x3E, 0xF0, 0x3E, 0xF8, 0x1F, 0xBC,
  0x0F, 0x3E, 0x07, 0xEF, 0x07, 0xDF, 0x81, 0xF3, 0xE1, 0xE7, 0xE0, 0x7C,
  0xF8, 0xF9, 0xF0, 0x1F, 0x3E, 0x3C, 0x7C, 0x0F, 0xCF, 0x9F, 0x1F, 0x03,
  0xE3, 0xE7, 0xCF, 0xC0, 0xF8, 0xFB, 0xE3, 0xF0, 0x3E, 0x3E, 0xF8, 0xF8,
  0x1F, 0x8F, 0xFC, 0x3E, 0x07, 0xE3, 0xFF, 0x1F, 0x81, 0xF0, 0xFF, 0x87,
  0xE0, 0x7C, 0x3F, 0xE1, 0xF8, 0x1F, 0x0F, 0xF0, 0x7C, 0x0F, 0xC3, 0xFC,
  0x1F, 0x03, 0xF0, 0xFE, 0x0F, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x07,
  0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xF0, 0x3F, 0x80, 0x1F, 0x07, 0xF8,
  0x03, 0xF0, 0x7F, 0xC0, 0x3F, 0x07, 0xFC, 0x03, 0xE0, 0x7F, 0xC0, 0x3E,
  0x07, 0xFC, 0x03, 0xE0, 0xFF, 0xE0, 0x7E, 0x0F, 0xBE, 0x07, 0xE0, 0xFB,
  0xE0, 0x7C, 0x0F, 0xBF, 0x07, 0xC0, 0xFB, 0xF0, 0xFC, 0x1F, 0x9F, 0x0F,
  0xC1, 0xF9, 0xF0, 0xFC, 0x1F, 0x1F, 0x8F, 0x81, 0xF1, 0xF8, 0xF8, 0x3F,
  0x0F, 0x9F, 0x83, 0xF0, 0xFD, 0xF8, 0x3F, 0x0F, 0xDF, 0x83, 0xE0, 0x7D,
  0xF0, 0x3E, 0x07, 0xDF, 0x07, 0xE0, 0x7F, 0xF0, 0x7E, 0x07, 0xFF, 0x07,
  0xC0, 0x3F, 0xE0, 0x7C, 0x03, 0xFE, 0x07, 0xC0, 0x3F, 0xE0, 0xFC, 0x03,
  0xFE, 0x0F, 0xC0, 0x1F, 0xE0, 0xF8, 0x01, 0xFC, 0x0F, 0x80, 0x1F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x80,
  0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x0F, 0xCF, 0xC0, 0x07, 0xEF, 0xE0,
  0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xDF,
  0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x07, 0xF0,
  0xFC, 0x07, 0xF8, 0x7F, 0x07, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFC, 0x3F, 0xC1, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xF1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x7F, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0x80, 0xFC, 0x3F,
  0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x0F, 0xCF, 0xC0, 0x07, 0xEF,
  0xE0, 0x03, 0xF7, 0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x1F,
  0xDF, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x07,
  0xF0, 0xFC, 0x07, 0xF8, 0x7F, 0x07, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F,
  0x87, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03,
  0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF8, 0x7E, 0x3F, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xF3,
  0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x8F, 0xC0, 0x7E, 0x3F,
  0x01, 0xF8, 0xFC, 0x07, 0xF3, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xF8, 0x38,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x08, 0x03, 0xF8, 0xF0,
  0x3F, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x87, 0xF0, 0x0F,
  0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01,
  0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x7E, 0x0F, 0xC0,
  0x3F, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F,
  0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0x87,
  0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x07,
  0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x01, 0xF8,
  0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07,
  0xE0, 0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E,
  0x3F, 0x00, 0x7C, 0x7E, 0x00, 0xF9, 0xF8, 0x01, 0xF3, 0xF0, 0x03, 0xE7,
  0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xFE,
  0x00, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0x01, 0xFB, 0xE0, 0x1F, 0xC0, 0x7E,
  0xF8, 0x0F, 0xF0, 0x1F, 0xBE, 0x03, 0xFC, 0x0F, 0xCF, 0x80, 0xFF, 0x03,
  0xF3, 0xE0, 0x7F, 0xC1, 0xF8, 0xF8, 0x1F, 0xF0, 0x7E, 0x3E, 0x0F, 0xFC,
  0x1F, 0x0F, 0x83, 0xFF, 0x0F, 0xC3, 0xE1, 0xF7, 0xC3, 0xF0, 0xF8, 0x7D,
  0xF1, 0xF8, 0x3E, 0x1F, 0x7C, 0x7E, 0x0F, 0x8F, 0x9F, 0x1F, 0x03, 0xE3,
  0xE7, 0xCF, 0xC0, 0xF9, 0xF1, 0xF3, 0xE0, 0x3E, 0x7C, 0x7D, 0xF8, 0x0F,
  0x9F, 0x1F, 0x7E, 0x03, 0xEF, 0x87, 0xDF, 0x00, 0xFB, 0xE1, 0xFF, 0xC0,
  0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x1E, 0xF8, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x0F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC3, 0xF0,
  0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x01,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0,
  0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xBF, 0x01, 0xFC, 0xF8, 0x0F, 0xC7, 0xE0,
  0xFE, 0x3F, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0xC7, 0xF0, 0x3E, 0x3F, 0x01,
  0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0xFC, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x1E, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x1E, 0x00, 0xF8, 0xF0, 0x0F, 0x87,
  0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x7C, 0x07, 0xC3, 0xC0, 0x3E, 0x3E,
  0x00, 0xF3, 0xE0, 0x07, 0xBF, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0x1F, 0x87, 0xE1, 0xF0, 0x78, 0x1E, 0x01, 0xF8, 0x7C,
  0x0F, 0xFB, 0xE0, 0x7F, 0xEF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F,
  0x1F, 0xC3, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF1, 0xFC, 0x0F,
  0xC7, 0xE0, 0x3E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x8F,
  0xE0, 0x7E, 0x3F, 0x83, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x7F, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xBE, 0x01, 0xF8, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x3F, 0x01, 0xFF, 0xFC, 0x0F, 0xBF, 0xE0, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x3F, 0x87, 0xE1, 0xF8, 0x3F, 0x0F, 0xC0, 0xF8, 0xFC, 0x07,
  0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0xFC, 0xFC,
  0x07, 0xE7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x8F, 0xC3, 0xF8,
  0xFF, 0xBF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xF7, 0xFC, 0x1F, 0x1F,
  0xC0, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF,
  0x87, 0xF0, 0x23, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x81, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE,
  0x07, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF1, 0xF0, 0x0F, 0xFB,
  0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFD, 0xFF, 0x07, 0xF1, 0xFC,
  0x1F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0xFC, 0x1F, 0x01, 0xF8, 0x7E,
  0x03, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x7F, 0x03, 0xF9,
  0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFB, 0xE0, 0x0F, 0xE7,
  0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF8,
  0x7C, 0x7E, 0x0F, 0xDF, 0x81, 0xF3, 0xF0, 0x3E, 0x7C, 0x0F, 0xDF, 0x8F,
  0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x43, 0xF8, 0x38, 0x7F, 0xFF,
  0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x3E, 0x03, 0xFE, 0xF8, 0x0F, 0xFD, 0xF0, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFC, 0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x1F, 0x81, 0xF8, 0x7F, 0x03, 0xF0, 0xFC, 0x07, 0xC1, 0xF8, 0x1F,
  0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF0,
  0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03,
  0xFF, 0x7C, 0x03, 0xFD, 0xF8, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x06, 0x01, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x3F, 0x01, 0xFB, 0xFC, 0x0F, 0xBF, 0xF0, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0xFE, 0x0F,
  0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0x81, 0xF8, 0xFC,
  0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x0F, 0x81, 0xF8,
  0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x1F, 0x81,
  0xF8, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x07, 0xE0,
  0xFC, 0x07, 0xC1, 0xFC, 0x0F, 0xC3, 0xF8, 0x0F, 0xC7, 0xF0, 0x0F, 0xCF,
  0xE0, 0x0F, 0xCF, 0xC0, 0x0F, 0x9F, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x3F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F,
  0x80, 0x7E, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7C, 0x0F,
  0xE0, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xC7, 0xE0, 0xFE,
  0x03, 0xEF, 0xF8, 0xFF, 0x81, 0xEF, 0xFE, 0xFF, 0xC0, 0xF7, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x0F, 0xF0, 0xFC, 0x3F, 0x87, 0xF0,
  0x7E, 0x1F, 0x83, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0x1F, 0x0F, 0xC0, 0xFC,
  0x1F, 0x87, 0xE0, 0x7C, 0x0F, 0xC3, 0xF0, 0x7E, 0x07, 0xE1, 0xF0, 0x3F,
  0x03, 0xF1, 0xF8, 0x1F, 0x81, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x7E, 0x07,
  0xC0, 0xFC, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0x03, 0xF0, 0x3F, 0x1F, 0x81,
  0xF8, 0x1F, 0x0F, 0xC0, 0xFC, 0x1F, 0x87, 0xE0, 0x7C, 0x0F, 0xC3, 0xE0,
  0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x03, 0xE0, 0x07, 0xC7, 0xE0, 0x3E, 0x7F,
  0x81, 0xE7, 0xFE, 0x0F, 0x7F, 0xF0, 0xFF, 0xFF, 0x87, 0xF0, 0xFC, 0x3F,
  0x87, 0xE1, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E,
  0x3F, 0x03, 0xF1, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0,
  0x7E, 0x3F, 0x03, 0xE1, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7,
  0xE0, 0x7E, 0x3F, 0x03, 0xE3, 0xF0, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7E, 0x1F, 0xDF, 0xC1,
  0xFB, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xBE, 0x03, 0xF7, 0xC0, 0x7E, 0xFC, 0x1F,
  0x9F, 0x87, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xF8,
  0x07, 0xFC, 0x00, 0x01, 0xF1, 0xF8, 0x03, 0xEF, 0xF8, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x3F, 0xEF, 0xE0, 0x7F, 0x0F, 0xC0, 0xFC, 0x1F, 0x81,
  0xF8, 0x1F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3E,
  0x03, 0xF0, 0x7C, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0,
  0x7E, 0x0F, 0xC1, 0xFC, 0x1F, 0x87, 0xF0, 0x7F, 0xDF, 0xE0, 0xFF, 0xFF,
  0x81, 0xF7, 0xFE, 0x03, 0xEF, 0xF8, 0x0F, 0xCF, 0xE0, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x7C, 0x0F, 0xFB, 0xE0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC,
  0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x7E,
  0x07, 0xE1, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF0, 0xFE, 0x0F,
  0xC3, 0xF8, 0x7F, 0x07, 0xF7, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xEF, 0x80,
  0xFF, 0x7E, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xC7, 0xC1,
  0xF3, 0xF0, 0x7D, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x00, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xC7,
  0x07, 0xE0, 0x41, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x20, 0x1F, 0x8F, 0x8F, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC,
  0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x90, 0xFF,
  0xC3, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x87,
  0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xF8, 0x0F,
  0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF0, 0xF8,
  0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x83, 0xF0,
  0xFC, 0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0xBF, 0xE1, 0xFF, 0xDF, 0x0F, 0xFE,
  0xF0, 0x3F, 0xEF, 0x80, 0xFC, 0x7C, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x7E,
  0xFC, 0x07, 0xE7, 0xC0, 0xFC, 0x7C, 0x0F, 0xC7, 0xC1, 0xF8, 0x7C, 0x1F,
  0x87, 0xC3, 0xF0, 0x7C, 0x3F, 0x07, 0xC3, 0xE0, 0x7C, 0x7E, 0x07, 0xC7,
  0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x1F, 0xC0, 0xFF, 0xE0, 0x7F, 0x07,
  0xEF, 0x83, 0xFC, 0x1F, 0x3E, 0x0F, 0xF0, 0xFC, 0xF8, 0x7F, 0xC3, 0xF3,
  0xE1, 0xFF, 0x1F, 0x8F, 0x87, 0xF8, 0x7E, 0x3E, 0x3F, 0xE1, 0xF0, 0xF8,
  0xF7, 0x8F, 0xC3, 0xE7, 0xDE, 0x3E, 0x0F, 0x9E, 0x79, 0xF8, 0x3E, 0x79,
  0xE7, 0xC0, 0xFB, 0xE7, 0x9F, 0x03, 0xEF, 0x1E, 0xFC, 0x0F, 0xFC, 0x7B,
  0xE0, 0x3F, 0xE1, 0xEF, 0x80, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xF0,
  0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x03,
  0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0xFE, 0x03, 0xF1, 0xFC, 0x01, 0xF1, 0xF8, 0x01,
  0xFB, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x0F,
  0xCF, 0xC0, 0x1F, 0xCF, 0xC0, 0x1F, 0x87, 0xE0, 0x3F, 0x07, 0xE0, 0x7F,
  0x07, 0xE0, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0xC0,
  0xF8, 0x0F, 0xC0, 0x7C, 0x0F, 0xE0, 0x3E, 0x07, 0xE0, 0x1F, 0x03, 0xE0,
  0x0F, 0x83, 0xF0, 0x07, 0xE1, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xF8,
  0x00, 0xFC, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xBE,
  0x00, 0x07, 0xDF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0xFC, 0x3F, 0xFF,
  0x8F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x1F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0x00,
  0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFF, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xE0, 0x00, 0x3F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0x00, 0xFF, 0xA0, 0x03, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 13, 31, 11, 0, -30 },
  { 52, 15, 11, 18, 4, -30 },
  { 73, 24, 30, 25, 1, -30 },
  { 163, 21, 34, 21, 1, -32 },
  { 253, 30, 30, 34, 2, -30 },
  { 366, 25, 30, 27, 1, -30 },
  { 460, 7, 11, 11, 4, -30 },
  { 470, 15, 37, 13, 1, -30 },
  { 540, 15, 38, 13, -3, -31 },
  { 612, 19, 19, 21, 3, -32 },
  { 658, 19, 20, 22, 2, -25 },
  { 706, 10, 11, 11, -2, -5 },
  { 720, 11, 5, 13, 1, -14 },
  { 727, 7, 7, 11, 0, -6 },
  { 734, 22, 30, 17, -2, -30 },
  { 817, 20, 30, 21, 1, -30 },
  { 892, 15, 30, 21, 4, -30 },
  { 949, 22, 30, 21, -1, -30 },
  { 1032, 21, 30, 21, 0, -30 },
  { 1111, 22, 30, 21, -1, -30 },
  { 1194, 22, 30, 21, 0, -30 },
  { 1277, 20, 30, 21, 2, -30 },
  { 1352, 22, 30, 21, 1, -30 },
  { 1435, 21, 30, 21, 1, -30 },
  { 1514, 20, 30, 21, 1, -30 },
  { 1589, 11, 24, 11, 0, -23 },
  { 1622, 13, 29, 11, -2, -23 },
  { 1670, 19, 22, 22, 2, -26 },
  { 1723, 19, 12, 22, 2, -21 },
  { 1752, 19, 22, 22, 2, -26 },
  { 1805, 17, 31, 17, 2, -30 },
  { 1871, 30, 34, 33, 2, -30 },
  { 1999, 24, 30, 24, -3, -30 },
  { 2089, 23, 30, 24, 1, -30 },
  { 2176, 23, 30, 23, 2, -30 },
  { 2263, 24, 30, 26, 1, -30 },
  { 2353, 21, 30, 21, 1, -30 },
  { 2432, 21, 30, 20, 1, -30 },
  { 2511, 25, 30, 26, 2, -30 },
  { 2605, 26, 30, 27, 1, -30 },
  { 2703, 19, 30, 15, -1, -30 },
  { 2775, 20, 39, 13, -7, -30 },
  { 2873, 26, 30, 23, 1, -30 },
  { 2971, 16, 30, 20, 1, -30 },
  { 3031, 34, 30, 34, 1, -30 },
  { 3159, 28, 30, 29, 1, -30 },
  { 3264, 25, 30, 28, 2, -30 },
  { 3358, 23, 30, 23, 1, -30 },
  { 3445, 25, 37, 28, 2, -30 },
  { 3561, 22, 30, 24, 1, -30 },
  { 3644, 21, 30, 20, 0, -30 },
  { 3723, 20, 30, 20, 3, -30 },
  { 3798, 25, 30, 26, 2, -30 },
  { 3892, 23, 30, 23, 4, -30 },
  { 3979, 34, 30, 35, 4, -30 },
  { 4107, 28, 30, 23, -2, -30 },
  { 4212, 21, 30, 22, 4, -30 },
  { 4291, 24, 30, 20, -1, -30 },
  { 4381, 17, 37, 13, -1, -30 },
  { 4460, 10, 30, 17, 4, -30 },
  { 4498, 17, 37, 13, -3, -30 },
  { 4577, 21, 19, 21, 0, -30 },
  { 4627, 16, 3, 16, -4, 4 },
  { 4633, 9, 7, 13, 6, -32 },
  { 4641, 22, 23, 23, 1, -23 },
  { 4705, 21, 32, 23, 0, -32 },
  { 4789, 18, 23, 19, 1, -23 },
  { 4841, 23, 32, 23, 1, -32 },
  { 4933, 19, 23, 21, 2, -23 },
  { 4988, 24, 42, 14, -5, -32 },
  { 5114, 23, 33, 23, 0, -23 },
  { 5209, 21, 32, 23, 0, -32 },
  { 5293, 13, 32, 11, 0, -32 },
  { 5345, 18, 42, 11, -5, -32 },
  { 5440, 24, 32, 22, 0, -32 },
  { 5536, 13, 32, 11, 0, -32 },
  { 5588, 33, 23, 34, 0, -23 },
  { 5683, 21, 23, 23, 0, -23 },
  { 5744, 19, 23, 22, 2, -23 },
  { 5799, 23, 33, 23, -2, -23 },
  { 5894, 22, 33, 23, 1, -23 },
  { 5985, 18, 23, 16, 0, -23 },
  { 6037, 18, 23, 18, 0, -23 },
  { 6089, 14, 28, 15, 2, -28 },
  { 6138, 21, 23, 23, 2, -23 },
  { 6199, 20, 23, 20, 2, -23 },
  { 6257, 30, 23, 30, 3, -23 },
  { 6344, 24, 23, 20, -2, -23 },
  { 6413, 25, 33, 20, -3, -23 },
  { 6517, 19, 23, 18, -1, -23 },
  { 6572, 17, 37, 15, 0, -30 },
  { 6651, 4, 42, 20, 8, -32 },
  { 6672, 16, 37, 15, -2, -30 },
  { 6746, 19, 7, 22, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC42PT7B_H_
