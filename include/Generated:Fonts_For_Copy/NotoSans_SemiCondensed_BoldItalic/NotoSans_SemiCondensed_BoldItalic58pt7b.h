#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC58PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0x00, 0x00,
  0x3F, 0x87, 0xFB, 0xFC, 0x3F, 0x9F, 0xE3, 0xFC, 0xFE, 0x1F, 0xC7, 0xF0,
  0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7,
  0xF0, 0xFE, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F,
  0xC3, 0xE0, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFD, 0xCF, 0x80, 0x7F, 0x8E, 0x0C, 0x03, 0xFC,
  0xF0, 0x00, 0x1F, 0xC7, 0x80, 0x00, 0xFE, 0x38, 0x00, 0x07, 0xF9, 0xC0,
  0x00, 0x3F, 0xEE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xF7, 0xFC, 0x00, 0x07, 0x1F, 0xE0,
  0x00, 0x38, 0xFF, 0x00, 0x01, 0xC7, 0xF8, 0xC0, 0x1E, 0x3F, 0xC7, 0x80,
  0xF3, 0xFC, 0x3F, 0x87, 0x3F, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x04, 0x00, 0x7F, 0xC0, 0x00, 0x7E,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xC0, 0x0F,
  0xFF, 0xC0, 0x07, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xF0, 0x01, 0xFC, 0xFE,
  0x00, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x3F,
  0x00, 0x1F, 0xC3, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0x01,
  0xF8, 0x3F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x83,
  0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x7F, 0x1F,
  0xC0, 0x00, 0xFE, 0x1F, 0xC7, 0xE0, 0x00, 0x3F, 0x87, 0xE3, 0xF0, 0xFF,
  0x0F, 0xE3, 0xF9, 0xFC, 0x7F, 0xE3, 0xF8, 0xFC, 0x7E, 0x3F, 0xFC, 0xFF,
  0xFF, 0x3F, 0x1F, 0xFF, 0x9F, 0xFF, 0x9F, 0xCF, 0xFF, 0xE7, 0xFF, 0xE7,
  0xE7, 0xF9, 0xF8, 0xFF, 0xF3, 0xF1, 0xFC, 0x7E, 0x1F, 0xF1, 0xFC, 0x7E,
  0x1F, 0xC1, 0xF0, 0x7E, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x0F, 0xC1, 0xF8,
  0x00, 0x1F, 0xC3, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xFC, 0x1F, 0x80, 0x03,
  0xF0, 0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x83, 0xF8, 0x00, 0x7E, 0x07,
  0xE0, 0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x07, 0xE0, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0x07, 0xE1, 0xF8, 0x01,
  0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0x00,
  0x1F, 0xFF, 0xC0, 0x1F, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x7F,
  0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xF7, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xF0, 0x3F,
  0xFF, 0x01, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xE0, 0xFF, 0xFF, 0x83, 0xFC,
  0x1F, 0xF7, 0xFC, 0x3F, 0xC3, 0xFE, 0x7F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFE,
  0x7F, 0x87, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xFE, 0x0F, 0xF8,
  0x0F, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xF8, 0x07, 0xFF, 0x80,
  0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0xF0, 0x0F, 0xFE, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xBF, 0xE0,
  0x0F, 0xFF, 0xE3, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xF8, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x3F, 0xDF, 0xE7, 0xF9, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8,
  0x7E, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x01, 0x80, 0xFC, 0x01, 0xF0,
  0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x7F, 0x9F, 0x00, 0x7F, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0x07, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x07, 0xFB, 0xF0, 0x07, 0xF9, 0xFC, 0x07, 0xFC, 0x7E, 0x00, 0xFC, 0x3F,
  0x80, 0x3C, 0x1F, 0xC0, 0x0C, 0x07, 0xF0, 0x02, 0x03, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0x81,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01,
  0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x0F, 0x0F, 0xE7, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFE, 0x7F, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x3F, 0xF1, 0xFF, 0x07, 0xF8, 0x1F, 0xE1, 0xFF, 0x03, 0xFC,
  0x3F, 0xC0, 0x7F, 0x8F, 0xF8, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x7F, 0xC0,
  0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xEF,
  0xF8, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF,
  0x00, 0x7F, 0xDF, 0xE0, 0x0F, 0xFB, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x7F,
  0xCF, 0xF0, 0x0F, 0xF9, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0xC7, 0xF8,
  0x0F, 0xF0, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC, 0x1F, 0xF0,
  0x7F, 0xEF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFE, 0xFE, 0x1F, 0xE7,
  0xF8, 0x3F, 0x1F, 0xE0, 0x78, 0x7F, 0x81, 0x81, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xC3, 0xFF, 0x00, 0x7E, 0x03, 0xFE, 0x00, 0xF0, 0x07, 0xFC,
  0x00, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0x03, 0xFF, 0x00, 0x60, 0x0F,
  0xF8, 0x02, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xC4, 0x00, 0x07, 0xFC, 0x38, 0x00, 0x7F, 0xE1, 0xFC,
  0x3F, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFB,
  0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xF9, 0xFE,
  0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x1F,
  0xC0, 0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x80, 0xFE, 0x01, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0xC0, 0x00, 0xFF, 0x83, 0xC0, 0x0F, 0xFE, 0x0F, 0xFB, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x7E, 0x00, 0x3F, 0xCF, 0xFC, 0x01, 0xFE, 0xFF, 0xF0, 0x0F, 0xEF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0xC0, 0x7F, 0x87, 0xFC,
  0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07,
  0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xF0,
  0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x80, 0xFF,
  0xDF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFC, 0x7F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x3F,
  0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80,
  0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0xC7, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x01, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x7F,
  0x80, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00,
  0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0x83, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0x3F, 0xC3, 0xFC, 0x07, 0xFC,
  0xFF, 0x80, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0x7F, 0x80,
  0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xEF,
  0xF0, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x7F, 0xE3, 0xFE, 0x3F,
  0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFD, 0xFC, 0x1F,
  0xFF, 0x7F, 0x81, 0xFF, 0xCF, 0xF0, 0x0F, 0xF1, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x70, 0x7F, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x3F, 0x80, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x1F, 0xE0, 0x3F, 0x80, 0x1C, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0x81, 0xFF, 0x0C,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x7F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x40, 0x07, 0xE0, 0x7E, 0x01, 0xFF,
  0xE0, 0xFC, 0x1F, 0xC0, 0x7F, 0xFF, 0x0F, 0xC3, 0xF0, 0x3F, 0xFF, 0xC1,
  0xF8, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x1F, 0x83, 0xFC, 0x3F, 0x07, 0xE7,
  0xE0, 0x7F, 0x07, 0xE0, 0xFC, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x9F, 0x83,
  0xF0, 0x3F, 0x03, 0xF7, 0xE0, 0xFC, 0x07, 0xE0, 0x7C, 0xFC, 0x1F, 0x80,
  0xFC, 0x0F, 0x9F, 0x87, 0xE0, 0x3F, 0x03, 0xF3, 0xE0, 0xFC, 0x07, 0xE0,
  0x7E, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xDF, 0x83, 0xF0, 0x1F, 0x83, 0xF3,
  0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xCF, 0xC1,
  0xF8, 0x3F, 0x83, 0xF1, 0xF8, 0x3F, 0x07, 0xF0, 0xFC, 0x3F, 0x07, 0xE1,
  0xFE, 0x3F, 0x87, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x1F, 0xFE, 0xFF,
  0xF8, 0x1F, 0x81, 0xFF, 0xCF, 0xFE, 0x01, 0xF8, 0x1F, 0xF0, 0xFF, 0x80,
  0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0x80, 0x1F,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x03, 0xFC, 0x7F,
  0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F,
  0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xC0,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x07, 0xF9, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFE, 0x0F, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0x01, 0xFE, 0x01, 0xFF,
  0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFE,
  0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F, 0xF8,
  0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F, 0xF8,
  0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xF0,
  0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xE1, 0xF8, 0x07, 0xFF, 0x00, 0x38, 0x07, 0xFE, 0x00, 0x08,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0x00,
  0x7F, 0xF0, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x1F, 0xFC, 0x01, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0,
  0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x1F,
  0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0xC0,
  0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x7F, 0xF0, 0x1F, 0xF0, 0x7F, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xC1,
  0xF8, 0x03, 0xFF, 0x80, 0x0E, 0x01, 0xFF, 0xC0, 0x00, 0x80, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x01, 0xFF, 0xF8, 0x7F, 0x80, 0x7F, 0xFE, 0x3F, 0xE0, 0x3F, 0xFF,
  0x8F, 0xF8, 0x0F, 0xFF, 0xE3, 0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0x80, 0xFF,
  0xFC, 0x3F, 0xE0, 0x7F, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF0, 0x1F,
  0xF0, 0x03, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x03, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x08, 0x1F, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x01, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xC7, 0xFC, 0x00,
  0x01, 0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x3F,
  0xE0, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00,
  0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x01, 0xFE, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x0F, 0xEF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xDF, 0x80, 0x1F,
  0xFF, 0x80, 0x3F, 0xBF, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFC, 0x03, 0xFB, 0xFC, 0x03, 0xFD, 0xF8, 0x07, 0xF7,
  0xF8, 0x07, 0xF3, 0xF0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xE0, 0x3F, 0x9F,
  0xC0, 0x1F, 0xCF, 0xC0, 0x7E, 0x7F, 0x80, 0x7F, 0x9F, 0x81, 0xFC, 0xFF,
  0x00, 0xFF, 0x3F, 0x03, 0xF1, 0xFE, 0x01, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8,
  0x03, 0xF8, 0xFE, 0x1F, 0x8F, 0xF0, 0x07, 0xF1, 0xFC, 0x7F, 0x1F, 0xE0,
  0x1F, 0xE3, 0xF8, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xF3, 0xF8, 0x7F, 0x80,
  0x7F, 0x0F, 0xE7, 0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0xDF, 0xC3, 0xFC, 0x01,
  0xFC, 0x3F, 0xBF, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0xFE, 0x0F, 0xF0, 0x0F,
  0xF0, 0x7F, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0xF0, 0x3F, 0x80, 0x3F,
  0x81, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x81, 0xFE, 0x01, 0xFE,
  0x07, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xFC, 0x07, 0xF0, 0x07, 0xF0,
  0x1F, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFE,
  0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFC, 0x01, 0xFF,
  0xF0, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x03,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xF8, 0x03,
  0xFB, 0xF8, 0x03, 0xF8, 0x03, 0xFB, 0xFC, 0x07, 0xF8, 0x03, 0xFB, 0xFC,
  0x07, 0xF8, 0x07, 0xFB, 0xFC, 0x07, 0xF0, 0x07, 0xF9, 0xFC, 0x07, 0xF0,
  0x07, 0xF1, 0xFE, 0x0F, 0xF0, 0x07, 0xF1, 0xFE, 0x0F, 0xF0, 0x07, 0xF0,
  0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFF, 0x0F,
  0xE0, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0, 0x0F,
  0xE0, 0x7F, 0x9F, 0xE0, 0x1F, 0xE0, 0x7F, 0x9F, 0xC0, 0x1F, 0xE0, 0x7F,
  0x9F, 0xC0, 0x1F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xC0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xFF,
  0x80, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x07,
  0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xE0,
  0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00,
  0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x07, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x0F,
  0xFC, 0x1F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFE, 0x03, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFF,
  0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF,
  0x07, 0xF8, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xFE, 0x07, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFF,
  0x3F, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x07,
  0xFD, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x8F,
  0xF8, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC,
  0x1F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0x87, 0xFF,
  0x00, 0xFF, 0x03, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0,
  0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xF8, 0x0F, 0xFC, 0x0F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF8, 0x01, 0xFE, 0x0F,
  0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x81, 0xFE, 0x01, 0xFF,
  0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xFC,
  0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xF1, 0xF8, 0x03, 0xFF, 0x00, 0xE0, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x40, 0x00, 0xFF, 0x01, 0x80, 0x07, 0xFC, 0x07, 0x80, 0x3F, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x03,
  0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80,
  0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F,
  0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xF8,
  0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0,
  0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0,
  0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80,
  0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x7F, 0x83, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x3F, 0x87, 0xF8, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0x3F, 0x8F, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x3F, 0x9F, 0xE0, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xF8, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0xE0, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFF, 0xF0,
  0x1F, 0xE0, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFF, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xF7, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF7, 0xF0,
  0x7F, 0x80, 0xFF, 0x07, 0xF7, 0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xE7, 0xF0,
  0xFF, 0x00, 0xFF, 0x0F, 0xE7, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xC7, 0xF1,
  0xFE, 0x00, 0xFF, 0x1F, 0xC7, 0xF1, 0xFE, 0x00, 0xFF, 0x1F, 0xC7, 0xF1,
  0xFC, 0x00, 0xFF, 0x3F, 0x87, 0xF3, 0xFC, 0x00, 0xFF, 0x3F, 0x87, 0xF3,
  0xF8, 0x00, 0xFF, 0x7F, 0x07, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x07, 0xF7,
  0xF8, 0x00, 0xFF, 0x7E, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x07, 0xEF,
  0xF0, 0x00, 0xFE, 0xFE, 0x07, 0xEF, 0xE0, 0x00, 0xFE, 0xFC, 0x07, 0xEF,
  0xE0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xF0,
  0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00,
  0x1F, 0xE3, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x01, 0xFF, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x0F, 0xFD, 0xFE, 0x00, 0x3F, 0xE7, 0xF8, 0x01, 0xFF, 0x1F, 0xE0, 0x07,
  0xFC, 0x7F, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x07, 0xFC,
  0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x01,
  0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x7F,
  0x9F, 0xE0, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE3, 0xF0, 0x01, 0xFC, 0x3F, 0x00,
  0x1F, 0x83, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00, 0xFC,
  0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x87, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F,
  0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x07,
  0xFF, 0x1F, 0xC0, 0x7F, 0xFC, 0xFE, 0x07, 0xFF, 0xEF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0x07, 0xFE,
  0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x7F,
  0x80, 0x3F, 0xC7, 0xFC, 0x01, 0xFE, 0x3F, 0xE0, 0x1F, 0xE1, 0xFE, 0x00,
  0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x80, 0x3F, 0xC7, 0xFC, 0x01, 0xFE,
  0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F,
  0x80, 0x7F, 0xC3, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0x7F, 0x00, 0x7F, 0xE3, 0xF8, 0x01,
  0xFE, 0x1F, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF9, 0xFF, 0x80,
  0x1F, 0xEF, 0xFE, 0x00, 0x7F, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFD, 0xFF, 0x80, 0xFF, 0xC1, 0xFE, 0x07, 0xFE,
  0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0xC1, 0xFE, 0x01,
  0xFF, 0x07, 0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F,
  0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xE1,
  0xFE, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F,
  0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xC0, 0xFF, 0xE3, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0x7F, 0xFF, 0x01, 0xFD, 0xFF, 0xF8, 0x07, 0xE3, 0xFF, 0xC0,
  0x3F, 0x87, 0xFC, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xF0, 0x08, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x30, 0x3F, 0xF0, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFF, 0xE7, 0xF8,
  0x01, 0xFF, 0xF7, 0xF8, 0x03, 0xFF, 0xF7, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0,
  0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0,
  0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xC0,
  0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xC7, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x7E, 0x00,
  0x3F, 0xFE, 0xFE, 0x00, 0x1F, 0xFC, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xC3, 0xFC, 0x3F, 0xC0, 0x7F, 0x1F, 0xE0, 0x1F, 0xCF, 0xF8, 0x07,
  0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x01, 0xFF, 0x7F, 0x80, 0xFF, 0x9F, 0xE3,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x04, 0x1F, 0xF0, 0x0F, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x84, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x7F, 0xF1, 0xFC, 0x01, 0xFF, 0xF3, 0xF8, 0x07, 0xFF, 0xEF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE,
  0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0,
  0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x81, 0xFE, 0x00,
  0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xEF, 0xF0, 0x01, 0xFF, 0x9F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x10, 0x00, 0x7F, 0xC0, 0x3C,
  0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x01, 0xFE, 0x7F, 0xE0, 0x0F, 0xE7,
  0xFF, 0x80, 0x7F, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0x87,
  0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0x01, 0xFE, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x3F,
  0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87,
  0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x3F,
  0xC1, 0xFE, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87,
  0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x21, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xFE,
  0x03, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xF0,
  0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0x7F, 0x80,
  0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF3, 0xFE, 0x00,
  0x0F, 0xF7, 0xFC, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x3F, 0xF7, 0xF8, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x7F, 0x83, 0xFE, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0x03, 0xF0, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x0F, 0xFC,
  0x0F, 0xFC, 0x03, 0xF1, 0xFF, 0xE3, 0xFF, 0xE0, 0x3F, 0x3F, 0xFE, 0x7F,
  0xFE, 0x07, 0xF7, 0xFF, 0xF7, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xBF, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0x0F,
  0xFC, 0x0F, 0xFC, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF1, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE1, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC3,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF8,
  0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x07, 0xF0, 0x07,
  0xF8, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03,
  0xF0, 0x3F, 0x80, 0x1F, 0x87, 0xFE, 0x00, 0xFC, 0x7F, 0xF8, 0x07, 0xE7,
  0xFF, 0xE0, 0x7F, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xC1, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3,
  0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x0F, 0xF8,
  0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F,
  0xE0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3,
  0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0,
  0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F,
  0xE1, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3,
  0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xC1, 0xFE, 0x1F, 0xF0,
  0x3F, 0xE7, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF7,
  0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F,
  0x80, 0x1F, 0xEF, 0xF0, 0x07, 0xFD, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x3F,
  0xE7, 0xF8, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x7E, 0x1F, 0xF8, 0x00, 0x7E, 0x7F, 0xFC, 0x00,
  0x7E, 0xFF, 0xFC, 0x00, 0xFE, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xE7, 0xFE, 0x00, 0xFF, 0x81, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x01,
  0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03,
  0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x07,
  0xF8, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x07,
  0xF8, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xFC, 0x1F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xEF, 0xFF, 0x80, 0x1F,
  0xE7, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC0, 0x40, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC1, 0xF8, 0x03, 0xFF, 0x1F, 0xC0, 0x7F,
  0xFC, 0xFE, 0x07, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFB, 0xFF, 0xC1, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC7, 0xFC,
  0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07,
  0xF8, 0xFF, 0x80, 0x3F, 0xC7, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xE1,
  0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC,
  0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x3F,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xEF, 0xE0,
  0x1F, 0xFE, 0xFF, 0x00, 0x7F, 0xE7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x01,
  0x83, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x7F, 0x3F, 0xC0,
  0x3F, 0x3F, 0xE0, 0x3F, 0xBF, 0xF0, 0x1F, 0xDF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xE0, 0xF8, 0x1F, 0xE0, 0x08, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0xC0, 0x07, 0xF8,
  0x7C, 0x0F, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xC1, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x40, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF,
  0x80, 0x07, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1,
  0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x07, 0xF8,
  0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F,
  0xF0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC3,
  0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x07, 0xF8,
  0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x1F,
  0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0xC1,
  0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0x07, 0xFE,
  0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0xF7,
  0xE0, 0x1F, 0xFF, 0x3F, 0x00, 0xFF, 0xF1, 0xF8, 0x01, 0xFE, 0x1F, 0xC0,
  0x03, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFE, 0xFF,
  0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x87, 0xF0, 0x07,
  0xF8, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x07,
  0xF0, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x87,
  0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00,
  0x3F, 0x9F, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xFB,
  0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xBF, 0x80, 0x7F, 0xC0, 0x3F, 0xDF,
  0xC0, 0x7F, 0xE0, 0x1F, 0xEF, 0xE0, 0x3F, 0xF0, 0x1F, 0xE7, 0xF0, 0x3F,
  0xF8, 0x0F, 0xF3, 0xF8, 0x1F, 0xFC, 0x0F, 0xF1, 0xFC, 0x0F, 0xFE, 0x07,
  0xF8, 0xFE, 0x0F, 0xFF, 0x07, 0xF8, 0x7F, 0x07, 0xFF, 0x83, 0xFC, 0x3F,
  0x87, 0xFF, 0xC1, 0xFC, 0x1F, 0xC3, 0xF7, 0xE1, 0xFE, 0x0F, 0xE1, 0xFB,
  0xF0, 0xFF, 0x07, 0xF1, 0xF9, 0xF8, 0xFF, 0x03, 0xF8, 0xFC, 0xFC, 0x7F,
  0x81, 0xFC, 0xFE, 0x7E, 0x3F, 0x80, 0xFE, 0x7E, 0x3F, 0x3F, 0xC0, 0x7F,
  0x3F, 0x1F, 0x9F, 0xC0, 0x3F, 0xBF, 0x0F, 0xDF, 0xE0, 0x1F, 0xDF, 0x87,
  0xEF, 0xE0, 0x0F, 0xEF, 0xC3, 0xF7, 0xF0, 0x07, 0xFF, 0xC1, 0xFB, 0xF8,
  0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0xFF,
  0xF0, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x83,
  0xFE, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0xFF,
  0x3F, 0xE0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x7F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00,
  0x07, 0xF7, 0xF8, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x40, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x5F, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x80, 0x01, 0xFE,
  0x00,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 18, 42, 16, 0, -41 },
  { 96, 21, 15, 25, 6, -41 },
  { 136, 34, 41, 34, 1, -41 },
  { 311, 29, 47, 29, 1, -44 },
  { 482, 42, 43, 46, 3, -42 },
  { 708, 36, 43, 37, 1, -42 },
  { 902, 10, 15, 15, 6, -41 },
  { 921, 20, 50, 18, 2, -41 },
  { 1046, 21, 51, 18, -4, -42 },
  { 1180, 25, 26, 29, 5, -44 },
  { 1262, 26, 29, 31, 3, -35 },
  { 1357, 14, 15, 16, -3, -7 },
  { 1384, 16, 7, 18, 1, -19 },
  { 1398, 10, 10, 16, 0, -9 },
  { 1411, 31, 42, 23, -3, -42 },
  { 1574, 27, 43, 29, 2, -42 },
  { 1720, 22, 41, 29, 5, -41 },
  { 1833, 31, 42, 29, -2, -42 },
  { 1996, 29, 43, 29, 0, -42 },
  { 2152, 30, 41, 29, -1, -41 },
  { 2306, 30, 42, 29, 0, -41 },
  { 2464, 29, 43, 29, 2, -42 },
  { 2620, 30, 41, 29, 2, -41 },
  { 2774, 29, 43, 29, 1, -42 },
  { 2930, 27, 43, 29, 2, -42 },
  { 3076, 15, 33, 16, 0, -32 },
  { 3138, 18, 40, 16, -3, -32 },
  { 3228, 26, 30, 31, 3, -36 },
  { 3326, 26, 17, 31, 3, -29 },
  { 3382, 26, 30, 31, 3, -36 },
  { 3480, 23, 43, 24, 3, -42 },
  { 3604, 43, 47, 45, 2, -42 },
  { 3857, 34, 41, 33, -4, -41 },
  { 4032, 32, 41, 33, 1, -41 },
  { 4196, 32, 43, 32, 3, -42 },
  { 4368, 34, 41, 36, 1, -41 },
  { 4543, 30, 41, 28, 1, -41 },
  { 4697, 30, 41, 28, 1, -41 },
  { 4851, 34, 43, 37, 3, -42 },
  { 5034, 37, 41, 37, 1, -41 },
  { 5224, 26, 41, 21, -2, -41 },
  { 5358, 28, 53, 18, -9, -41 },
  { 5544, 37, 41, 32, 1, -41 },
  { 5734, 22, 41, 27, 1, -41 },
  { 5847, 47, 41, 47, 1, -41 },
  { 6088, 40, 41, 40, 1, -41 },
  { 6293, 34, 43, 38, 3, -42 },
  { 6476, 32, 41, 32, 1, -41 },
  { 6640, 34, 52, 38, 3, -42 },
  { 6861, 31, 41, 33, 1, -41 },
  { 7020, 30, 43, 28, 0, -42 },
  { 7182, 27, 41, 28, 5, -41 },
  { 7321, 34, 42, 36, 3, -41 },
  { 7500, 32, 41, 32, 5, -41 },
  { 7664, 48, 41, 48, 5, -41 },
  { 7910, 39, 41, 32, -3, -41 },
  { 8110, 30, 41, 30, 5, -41 },
  { 8264, 33, 41, 28, -2, -41 },
  { 8434, 24, 50, 18, -2, -41 },
  { 8584, 13, 42, 24, 6, -42 },
  { 8653, 24, 50, 18, -4, -41 },
  { 8803, 28, 27, 29, 1, -42 },
  { 8898, 22, 4, 22, -5, 5 },
  { 8909, 12, 9, 18, 8, -44 },
  { 8923, 29, 33, 32, 2, -32 },
  { 9043, 30, 45, 32, 0, -44 },
  { 9212, 25, 33, 26, 2, -32 },
  { 9316, 32, 45, 32, 2, -44 },
  { 9496, 26, 33, 29, 2, -32 },
  { 9604, 32, 58, 20, -6, -44 },
  { 9836, 31, 46, 32, 0, -32 },
  { 10015, 29, 44, 32, 1, -44 },
  { 10175, 18, 44, 16, 0, -44 },
  { 10274, 25, 58, 16, -7, -44 },
  { 10456, 32, 44, 30, 1, -44 },
  { 10632, 18, 44, 16, 0, -44 },
  { 10731, 44, 32, 48, 1, -32 },
  { 10907, 29, 32, 32, 1, -32 },
  { 11023, 27, 33, 31, 2, -32 },
  { 11135, 32, 46, 32, -2, -32 },
  { 11319, 29, 46, 32, 2, -32 },
  { 11486, 25, 32, 22, 0, -32 },
  { 11586, 25, 33, 25, 0, -32 },
  { 11690, 20, 39, 21, 3, -38 },
  { 11788, 29, 33, 32, 2, -32 },
  { 11908, 28, 32, 27, 3, -32 },
  { 12020, 41, 32, 42, 4, -32 },
  { 12184, 34, 32, 28, -3, -32 },
  { 12320, 35, 46, 28, -4, -32 },
  { 12522, 27, 32, 24, -2, -32 },
  { 12630, 24, 50, 20, 0, -41 },
  { 12780, 6, 57, 28, 11, -44 },
  { 12823, 23, 50, 20, -3, -41 },
  { 12967, 26, 9, 31, 3, -25 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC58PT7B_H_
