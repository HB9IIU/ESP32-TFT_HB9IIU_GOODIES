#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC43PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x01, 0xF0, 0x1F, 0x81, 0xFE, 0x0F, 0xE0,
  0x7F, 0x01, 0xF0, 0x02, 0x00, 0x3E, 0x3F, 0x3E, 0x3E, 0x7E, 0x3E, 0x7E,
  0x7E, 0x7C, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0x78, 0x78, 0xF8,
  0x78, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F,
  0x00, 0x0F, 0x87, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1,
  0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF0, 0xF0, 0x0F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x0F, 0x0F, 0x00, 0x0F,
  0x8F, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xE3, 0xE0, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0,
  0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x0F, 0x00,
  0x07, 0x87, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xE1, 0xE0,
  0x01, 0xF1, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x7E, 0xE3, 0x07, 0xE7, 0x00, 0x3F, 0x30, 0x01,
  0xF9, 0x80, 0x0F, 0xEC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x37, 0xF0, 0x01, 0x9F, 0x80, 0x1C, 0xFC, 0x80, 0xE7, 0xE7, 0x06, 0x7E,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0xFF,
  0xE0, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0xF0, 0x03, 0xC0, 0x3F,
  0xF0, 0x0F, 0x80, 0xFF, 0xE0, 0x3E, 0x03, 0xE7, 0xC0, 0x78, 0x07, 0xCF,
  0x81, 0xF0, 0x1F, 0x1F, 0x07, 0xC0, 0x3E, 0x3E, 0x0F, 0x00, 0x7C, 0x7C,
  0x3E, 0x00, 0xF0, 0xF8, 0xF8, 0x03, 0xE1, 0xF1, 0xE0, 0x07, 0xC3, 0xC7,
  0xC0, 0x0F, 0x8F, 0x9F, 0x1F, 0x1F, 0x1F, 0x3C, 0x7F, 0x3E, 0x7C, 0xFB,
  0xFF, 0x3F, 0xFB, 0xE7, 0xFF, 0x7F, 0xE7, 0x9F, 0xBE, 0x7F, 0x9F, 0x3E,
  0x7C, 0x7E, 0x7C, 0xF8, 0xF8, 0x00, 0xF1, 0xF1, 0xF0, 0x03, 0xE3, 0xC3,
  0xE0, 0x0F, 0x8F, 0x87, 0xC0, 0x1E, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x3E,
  0x01, 0xF0, 0x7C, 0x7C, 0x03, 0xC0, 0xF8, 0xF8, 0x0F, 0x81, 0xF3, 0xE0,
  0x3E, 0x03, 0xFF, 0xC0, 0x78, 0x03, 0xFF, 0x01, 0xF0, 0x07, 0xFC, 0x07,
  0xC0, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFC, 0x7E, 0x00,
  0x3E, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0xFC,
  0x00, 0x3E, 0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0x1F, 0xFE, 0x1F, 0x8F,
  0xFF, 0x87, 0xE3, 0xF3, 0xF1, 0xF1, 0xF8, 0xFE, 0xFC, 0xFE, 0x1F, 0xFE,
  0x3F, 0x07, 0xFF, 0x8F, 0xC0, 0xFF, 0xC3, 0xF0, 0x3F, 0xE0, 0xFC, 0x07,
  0xF8, 0x3F, 0x83, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xBF, 0x81, 0xFF, 0x87, 0xF0, 0x3F, 0x3E, 0x7E,
  0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x40, 0xF0, 0x1C,
  0x3C, 0x0F, 0xCF, 0x03, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0x3F,
  0xFC, 0x1F, 0xFF, 0x0F, 0xF0, 0x0F, 0xFE, 0x07, 0xF7, 0x81, 0xF9, 0xF0,
  0x3C, 0x7C, 0x06, 0x0F, 0x80, 0x83, 0xC0, 0x00, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xE1, 0xF0,
  0x7C, 0x3E, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x08,
  0x7D, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x07, 0xF1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0x3F, 0x1F, 0x81, 0xF9,
  0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x07, 0xF7, 0xF0, 0x3F, 0x3F, 0x01,
  0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF7, 0xF0, 0x3F, 0xBF,
  0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x07, 0xF3, 0xF0, 0x3F,
  0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0x87, 0xF1, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE,
  0x7F, 0xFC, 0xFE, 0xFC, 0x7C, 0xFC, 0x38, 0xFC, 0x20, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x7E, 0x3F, 0x80, 0xF0, 0x3F, 0x80, 0x80, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80,
  0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0x0F, 0xF0, 0x10,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x80, 0x0F, 0xE3, 0x00, 0x7F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFB,
  0xF0, 0x01, 0xF7, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3F, 0x00, 0x7E, 0x7E,
  0x00, 0xF8, 0xFC, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xE0, 0x3E, 0x0F, 0xC0,
  0x7C, 0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x80, 0x0F, 0xE3, 0x80,
  0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x7C, 0x07,
  0xEF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0x0F,
  0xC7, 0xF0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E,
  0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0x87, 0xE1, 0xFC,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F,
  0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0x7F, 0x87, 0xE0, 0xFC,
  0x3F, 0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0,
  0xFC, 0x1F, 0xCF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xC7, 0xF0, 0xFC, 0x1F,
  0x8F, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC,
  0x07, 0xE7, 0xE0, 0x7E, 0x3F, 0xCF, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x07,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF1, 0xFC, 0x7F, 0x1F, 0x83, 0xF3,
  0xF8, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xF7, 0xF0, 0x3F,
  0x7E, 0x03, 0xF7, 0xF0, 0x7F, 0x3F, 0x0F, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x1F, 0xF7, 0xE0, 0x7E, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0xF8, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xE0, 0x10, 0x00, 0x00,
  0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFC,
  0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xFF, 0x0F,
  0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xF8, 0xE0, 0xFC, 0x40, 0x7E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0x20, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1E, 0x1F, 0x00,
  0xE0, 0x3E, 0x3E, 0x0F, 0xFE, 0x3C, 0xF8, 0x3F, 0xF8, 0x79, 0xE0, 0xFF,
  0xF0, 0xF7, 0xC3, 0xE1, 0xE1, 0xEF, 0x0F, 0x87, 0xC3, 0xDE, 0x1E, 0x0F,
  0x07, 0xFC, 0x7C, 0x1E, 0x0F, 0xF0, 0xF0, 0x3C, 0x3F, 0xE1, 0xE0, 0xF8,
  0x7B, 0xC7, 0xC1, 0xE0, 0xF7, 0x8F, 0x83, 0xC3, 0xEF, 0x1F, 0x0F, 0x87,
  0x9E, 0x3E, 0x1F, 0x1F, 0x3C, 0x7C, 0x7E, 0x7C, 0x78, 0x7F, 0xFF, 0xF8,
  0xF0, 0xFF, 0x3F, 0xC1, 0xF0, 0xFC, 0x7F, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x80, 0x0F,
  0xF0, 0x0F, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xBE, 0x00,
  0x0F, 0x9F, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE3, 0xF0,
  0x03, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x3F,
  0x00, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xC0,
  0x1F, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0,
  0x01, 0xFB, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFC,
  0x3F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80,
  0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x7F, 0x83, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0xFC, 0x0F, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x1F,
  0x80, 0x7E, 0x3F, 0x01, 0xFC, 0x7E, 0x03, 0xF0, 0xFC, 0x1F, 0xE1, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFC, 0x7C, 0x0F, 0xF0, 0x08, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x81, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0x83, 0xFC, 0x0F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xE1, 0xF8, 0x07,
  0xF0, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00,
  0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xE0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF0, 0xFC,
  0x07, 0xF8, 0x7E, 0x07, 0xF8, 0x3F, 0x1F, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xE0, 0xF0, 0x3F,
  0xC0, 0x08, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x09,
  0xF8, 0x1F, 0xF8, 0xFC, 0x1F, 0xFC, 0xFE, 0x0F, 0xFE, 0x7F, 0x07, 0xFF,
  0x3F, 0x83, 0xFF, 0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xF0, 0x07,
  0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0xC0,
  0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC,
  0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x0F, 0xC0,
  0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x81,
  0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x3F,
  0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x03, 0xF0,
  0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xF0,
  0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0x1F, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x11, 0xFE, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0xFE, 0x03,
  0xF8, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x7F,
  0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F,
  0x3F, 0x80, 0x07, 0xEF, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7F, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF1, 0xF8, 0x00,
  0x7E, 0x3F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F,
  0xE0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F,
  0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F,
  0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C,
  0x07, 0xDF, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0xFB, 0xF0, 0x3F, 0x7C, 0x1F,
  0x7E, 0x07, 0xEF, 0x87, 0xCF, 0xC0, 0xF9, 0xF0, 0xF9, 0xF0, 0x1F, 0x3E,
  0x3E, 0x7E, 0x03, 0xE7, 0xC7, 0xCF, 0xC0, 0xFC, 0xF9, 0xF1, 0xF8, 0x1F,
  0x9F, 0x3E, 0x3F, 0x03, 0xE3, 0xEF, 0x87, 0xC0, 0x7C, 0x7D, 0xF1, 0xF8,
  0x1F, 0x8F, 0xFC, 0x3F, 0x03, 0xF0, 0xFF, 0x87, 0xE0, 0x7E, 0x1F, 0xF0,
  0xF8, 0x0F, 0x83, 0xFC, 0x1F, 0x01, 0xF0, 0x7F, 0x87, 0xE0, 0x7E, 0x0F,
  0xE0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x3E,
  0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0,
  0xFF, 0x00, 0x7E, 0x0F, 0xF8, 0x03, 0xE0, 0x7F, 0xC0, 0x1F, 0x03, 0xFE,
  0x01, 0xF8, 0x1F, 0xF8, 0x0F, 0xC0, 0xFF, 0xC0, 0x7E, 0x0F, 0xFE, 0x03,
  0xE0, 0x7D, 0xF8, 0x1F, 0x03, 0xEF, 0xC1, 0xF8, 0x1F, 0x7E, 0x0F, 0xC0,
  0xF9, 0xF0, 0x7E, 0x0F, 0xCF, 0xC3, 0xE0, 0x7E, 0x7E, 0x3F, 0x03, 0xE1,
  0xF1, 0xF8, 0x1F, 0x0F, 0x8F, 0xC1, 0xF8, 0x7E, 0x7C, 0x0F, 0xC3, 0xF3,
  0xE0, 0x7E, 0x0F, 0x9F, 0x03, 0xE0, 0x7F, 0xF8, 0x1F, 0x03, 0xFF, 0xC1,
  0xF8, 0x1F, 0xFC, 0x0F, 0xC0, 0x7F, 0xE0, 0x7E, 0x03, 0xFF, 0x03, 0xE0,
  0x1F, 0xF8, 0x1F, 0x00, 0x7F, 0xC1, 0xF8, 0x03, 0xFC, 0x0F, 0xC0, 0x1F,
  0xE0, 0x7E, 0x00, 0xFF, 0x03, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x7F, 0x80, 0x7E, 0x1F,
  0xC0, 0x1F, 0x8F, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0x7F,
  0x7F, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00,
  0x7E, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8,
  0x00, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x0F, 0xE3,
  0xF8, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xE1, 0xFE, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x7E, 0x0F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x83, 0xFC, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x7F, 0x80,
  0x7E, 0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xFC, 0xFC,
  0x00, 0x7F, 0x7F, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xE7, 0xE0, 0x01, 0xF9,
  0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03,
  0xF3, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0x8F, 0xE0,
  0x0F, 0xE3, 0xF8, 0x07, 0xF8, 0x7F, 0x03, 0xFC, 0x1F, 0xE1, 0xFE, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFC, 0x7F, 0x81, 0xF8, 0x3F, 0x03,
  0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF0, 0x7E,
  0x07, 0xE0, 0xFC, 0x1F, 0xC3, 0xF0, 0x7F, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xF8, 0xFC,
  0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0,
  0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x8F,
  0xC0, 0x7F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F,
  0xE3, 0xC0, 0xFE, 0x01, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x40, 0x1F, 0xC3, 0xC0, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x0F,
  0xC1, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xF8,
  0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x03,
  0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8,
  0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x83,
  0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xF7, 0xE0,
  0x0F, 0xEF, 0xC0, 0x1F, 0x9F, 0x80, 0x7F, 0x3F, 0x00, 0xFC, 0x7E, 0x01,
  0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x03, 0xE0, 0x7E,
  0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x80,
  0x7C, 0x7E, 0x00, 0xF8, 0xFC, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xE0, 0x07,
  0xCF, 0xC0, 0x0F, 0xBF, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xFF, 0x80, 0x7E, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x7E, 0x03, 0xF8,
  0x07, 0xEF, 0xC0, 0x7F, 0x01, 0xFD, 0xF8, 0x0F, 0xE0, 0x3F, 0x3F, 0x03,
  0xFC, 0x07, 0xE7, 0xE0, 0x7F, 0x81, 0xF8, 0xFC, 0x1F, 0xF0, 0x3F, 0x1F,
  0x83, 0xFE, 0x0F, 0xC3, 0xF0, 0xFF, 0xC1, 0xF8, 0x7E, 0x1F, 0xF8, 0x3F,
  0x0F, 0xC3, 0xFF, 0x0F, 0xC1, 0xF0, 0xFB, 0xE1, 0xF8, 0x3E, 0x1F, 0x7C,
  0x7E, 0x07, 0xC7, 0xCF, 0x8F, 0xC0, 0xF8, 0xF9, 0xF1, 0xF0, 0x1F, 0x3F,
  0x3E, 0x7E, 0x03, 0xE7, 0xC7, 0xCF, 0xC0, 0x7C, 0xF8, 0xFB, 0xF0, 0x0F,
  0xBE, 0x1F, 0x7E, 0x01, 0xF7, 0xC3, 0xEF, 0x80, 0x3E, 0xF0, 0x7F, 0xF0,
  0x07, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x3F,
  0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x0F, 0xF0,
  0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00,
  0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x9F, 0x81, 0xFC, 0x7E, 0x07, 0xE1, 0xF8,
  0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0x3E, 0x3F, 0x80, 0xFC, 0xFC,
  0x03, 0xF7, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xF0,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xF0, 0xF8, 0x7C, 0x3E, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x1F,
  0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xF3, 0xC0, 0x0F,
  0x9E, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x1E, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0xC3, 0xE0, 0x3E, 0x3E, 0x00, 0xF1, 0xF0, 0x07, 0xDF, 0x00,
  0x3F, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0, 0xFE,
  0x3F, 0x1F, 0x87, 0xE1, 0xF0, 0x78, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0xF1,
  0xF0, 0x7F, 0xEF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0x9F, 0xE1,
  0xFC, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC7, 0xF0,
  0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0x87, 0xE0, 0x7E,
  0x3F, 0x81, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x87, 0xE1, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFE, 0xF8, 0x07, 0xF3,
  0xE0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x8F, 0x00, 0x7E, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0x1F, 0xC3, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC,
  0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E,
  0x07, 0xF1, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFC, 0x0F,
  0xC3, 0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07,
  0xDF, 0xF8, 0x1F, 0x7F, 0xC0, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xC3, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x18, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC,
  0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0xFC, 0x01,
  0xFC, 0xFC, 0x07, 0xFE, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F,
  0xC7, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E,
  0x03, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xF7, 0xC0, 0x3F, 0xE7, 0x80, 0x1F, 0xC7, 0x80, 0x00, 0x7E, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFE, 0x7F, 0x0F, 0xCF, 0xC1,
  0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xFF, 0xC3, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xCF, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x04, 0x7F, 0x07, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xE2, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFE, 0x7C, 0x0F, 0xFD, 0xF8, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFE, 0x7F, 0x83, 0xF8, 0x7F, 0x0F, 0xE0,
  0xFE, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0xFE, 0x07, 0xE1, 0xF8, 0x0F,
  0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8,
  0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x3F, 0x81, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFD, 0xF0, 0x07, 0xE7, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x0C, 0x03,
  0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x7E, 0xFF, 0x01, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0x1F, 0xC3, 0xF8, 0x3F,
  0x0F, 0xE0, 0xFC, 0x3F, 0x03, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x1F,
  0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03,
  0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x7E, 0x07, 0xE1,
  0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0xE0, 0x00,
  0x70, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x80, 0xF8, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x01,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x07, 0xE1, 0xFC, 0x07, 0xC3, 0xF8,
  0x0F, 0xC7, 0xF0, 0x0F, 0xCF, 0xE0, 0x0F, 0xCF, 0xC0, 0x0F, 0x9F, 0x80,
  0x1F, 0xBF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0x1F, 0x80,
  0x3F, 0x1F, 0x80, 0x3E, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xE0,
  0x7E, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x01, 0xF3, 0xFC, 0x3F, 0xC0,
  0x7D, 0xFF, 0x9F, 0xF8, 0x1F, 0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x83, 0xFC, 0x7F, 0xC7, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x07, 0xE1, 0xF8, 0x1F,
  0x81, 0xF8, 0x7E, 0x07, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x1F, 0x87, 0xE0,
  0x7C, 0x0F, 0xC3, 0xF0, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC0, 0xFC, 0x3F,
  0x03, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x0F, 0x83, 0xE0, 0x7E, 0x07, 0xE1,
  0xF8, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x1F,
  0x87, 0xE0, 0x7E, 0x0F, 0xC3, 0xF0, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x1F, 0x3F, 0xC0, 0x7D, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F,
  0xC7, 0xF0, 0xFE, 0x0F, 0xC3, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x7F, 0x03,
  0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE3,
  0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0,
  0x3F, 0x1F, 0x80, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E,
  0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF,
  0xE1, 0xFF, 0xFE, 0x7F, 0x1F, 0xCF, 0xC1, 0xFB, 0xF8, 0x3F, 0x7E, 0x07,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xDF, 0x83, 0xFB, 0xF0, 0xFE,
  0x7F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xF0, 0x01, 0xF3, 0xFC, 0x01, 0xF7, 0xFE, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F,
  0x07, 0xE0, 0x7F, 0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFE,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFC, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0x3F, 0xE0, 0x3F, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xF9, 0xF0,
  0x3F, 0xF7, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x1F, 0xE1, 0xF8,
  0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F,
  0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0x87, 0xE0, 0x7E, 0x3F,
  0x81, 0xF8, 0xFE, 0x07, 0xE3, 0xF8, 0x3F, 0x87, 0xE1, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFE, 0xF8, 0x07, 0xE7, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xC1, 0xF3, 0xF0, 0x7D, 0xFC, 0x1F,
  0x7F, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0x87, 0xE0, 0x61,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xCC, 0x07, 0xF3, 0xF7, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F,
  0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x07, 0xFF, 0xDF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFC, 0x3F, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F,
  0xF0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0x81, 0xF8,
  0xFC, 0x0F, 0xC7, 0xC0, 0x7E, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81,
  0xF8, 0xFC, 0x0F, 0xC7, 0xC0, 0x7E, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F,
  0x81, 0xF8, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F,
  0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0xC7, 0xE1, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x0F, 0xFE, 0xF8, 0x3F, 0xE7, 0xC0, 0xFE, 0x3C, 0x00, 0xFC, 0x03,
  0xFF, 0xE0, 0x3F, 0x9F, 0x01, 0xF8, 0xF8, 0x1F, 0xC7, 0xC0, 0xFC, 0x3E,
  0x07, 0xE1, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8,
  0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xEF, 0xC0, 0x1F, 0x7E, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xF8,
  0x1F, 0xC0, 0xFF, 0xE0, 0x7F, 0x03, 0xEF, 0x83, 0xFC, 0x1F, 0xBE, 0x0F,
  0xF0, 0x7E, 0xF8, 0x7F, 0xC3, 0xF3, 0xE1, 0xFF, 0x0F, 0xCF, 0x87, 0xBC,
  0x7E, 0x3E, 0x3E, 0xF1, 0xF8, 0xF8, 0xF7, 0xC7, 0xC3, 0xE7, 0xDF, 0x3F,
  0x0F, 0x9F, 0x7C, 0xF8, 0x3E, 0x79, 0xF7, 0xE0, 0xFB, 0xE7, 0xDF, 0x83,
  0xEF, 0x1F, 0x7C, 0x0F, 0xBC, 0x7F, 0xF0, 0x3F, 0xF1, 0xFF, 0x80, 0xFF,
  0x87, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC1,
  0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x7F, 0x81, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x80,
  0x7F, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xF1,
  0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x83, 0xF8,
  0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0xF8, 0x0F, 0xE0, 0x3E, 0x03, 0xF0,
  0x0F, 0x80, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F,
  0x3F, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0x7D, 0xF8, 0x00,
  0x1F, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0x80, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00,
  0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x17, 0xFC, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x80, 0x3F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 13, 32, 12, 0, -31 },
  { 53, 16, 11, 19, 4, -31 },
  { 75, 25, 31, 25, 1, -31 },
  { 172, 21, 36, 22, 1, -33 },
  { 267, 31, 31, 34, 2, -31 },
  { 388, 26, 31, 27, 1, -31 },
  { 489, 8, 11, 11, 4, -31 },
  { 500, 16, 38, 14, 1, -31 },
  { 576, 15, 38, 14, -3, -31 },
  { 648, 18, 20, 21, 4, -33 },
  { 693, 20, 21, 23, 2, -26 },
  { 746, 10, 11, 12, -2, -5 },
  { 760, 11, 5, 13, 1, -14 },
  { 767, 7, 8, 12, 0, -7 },
  { 774, 23, 31, 17, -2, -31 },
  { 864, 21, 31, 22, 1, -31 },
  { 946, 16, 31, 22, 4, -31 },
  { 1008, 23, 31, 22, -1, -31 },
  { 1098, 22, 31, 22, 0, -31 },
  { 1184, 23, 31, 22, -1, -31 },
  { 1274, 22, 31, 22, 0, -31 },
  { 1360, 21, 31, 22, 2, -31 },
  { 1442, 23, 31, 22, 1, -31 },
  { 1532, 21, 31, 22, 1, -31 },
  { 1614, 20, 31, 22, 1, -31 },
  { 1692, 11, 25, 12, 0, -24 },
  { 1727, 13, 30, 12, -2, -24 },
  { 1776, 20, 21, 23, 2, -26 },
  { 1829, 20, 13, 23, 2, -22 },
  { 1862, 20, 21, 23, 2, -26 },
  { 1915, 17, 32, 18, 2, -31 },
  { 1983, 31, 35, 34, 2, -31 },
  { 2119, 25, 31, 25, -3, -31 },
  { 2216, 23, 31, 24, 1, -31 },
  { 2306, 24, 31, 24, 2, -31 },
  { 2399, 25, 31, 27, 1, -31 },
  { 2496, 22, 31, 21, 1, -31 },
  { 2582, 22, 31, 21, 1, -31 },
  { 2668, 25, 31, 27, 2, -31 },
  { 2765, 27, 31, 27, 1, -31 },
  { 2870, 19, 31, 15, -1, -31 },
  { 2944, 21, 40, 13, -7, -31 },
  { 3049, 27, 31, 24, 1, -31 },
  { 3154, 16, 31, 20, 1, -31 },
  { 3216, 35, 31, 35, 1, -31 },
  { 3352, 29, 31, 30, 1, -31 },
  { 3465, 26, 31, 28, 2, -31 },
  { 3566, 24, 31, 24, 1, -31 },
  { 3659, 26, 38, 28, 2, -31 },
  { 3783, 23, 31, 24, 1, -31 },
  { 3873, 22, 31, 21, 0, -31 },
  { 3959, 21, 31, 21, 3, -31 },
  { 4041, 26, 31, 27, 2, -31 },
  { 4142, 23, 31, 23, 4, -31 },
  { 4232, 35, 31, 35, 4, -31 },
  { 4368, 30, 31, 24, -3, -31 },
  { 4485, 22, 31, 22, 4, -31 },
  { 4571, 24, 31, 21, -1, -31 },
  { 4664, 18, 38, 14, -1, -31 },
  { 4750, 9, 31, 17, 5, -31 },
  { 4785, 18, 38, 14, -3, -31 },
  { 4871, 21, 20, 22, 0, -31 },
  { 4924, 17, 3, 16, -4, 4 },
  { 4931, 9, 7, 14, 6, -33 },
  { 4939, 22, 24, 23, 1, -24 },
  { 5005, 22, 33, 23, 0, -33 },
  { 5096, 19, 24, 19, 1, -24 },
  { 5153, 24, 33, 23, 1, -33 },
  { 5252, 19, 24, 22, 2, -24 },
  { 5309, 24, 43, 15, -5, -33 },
  { 5438, 23, 34, 24, 0, -24 },
  { 5536, 22, 33, 24, 0, -33 },
  { 5627, 13, 33, 12, 0, -33 },
  { 5681, 18, 43, 12, -5, -33 },
  { 5778, 24, 33, 22, 0, -33 },
  { 5877, 13, 33, 12, 0, -33 },
  { 5931, 34, 24, 35, 0, -24 },
  { 6033, 22, 24, 24, 0, -24 },
  { 6099, 19, 24, 23, 2, -24 },
  { 6156, 24, 34, 23, -2, -24 },
  { 6258, 22, 34, 23, 1, -24 },
  { 6352, 18, 24, 17, 0, -24 },
  { 6406, 18, 24, 19, 0, -24 },
  { 6460, 15, 28, 16, 2, -28 },
  { 6513, 21, 23, 24, 2, -23 },
  { 6574, 21, 23, 20, 2, -23 },
  { 6635, 30, 23, 31, 3, -23 },
  { 6722, 25, 23, 21, -2, -23 },
  { 6794, 26, 33, 20, -3, -23 },
  { 6902, 20, 23, 18, -1, -23 },
  { 6960, 18, 38, 15, 0, -31 },
  { 7046, 5, 43, 21, 8, -33 },
  { 7073, 17, 38, 15, -2, -31 },
  { 7154, 20, 7, 23, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC43PT7B_H_
