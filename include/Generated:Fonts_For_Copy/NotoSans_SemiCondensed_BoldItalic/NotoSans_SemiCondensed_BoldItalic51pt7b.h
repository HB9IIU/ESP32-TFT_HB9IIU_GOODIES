#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC51PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x3F,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x00, 0x7E,
  0x00, 0x18, 0x00, 0x3F, 0x9F, 0xDF, 0xC7, 0xF7, 0xF1, 0xFD, 0xF8, 0x7E,
  0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF1, 0xF0, 0xFC, 0x7C, 0x3F, 0x3F,
  0x0F, 0xCF, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x00, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x11, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x1F, 0x80, 0x00, 0xF8, 0x7C,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x3E, 0x00,
  0x03, 0xF0, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x00, 0x7C,
  0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x1F,
  0x00, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFE, 0xE7, 0x81, 0xFC,
  0x60, 0x80, 0xFE, 0x70, 0x00, 0x7F, 0x38, 0x00, 0x3F, 0x9C, 0x00, 0x1F,
  0xEE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0E, 0xFF, 0x00, 0x0E, 0x7F,
  0x80, 0x07, 0x1F, 0xC8, 0x03, 0x9F, 0xC7, 0x01, 0xCF, 0xE3, 0xE0, 0xCF,
  0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x80, 0x7F, 0xC0, 0x01, 0xF0, 0x0F, 0xFE, 0x00,
  0x3F, 0x01, 0xFF, 0xF0, 0x07, 0xE0, 0x1F, 0xFF, 0x00, 0x7C, 0x03, 0xF3,
  0xF0, 0x0F, 0xC0, 0x3F, 0x1F, 0x01, 0xF8, 0x07, 0xE1, 0xF0, 0x1F, 0x00,
  0x7E, 0x1F, 0x03, 0xF0, 0x07, 0xC1, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x07,
  0xC0, 0x0F, 0xC3, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x1F, 0x80, 0x0F, 0xC3,
  0xE1, 0xF0, 0x00, 0xF8, 0x7E, 0x3F, 0x00, 0x0F, 0x87, 0xE7, 0xE3, 0xF8,
  0xF8, 0x7C, 0x7C, 0x7F, 0xEF, 0xCF, 0xCF, 0xCF, 0xFE, 0xFF, 0xF9, 0xF9,
  0xFF, 0xF7, 0xFF, 0x9F, 0x3F, 0xFF, 0x7F, 0xF3, 0xF3, 0xF3, 0xF3, 0xFE,
  0x7E, 0x7E, 0x1F, 0x0F, 0x87, 0xC7, 0xE1, 0xF0, 0x00, 0xFC, 0x7C, 0x3F,
  0x00, 0x1F, 0x8F, 0xC3, 0xF0, 0x01, 0xF0, 0xFC, 0x3F, 0x00, 0x3F, 0x0F,
  0xC3, 0xF0, 0x07, 0xE0, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x87, 0xE0, 0x0F,
  0xC0, 0xF8, 0x7E, 0x01, 0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0x00, 0xF8, 0xFC,
  0x03, 0xE0, 0x0F, 0xDF, 0xC0, 0x7E, 0x00, 0xFF, 0xF8, 0x07, 0xC0, 0x07,
  0xFF, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0,
  0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0xCF,
  0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x03,
  0xF8, 0x3F, 0xFE, 0x0F, 0xE0, 0xFF, 0xFC, 0x1F, 0xC3, 0xFF, 0xFC, 0x7F,
  0x0F, 0xF3, 0xF8, 0xFE, 0x3F, 0xC7, 0xFB, 0xF8, 0x7F, 0x07, 0xFF, 0xF1,
  0xFE, 0x0F, 0xFF, 0xC3, 0xF8, 0x0F, 0xFF, 0x87, 0xF0, 0x0F, 0xFE, 0x0F,
  0xE0, 0x1F, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3F, 0x9F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF8, 0xF8,
  0x7C, 0x7E, 0x3F, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x02, 0x03, 0xE0, 0x06, 0x07, 0xC0, 0x0F, 0x0F, 0x80, 0x3F, 0x9F,
  0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x1F, 0xDF, 0x00, 0xFF, 0x3F, 0x00, 0xFE, 0x3E, 0x00, 0xF8, 0x7E, 0x00,
  0xE0, 0xFE, 0x00, 0xC1, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x7F,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x03, 0xF0,
  0x7E, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xBF, 0xFE,
  0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x00, 0x1E, 0x1F, 0x9F, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFC, 0x10, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0xF3, 0xFC, 0x0F, 0xF0, 0xFE, 0x0F,
  0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0xC7, 0xF8, 0x0F, 0xE3, 0xF8, 0x07, 0xF1,
  0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE,
  0x7F, 0x80, 0x7F, 0x3F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x1F,
  0xE7, 0xF0, 0x0F, 0xF3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF9, 0xFE, 0x03,
  0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFF, 0x1F, 0xC0,
  0x7F, 0x8F, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x3F, 0xC0, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFF, 0x07,
  0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xE7, 0xE1, 0xF9, 0xFC, 0x1E,
  0x3F, 0x83, 0x07, 0xF0, 0x40, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x0F,
  0x81, 0xFE, 0x00, 0xE0, 0x1F, 0xE0, 0x10, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0x0F, 0xFC, 0x03, 0x00, 0xFF, 0x00, 0x80, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x20, 0x00, 0xFF, 0x0E, 0x00, 0x7F, 0xC3, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF,
  0x80, 0x03, 0xF7, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x0F,
  0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0x83, 0xF8,
  0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0,
  0x7F, 0x03, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC8, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x08, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x80, 0x03, 0xFC, 0x3C, 0x03, 0xFF, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFC, 0x04, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x1C, 0x00, 0xFE, 0x7F, 0x80, 0xFE, 0xFF,
  0xE0, 0x7F, 0x7F, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x1F, 0xFC,
  0x7F, 0x8F, 0xF8, 0x1F, 0xC7, 0xF8, 0x0F, 0xE3, 0xFC, 0x07, 0xF1, 0xFC,
  0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFF, 0x1F,
  0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x3F, 0xC3, 0xFC, 0x3F, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xE0, 0x3F, 0x87,
  0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x3F, 0xC7, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x01,
  0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0x8F, 0xE0,
  0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFF, 0x0F, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x0F, 0xF8, 0xFF, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F,
  0x3F, 0x80, 0xFF, 0x3F, 0x80, 0xFF, 0x3F, 0x81, 0xFF, 0x3F, 0xC3, 0xFF,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFE, 0xFE,
  0x0F, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00,
  0x01, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x81,
  0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xC0, 0xFC, 0x01, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x1E, 0x0F, 0xF1, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x0F, 0xE0, 0x3E,
  0x1F, 0x01, 0xFF, 0xF1, 0xF1, 0xF8, 0x3F, 0xFF, 0x0F, 0x8F, 0x83, 0xFF,
  0xF8, 0x7C, 0xF8, 0x3F, 0xCF, 0xC3, 0xE7, 0xC1, 0xF8, 0x7E, 0x1F, 0x7E,
  0x1F, 0x83, 0xE0, 0xFB, 0xE0, 0xF8, 0x1F, 0x07, 0xDF, 0x0F, 0xC0, 0xF8,
  0x3E, 0xF8, 0x7C, 0x0F, 0xC1, 0xFF, 0x83, 0xE0, 0x7C, 0x0F, 0xFC, 0x3F,
  0x03, 0xE0, 0xFB, 0xE1, 0xF0, 0x3F, 0x07, 0xDF, 0x0F, 0x81, 0xF8, 0x7E,
  0xF8, 0x7C, 0x0F, 0x83, 0xE7, 0xC3, 0xE0, 0xFC, 0x3F, 0x3E, 0x1F, 0x8F,
  0xE3, 0xF1, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0x83, 0xFF, 0x7F, 0xF8, 0x7C,
  0x1F, 0xFB, 0xFF, 0x83, 0xF0, 0x7F, 0x8F, 0xF0, 0x0F, 0x80, 0x60, 0x0C,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0x80, 0x01, 0xFF, 0x00, 0x7C, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7E, 0xFC,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF9, 0xF8, 0x00,
  0x1F, 0x8F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFE,
  0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F,
  0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0x07,
  0xE0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE7,
  0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xF8,
  0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE,
  0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x1F,
  0xC0, 0x3F, 0x83, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03,
  0xF8, 0x3F, 0x80, 0x7F, 0x83, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x07,
  0xF0, 0x1F, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0x9F,
  0x80, 0xFF, 0xC0, 0x18, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x80, 0x7F, 0xC0, 0x70,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xE0, 0x7F, 0xC0, 0x7F, 0x01, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x3F, 0xC0,
  0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F,
  0x83, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0,
  0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x3F,
  0xC7, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFC, 0x01, 0xFF, 0x0F,
  0xE0, 0x1F, 0xF0, 0x7F, 0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0xC7,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x04, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x3F, 0x80, 0xFF, 0xC0, 0x1C, 0x0F,
  0xF8, 0x00, 0x20, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0xE7, 0xF8, 0x1F, 0xFF, 0x3F,
  0xC0, 0xFF, 0xF9, 0xFE, 0x07, 0xFF, 0xCF, 0xE0, 0x3F, 0xFC, 0x7F, 0x03,
  0xFF, 0xE3, 0xF8, 0x1F, 0xFF, 0x1F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x3F,
  0xC7, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x0F,
  0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0x81, 0xFF, 0x01, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFC,
  0x07, 0xF8, 0x01, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xFC,
  0x07, 0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x07, 0xF0,
  0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0,
  0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x1F, 0xC0,
  0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0x80,
  0xFF, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFC, 0x03,
  0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x0F,
  0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0xE0, 0x03, 0xF8, 0x3F,
  0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF1, 0xFF,
  0x00, 0x07, 0xF1, 0xFE, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x07, 0xF7, 0xF8,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xE0,
  0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x1F, 0xBF, 0x01, 0xFB, 0xF0, 0x0F, 0xFF, 0x80, 0xFD, 0xF8, 0x0F, 0xDF,
  0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x03, 0xE7, 0xE0, 0x3F,
  0xBF, 0x03, 0xF7, 0xF0, 0x1F, 0xDF, 0x81, 0xFB, 0xF8, 0x0F, 0xCF, 0xC1,
  0xF9, 0xFC, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0xFC, 0xFE,
  0x03, 0xF9, 0xF8, 0x7E, 0x7F, 0x01, 0xFC, 0xFC, 0x7E, 0x3F, 0x80, 0xFC,
  0x7E, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x3F, 0x0F, 0xC0, 0x7F, 0x0F, 0x9F,
  0x8F, 0xE0, 0x3F, 0x87, 0xDF, 0x87, 0xF0, 0x1F, 0xC3, 0xEF, 0xC3, 0xF8,
  0x0F, 0xC1, 0xFF, 0xC1, 0xFC, 0x07, 0xE0, 0xFF, 0xE0, 0xFC, 0x07, 0xF0,
  0x7F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xF0,
  0x3F, 0x80, 0xFC, 0x0F, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xF8, 0x0F, 0xC0,
  0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0x01,
  0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x3F, 0xF8,
  0x01, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0xFF, 0xF0, 0x07, 0xE0, 0x1F,
  0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x80, 0xFD, 0xF8, 0x07, 0xF0,
  0x1F, 0xBF, 0x80, 0xFC, 0x03, 0xF7, 0xF0, 0x1F, 0x80, 0x7E, 0x7E, 0x07,
  0xF0, 0x0F, 0xCF, 0xC0, 0xFE, 0x03, 0xF9, 0xFC, 0x1F, 0xC0, 0x7F, 0x3F,
  0x83, 0xF0, 0x0F, 0xC3, 0xF0, 0xFE, 0x01, 0xF8, 0x7F, 0x1F, 0xC0, 0x7F,
  0x0F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFC, 0x7F, 0x01, 0xFC, 0x1F, 0x8F, 0xC0,
  0x3F, 0x03, 0xF9, 0xF8, 0x07, 0xE0, 0x7F, 0x7F, 0x01, 0xFC, 0x0F, 0xEF,
  0xE0, 0x3F, 0x80, 0xFD, 0xF8, 0x07, 0xF0, 0x1F, 0xFF, 0x00, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0x80, 0x3F, 0xFC, 0x07, 0xF0, 0x07, 0xFF, 0x80, 0xFE,
  0x00, 0xFF, 0xE0, 0x1F, 0xC0, 0x1F, 0xFC, 0x03, 0xF0, 0x01, 0xFF, 0x80,
  0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xC0, 0x07, 0xFE, 0x03, 0xF8, 0x00, 0xFF,
  0x80, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x03, 0xFF, 0x03, 0xFE,
  0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0x8F,
  0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFB, 0xFC, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x07,
  0xFB, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xFC,
  0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFE, 0x3F,
  0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x07, 0xFC,
  0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x07,
  0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07,
  0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0xFE, 0x03,
  0xFE, 0x0F, 0xE0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xF3,
  0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x0F,
  0xE1, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFD,
  0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0xBF, 0xC0,
  0x01, 0xFE, 0xFE, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0x7F, 0x3F, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x7F,
  0x8F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0xC3,
  0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xF1, 0xFF,
  0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0xFF,
  0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xF0, 0x7F, 0x01, 0xFE,
  0x0F, 0xE0, 0x3F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x07, 0xFC, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xF1, 0xFC, 0x01, 0xFE, 0x3F,
  0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x1F,
  0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F,
  0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xF8,
  0x03, 0xFC, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xF0, 0x1C, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x80, 0x03, 0xFC, 0x18, 0x01, 0xFE, 0x07, 0x80, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0xFE, 0x00, 0x7F,
  0x03, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0xC1,
  0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF,
  0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80,
  0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F,
  0xF0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xF8,
  0x3F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFC, 0x0F,
  0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFE,
  0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFB,
  0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00,
  0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x3F,
  0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x7F, 0x80, 0x7E,
  0x0F, 0xE0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xE0,
  0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xF3,
  0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFB, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xEF, 0xC0, 0x0F, 0xF0, 0x07, 0xF3, 0xF0,
  0x03, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x3F, 0x00, 0x7F,
  0xC0, 0x3F, 0x8F, 0xC0, 0x3F, 0xF0, 0x0F, 0xE3, 0xF0, 0x0F, 0xFC, 0x07,
  0xF0, 0xFC, 0x03, 0xFF, 0x01, 0xFC, 0x3F, 0x01, 0xFF, 0xC0, 0xFE, 0x0F,
  0xC0, 0x7F, 0xF0, 0x3F, 0x83, 0xF0, 0x3F, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F,
  0xFF, 0x07, 0xF0, 0x3F, 0x07, 0xEF, 0xC1, 0xFC, 0x0F, 0xC1, 0xFB, 0xF0,
  0xFE, 0x03, 0xF0, 0x7E, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x3F, 0x0F, 0xC0,
  0x3F, 0x0F, 0xCF, 0xC7, 0xF0, 0x0F, 0xC7, 0xE3, 0xF1, 0xFC, 0x03, 0xF1,
  0xF8, 0xFC, 0xFE, 0x00, 0xFC, 0xFC, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x0F,
  0xCF, 0xC0, 0x0F, 0xCF, 0xC3, 0xF7, 0xF0, 0x03, 0xF7, 0xE0, 0xFD, 0xFC,
  0x00, 0xFD, 0xF8, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x03, 0xEF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x03, 0xF9, 0xFE, 0x00,
  0x00, 0x7F, 0xBF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F,
  0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xEF, 0xE0, 0x0F, 0xF3, 0xFC, 0x03, 0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xC0,
  0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x0F,
  0xE3, 0xFC, 0x03, 0xF9, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xBF, 0xC0,
  0x07, 0xEF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBF,
  0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x0F, 0xC1,
  0xF8, 0x07, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x1F, 0x83, 0xF0,
  0x0F, 0xC3, 0xF0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x7E, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x0F,
  0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x00, 0xFE, 0x1F,
  0x80, 0xFF, 0xCF, 0xC0, 0xFF, 0xE7, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0,
  0xFF, 0x3F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0,
  0x0F, 0xE7, 0xF8, 0x07, 0xF3, 0xFC, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE,
  0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFF, 0x1F, 0xC0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x87, 0xF8, 0x7F, 0xC3, 0xFE, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFD, 0xF8, 0x0F, 0xFC, 0xFC, 0x03, 0xFC, 0x7E,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE3, 0xF0, 0x03, 0xFB, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0x7F, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F, 0xF0, 0x1F,
  0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x1F, 0xC0,
  0x3F, 0xC7, 0xF0, 0x0F, 0xF1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F,
  0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC,
  0x3F, 0xC1, 0xFE, 0x0F, 0xFC, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0x7E, 0xFF, 0xF0, 0x1F, 0x9F, 0xF8, 0x0F, 0xC3, 0xFC, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0x80, 0x87, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xC3,
  0xFF, 0x7E, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xE3,
  0xF8, 0x01, 0xFF, 0xBF, 0x80, 0x3F, 0xFB, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x0F, 0xE0,
  0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFF,
  0x07, 0xF8, 0x0F, 0xF9, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFB, 0xF0, 0x03, 0xFF, 0x3F, 0x00, 0x1F, 0xE3, 0xF0, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFE, 0x1F, 0xC7, 0xF0, 0x3F, 0x9F,
  0xE0, 0x7F, 0x3F, 0x80, 0xFE, 0xFF, 0x03, 0xFD, 0xFC, 0x0F, 0xF3, 0xF8,
  0x7F, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x80, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x04, 0x3F, 0xE0, 0x78, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xE0,
  0x0F, 0xFC, 0xFC, 0x03, 0xFF, 0x9F, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFE, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F,
  0xF0, 0x3F, 0xC3, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC1, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC,
  0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xFC,
  0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x87, 0xFC, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xBF, 0x80,
  0x3F, 0xF7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x80, 0x07, 0xF0, 0x1C,
  0x01, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE3, 0xF8, 0x03, 0xFB, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0x0F, 0xF0, 0x7F, 0x81,
  0xFC, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0xFE,
  0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1,
  0xFC, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F, 0xF0, 0x1F,
  0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xE0,
  0x3F, 0x87, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x01, 0xFE, 0x1F,
  0xC0, 0x7F, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x0F, 0xF0,
  0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x3F,
  0x8F, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F,
  0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0,
  0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F,
  0x80, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0x03, 0xF0, 0xFE, 0x03, 0xF8, 0x03, 0xF3, 0xFF, 0x0F, 0xFC, 0x03,
  0xF7, 0xFF, 0x9F, 0xFE, 0x03, 0xEF, 0xFF, 0xBF, 0xFE, 0x07, 0xEF, 0xFF,
  0xBF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0xFF,
  0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x1F,
  0xC0, 0x7F, 0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x01, 0xFC,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x03,
  0xF8, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0xFE,
  0x00, 0xFC, 0xFF, 0xC0, 0x3F, 0x7F, 0xF8, 0x0F, 0x9F, 0xFE, 0x07, 0xEF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0x7F, 0x07,
  0xF8, 0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0xFE,
  0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00,
  0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0xFE,
  0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE1,
  0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x87, 0xF0, 0x1F,
  0xC3, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xF8, 0x7F,
  0x9F, 0xE0, 0x7F, 0x3F, 0x80, 0xFE, 0xFF, 0x01, 0xFD, 0xFC, 0x03, 0xFB,
  0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0,
  0x1F, 0xEF, 0xE0, 0x3F, 0x9F, 0xE0, 0xFF, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xCF, 0xFC, 0x00,
  0xFD, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x3F, 0xC0, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF0,
  0x07, 0xF0, 0x3F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x0F, 0xFD, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFD, 0xFF, 0xC0, 0x1F,
  0xDF, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0x81, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x0F, 0x80, 0xFF, 0xCF, 0xC0, 0xFF, 0xF7, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0x81,
  0xFE, 0x3F, 0x80, 0xFF, 0x1F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F, 0x8F, 0xE0,
  0x1F, 0xC7, 0xF0, 0x0F, 0xE7, 0xF8, 0x07, 0xF3, 0xF8, 0x03, 0xF1, 0xFC,
  0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFF, 0x1F,
  0xC0, 0x7F, 0x0F, 0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFE, 0x7F, 0xE1,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFD, 0xFC,
  0x03, 0xF8, 0xFE, 0x00, 0x20, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0xFC, 0x0F, 0xCF, 0xE0, 0x3F,
  0x7F, 0x80, 0xFD, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x3F, 0xC3, 0xC1, 0xFE, 0x03, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE3, 0x00, 0x7F, 0x8F, 0x87,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x7F, 0xFF,
  0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFE, 0x0F, 0xE0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x98, 0x3F,
  0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x30,
  0x00, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F,
  0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0,
  0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F,
  0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0,
  0x1F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F,
  0xE0, 0x3F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0xC3, 0xFE,
  0x0F, 0xFB, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFD, 0xF0, 0x1F, 0xFE,
  0xFC, 0x03, 0xFF, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x02, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFC,
  0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0,
  0xFE, 0x0F, 0xF0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x1F, 0xC0,
  0x7E, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x7F, 0x00,
  0x7E, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xBF, 0x81, 0xFF,
  0x03, 0xF9, 0xFC, 0x0F, 0xF8, 0x1F, 0xCF, 0xE0, 0xFF, 0xC0, 0xFE, 0x7F,
  0x07, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0xF0, 0x7F, 0x1F, 0xC3, 0xEF, 0x87,
  0xF0, 0xFE, 0x1F, 0x7C, 0x3F, 0x87, 0xF1, 0xFB, 0xE1, 0xF8, 0x3F, 0x8F,
  0x9F, 0x1F, 0xC1, 0xFC, 0x7C, 0xF8, 0xFC, 0x0F, 0xE7, 0xEF, 0xCF, 0xE0,
  0x7F, 0x3E, 0x7E, 0x7F, 0x03, 0xFB, 0xF3, 0xF3, 0xF0, 0x1F, 0xDF, 0x1F,
  0xBF, 0x80, 0x7E, 0xF8, 0xFD, 0xF8, 0x03, 0xEF, 0xC7, 0xFF, 0xC0, 0x1F,
  0x7C, 0x3F, 0xFC, 0x00, 0xFB, 0xE1, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xF8,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x7F,
  0x00, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x7F, 0x1F, 0xE0,
  0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x03,
  0xFC, 0x07, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x01, 0xFC, 0x01, 0xFE, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x7F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x7E,
  0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0,
  0x7F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x01, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x80, 0x07, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 16, 37, 14, 0, -36 },
  { 75, 18, 13, 22, 5, -36 },
  { 105, 30, 36, 30, 1, -36 },
  { 240, 25, 42, 26, 1, -39 },
  { 372, 36, 37, 41, 3, -37 },
  { 539, 31, 38, 33, 1, -37 },
  { 687, 9, 13, 13, 5, -36 },
  { 702, 19, 44, 16, 1, -36 },
  { 807, 19, 45, 16, -4, -37 },
  { 914, 23, 23, 25, 4, -39 },
  { 981, 24, 24, 27, 2, -30 },
  { 1053, 12, 13, 14, -3, -6 },
  { 1073, 14, 7, 16, 1, -17 },
  { 1086, 9, 9, 14, 0, -8 },
  { 1097, 27, 37, 21, -2, -37 },
  { 1222, 25, 38, 26, 1, -37 },
  { 1341, 19, 36, 26, 5, -36 },
  { 1427, 27, 37, 26, -1, -37 },
  { 1552, 26, 38, 26, 0, -37 },
  { 1676, 27, 36, 26, -1, -36 },
  { 1798, 26, 37, 26, 0, -36 },
  { 1919, 25, 38, 26, 2, -37 },
  { 2038, 26, 36, 26, 2, -36 },
  { 2155, 25, 38, 26, 1, -37 },
  { 2274, 24, 38, 26, 1, -37 },
  { 2388, 13, 29, 14, 0, -28 },
  { 2436, 16, 35, 14, -3, -28 },
  { 2506, 24, 26, 27, 2, -31 },
  { 2584, 24, 16, 27, 2, -26 },
  { 2632, 24, 26, 27, 2, -31 },
  { 2710, 20, 38, 21, 3, -37 },
  { 2805, 37, 41, 40, 2, -37 },
  { 2995, 29, 36, 29, -3, -36 },
  { 3126, 28, 36, 29, 1, -36 },
  { 3252, 28, 38, 28, 3, -37 },
  { 3385, 29, 36, 31, 1, -36 },
  { 3516, 26, 36, 25, 1, -36 },
  { 3633, 26, 36, 24, 1, -36 },
  { 3750, 29, 38, 32, 3, -37 },
  { 3888, 32, 36, 33, 1, -36 },
  { 4032, 23, 36, 18, -2, -36 },
  { 4136, 24, 47, 15, -8, -36 },
  { 4277, 32, 36, 28, 1, -36 },
  { 4421, 20, 36, 24, 1, -36 },
  { 4511, 41, 36, 41, 1, -36 },
  { 4696, 35, 36, 35, 1, -36 },
  { 4854, 30, 38, 34, 3, -37 },
  { 4997, 28, 36, 28, 1, -36 },
  { 5123, 30, 46, 34, 3, -37 },
  { 5296, 27, 36, 29, 1, -36 },
  { 5418, 26, 38, 25, 0, -37 },
  { 5542, 24, 36, 25, 4, -36 },
  { 5650, 30, 37, 32, 3, -36 },
  { 5789, 27, 36, 28, 5, -36 },
  { 5911, 42, 36, 42, 5, -36 },
  { 6100, 35, 36, 28, -3, -36 },
  { 6258, 26, 36, 26, 5, -36 },
  { 6375, 29, 36, 25, -2, -36 },
  { 6506, 21, 44, 16, -1, -36 },
  { 6622, 12, 37, 21, 5, -37 },
  { 6678, 21, 44, 16, -4, -36 },
  { 6794, 25, 23, 26, 0, -37 },
  { 6866, 20, 3, 19, -5, 5 },
  { 6874, 11, 8, 16, 7, -39 },
  { 6885, 25, 29, 28, 2, -28 },
  { 6976, 26, 40, 28, 0, -39 },
  { 7106, 21, 29, 22, 2, -28 },
  { 7183, 28, 40, 28, 2, -39 },
  { 7323, 23, 29, 26, 2, -28 },
  { 7407, 29, 51, 17, -6, -39 },
  { 7592, 27, 40, 28, 0, -28 },
  { 7727, 26, 39, 28, 0, -39 },
  { 7854, 16, 39, 14, 0, -39 },
  { 7932, 22, 51, 14, -6, -39 },
  { 8073, 29, 39, 26, 0, -39 },
  { 8215, 16, 39, 14, 0, -39 },
  { 8293, 40, 28, 42, 0, -28 },
  { 8433, 26, 28, 28, 0, -28 },
  { 8524, 23, 29, 27, 2, -28 },
  { 8608, 28, 40, 28, -2, -28 },
  { 8748, 25, 40, 28, 2, -28 },
  { 8873, 22, 28, 20, 0, -28 },
  { 8950, 22, 29, 22, 0, -28 },
  { 9030, 18, 35, 19, 2, -34 },
  { 9109, 26, 29, 28, 2, -28 },
  { 9204, 24, 28, 24, 3, -28 },
  { 9288, 37, 28, 37, 3, -28 },
  { 9418, 30, 28, 25, -3, -28 },
  { 9523, 31, 40, 24, -4, -28 },
  { 9678, 23, 28, 22, -1, -28 },
  { 9759, 21, 44, 18, 0, -36 },
  { 9875, 6, 51, 25, 9, -39 },
  { 9914, 21, 44, 18, -3, -36 },
  { 10030, 24, 8, 27, 2, -22 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC51PT7B_H_
