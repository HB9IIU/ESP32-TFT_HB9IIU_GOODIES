#ifndef _IBMPLEXMONO_SEMIBOLDITALIC7PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x54, 0xC0, 0xB4, 0x35, 0xEF, 0xA0, 0x27, 0x66, 0x5E, 0x40, 0x5D,
  0x91, 0x6B, 0x00, 0x75, 0x6A, 0xF0, 0xC0, 0x72, 0x48, 0x80, 0x64, 0x95,
  0x80, 0x2F, 0x6A, 0x22, 0xD4, 0xE0, 0xC0, 0xC0, 0x12, 0x24, 0x48, 0x75,
  0xB9, 0x60, 0x26, 0x22, 0xF0, 0x79, 0x34, 0xF0, 0x71, 0x61, 0xE0, 0x35,
  0x6F, 0x20, 0x74, 0x71, 0xE0, 0x34, 0xF9, 0x60, 0xF5, 0x28, 0x75, 0x69,
  0xE0, 0x79, 0x72, 0x60, 0x53, 0x53, 0x80, 0x3A, 0x20, 0x7F, 0x43, 0x2C,
  0xE5, 0x48, 0x7B, 0xDD, 0xA6, 0x26, 0x5F, 0x90, 0x75, 0x69, 0xE0, 0x75,
  0x8A, 0x70, 0x75, 0x59, 0xE0, 0x74, 0x78, 0xF0, 0x74, 0x78, 0x80, 0x75,
  0xB9, 0x70, 0x55, 0x79, 0x90, 0x72, 0x24, 0xE0, 0x71, 0x12, 0xE0, 0x5B,
  0x19, 0x49, 0x00, 0x44, 0x44, 0xF0, 0x5D, 0xBD, 0x90, 0x55, 0xBB, 0xB0,
  0x75, 0x99, 0x60, 0x75, 0x78, 0x80, 0x75, 0x99, 0x63, 0x75, 0x7A, 0xB0,
  0x74, 0x61, 0xE0, 0xF4, 0x48, 0x80, 0x55, 0x99, 0x60, 0xBA, 0xAC, 0xC0,
  0x9D, 0xAD, 0xEB, 0x00, 0x5A, 0x88, 0xC9, 0x00, 0xBA, 0xC4, 0x80, 0x71,
  0x24, 0xF0, 0x72, 0x49, 0x80, 0xA9, 0x50, 0x64, 0x93, 0x80, 0x25, 0x90,
  0xE0, 0x90, 0x79, 0x9F, 0x46, 0x59, 0xE0, 0x27, 0x87, 0x17, 0x99, 0xE0,
  0x25, 0xE7, 0x3B, 0x88, 0x44, 0x60, 0x79, 0x96, 0xE0, 0x46, 0x59, 0xA0,
  0x26, 0xC5, 0x60, 0x36, 0x22, 0x2E, 0x47, 0x5A, 0xB0, 0xD2, 0x6E, 0xDB,
  0xDD, 0x65, 0x9A, 0x69, 0x96, 0x65, 0x9E, 0x80, 0x79, 0x9E, 0x20, 0xEA,
  0x40, 0x65, 0x2F, 0x27, 0xC6, 0x70, 0x55, 0x9E, 0xD5, 0x56, 0xBB, 0xDE,
  0x5B, 0x2F, 0x55, 0x96, 0xE0, 0x7A, 0x5F, 0x69, 0x69, 0x80, 0x56, 0xA0,
  0x62, 0x25, 0x4C, 0x5A,
};

const GFXglyph IBMPlexMono_SemiBoldItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 3, 2, 4, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 7, 4, 0, -6 },
  { 11, 5, 5, 4, 0, -5 },
  { 15, 4, 5, 4, 0, -5 },
  { 18, 1, 2, 4, 2, -5 },
  { 19, 3, 6, 4, 1, -5 },
  { 22, 3, 6, 4, 0, -5 },
  { 25, 4, 4, 4, 0, -4 },
  { 27, 4, 4, 4, 0, -4 },
  { 29, 2, 2, 4, 1, -1 },
  { 30, 2, 1, 4, 1, -3 },
  { 31, 2, 1, 4, 1, -1 },
  { 32, 4, 6, 4, 0, -5 },
  { 35, 4, 5, 4, 0, -5 },
  { 38, 4, 5, 4, 0, -5 },
  { 41, 4, 5, 4, 0, -5 },
  { 44, 4, 5, 4, 0, -5 },
  { 47, 4, 5, 4, 0, -5 },
  { 50, 4, 5, 4, 0, -5 },
  { 53, 4, 5, 4, 0, -5 },
  { 56, 3, 5, 4, 1, -5 },
  { 58, 4, 5, 4, 0, -5 },
  { 61, 4, 5, 4, 0, -5 },
  { 64, 2, 4, 4, 1, -4 },
  { 65, 2, 5, 4, 1, -4 },
  { 67, 3, 4, 4, 1, -4 },
  { 69, 4, 2, 4, 0, -3 },
  { 70, 4, 4, 4, 0, -4 },
  { 72, 3, 5, 4, 1, -5 },
  { 74, 4, 6, 4, 0, -5 },
  { 77, 4, 5, 4, 0, -5 },
  { 80, 4, 5, 4, 0, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 4, 5, 4, 0, -5 },
  { 89, 4, 5, 4, 0, -5 },
  { 92, 4, 5, 4, 0, -5 },
  { 95, 4, 5, 4, 0, -5 },
  { 98, 4, 5, 4, 0, -5 },
  { 101, 4, 5, 4, 0, -5 },
  { 104, 4, 5, 4, 0, -5 },
  { 107, 5, 5, 4, 0, -5 },
  { 111, 4, 5, 4, 0, -5 },
  { 114, 4, 5, 4, 0, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 4, 5, 4, 0, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 4, 6, 4, 0, -5 },
  { 129, 4, 5, 4, 0, -5 },
  { 132, 4, 5, 4, 0, -5 },
  { 135, 4, 5, 4, 1, -5 },
  { 138, 4, 5, 4, 0, -5 },
  { 141, 4, 5, 4, 1, -5 },
  { 144, 5, 5, 4, 0, -5 },
  { 148, 5, 5, 4, 0, -5 },
  { 152, 4, 5, 4, 1, -5 },
  { 155, 4, 5, 4, 0, -5 },
  { 158, 3, 6, 4, 1, -5 },
  { 161, 2, 6, 4, 1, -5 },
  { 163, 3, 6, 4, 0, -5 },
  { 166, 4, 3, 4, 0, -5 },
  { 168, 3, 1, 4, 0, 0 },
  { 169, 2, 2, 4, 1, -6 },
  { 170, 4, 4, 4, 0, -4 },
  { 172, 4, 5, 4, 0, -5 },
  { 175, 4, 4, 4, 0, -4 },
  { 177, 4, 5, 4, 0, -5 },
  { 180, 4, 4, 4, 0, -4 },
  { 182, 5, 6, 4, 0, -5 },
  { 186, 4, 5, 4, 0, -4 },
  { 189, 4, 5, 4, 0, -5 },
  { 192, 4, 5, 4, 0, -5 },
  { 195, 4, 6, 4, 0, -5 },
  { 198, 4, 5, 4, 0, -5 },
  { 201, 3, 5, 4, 1, -5 },
  { 203, 4, 4, 4, 0, -4 },
  { 205, 4, 4, 4, 0, -4 },
  { 207, 4, 4, 4, 0, -4 },
  { 209, 4, 5, 4, 0, -4 },
  { 212, 4, 5, 4, 0, -4 },
  { 215, 3, 4, 4, 1, -4 },
  { 217, 4, 4, 4, 0, -4 },
  { 219, 4, 5, 4, 0, -5 },
  { 222, 4, 4, 4, 0, -4 },
  { 224, 4, 4, 4, 0, -4 },
  { 226, 4, 4, 4, 0, -4 },
  { 228, 4, 4, 4, 0, -4 },
  { 230, 4, 5, 4, 0, -4 },
  { 233, 4, 4, 4, 0, -4 },
  { 235, 3, 6, 4, 1, -5 },
  { 238, 2, 6, 4, 1, -5 },
  { 240, 4, 6, 4, 0, -5 },
  { 243, 4, 2, 4, 0, -3 },
};

const GFXfont IBMPlexMono_SemiBoldItalic7pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic7pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC7PT7B_H_
