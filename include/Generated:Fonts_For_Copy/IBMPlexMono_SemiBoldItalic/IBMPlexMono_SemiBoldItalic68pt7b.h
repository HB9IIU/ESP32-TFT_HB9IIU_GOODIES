#ifndef _IBMPLEXMONO_SEMIBOLDITALIC68PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x7F,
  0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8,
  0x7F, 0x81, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F,
  0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xF8,
  0x0F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87,
  0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF9, 0xF3, 0xFF,
  0x00, 0xFF, 0xC3, 0xE1, 0xFC, 0x03, 0xFF, 0x0F, 0xC1, 0xF0, 0x07, 0xFC,
  0x1F, 0x81, 0xC0, 0x0F, 0xF0, 0x3F, 0x01, 0x00, 0x1F, 0xE0, 0x7E, 0x00,
  0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x00, 0xFF, 0x81, 0xF0, 0x00, 0x01, 0xFF,
  0x03, 0xE0, 0x00, 0x03, 0xFE, 0x0F, 0xC0, 0x00, 0x03, 0xFE, 0x1F, 0x80,
  0x00, 0x07, 0xFF, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE7, 0xFF, 0x00,
  0x00, 0x0F, 0xC3, 0xFE, 0x00, 0x00, 0x1F, 0x07, 0xFE, 0x00, 0x00, 0x3E,
  0x07, 0xFC, 0x00, 0x00, 0x7C, 0x0F, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0xF0,
  0x00, 0x03, 0xF0, 0x3F, 0xE0, 0x20, 0x07, 0xE0, 0x7F, 0x80, 0x60, 0x0F,
  0xC1, 0xFF, 0x01, 0xE0, 0x1F, 0x03, 0xFE, 0x0F, 0xE0, 0x3E, 0x0F, 0xF8,
  0x3F, 0xF0, 0xFC, 0x3F, 0xF0, 0xFF, 0xF9, 0xF9, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0x80, 0x1F, 0xC1, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0,
  0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0x80, 0xFE, 0x00,
  0x1F, 0x80, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC3, 0xF8, 0x00, 0x07,
  0xE0, 0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x00, 0x1F,
  0xC1, 0xFC, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xF1, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFC,
  0x7F, 0x87, 0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xE3,
  0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x87, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x0F,
  0xC0, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x81, 0xF8,
  0x03, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0x80,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x03, 0x0F,
  0xF8, 0x01, 0xFE, 0x03, 0xC7, 0xFC, 0x00, 0xFF, 0x81, 0xF9, 0xFE, 0x00,
  0x7F, 0xC1, 0xFE, 0xFF, 0x00, 0x6F, 0xF1, 0xFE, 0x7F, 0xC0, 0x77, 0xF8,
  0xFE, 0x3F, 0xF0, 0x7B, 0xFC, 0xFE, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0xFF, 0xFE,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xF0, 0xFE, 0x0F, 0xE1,
  0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0xC3,
  0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87,
  0xF8, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0x80, 0x1F, 0xE0, 0x0E, 0x3F, 0x01, 0xFE, 0x07,
  0xE3, 0xFE, 0x1F, 0xC3, 0xFE, 0x7F, 0xFD, 0xFD, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0x0F, 0xC1, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0x9F, 0xF8, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xF0,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x1F,
  0xF7, 0xFC, 0x0F, 0x80, 0xFF, 0xBF, 0xE0, 0xFE, 0x07, 0xFD, 0xFF, 0x0F,
  0xF8, 0x7F, 0xEF, 0xF8, 0x7F, 0xC3, 0xFE, 0xFF, 0xC3, 0xFE, 0x1F, 0xF7,
  0xFC, 0x1F, 0xE0, 0xFF, 0xBF, 0xE0, 0xFF, 0x07, 0xFD, 0xFF, 0x03, 0xF0,
  0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x3F,
  0xE7, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07,
  0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xBF,
  0xC0, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF1,
  0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFF,
  0x07, 0xF8, 0x01, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x1F,
  0xE0, 0x3F, 0xE0, 0x03, 0xF0, 0x0F, 0xF8, 0x00, 0x78, 0x03, 0xFE, 0x00,
  0x0C, 0x00, 0xFF, 0x00, 0x02, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x1F,
  0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x60, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0xF0, 0x07,
  0x80, 0x00, 0xFF, 0xC0, 0x0C, 0x00, 0x03, 0xFF, 0x00, 0x10, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x06, 0x00, 0x00, 0x7F, 0xE0, 0x38, 0x00, 0x01, 0xFF, 0x01,
  0xF0, 0x00, 0x0F, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03,
  0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F,
  0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x03, 0xFC, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x00, 0x7F, 0x07, 0xFF, 0x80, 0x01, 0xFC, 0x7F, 0xFF, 0x80, 0x07,
  0xF3, 0xFF, 0xFF, 0x00, 0x1F, 0xDF, 0xFF, 0xFE, 0x00, 0xFE, 0xFF, 0xFF,
  0xFC, 0x03, 0xFB, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xE0, 0x03, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x10, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x80,
  0x00, 0x1F, 0xF8, 0x0F, 0x00, 0x00, 0x7F, 0xC0, 0x7C, 0x00, 0x03, 0xFF,
  0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0xE0, 0x0F,
  0xFC, 0xFF, 0xFE, 0x01, 0xFF, 0x3F, 0xFF, 0xF0, 0x7F, 0xCF, 0xFF, 0xFE,
  0x0F, 0xFB, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFE, 0x03,
  0xFF, 0xCF, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE7, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0xC7, 0xF0,
  0x00, 0x0F, 0xF8, 0x7F, 0x00, 0x01, 0xFF, 0x8F, 0xF0, 0x00, 0x1F, 0xF0,
  0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x07,
  0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFF,
  0x83, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0xFF, 0xE0, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0x87, 0xFE,
  0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xE7,
  0xFC, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xEF, 0xF8,
  0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0xF3,
  0xFF, 0xC0, 0x7F, 0xFC, 0x7F, 0xFF, 0xFE, 0xFF, 0x87, 0xFF, 0xFF, 0xDF,
  0xF0, 0xFF, 0xFF, 0xF7, 0xFC, 0x0F, 0xFF, 0xFC, 0xFF, 0x80, 0xFF, 0xFF,
  0x3F, 0xE0, 0x07, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x1F, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFC, 0x0F, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xCF, 0x80, 0x01, 0xFF, 0x0E,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x7F,
  0x80, 0x3E, 0x0F, 0xC3, 0xF8, 0x07, 0xFC, 0x7E, 0x1F, 0xC0, 0x7F, 0xF3,
  0xF0, 0xFE, 0x07, 0xFF, 0xBF, 0x8F, 0xE0, 0x7F, 0xFF, 0xFC, 0x7F, 0x07,
  0xFC, 0x3F, 0xE3, 0xF8, 0x3F, 0x80, 0xFF, 0x1F, 0xC3, 0xFC, 0x07, 0xF9,
  0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0xFE, 0x01, 0xFC, 0x7F, 0x0F, 0xE0,
  0x0F, 0xE3, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0xFE,
  0x1F, 0xC0, 0x1F, 0xCF, 0xF0, 0xFE, 0x00, 0xFC, 0x7F, 0x07, 0xF0, 0x0F,
  0xE3, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0xFE, 0x1F,
  0xC0, 0x3F, 0xC7, 0xF0, 0xFE, 0x01, 0xFE, 0x3F, 0x87, 0xF8, 0x1F, 0xE1,
  0xFC, 0x1F, 0xC1, 0xFF, 0x0F, 0xE0, 0xFF, 0x1F, 0xF8, 0x7F, 0x07, 0xFF,
  0xDF, 0xC3, 0xF8, 0x3F, 0xFE, 0xFE, 0x1F, 0xC0, 0xFF, 0xE7, 0xF0, 0xFE,
  0x07, 0xFE, 0x3F, 0x07, 0xF0, 0x1F, 0xE3, 0xF8, 0x3F, 0x80, 0x3C, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0xFF, 0x00,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xE0, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xE0, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x07, 0xFC,
  0x3F, 0xC0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x03, 0xFF, 0x87, 0xF8,
  0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x8F,
  0xF8, 0x00, 0x07, 0xC0, 0x7F, 0xC0, 0x00, 0x20, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0E, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x01, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0x7F, 0xE0, 0xFF, 0x00, 0x01, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0xFE, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03,
  0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F,
  0x80, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFC,
  0x00, 0x7F, 0xF0, 0x0F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF0,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0xE0, 0x00,
  0x20, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0xFC, 0x7F, 0xC0, 0x3F, 0xFF, 0xE3,
  0xFE, 0x01, 0xFF, 0xFE, 0x1F, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0x80, 0x7F,
  0xFF, 0x87, 0xFC, 0x07, 0xFF, 0xFC, 0x7F, 0xE0, 0x3F, 0xFF, 0xE3, 0xFF,
  0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x3F,
  0x87, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x80,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x07,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xBF, 0xC0, 0x3F,
  0xFF, 0xF9, 0xFE, 0x00, 0xFF, 0xFF, 0xCF, 0xE0, 0x07, 0xFF, 0xFC, 0xFF,
  0x00, 0x0F, 0xFF, 0xC7, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0x00,
  0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xF8,
  0x03, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0xF0, 0x00, 0x07,
  0xFC, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x8F, 0xFC,
  0x00, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xBF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xDF, 0xF0, 0x00, 0x01, 0xFF, 0xF3, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x83, 0xF7, 0xF0, 0x07, 0xF3, 0xF0, 0xFE, 0xFE, 0x00, 0xFE, 0x7F, 0x3F,
  0x9F, 0xC0, 0x1F, 0xCF, 0xE7, 0xF3, 0xF8, 0x03, 0xF9, 0xFD, 0xFC, 0xFF,
  0x00, 0xFF, 0x3F, 0xBF, 0x9F, 0xE0, 0x1F, 0xE3, 0xFF, 0xE3, 0xF8, 0x03,
  0xFC, 0x7F, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xFF, 0x0F, 0xE0, 0x0F, 0xE1,
  0xFF, 0xC3, 0xFC, 0x03, 0xFC, 0x1F, 0xF8, 0x7F, 0x80, 0x7F, 0x83, 0xFE,
  0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC1, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x3F,
  0x80, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x1F, 0x81, 0xFE, 0x01,
  0xFE, 0x03, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7C, 0x07, 0xF8, 0x07, 0xF8,
  0x0F, 0x00, 0xFE, 0x00, 0xFF, 0x01, 0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x18,
  0x07, 0xF8, 0x03, 0xF8, 0x03, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x40, 0x1F,
  0xE0, 0x1F, 0xE0, 0x08, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x03,
  0xFF, 0xC0, 0x03, 0xFC, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xFF, 0x00,
  0x0F, 0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0x80,
  0x7F, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0xF8, 0x01, 0xFE, 0x03, 0xFF, 0xF0,
  0x03, 0xFC, 0x07, 0xFF, 0xE0, 0x07, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xE0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x7F,
  0x00, 0xFF, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0x03, 0xFD, 0xFE, 0x03, 0xFC,
  0x07, 0xFB, 0xFC, 0x07, 0xF0, 0x0F, 0xE3, 0xF8, 0x0F, 0xE0, 0x1F, 0xC7,
  0xF0, 0x3F, 0xC0, 0x7F, 0x8F, 0xE0, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0xFF,
  0x01, 0xFE, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x3F, 0x83, 0xF8, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x3F,
  0xC0, 0x7F, 0x83, 0xFC, 0x7F, 0x80, 0xFF, 0x03, 0xF8, 0xFF, 0x01, 0xFE,
  0x07, 0xF1, 0xFC, 0x03, 0xF8, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0x1F, 0xCF,
  0xF0, 0x1F, 0xE0, 0x3F, 0xDF, 0xE0, 0x3F, 0xC0, 0x3F, 0xBF, 0xC0, 0x7F,
  0x80, 0x7F, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFC, 0x01, 0xFF,
  0xFC, 0x03, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F,
  0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0x80, 0x1F,
  0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x07,
  0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xE0, 0x01,
  0xFF, 0xE0, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x03, 0xFE,
  0xFF, 0xC0, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0x0F, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x03, 0xFE, 0xFF,
  0xC0, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x07,
  0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x03, 0xFF, 0x7F, 0xC0,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F,
  0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0x1F,
  0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFC, 0x00, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x03,
  0xFE, 0xFF, 0xC0, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xE0,
  0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x03, 0xFE,
  0xFF, 0xC0, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00,
  0x07, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x03, 0xFF, 0x7F,
  0xC0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xE0,
  0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x08,
  0x00, 0x01, 0xFF, 0x00, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0x80, 0x00, 0x3F,
  0xE0, 0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xFE, 0x03, 0xFE, 0x00,
  0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x1F, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFC, 0x00,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x01, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0x0F,
  0xFC, 0x00, 0x03, 0x80, 0x1F, 0xF0, 0x00, 0x02, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x40, 0x00, 0x03, 0xFF, 0x01, 0xC0,
  0x00, 0x07, 0xFC, 0x07, 0xC0, 0x00, 0x0F, 0xF8, 0x1F, 0xC0, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x03,
  0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x01, 0xFE,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFE, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x07, 0xFC,
  0x1F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x03, 0xFC, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFE,
  0x7F, 0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xE1,
  0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0x1F, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x1F,
  0xC0, 0x7F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xF8, 0x1F, 0xC0, 0x7F, 0x03,
  0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xFC,
  0x1F, 0xC0, 0x7F, 0x83, 0xFF, 0x83, 0xF8, 0x0F, 0xF0, 0x7F, 0xF0, 0x7F,
  0x01, 0xFC, 0x1F, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xEF, 0xC3, 0xF8, 0x07,
  0xF0, 0x7D, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xBF, 0x0F, 0xE0, 0x1F, 0xC3,
  0xE7, 0xE1, 0xFC, 0x03, 0xF8, 0x7C, 0xFC, 0x7F, 0x00, 0xFF, 0x1F, 0x9F,
  0x8F, 0xE0, 0x1F, 0xE3, 0xE3, 0xF1, 0xFC, 0x03, 0xFC, 0x7C, 0x7E, 0x3F,
  0x80, 0x7F, 0x9F, 0x8F, 0xCF, 0xF0, 0x0F, 0xE3, 0xE1, 0xF9, 0xFC, 0x01,
  0xFC, 0xFC, 0x3F, 0x3F, 0x80, 0x3F, 0x9F, 0x87, 0xE7, 0xF0, 0x07, 0xF3,
  0xE0, 0xFC, 0xFE, 0x00, 0xFE, 0xFC, 0x1F, 0xBF, 0x80, 0x1F, 0xDF, 0x83,
  0xF7, 0xF0, 0x07, 0xFB, 0xE0, 0x7E, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xDF,
  0xC0, 0x1F, 0xFF, 0x81, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0xC0,
  0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x1F,
  0xEF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x3F,
  0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC1,
  0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01,
  0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x00,
  0x00, 0x0F, 0xF1, 0xF0, 0x00, 0x00, 0xFC, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0xF0, 0x3F, 0x8F, 0xF8,
  0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F,
  0x03, 0xF0, 0x3E, 0x01, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x07, 0xFC, 0x03, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0x1F, 0xF0, 0x3F,
  0xFF, 0xF3, 0xFC, 0x0F, 0xFF, 0xFE, 0x7F, 0x83, 0xFF, 0xFF, 0xEF, 0xF0,
  0x7F, 0xF0, 0x1F, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0xC3, 0xFE, 0x00, 0x1F,
  0xF8, 0xFF, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC7, 0xFE, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xE3,
  0xFE, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F,
  0xF1, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0xC3, 0xFE,
  0x00, 0x3F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFF, 0x0F, 0xFC, 0x03, 0xBF, 0xC0,
  0xFF, 0xC1, 0xF7, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F,
  0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xFE,
  0x07, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0xE0, 0x03,
  0xFC, 0x3F, 0xFF, 0x00, 0x3F, 0xC7, 0xFF, 0xF8, 0x07, 0xFC, 0xFF, 0xFF,
  0xC0, 0x7F, 0xCF, 0xFF, 0xFC, 0x07, 0xFD, 0xFF, 0xFF, 0xE0, 0x7F, 0xBE,
  0x0F, 0xFE, 0x07, 0xFB, 0x80, 0x3F, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x0F,
  0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x00,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x3F,
  0xE1, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF,
  0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xF9, 0xFF,
  0xFF, 0xE0, 0x7F, 0x9F, 0xFF, 0xFC, 0x07, 0xF8, 0xFF, 0xFF, 0x80, 0xFF,
  0x87, 0xFF, 0xF0, 0x0F, 0xF8, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x01,
  0xFF, 0x1F, 0xF8, 0x00, 0xFE, 0x1F, 0xF0, 0x00, 0x78, 0x3F, 0xE0, 0x00,
  0x40, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x20, 0xFF, 0x80, 0x00,
  0x70, 0xFF, 0x80, 0x00, 0x7C, 0xFF, 0x80, 0x00, 0xFE, 0x7F, 0xC0, 0x01,
  0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0x3F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xFE,
  0x1F, 0xE0, 0x07, 0xFF, 0xFC, 0x7F, 0x80, 0x3F, 0xFF, 0xF9, 0xFE, 0x01,
  0xFF, 0xFF, 0xEF, 0xF8, 0x0F, 0xFF, 0xFF, 0xBF, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x01, 0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xE0,
  0x01, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xF8,
  0x0F, 0xFC, 0x01, 0xDF, 0xE0, 0x1F, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xFF,
  0xFB, 0xFE, 0x01, 0xFF, 0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0xFF, 0x3F, 0xC0,
  0x07, 0xFF, 0xF8, 0xFF, 0x00, 0x1F, 0xFF, 0xC3, 0xFC, 0x00, 0x1F, 0xFC,
  0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x1F, 0xF3, 0xFC, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0x81,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x30, 0x7F, 0xC0, 0x00, 0x3C, 0x1F, 0xE0, 0x00, 0x3F, 0x8F,
  0xF8, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x7F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7C,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xFD, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x1F, 0xF0, 0x03,
  0xFF, 0xF8, 0x7F, 0xC0, 0x1F, 0xFF, 0xF1, 0xFE, 0x00, 0xFF, 0xFF, 0xE7,
  0xF8, 0x07, 0xFF, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F,
  0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF8,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x80,
  0x00, 0x7F, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFC, 0x01,
  0xDF, 0xE0, 0x1F, 0xFC, 0x1F, 0x7F, 0x80, 0x7F, 0xFF, 0xFB, 0xFE, 0x00,
  0xFF, 0xFF, 0xEF, 0xF8, 0x03, 0xFF, 0xFF, 0x3F, 0xE0, 0x07, 0xFF, 0xF8,
  0xFF, 0x80, 0x0F, 0xFF, 0xC3, 0xFC, 0x00, 0x1F, 0xFE, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0x00, 0x00, 0xFF, 0x80, 0x0E,
  0x00, 0x07, 0xFC, 0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x03, 0xFC, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xF0, 0x03, 0xFE, 0x1F,
  0xFF, 0x00, 0x7F, 0xC7, 0xFF, 0xF0, 0x0F, 0xF1, 0xFF, 0xFF, 0x03, 0xFE,
  0x7F, 0xFF, 0xE0, 0x7F, 0xCF, 0xFF, 0xFC, 0x0F, 0xFB, 0xC1, 0xFF, 0xC1,
  0xFF, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x3F,
  0xE1, 0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xF8,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F,
  0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x10, 0x00, 0x7F,
  0x80, 0x38, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x0F, 0xFC, 0x01, 0xFF,
  0x1F, 0xF8, 0x01, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01,
  0x00, 0x0F, 0xF0, 0x00, 0x30, 0x03, 0xFE, 0x00, 0x1F, 0x00, 0x7F, 0xC0,
  0x07, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x3F,
  0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x07, 0xFE,
  0x3F, 0xE0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x83, 0xFF, 0x80, 0x03, 0xFE,
  0x1F, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0xFE, 0x00, 0x3F, 0xC7, 0xFF, 0xFC,
  0x01, 0xFF, 0x3F, 0xFF, 0xF0, 0x07, 0xFD, 0xFF, 0xFF, 0xE0, 0x1F, 0xF7,
  0x83, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF8,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x03, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0x01,
  0xFF, 0x3F, 0xF8, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x1F, 0xE3, 0xFE,
  0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x0C, 0x0F,
  0xF8, 0x7F, 0xC0, 0x78, 0x3F, 0xE1, 0xFF, 0x03, 0xF0, 0xFF, 0x03, 0xFE,
  0x1F, 0xE3, 0xFC, 0x0F, 0xF8, 0xFF, 0xDF, 0xF0, 0x1F, 0xF7, 0xFC, 0x7F,
  0xC0, 0x7F, 0xFF, 0xE1, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFC, 0x03, 0xFF,
  0xF8, 0x1F, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0x80, 0x1F, 0xFE, 0x03, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x0C, 0x00, 0xFF, 0x00, 0x78,
  0x03, 0xFC, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC1,
  0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0x00, 0x7F,
  0x8F, 0xFC, 0x01, 0xFE, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x01, 0xF8, 0x07, 0xF9, 0xFF, 0x07, 0xFC, 0x07, 0xF1, 0xFF, 0x0F, 0xFE,
  0x07, 0xF3, 0xFF, 0x9F, 0xFE, 0x07, 0xF7, 0xFF, 0x9F, 0xFF, 0x07, 0xF7,
  0xFF, 0xBF, 0xFF, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0x0F, 0xFC, 0x7F, 0xF0,
  0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x80, 0xFE,
  0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x03, 0xF8,
  0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x07,
  0xF0, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0xFE,
  0x03, 0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xFC, 0x01, 0xFE,
  0x1F, 0xFF, 0xC0, 0x3F, 0xC7, 0xFF, 0xFC, 0x0F, 0xF9, 0xFF, 0xFF, 0x81,
  0xFF, 0x3F, 0xFF, 0xF0, 0x3F, 0xEF, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x7F,
  0xE0, 0xFF, 0xE0, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x87, 0xFF, 0x00,
  0x1F, 0xF0, 0xFF, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC3,
  0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x1F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0x00,
  0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xDF, 0xF8, 0x00, 0x0F, 0xF7, 0xFC,
  0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xDF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xE0, 0x00,
  0x7F, 0xE7, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xE0,
  0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0xFC, 0x00, 0x3F, 0xC7, 0xFF, 0xF8, 0x01, 0xFF, 0x3F, 0xFF,
  0xF0, 0x07, 0xFC, 0xFF, 0xFF, 0xC0, 0x1F, 0xF7, 0xFF, 0xFF, 0x80, 0x7F,
  0xBE, 0x0F, 0xFE, 0x01, 0xFE, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0x3F,
  0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x03, 0xFF,
  0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFE, 0x00,
  0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xF9, 0xFF, 0xFF, 0xE0, 0x1F, 0xE7, 0xFF,
  0xFF, 0x00, 0x7F, 0x8F, 0xFF, 0xF8, 0x03, 0xFE, 0x1F, 0xFF, 0xC0, 0x0F,
  0xF8, 0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0xFE, 0x1F,
  0xE0, 0x1F, 0xFF, 0xF1, 0xFE, 0x03, 0xFF, 0xFF, 0x9F, 0xE0, 0x7F, 0xFF,
  0xFB, 0xFE, 0x0F, 0xFF, 0xFF, 0xBF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F,
  0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x07, 0xF8, 0xFF,
  0xC0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0x80, 0x07, 0xFE,
  0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFE, 0x07,
  0xBF, 0xE0, 0x7F, 0xFF, 0xFB, 0xFE, 0x07, 0xFF, 0xFF, 0x3F, 0xE0, 0x3F,
  0xFF, 0xF3, 0xFE, 0x01, 0xFF, 0xFE, 0x3F, 0xC0, 0x1F, 0xFF, 0xC3, 0xFC,
  0x00, 0x7F, 0xF0, 0x7F, 0xC0, 0x01, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xBF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFC, 0x01, 0xFF, 0x7F, 0xFE, 0x00, 0xFF, 0xBF, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xDC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xF8, 0x07, 0xFC, 0x00, 0x3C, 0x03,
  0xFE, 0x00, 0x02, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0xC0, 0x00, 0x1F, 0xE0, 0x78, 0x00, 0x0F, 0xF8, 0x3F, 0x00, 0x03, 0xFE,
  0x1F, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x10, 0x01, 0xFF, 0x00, 0x3C, 0x00, 0xFF, 0x80, 0x3E, 0x00,
  0x7F, 0xC0, 0x3F, 0x80, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x7F, 0xF8,
  0x0F, 0xF0, 0x7F, 0xF0, 0x07, 0xF8, 0xFF, 0xE0, 0x03, 0xFC, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x0F, 0xF1, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xC7, 0xF8, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x1F, 0xF8, 0xFF,
  0x80, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0xC3,
  0xFF, 0x01, 0xDF, 0xF0, 0xFF, 0xE0, 0xF7, 0xFC, 0x3F, 0xFF, 0xF9, 0xFF,
  0x07, 0xFF, 0xFE, 0x7F, 0x81, 0xFF, 0xFF, 0x1F, 0xE0, 0x3F, 0xFF, 0x8F,
  0xF8, 0x07, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x1F, 0xFF, 0xC0, 0x07, 0xC7, 0xFF,
  0xF0, 0x0F, 0xF9, 0xFF, 0xFC, 0x03, 0xFE, 0x7F, 0xFE, 0x00, 0xFF, 0xBF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x1F,
  0xE0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xFE,
  0x03, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF,
  0xE0, 0x1F, 0xF0, 0xFF, 0xF0, 0x07, 0xFC, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x1F, 0xC0, 0x7F,
  0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0x3F, 0x83, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xF8,
  0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x7F,
  0x01, 0xFC, 0x07, 0xF1, 0xFC, 0x07, 0xF0, 0x1F, 0xC7, 0xF0, 0x1F, 0xC0,
  0x7F, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x07, 0xF1, 0xF8,
  0x07, 0xE0, 0x1F, 0xCF, 0xE0, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0xFE, 0x01,
  0xFC, 0xFE, 0x03, 0xF8, 0x07, 0xF3, 0xF8, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0,
  0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFC, 0x03, 0xF9, 0xFC, 0x07, 0xF0, 0x0F,
  0xE7, 0xF0, 0x1F, 0xC0, 0x3F, 0x9F, 0xC0, 0x7F, 0x01, 0xFC, 0x7F, 0x01,
  0xFC, 0x07, 0xF1, 0xFC, 0x07, 0xF0, 0x1F, 0xC7, 0xF0, 0x3F, 0xC0, 0xFE,
  0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x1F, 0xC3, 0xFC, 0x3B,
  0xF0, 0xFF, 0x07, 0xFF, 0xEF, 0xC7, 0xF8, 0x1F, 0xFF, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFC, 0xFF, 0xFE, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0x03, 0xFF, 0x07,
  0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x0F,
  0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFF, 0xE3,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF1, 0xFF, 0xF8, 0x1F, 0xFF, 0xF9, 0xFF, 0xFE,
  0x1F, 0xFD, 0xFC, 0xF0, 0xFF, 0x3F, 0xF8, 0xFE, 0x70, 0x7F, 0x8F, 0xF8,
  0x3F, 0x70, 0x1F, 0xC3, 0xF0, 0x1F, 0xB8, 0x0F, 0xE0, 0xF0, 0x0F, 0xFC,
  0x07, 0xF0, 0x60, 0x07, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x01, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7C, 0x03,
  0xFE, 0x00, 0x40, 0xFE, 0x01, 0xFF, 0x00, 0x70, 0x7F, 0x01, 0xFF, 0x80,
  0x7C, 0x3F, 0x80, 0xFF, 0xC0, 0x7E, 0x1F, 0xC0, 0xFF, 0xE0, 0xFF, 0x8F,
  0xF0, 0x77, 0xF0, 0xFF, 0xC7, 0xF8, 0x79, 0xFD, 0xFF, 0xC3, 0xFF, 0xFC,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0x7F, 0xFE, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x3F,
  0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFE,
  0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x3D, 0xFF, 0x00, 0xFF, 0xFF, 0xEF, 0xF8,
  0x07, 0xFF, 0xFE, 0x7F, 0x80, 0x3F, 0xFF, 0xE3, 0xFC, 0x00, 0xFF, 0xFE,
  0x3F, 0xE0, 0x03, 0xFF, 0xE1, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xF8, 0x00,
  0x1F, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x01, 0x80,
  0x01, 0xFF, 0x80, 0x1E, 0x00, 0x1F, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0xFF, 0x81, 0xFE, 0x07,
  0xFF, 0xFF, 0x0F, 0xF0, 0x3F, 0xFF, 0xFC, 0x7F, 0x83, 0xFF, 0xFF, 0xFB,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xE0,
  0x07, 0xFF, 0xF0, 0x7F, 0x00, 0x0F, 0xFF, 0x03, 0xF0, 0x00, 0x7F, 0xE0,
  0x1F, 0x80, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x10, 0x00, 0x1F,
  0xF8, 0x03, 0x80, 0x03, 0xFF, 0x80, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xF0,
  0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x00, 0xFE, 0x03, 0xFF, 0x00,
  0x03, 0xF0, 0x7F, 0xFC, 0x00, 0x1F, 0x87, 0xFF, 0xFF, 0x00, 0xFE, 0x3F,
  0xFF, 0xFF, 0xC7, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE7, 0xFF, 0xFF,
  0xF8, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xC0,
  0x1F, 0xFF, 0xC1, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xC0,
  0x03, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xFE, 0x00, 0x1F, 0x81, 0xFF, 0xFC,
  0x00, 0xFE, 0x07, 0xFF, 0xF0, 0x03, 0xF8, 0x3F, 0xFF, 0xE0, 0x0F, 0xC1,
  0xFF, 0xFF, 0xC0, 0x7F, 0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x3F, 0xC3, 0xFE,
  0x0F, 0xE0, 0xFE, 0x07, 0xFC, 0x7F, 0x87, 0xF0, 0x0F, 0xFF, 0xFC, 0x1F,
  0xC0, 0x3F, 0xFF, 0xF0, 0x7E, 0x00, 0x7F, 0xFF, 0x83, 0xF8, 0x00, 0xFF,
  0xFC, 0x0F, 0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x0C,
  0x00, 0x03, 0xF0, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 18, 48, 41, 12, -47 },
  { 109, 26, 21, 41, 11, -50 },
  { 178, 43, 47, 41, 0, -47 },
  { 431, 39, 63, 41, 1, -55 },
  { 739, 47, 49, 41, -2, -48 },
  { 1027, 41, 49, 41, 0, -48 },
  { 1279, 12, 21, 41, 18, -50 },
  { 1311, 28, 61, 41, 12, -52 },
  { 1525, 28, 61, 41, 2, -52 },
  { 1739, 36, 34, 41, 3, -37 },
  { 1892, 34, 33, 41, 4, -37 },
  { 2033, 18, 21, 41, 8, -11 },
  { 2081, 22, 8, 41, 10, -25 },
  { 2103, 13, 12, 41, 12, -11 },
  { 2123, 40, 61, 41, 1, -52 },
  { 2428, 37, 49, 41, 3, -48 },
  { 2655, 34, 47, 41, 3, -47 },
  { 2855, 38, 48, 41, 1, -48 },
  { 3083, 38, 49, 41, 1, -48 },
  { 3316, 38, 47, 41, 1, -47 },
  { 3540, 38, 48, 41, 2, -47 },
  { 3768, 35, 48, 41, 3, -47 },
  { 3978, 36, 47, 41, 6, -47 },
  { 4190, 38, 49, 41, 2, -48 },
  { 4423, 35, 48, 41, 5, -48 },
  { 4633, 17, 36, 41, 12, -35 },
  { 4710, 21, 45, 41, 8, -35 },
  { 4829, 33, 40, 41, 6, -41 },
  { 4994, 36, 22, 41, 3, -32 },
  { 5093, 33, 40, 41, 3, -41 },
  { 5258, 30, 49, 41, 8, -48 },
  { 5442, 37, 56, 41, 3, -48 },
  { 5701, 39, 47, 41, -2, -47 },
  { 5931, 36, 47, 41, 3, -47 },
  { 6143, 37, 49, 41, 4, -48 },
  { 6370, 38, 47, 41, 2, -47 },
  { 6594, 38, 47, 41, 3, -47 },
  { 6818, 39, 47, 41, 3, -47 },
  { 7048, 37, 49, 41, 3, -48 },
  { 7275, 39, 47, 41, 2, -47 },
  { 7505, 38, 47, 41, 2, -47 },
  { 7729, 36, 48, 41, 3, -47 },
  { 7945, 43, 47, 41, 2, -47 },
  { 8198, 31, 47, 41, 4, -47 },
  { 8381, 43, 47, 41, 0, -47 },
  { 8634, 39, 47, 41, 2, -47 },
  { 8864, 37, 49, 41, 3, -48 },
  { 9091, 37, 47, 41, 3, -47 },
  { 9309, 37, 62, 41, 3, -48 },
  { 9596, 37, 47, 41, 3, -47 },
  { 9814, 39, 49, 41, 1, -48 },
  { 10053, 39, 47, 41, 5, -47 },
  { 10283, 37, 48, 41, 4, -47 },
  { 10505, 38, 47, 41, 6, -47 },
  { 10729, 43, 47, 41, 1, -47 },
  { 10982, 46, 47, 41, -2, -47 },
  { 11253, 39, 47, 41, 6, -47 },
  { 11483, 42, 47, 41, 0, -47 },
  { 11730, 31, 61, 41, 9, -52 },
  { 11967, 19, 61, 41, 11, -52 },
  { 12112, 31, 61, 41, 2, -52 },
  { 12349, 36, 29, 41, 3, -47 },
  { 12480, 34, 7, 41, -1, 5 },
  { 12510, 12, 15, 41, 13, -54 },
  { 12533, 35, 37, 41, 3, -36 },
  { 12695, 36, 51, 41, 2, -50 },
  { 12925, 32, 37, 41, 4, -36 },
  { 13073, 38, 51, 41, 3, -50 },
  { 13316, 33, 37, 41, 4, -36 },
  { 13469, 46, 64, 41, -2, -50 },
  { 13837, 38, 50, 41, 1, -36 },
  { 14075, 35, 50, 41, 2, -50 },
  { 14294, 32, 51, 41, 5, -50 },
  { 14498, 35, 64, 41, 1, -50 },
  { 14778, 38, 51, 41, 2, -50 },
  { 15021, 30, 51, 41, 6, -50 },
  { 15213, 40, 36, 41, 0, -36 },
  { 15393, 35, 36, 41, 2, -36 },
  { 15551, 34, 37, 41, 3, -36 },
  { 15709, 38, 50, 41, 0, -36 },
  { 15947, 36, 50, 41, 3, -36 },
  { 16172, 33, 35, 41, 7, -35 },
  { 16317, 34, 37, 41, 3, -36 },
  { 16475, 33, 48, 41, 5, -47 },
  { 16673, 34, 36, 41, 4, -35 },
  { 16826, 34, 37, 41, 3, -36 },
  { 16984, 38, 37, 41, 1, -36 },
  { 17160, 41, 37, 41, 0, -36 },
  { 17350, 37, 49, 41, 1, -35 },
  { 17577, 37, 37, 41, 2, -36 },
  { 17749, 33, 61, 41, 7, -52 },
  { 18001, 18, 61, 41, 12, -52 },
  { 18139, 33, 61, 41, 2, -52 },
  { 18391, 38, 17, 41, 2, -29 },
};

const GFXfont IBMPlexMono_SemiBoldItalic68pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic68pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic68pt7bGlyphs,
  0x20, 0x7E, 88
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC68PT7B_H_
