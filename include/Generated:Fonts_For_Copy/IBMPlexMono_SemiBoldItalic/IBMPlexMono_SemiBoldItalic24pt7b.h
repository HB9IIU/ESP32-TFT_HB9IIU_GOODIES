#ifndef _IBMPLEXMONO_SEMIBOLDITALIC24PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0x70, 0xE3, 0xC7, 0x8E, 0x1C, 0x18, 0x20, 0x40, 0x00,
  0x0E, 0x3E, 0x78, 0x70, 0x73, 0xB9, 0xDC, 0xEC, 0x66, 0x77, 0x3B, 0x9C,
  0x01, 0x9C, 0x07, 0x30, 0x0E, 0x60, 0x19, 0xC0, 0x73, 0x07, 0xE7, 0xCF,
  0x9F, 0x87, 0x30, 0x0E, 0x60, 0x19, 0xC3, 0xF3, 0xE7, 0xE7, 0xC1, 0x9C,
  0x07, 0x30, 0x0C, 0x60, 0x19, 0xC0, 0x73, 0x00, 0x00, 0xE0, 0x03, 0x00,
  0x3F, 0x03, 0xFE, 0x1F, 0xFC, 0x73, 0x63, 0x99, 0x0E, 0x60, 0x3F, 0x80,
  0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x03, 0x78, 0x0C, 0xE2, 0x33, 0x9C, 0xDE,
  0xFF, 0xF0, 0xFF, 0x81, 0xFC, 0x01, 0x80, 0x06, 0x00, 0x07, 0x83, 0x8F,
  0xC1, 0x86, 0x71, 0x83, 0x19, 0xC3, 0x8D, 0xC1, 0x8E, 0xC0, 0xE6, 0xE0,
  0x3F, 0x00, 0x0F, 0x3C, 0x00, 0x3E, 0x01, 0xB1, 0x81, 0x98, 0xC1, 0xDC,
  0x60, 0xCC, 0x70, 0xC7, 0x30, 0xE1, 0xF8, 0xE0, 0x78, 0x00, 0x03, 0xE0,
  0x1F, 0xC0, 0xE3, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x01, 0x9C,
  0x3F, 0xC1, 0xCC, 0x06, 0x38, 0x38, 0xE0, 0xE1, 0xCB, 0x87, 0x3F, 0x2D,
  0x9F, 0xBE, 0x3C, 0x70, 0x7F, 0xFF, 0xF0, 0x03, 0xC1, 0xC0, 0xE0, 0x70,
  0x18, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x06, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x60, 0x1E, 0x00, 0x1E, 0x01,
  0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x18,
  0x06, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0xE0,
  0x00, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x8E, 0x2F, 0xFF, 0xFF, 0xFC, 0x7F,
  0x03, 0xF0, 0x1F, 0x81, 0xCE, 0x1C, 0x70, 0x41, 0x00, 0x07, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0xE1, 0xFF, 0xFF, 0xF8, 0x60, 0x0C, 0x03, 0x80, 0x70,
  0x0E, 0x00, 0x3C, 0xF7, 0x9C, 0x73, 0x8E, 0x30, 0x7F, 0x7F, 0xFF, 0x77,
  0xFE, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x07, 0xC0, 0xFF, 0x8F, 0xFC, 0x78, 0xF7, 0x83, 0xB8,
  0x1D, 0xC0, 0xFE, 0xE7, 0xE7, 0x3F, 0x3B, 0xF8, 0x1F, 0xC0, 0xEE, 0x0F,
  0x78, 0xF1, 0xFF, 0x8F, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0xFC, 0x0F, 0xC1,
  0xDC, 0x3D, 0xC7, 0x9C, 0x73, 0x82, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x3F,
  0xE1, 0xFF, 0x87, 0x0F, 0x38, 0x3C, 0x20, 0xF0, 0x03, 0x80, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xE0, 0x07, 0xFF, 0x9F,
  0xFC, 0xFF, 0xF0, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x87, 0x0F, 0x08, 0x3C,
  0x00, 0xE0, 0x07, 0x81, 0xFC, 0x07, 0xC0, 0x1F, 0xC0, 0x07, 0x00, 0x1E,
  0x20, 0x7B, 0xC3, 0xC7, 0xFF, 0x0F, 0xF8, 0x1F, 0x80, 0x00, 0x78, 0x03,
  0xE0, 0x1F, 0x80, 0x6E, 0x03, 0xF0, 0x1D, 0xC0, 0xE7, 0x03, 0x1C, 0x18,
  0x70, 0xE1, 0xC7, 0x0E, 0x1F, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0x1F, 0xF8, 0xFF, 0xCF, 0xFE, 0x70, 0x03, 0x80, 0x19,
  0xE1, 0xFF, 0x8F, 0xFE, 0x70, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE4, 0x0F,
  0x78, 0xF3, 0xFF, 0x8F, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3C, 0x0F, 0x01,
  0xE0, 0x1C, 0x03, 0xBC, 0x7F, 0xE7, 0xFF, 0x78, 0xFF, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7F, 0x0F, 0x7F, 0xE7, 0xFC, 0x1F, 0x00, 0x7F, 0xFB, 0xFF,
  0x9F, 0xFD, 0xC0, 0xEE, 0x0E, 0x70, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70,
  0x00, 0x07, 0xE0, 0xFF, 0x8F, 0xFE, 0x70, 0xF3, 0x83, 0x98, 0x1C, 0xE1,
  0xC3, 0xFC, 0x0F, 0xC3, 0xFF, 0x3C, 0x3D, 0xC0, 0xEE, 0x07, 0x70, 0x7B,
  0xFF, 0x8F, 0xF8, 0x3F, 0x80, 0x0F, 0x83, 0xFE, 0x7F, 0xEF, 0x0F, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xF1, 0xFF, 0xFE, 0x7E, 0xE3, 0xDC, 0x03,
  0x80, 0x78, 0x0F, 0x03, 0xC0, 0xF8, 0x00, 0x3C, 0xF3, 0xCE, 0x00, 0x00,
  0x00, 0x01, 0xCF, 0xBE, 0x70, 0x1E, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x78, 0xF3, 0xC7, 0x0E, 0x38, 0x70, 0xC0, 0x00, 0x10, 0x06, 0x01,
  0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x0E, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xC0, 0x08, 0x7F, 0xFB, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x20, 0x03, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0xF0, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0x80, 0xE0,
  0x08, 0x00, 0x1F, 0x0F, 0xF9, 0xFF, 0x70, 0xEE, 0x1E, 0x03, 0x80, 0x70,
  0x7C, 0x3F, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x1E, 0x03, 0xC0,
  0x70, 0x00, 0x07, 0xC0, 0x7F, 0x87, 0x0C, 0x70, 0x73, 0x01, 0xB9, 0xED,
  0x9F, 0xEC, 0xE7, 0xEE, 0x37, 0x71, 0xBB, 0x8D, 0xDC, 0xEC, 0xE7, 0x67,
  0xFB, 0x1D, 0x9C, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xEE, 0x03, 0xB8, 0x1C, 0xE0, 0x73, 0x83,
  0xCE, 0x0E, 0x38, 0x38, 0xE1, 0xFF, 0x87, 0xFE, 0x3F, 0xFC, 0xE0, 0xF7,
  0x81, 0xDC, 0x07, 0xF0, 0x1C, 0x1F, 0xE1, 0xFF, 0x8F, 0xFC, 0x70, 0xF3,
  0x83, 0x9C, 0x3C, 0xE1, 0xCF, 0xFC, 0x7F, 0x83, 0xFF, 0x1C, 0x1C, 0xE0,
  0xE7, 0x07, 0x70, 0x7B, 0xFF, 0x9F, 0xF8, 0xFF, 0x80, 0x03, 0xC0, 0x7F,
  0x87, 0xFE, 0x78, 0x73, 0x83, 0xBC, 0x11, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x3C, 0x01, 0xC0, 0xCF, 0x07, 0x38, 0x71, 0xFF, 0x87, 0xF8, 0x1F,
  0x00, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0x70, 0xF3, 0x83, 0x9C, 0x1C, 0xE0,
  0xEE, 0x07, 0x70, 0x7B, 0x83, 0xDC, 0x1C, 0xE0, 0xE7, 0x0F, 0x70, 0xF3,
  0xFF, 0x9F, 0xF8, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0xCF, 0xFE, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0F, 0xFE, 0x7F, 0xF3, 0xFF, 0x9C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0xFF, 0x9F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF,
  0xE3, 0xFF, 0x8E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1F, 0xFC, 0x7F,
  0xF1, 0xFF, 0x87, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x07, 0xC0, 0x7F, 0x87, 0xFC, 0x78, 0xF7, 0x83, 0xB8,
  0x11, 0xC0, 0x0E, 0x00, 0xF3, 0xF7, 0x9F, 0xB8, 0xFD, 0xC0, 0xEF, 0x07,
  0x78, 0x79, 0xFF, 0x8F, 0xDC, 0x1C, 0xE0, 0x38, 0x3C, 0xE0, 0xE3, 0x83,
  0x8E, 0x0E, 0x38, 0x39, 0xE0, 0xE7, 0x07, 0x9F, 0xFC, 0x7F, 0xF1, 0xFF,
  0xC7, 0x07, 0x1C, 0x1C, 0xE0, 0xF3, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0xE0,
  0xE0, 0x1F, 0xF9, 0xFF, 0xCF, 0xFE, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x03,
  0xFF, 0x9F, 0xFC, 0xFF, 0xE0, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x41,
  0xCE, 0x1E, 0x78, 0xE1, 0xFF, 0x0F, 0xF0, 0x3F, 0x00, 0x3C, 0x1E, 0x70,
  0x78, 0xE1, 0xE1, 0xC7, 0x83, 0x9E, 0x07, 0x78, 0x1E, 0xE0, 0x3B, 0x80,
  0x7F, 0x80, 0xFF, 0x01, 0xEF, 0x03, 0x8E, 0x0F, 0x1C, 0x1C, 0x3C, 0x38,
  0x38, 0x70, 0x78, 0xE0, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x1F, 0xFB, 0xFF, 0xFF, 0xE0, 0x1E, 0x1E, 0x3C, 0x3C, 0xF8, 0xF9, 0xF1,
  0xE3, 0xE6, 0xC7, 0xEF, 0x8E, 0xF7, 0x19, 0xEE, 0x33, 0x9C, 0xE7, 0x31,
  0xCC, 0x63, 0x89, 0xC7, 0x23, 0x8C, 0x07, 0x18, 0x0E, 0x70, 0x1C, 0xE0,
  0x30, 0x3C, 0x1C, 0xF8, 0x63, 0xE3, 0x8F, 0x8E, 0x3E, 0x39, 0xD8, 0xE7,
  0x63, 0x9D, 0xCC, 0x77, 0x71, 0xCD, 0xC6, 0x37, 0x18, 0xDC, 0xE3, 0xF3,
  0x8F, 0x8E, 0x3E, 0x38, 0x78, 0xC1, 0xE0, 0x07, 0xC0, 0xFF, 0x8F, 0xFC,
  0x78, 0xF7, 0x83, 0xB8, 0x1D, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8,
  0x1F, 0xC0, 0xEE, 0x0F, 0x78, 0xF1, 0xFF, 0x8F, 0xF8, 0x1F, 0x00, 0x1F,
  0xE1, 0xFF, 0x8F, 0xFE, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xEF, 0x0F,
  0x7F, 0xF3, 0xFF, 0x1F, 0xF0, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x00, 0x07, 0xC0, 0xFF, 0x8F, 0xFC, 0x78, 0xF7, 0x83, 0xB8,
  0x1D, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xEE, 0x0F,
  0x78, 0xF1, 0xFF, 0x8F, 0xF8, 0x1F, 0x00, 0x38, 0x81, 0xCC, 0x07, 0xF0,
  0x3E, 0x00, 0xE0, 0x1F, 0xE1, 0xFF, 0x8F, 0xFE, 0x70, 0x73, 0x83, 0x9C,
  0x1C, 0xE0, 0xEF, 0x0F, 0x7F, 0xF3, 0xFF, 0x1F, 0xF0, 0xE7, 0x07, 0x1C,
  0x78, 0xE3, 0x87, 0x1C, 0x1C, 0xE0, 0xE0, 0x03, 0xE0, 0x3F, 0xE1, 0xFF,
  0xC7, 0x07, 0x3C, 0x10, 0xF0, 0x01, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x0F,
  0xE0, 0x07, 0x80, 0x0E, 0x20, 0x39, 0xC1, 0xEF, 0xFF, 0x0F, 0xF8, 0x1F,
  0x80, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x81, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x3C, 0xE0, 0xE3, 0x83,
  0x8E, 0x0E, 0x38, 0x39, 0xC0, 0xE7, 0x07, 0x9C, 0x1C, 0x70, 0x71, 0xC1,
  0xC7, 0x07, 0x38, 0x1C, 0xE0, 0xE3, 0xC7, 0x87, 0xFE, 0x1F, 0xF0, 0x1F,
  0x00, 0xF0, 0x3F, 0xC0, 0xEF, 0x07, 0x9C, 0x1C, 0x70, 0x71, 0xC3, 0x87,
  0x0E, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x38, 0x1C, 0xE0, 0x37, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x38, 0x07, 0x38, 0x06, 0x38,
  0x06, 0x30, 0x0E, 0x31, 0xCE, 0x33, 0xCC, 0x33, 0xCC, 0x73, 0xDC, 0x76,
  0xDC, 0x76, 0xDC, 0x76, 0xD8, 0x7C, 0xD8, 0x7C, 0xF8, 0x6C, 0xF8, 0x78,
  0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0x1E, 0x07, 0x87, 0x07, 0x03, 0xC7, 0x80,
  0xE3, 0x80, 0x73, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x01, 0xEE, 0x00, 0xE7, 0x00, 0xE3, 0xC0, 0xF0,
  0xE0, 0xF0, 0x70, 0xF0, 0x3C, 0x00, 0xE0, 0x3F, 0xC0, 0xE7, 0x07, 0x1C,
  0x3C, 0x78, 0xE0, 0xE7, 0x03, 0x9C, 0x0E, 0xE0, 0x1F, 0x00, 0x7C, 0x01,
  0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x1F, 0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0xFF, 0xF0, 0x0F, 0xE3, 0xFC, 0x70,
  0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x7F, 0x8F,
  0xF0, 0xE1, 0xC1, 0x83, 0x06, 0x0E, 0x1C, 0x18, 0x30, 0x60, 0xE1, 0xC1,
  0x83, 0x06, 0x0E, 0x1C, 0x18, 0x30, 0x60, 0xE0, 0x1F, 0xE3, 0xF8, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x7F, 0x0F,
  0xE0, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1D, 0xC1, 0xCE, 0x0E, 0x30, 0xE1,
  0xCE, 0x0E, 0x70, 0x3F, 0x01, 0x80, 0xFF, 0xFF, 0xFE, 0xEE, 0x67, 0x20,
  0x1F, 0x73, 0xFF, 0x78, 0xF7, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xEE, 0x0E,
  0xE1, 0xEF, 0x3E, 0x7E, 0xF3, 0xCF, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x39, 0xE7, 0xFF, 0x74, 0x77, 0x87, 0x70, 0x77, 0x07,
  0x70, 0x7F, 0x07, 0xE0, 0xFF, 0x1E, 0xEF, 0xCE, 0xF8, 0x07, 0xC1, 0xFE,
  0x38, 0x77, 0x04, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x04, 0x70, 0x77, 0x0E,
  0x3F, 0xC1, 0xF0, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0xF7, 0x0F, 0xFC, 0x78, 0xF1, 0xC1, 0xCF, 0x07, 0x38, 0x1C,
  0xE0, 0xF3, 0x83, 0x8E, 0x0E, 0x3C, 0x78, 0x7E, 0xE0, 0xF3, 0x80, 0x07,
  0xC1, 0xFF, 0x38, 0x77, 0x07, 0x71, 0xF7, 0xFE, 0xFF, 0x0E, 0x00, 0x70,
  0x67, 0x0F, 0x3F, 0xC1, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x18, 0xE0, 0x1E, 0x70, 0x03,
  0xB8, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x07, 0x9C, 0x7F, 0xE3, 0xC7, 0x8E,
  0x0E, 0x78, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x1C, 0x70, 0x71, 0xE3, 0xC3,
  0xF7, 0x07, 0x9C, 0x00, 0xE0, 0x03, 0x86, 0x1E, 0x3F, 0xF0, 0x3F, 0x00,
  0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x39, 0xE3, 0xBF,
  0x7C, 0x77, 0x87, 0x70, 0x77, 0x07, 0x70, 0x77, 0x0E, 0xE0, 0xEE, 0x0E,
  0xE0, 0xEE, 0x0E, 0x07, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x00, 0x00, 0x3F,
  0x87, 0xF0, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC4, 0x39, 0xCF, 0x71,
  0xDC, 0x3F, 0x03, 0xC0, 0x00, 0x70, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC1, 0x1C, 0x3C, 0xE0, 0xE7,
  0x03, 0xB8, 0x0F, 0x80, 0x3C, 0x00, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE7, 0x87, 0xFE, 0x74, 0x73, 0xC3, 0x9C, 0x1C,
  0xE1, 0xC7, 0x78, 0x3F, 0x83, 0x9C, 0x5C, 0x77, 0xE3, 0xE7, 0x0E, 0x00,
  0x7F, 0x1F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x1C, 0x03, 0x88, 0x71, 0xCE, 0x71, 0xDC, 0x3F, 0x03,
  0x80, 0x33, 0x38, 0xDE, 0xF3, 0xBD, 0xDC, 0xE7, 0x73, 0x9D, 0xCE, 0x76,
  0x31, 0x98, 0xC6, 0xE7, 0x1B, 0x9C, 0xEE, 0x73, 0xB1, 0xCE, 0x39, 0xE3,
  0xBF, 0x7C, 0x77, 0x87, 0x70, 0x77, 0x07, 0x70, 0x77, 0x0E, 0xE0, 0xEE,
  0x0E, 0xE0, 0xEE, 0x0E, 0x0F, 0xC1, 0xFE, 0x38, 0xF7, 0x07, 0x70, 0x7F,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xE7, 0x1E, 0x7F, 0xC1, 0xF0, 0x1C, 0xF0,
  0xFF, 0xCE, 0x8E, 0x78, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x70,
  0x7B, 0xC7, 0x9D, 0xF8, 0xEF, 0x87, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x00, 0x0F, 0x39, 0xFF, 0x9E, 0x3C, 0xE0, 0xEF, 0x07, 0x70, 0x3B,
  0x83, 0xDC, 0x1C, 0xE0, 0xE7, 0x8F, 0x1F, 0xB8, 0x79, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x7E, 0x7F, 0xEF, 0x1D, 0xF1, 0xD0,
  0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x0F, 0xC3, 0xFF, 0x38, 0x63, 0x80, 0x38, 0x03, 0xF8, 0x1F, 0xE0, 0x1E,
  0x40, 0xE6, 0x0E, 0xFF, 0xC3, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xC1, 0xFF, 0xFF, 0xF8, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x84,
  0x73, 0xCE, 0xE1, 0xF8, 0x1C, 0x00, 0x38, 0x7B, 0xC3, 0x9C, 0x1C, 0xE0,
  0xE7, 0x07, 0x38, 0x39, 0xC3, 0x9E, 0x1C, 0xE1, 0xE3, 0x8F, 0x1F, 0xB8,
  0x7B, 0xC0, 0xFC, 0x2F, 0x8F, 0x38, 0x73, 0x87, 0x38, 0x73, 0x87, 0x38,
  0x77, 0x8E, 0x71, 0xE7, 0x3C, 0x7F, 0x83, 0xE0, 0x63, 0x33, 0x19, 0xD8,
  0xCF, 0xCE, 0x7E, 0x73, 0xF3, 0x9F, 0x18, 0xD8, 0xC6, 0xCE, 0x36, 0x73,
  0x3D, 0x91, 0xC7, 0x00, 0x0E, 0x3C, 0xFD, 0xF7, 0xB4, 0xC8, 0xE3, 0x03,
  0x90, 0x0E, 0x00, 0x38, 0x09, 0xE0, 0xE7, 0x9B, 0xBE, 0xFF, 0xBF, 0x1C,
  0x78, 0x1C, 0x3C, 0x70, 0xE3, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0xE0, 0xE3,
  0x87, 0x0E, 0x1C, 0x78, 0x70, 0xE3, 0xC3, 0xF7, 0x07, 0x9C, 0x00, 0xE0,
  0x03, 0x86, 0x1C, 0x3F, 0xF0, 0x3F, 0x00, 0x1F, 0x39, 0xFD, 0xDC, 0x7C,
  0xC3, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x8C, 0x78, 0x77, 0xF1, 0xBF,
  0xFD, 0x87, 0xC0, 0x03, 0xF0, 0x7F, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70,
  0x03, 0x00, 0x30, 0x07, 0x07, 0xE0, 0x7E, 0x08, 0x60, 0x07, 0x00, 0x60,
  0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0xF8, 0x1F, 0x80, 0x0E,
  0x18, 0x70, 0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xE1, 0xC3, 0x06, 0x1C,
  0x38, 0x70, 0xE1, 0x83, 0x0E, 0x00, 0x1F, 0x83, 0xF8, 0x07, 0x00, 0xE0,
  0x18, 0x06, 0x01, 0x80, 0x70, 0x0E, 0x00, 0xFC, 0x1F, 0x87, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x7F, 0x0F, 0xC0, 0x3C,
  0x1B, 0xF1, 0xF9, 0xCD, 0x87, 0xCC, 0x1C, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 7, 17, 14, 4, -17 },
  { 16, 9, 7, 14, 4, -18 },
  { 24, 15, 17, 14, 0, -17 },
  { 56, 14, 21, 14, 0, -19 },
  { 93, 17, 17, 14, -1, -17 },
  { 130, 14, 17, 14, 0, -17 },
  { 160, 3, 7, 14, 7, -18 },
  { 163, 10, 21, 14, 4, -18 },
  { 190, 10, 21, 14, 1, -18 },
  { 217, 13, 12, 14, 1, -13 },
  { 237, 11, 12, 14, 2, -13 },
  { 254, 6, 8, 14, 3, -4 },
  { 260, 8, 3, 14, 3, -9 },
  { 263, 5, 4, 14, 4, -4 },
  { 266, 14, 21, 14, 0, -18 },
  { 303, 13, 17, 14, 1, -17 },
  { 331, 12, 17, 14, 1, -17 },
  { 357, 14, 17, 14, 0, -17 },
  { 387, 14, 17, 14, 0, -17 },
  { 417, 14, 17, 14, 0, -17 },
  { 447, 13, 17, 14, 1, -17 },
  { 475, 12, 17, 14, 1, -17 },
  { 501, 13, 17, 14, 2, -17 },
  { 529, 13, 17, 14, 1, -17 },
  { 557, 12, 17, 14, 2, -17 },
  { 583, 6, 13, 14, 4, -13 },
  { 593, 7, 17, 14, 3, -13 },
  { 608, 12, 14, 14, 2, -14 },
  { 629, 13, 7, 14, 1, -11 },
  { 641, 12, 14, 14, 1, -14 },
  { 662, 11, 17, 14, 3, -17 },
  { 686, 13, 20, 14, 1, -17 },
  { 719, 14, 17, 14, -1, -17 },
  { 749, 13, 17, 14, 1, -17 },
  { 777, 13, 17, 14, 1, -17 },
  { 805, 13, 17, 14, 1, -17 },
  { 833, 13, 17, 14, 1, -17 },
  { 861, 14, 17, 14, 1, -17 },
  { 891, 13, 17, 14, 1, -17 },
  { 919, 14, 17, 14, 1, -17 },
  { 949, 13, 17, 14, 1, -17 },
  { 977, 13, 17, 14, 1, -17 },
  { 1005, 15, 17, 14, 1, -17 },
  { 1037, 11, 17, 14, 1, -17 },
  { 1061, 15, 17, 14, 0, -17 },
  { 1093, 14, 17, 14, 1, -17 },
  { 1123, 13, 17, 14, 1, -17 },
  { 1151, 13, 17, 14, 1, -17 },
  { 1179, 13, 22, 14, 1, -17 },
  { 1215, 13, 17, 14, 1, -17 },
  { 1243, 14, 17, 14, 0, -17 },
  { 1273, 14, 17, 14, 2, -17 },
  { 1303, 14, 17, 14, 1, -17 },
  { 1333, 14, 17, 14, 2, -17 },
  { 1363, 16, 17, 14, 0, -17 },
  { 1397, 17, 17, 14, -1, -17 },
  { 1434, 14, 17, 14, 2, -17 },
  { 1464, 15, 17, 14, 0, -17 },
  { 1496, 11, 21, 14, 3, -18 },
  { 1525, 7, 21, 14, 4, -18 },
  { 1544, 11, 21, 14, 1, -18 },
  { 1573, 13, 10, 14, 1, -17 },
  { 1590, 12, 2, 14, 0, 2 },
  { 1593, 4, 5, 14, 5, -19 },
  { 1596, 12, 12, 14, 1, -12 },
  { 1614, 12, 18, 14, 1, -18 },
  { 1641, 12, 12, 14, 1, -12 },
  { 1659, 14, 18, 14, 1, -18 },
  { 1691, 12, 12, 14, 1, -12 },
  { 1709, 17, 23, 14, -1, -18 },
  { 1758, 14, 17, 14, 0, -12 },
  { 1788, 12, 18, 14, 1, -18 },
  { 1815, 11, 18, 14, 2, -18 },
  { 1840, 13, 23, 14, 0, -18 },
  { 1878, 13, 18, 14, 1, -18 },
  { 1908, 11, 18, 14, 2, -18 },
  { 1933, 14, 12, 14, 0, -12 },
  { 1954, 12, 12, 14, 1, -12 },
  { 1972, 12, 12, 14, 1, -12 },
  { 1990, 13, 17, 14, 0, -12 },
  { 2018, 13, 17, 14, 1, -12 },
  { 2046, 12, 12, 14, 2, -12 },
  { 2064, 12, 12, 14, 1, -12 },
  { 2082, 11, 17, 14, 2, -17 },
  { 2106, 13, 12, 14, 1, -12 },
  { 2126, 12, 12, 14, 1, -12 },
  { 2144, 13, 12, 14, 1, -12 },
  { 2164, 14, 12, 14, 0, -12 },
  { 2185, 14, 17, 14, 0, -12 },
  { 2215, 13, 12, 14, 1, -12 },
  { 2235, 12, 21, 14, 2, -18 },
  { 2267, 7, 21, 14, 4, -18 },
  { 2286, 11, 21, 14, 1, -18 },
  { 2315, 13, 5, 14, 1, -10 },
};

const GFXfont IBMPlexMono_SemiBoldItalic24pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic24pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic24pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC24PT7B_H_
