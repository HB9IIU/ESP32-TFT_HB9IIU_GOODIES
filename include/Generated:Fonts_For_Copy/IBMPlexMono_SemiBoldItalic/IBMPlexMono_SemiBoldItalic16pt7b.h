#ifndef _IBMPLEXMONO_SEMIBOLDITALIC16PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x76, 0x66, 0x40, 0xEE, 0xC0, 0xCF, 0x2D, 0xB6, 0xD8, 0x0C,
  0x83, 0x60, 0x91, 0xEF, 0x7B, 0xC4, 0x8F, 0x7B, 0xDE, 0x24, 0x1B, 0x06,
  0xC0, 0x02, 0x03, 0x07, 0xC7, 0xF3, 0x4B, 0xA0, 0xF0, 0x7E, 0x0F, 0x84,
  0xDA, 0xFF, 0xE3, 0xE0, 0xC0, 0x60, 0x1C, 0x33, 0xE4, 0x36, 0xC2, 0x78,
  0x3C, 0x01, 0xDC, 0x03, 0xC1, 0xE4, 0x36, 0x42, 0x7C, 0xC3, 0x80, 0x0F,
  0x07, 0xC1, 0x98, 0x66, 0x1B, 0x1F, 0x8C, 0xC3, 0x34, 0xCE, 0xBF, 0xF7,
  0x30, 0x6D, 0xAC, 0x0C, 0x63, 0x18, 0x43, 0x0C, 0x30, 0xC3, 0x0C, 0x10,
  0x60, 0xC0, 0x18, 0x18, 0x10, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x30,
  0xC3, 0x1C, 0x00, 0x08, 0x18, 0xD9, 0xFF, 0x3C, 0x3C, 0x6C, 0xC6, 0x08,
  0x18, 0x18, 0xFF, 0xFF, 0x18, 0x10, 0x30, 0x76, 0x6C, 0xC0, 0x7F, 0xE0,
  0xFF, 0x00, 0x01, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x20,
  0x18, 0x04, 0x03, 0x01, 0x80, 0x60, 0x30, 0x00, 0x1E, 0x7F, 0x63, 0xC3,
  0xC3, 0xDB, 0xDB, 0xC3, 0xC6, 0xFE, 0x78, 0x1E, 0x3C, 0x3C, 0x6C, 0xEC,
  0x4C, 0x8C, 0x18, 0x18, 0xFF, 0xFE, 0x0F, 0x1F, 0xCC, 0x6C, 0x30, 0x38,
  0x38, 0x38, 0x38, 0x70, 0x3F, 0xBF, 0xC0, 0x0F, 0x1F, 0xCC, 0x60, 0x30,
  0xF0, 0xF8, 0x0C, 0x06, 0xC3, 0x3F, 0x8F, 0x00, 0x03, 0x83, 0xC3, 0xC3,
  0x61, 0x31, 0x19, 0x8D, 0xFF, 0xFF, 0x83, 0x01, 0x80, 0x1F, 0x9F, 0xCC,
  0x05, 0xE3, 0xF3, 0x1C, 0x06, 0x07, 0x63, 0x7F, 0x8F, 0x00, 0x0F, 0x18,
  0x30, 0x6E, 0xDF, 0xE7, 0xC3, 0xC3, 0xC6, 0xFE, 0x7C, 0x7F, 0xBF, 0xD0,
  0xD8, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x38, 0x18, 0x18, 0x00, 0x1F, 0x1F,
  0xCC, 0x66, 0x31, 0xF1, 0xF9, 0x8E, 0xC3, 0xE3, 0xBF, 0x8F, 0x80, 0x1E,
  0x7F, 0x63, 0xC3, 0xC3, 0xE3, 0xFF, 0x7E, 0x0C, 0x18, 0xF0, 0x77, 0x60,
  0x00, 0xEE, 0xC0, 0x39, 0xCC, 0x00, 0x01, 0xCC, 0x66, 0x30, 0x01, 0x07,
  0x1E, 0x70, 0xC0, 0xF0, 0x3C, 0x0E, 0x02, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x40, 0x70, 0x3C, 0x0E, 0x03, 0x1E, 0x78, 0xE0, 0x80, 0x3C, 0xFF,
  0x1C, 0x30, 0xC7, 0x18, 0x00, 0x60, 0xC3, 0x80, 0x1E, 0x3F, 0x61, 0xCD,
  0xDF, 0xDB, 0xF3, 0xB3, 0xBE, 0x9A, 0xC0, 0xFC, 0x7C, 0x0E, 0x07, 0x86,
  0xC3, 0x61, 0xB1, 0x98, 0xCC, 0xFE, 0x7F, 0x71, 0xF0, 0x60, 0x7E, 0x7F,
  0x63, 0x63, 0x7E, 0x7E, 0xC7, 0xC3, 0xC6, 0xFE, 0xFC, 0x1E, 0x1F, 0x98,
  0xCC, 0x3C, 0x06, 0x03, 0x01, 0x86, 0xC6, 0x7F, 0x1F, 0x00, 0x7E, 0x7F,
  0x63, 0x63, 0x63, 0xE3, 0xC3, 0xC3, 0xC6, 0xFE, 0xF8, 0x7F, 0xBF, 0x98,
  0x0C, 0x07, 0xF3, 0xF3, 0x01, 0x80, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0xBF,
  0xD8, 0x0C, 0x07, 0xF3, 0xF3, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x00, 0x1E,
  0x3F, 0x63, 0xE3, 0xC0, 0xCF, 0xCF, 0xC3, 0xC6, 0xFE, 0x76, 0x30, 0xCC,
  0x63, 0x18, 0xC6, 0x3F, 0x9F, 0xE6, 0x19, 0x8C, 0x63, 0x18, 0xCE, 0x30,
  0x7F, 0xBF, 0x83, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x7F, 0x3F,
  0x80, 0x3F, 0x3F, 0x03, 0x03, 0x06, 0x06, 0x06, 0x46, 0xCE, 0xFC, 0x78,
  0x61, 0xD8, 0xC6, 0x61, 0xB0, 0x7C, 0x3F, 0x0E, 0xC3, 0x30, 0xC6, 0x31,
  0x8C, 0x70, 0x30, 0x61, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xC1, 0xFF, 0xF8,
  0x31, 0xCE, 0x73, 0xBD, 0xBA, 0x6F, 0x9B, 0x66, 0x99, 0x26, 0x41, 0xB0,
  0x4C, 0x30, 0x38, 0xCE, 0x23, 0x98, 0xB6, 0x2D, 0x9B, 0x66, 0xD9, 0x94,
  0x67, 0x11, 0xCC, 0x70, 0x1E, 0x7F, 0x63, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC6, 0xFE, 0x78, 0x7E, 0x7F, 0x63, 0x63, 0x63, 0x7F, 0xFE, 0xC0, 0xC0,
  0xC0, 0xC0, 0x1E, 0x7F, 0x63, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xFE,
  0x7C, 0x1B, 0x0F, 0x0E, 0x7E, 0x7F, 0x63, 0x63, 0x63, 0x7F, 0xFC, 0xCC,
  0xCC, 0xC6, 0xC6, 0x1F, 0x1F, 0xCC, 0x66, 0x03, 0xC1, 0xF8, 0x1E, 0x03,
  0x63, 0x7F, 0x8F, 0x80, 0xFF, 0xFF, 0xC3, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x18, 0x0C, 0x00, 0x61, 0xB1, 0xD8, 0xCC, 0x6C, 0x36, 0x1B,
  0x0D, 0x8C, 0xC6, 0x7F, 0x1F, 0x00, 0xE1, 0xB0, 0xD8, 0xCC, 0x66, 0x63,
  0x31, 0x98, 0xD8, 0x6C, 0x3C, 0x0E, 0x00, 0x60, 0x58, 0x36, 0x0D, 0xBB,
  0x6E, 0x9B, 0xE7, 0xF9, 0x5E, 0x57, 0x3D, 0xCE, 0x70, 0x30, 0xCC, 0x61,
  0xB8, 0x6C, 0x1E, 0x03, 0x01, 0xE0, 0xD8, 0x77, 0x18, 0xCC, 0x38, 0xE1,
  0xD8, 0xE6, 0x30, 0xD8, 0x3E, 0x0F, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03,
  0x00, 0x3F, 0xCF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x3F, 0xCF, 0xF0, 0x3E, 0x7C, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x60, 0x81,
  0x02, 0x0F, 0x9F, 0x00, 0x8C, 0xCC, 0x44, 0x66, 0x62, 0x23, 0x33, 0x1F,
  0x1E, 0x02, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x7C,
  0xF8, 0x1C, 0x1E, 0x36, 0x66, 0x63, 0xC3, 0x83, 0xFF, 0xFF, 0x59, 0xB0,
  0x3B, 0x7B, 0xE6, 0xC6, 0xC6, 0xCE, 0xF7, 0x77, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x71, 0xFD, 0xC6, 0xC3, 0x61, 0xB1, 0x9F, 0xDD, 0xC0, 0x3C, 0x7E,
  0xE3, 0xC0, 0xC2, 0xC6, 0xFC, 0x78, 0x01, 0x81, 0x80, 0xC0, 0x63, 0xB3,
  0xFB, 0x8D, 0x84, 0xC6, 0x67, 0x3F, 0x8E, 0xC0, 0x3E, 0x7F, 0xE3, 0xC6,
  0xFC, 0xC2, 0xFE, 0x7C, 0x03, 0xC1, 0xF0, 0x60, 0x18, 0x3F, 0xCF, 0xF0,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC2, 0x60, 0xD8, 0x1E, 0x03, 0x00, 0x1D,
  0x9F, 0xDC, 0x6C, 0x36, 0x33, 0x39, 0xFC, 0x76, 0x47, 0x7F, 0x1F, 0x00,
  0x70, 0x60, 0x60, 0x60, 0x6E, 0x7F, 0xE3, 0xE3, 0xC6, 0xC6, 0xC6, 0xC6,
  0x1C, 0x1C, 0x00, 0xF8, 0xF8, 0x18, 0x30, 0x32, 0x37, 0x3E, 0x38, 0x03,
  0x03, 0x00, 0x3F, 0x3E, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x4C, 0xEC, 0x7C,
  0x38, 0x70, 0x60, 0x60, 0x60, 0x6E, 0x7F, 0xE3, 0xE6, 0xD8, 0xDB, 0xDF,
  0xCE, 0x78, 0xF2, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x36, 0x7D, 0xF1, 0xC0,
  0x6D, 0xBF, 0xDB, 0x29, 0xB4, 0xDE, 0x4F, 0x27, 0xB2, 0x6E, 0x7F, 0x63,
  0xE3, 0xC6, 0xC6, 0xC6, 0xC6, 0x3C, 0x7E, 0xE3, 0xC3, 0xC3, 0xC6, 0xFE,
  0x78, 0x37, 0x1F, 0xDC, 0x6C, 0x36, 0x1B, 0x19, 0xFC, 0xDC, 0xC0, 0x60,
  0x30, 0x00, 0x3B, 0x7F, 0xE3, 0xC3, 0xC6, 0xCE, 0xFE, 0x76, 0x06, 0x0C,
  0x0C, 0xF7, 0xFE, 0x30, 0x60, 0x60, 0x60, 0x60, 0xE0, 0x3E, 0x7F, 0x60,
  0x7C, 0x3E, 0x86, 0xFE, 0x7C, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x30, 0x30,
  0x32, 0x36, 0x7D, 0x38, 0x63, 0x63, 0xC3, 0xC6, 0xC6, 0xCE, 0xF6, 0x76,
  0xE6, 0xE3, 0x63, 0x63, 0x66, 0x4E, 0x7C, 0x78, 0x65, 0xB6, 0xD3, 0x29,
  0xB4, 0xDE, 0xCF, 0xE4, 0xDC, 0x19, 0x8E, 0xE6, 0xCC, 0x32, 0xCD, 0x37,
  0x6F, 0xF1, 0x98, 0x31, 0x98, 0xD8, 0x6C, 0x66, 0x33, 0x39, 0xEC, 0x76,
  0x46, 0x7F, 0x1F, 0x00, 0x3D, 0x9F, 0xD8, 0xE1, 0xC1, 0x93, 0x89, 0xFF,
  0x9E, 0x1E, 0x3C, 0xC0, 0x81, 0x83, 0x3C, 0x78, 0x10, 0x61, 0x82, 0x07,
  0x8F, 0x00, 0x33, 0x32, 0x26, 0x66, 0x64, 0xCC, 0xCC, 0x1E, 0x1E, 0x06,
  0x04, 0x08, 0x08, 0x1F, 0x0F, 0x18, 0x18, 0x08, 0x08, 0x78, 0xF8, 0x38,
  0xBE, 0xDB, 0xD8, 0xE0,
};

const GFXglyph IBMPlexMono_SemiBoldItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 11, 10, 3, -11 },
  { 7, 6, 5, 10, 3, -12 },
  { 11, 10, 11, 10, 0, -11 },
  { 25, 9, 15, 10, 0, -13 },
  { 42, 12, 11, 10, -1, -11 },
  { 59, 10, 11, 10, 0, -11 },
  { 73, 3, 5, 10, 4, -12 },
  { 75, 6, 14, 10, 3, -12 },
  { 86, 7, 14, 10, 0, -12 },
  { 99, 8, 8, 10, 1, -9 },
  { 107, 8, 8, 10, 1, -9 },
  { 115, 4, 5, 10, 2, -3 },
  { 118, 6, 2, 10, 2, -6 },
  { 120, 3, 3, 10, 3, -3 },
  { 122, 10, 14, 10, 0, -12 },
  { 140, 8, 11, 10, 1, -11 },
  { 151, 8, 11, 10, 1, -11 },
  { 162, 9, 11, 10, 0, -11 },
  { 175, 9, 11, 10, 0, -11 },
  { 188, 9, 11, 10, 0, -11 },
  { 201, 9, 11, 10, 0, -11 },
  { 214, 8, 11, 10, 1, -11 },
  { 225, 9, 11, 10, 1, -11 },
  { 238, 9, 11, 10, 0, -11 },
  { 251, 8, 11, 10, 1, -11 },
  { 262, 4, 9, 10, 3, -9 },
  { 267, 5, 11, 10, 2, -9 },
  { 274, 8, 9, 10, 1, -9 },
  { 283, 8, 6, 10, 1, -8 },
  { 289, 8, 9, 10, 1, -9 },
  { 298, 7, 11, 10, 2, -11 },
  { 308, 8, 13, 10, 1, -11 },
  { 321, 9, 11, 10, 0, -11 },
  { 334, 8, 11, 10, 1, -11 },
  { 345, 9, 11, 10, 1, -11 },
  { 358, 8, 11, 10, 1, -11 },
  { 369, 9, 11, 10, 1, -11 },
  { 382, 9, 11, 10, 1, -11 },
  { 395, 8, 11, 10, 1, -11 },
  { 406, 10, 11, 10, 0, -11 },
  { 420, 9, 11, 10, 1, -11 },
  { 433, 8, 11, 10, 1, -11 },
  { 444, 10, 11, 10, 1, -11 },
  { 458, 7, 11, 10, 1, -11 },
  { 468, 10, 11, 10, 0, -11 },
  { 482, 10, 11, 10, 0, -11 },
  { 496, 8, 11, 10, 1, -11 },
  { 507, 8, 11, 10, 1, -11 },
  { 518, 8, 14, 10, 1, -11 },
  { 532, 8, 11, 10, 1, -11 },
  { 543, 9, 11, 10, 0, -11 },
  { 556, 9, 11, 10, 1, -11 },
  { 569, 9, 11, 10, 1, -11 },
  { 582, 9, 11, 10, 1, -11 },
  { 595, 10, 11, 10, 0, -11 },
  { 609, 10, 11, 10, 0, -11 },
  { 623, 10, 11, 10, 1, -11 },
  { 637, 10, 11, 10, 0, -11 },
  { 651, 7, 14, 10, 2, -12 },
  { 664, 4, 14, 10, 3, -12 },
  { 671, 8, 14, 10, 0, -12 },
  { 685, 8, 7, 10, 1, -11 },
  { 692, 8, 2, 10, 0, 1 },
  { 694, 3, 4, 10, 3, -13 },
  { 696, 8, 8, 10, 1, -8 },
  { 704, 9, 12, 10, 0, -12 },
  { 718, 8, 8, 10, 1, -8 },
  { 726, 9, 12, 10, 1, -12 },
  { 740, 8, 8, 10, 1, -8 },
  { 748, 10, 15, 10, 0, -12 },
  { 767, 9, 11, 10, 0, -8 },
  { 780, 8, 12, 10, 1, -12 },
  { 792, 8, 11, 10, 1, -11 },
  { 803, 8, 14, 10, 0, -11 },
  { 817, 8, 12, 10, 1, -12 },
  { 829, 7, 12, 10, 1, -12 },
  { 840, 9, 8, 10, 0, -8 },
  { 849, 8, 8, 10, 1, -8 },
  { 857, 8, 8, 10, 1, -8 },
  { 865, 9, 11, 10, 0, -8 },
  { 878, 8, 11, 10, 1, -8 },
  { 889, 8, 8, 10, 2, -8 },
  { 897, 8, 8, 10, 1, -8 },
  { 905, 8, 11, 10, 1, -11 },
  { 916, 8, 8, 10, 1, -8 },
  { 924, 8, 8, 10, 1, -8 },
  { 932, 9, 8, 10, 0, -8 },
  { 941, 10, 8, 10, 0, -8 },
  { 951, 9, 11, 10, 0, -8 },
  { 964, 9, 8, 10, 0, -8 },
  { 973, 7, 14, 10, 2, -12 },
  { 986, 4, 14, 10, 3, -12 },
  { 993, 8, 14, 10, 0, -12 },
  { 1007, 9, 4, 10, 0, -7 },
};

const GFXfont IBMPlexMono_SemiBoldItalic16pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic16pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC16PT7B_H_
