#ifndef _IBMPLEXMONO_SEMIBOLDITALIC17PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x63, 0x10, 0x84, 0x07, 0x39, 0xC0, 0x6F, 0x3C, 0xF3,
  0xD8, 0x06, 0xC1, 0x90, 0x36, 0x3C, 0xF7, 0x9C, 0x36, 0x04, 0xC7, 0x9E,
  0xF7, 0x84, 0xC1, 0x90, 0x36, 0x00, 0x03, 0x00, 0x80, 0xF8, 0xFF, 0x36,
  0x8D, 0x83, 0xC0, 0xFC, 0x0F, 0x81, 0x60, 0xD9, 0xB6, 0xFF, 0x8F, 0x80,
  0x80, 0x60, 0x1E, 0x33, 0xE2, 0x32, 0x62, 0x6C, 0x3E, 0x81, 0xD0, 0x01,
  0xC0, 0xFE, 0x1A, 0x63, 0x66, 0x63, 0xCC, 0x38, 0x0F, 0x07, 0xE1, 0x98,
  0x66, 0x19, 0x8F, 0xC6, 0xC3, 0x30, 0xC6, 0xB1, 0xBF, 0xB9, 0xCE, 0xFF,
  0xC0, 0x0E, 0x30, 0xC1, 0x06, 0x08, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x06,
  0x0C, 0x0E, 0x00, 0x30, 0x60, 0xC3, 0x04, 0x10, 0x41, 0x0C, 0x30, 0x86,
  0x31, 0x8C, 0x00, 0x0C, 0x06, 0x22, 0x7F, 0xF3, 0xE1, 0xE1, 0xB1, 0xCC,
  0x44, 0x00, 0x0C, 0x0C, 0x08, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x3B, 0x98,
  0xCC, 0x60, 0x7F, 0xF0, 0xFF, 0x80, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03,
  0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C,
  0x00, 0x1E, 0x1F, 0x9C, 0xFC, 0x3C, 0x9E, 0xCF, 0x6F, 0x87, 0xC3, 0x63,
  0xBF, 0x8F, 0x80, 0x1E, 0x3E, 0x36, 0x6E, 0xEC, 0x4C, 0x0C, 0x0C, 0x0C,
  0x1C, 0xFF, 0xFF, 0x0F, 0x07, 0xE3, 0x1C, 0x47, 0x01, 0x80, 0xE0, 0x70,
  0x38, 0x38, 0x1C, 0x07, 0xFB, 0xFE, 0x0F, 0x0F, 0xE3, 0x1C, 0x07, 0x01,
  0x83, 0xC0, 0xF0, 0x4E, 0x41, 0xB8, 0xE7, 0xF0, 0xF8, 0x03, 0x81, 0xE0,
  0x78, 0x36, 0x1B, 0x8C, 0xC3, 0x31, 0x8C, 0xFF, 0xFF, 0xE0, 0x30, 0x18,
  0x1F, 0xC7, 0xF3, 0x00, 0xC0, 0x3F, 0x0B, 0xE7, 0x18, 0x06, 0x41, 0x98,
  0xEF, 0xF0, 0xF8, 0x0F, 0x1C, 0x38, 0x70, 0x6E, 0xFF, 0xE3, 0xC3, 0xC3,
  0xC7, 0xFE, 0x7C, 0x7F, 0xBF, 0xD8, 0x78, 0x60, 0x70, 0x30, 0x30, 0x18,
  0x18, 0x1C, 0x0C, 0x0E, 0x00, 0x0F, 0x87, 0xF3, 0x0C, 0xC3, 0x31, 0x87,
  0xC3, 0xF1, 0x86, 0x61, 0xB8, 0xE7, 0xF8, 0xF8, 0x1E, 0x3F, 0x98, 0xFC,
  0x3C, 0x1F, 0x1D, 0xFC, 0xF6, 0x06, 0x07, 0x06, 0x1E, 0x00, 0x77, 0x70,
  0x00, 0xEE, 0xE0, 0x39, 0xCE, 0x00, 0x00, 0xEE, 0x63, 0x31, 0x80, 0x00,
  0x81, 0x83, 0xC7, 0x87, 0x07, 0x01, 0xE0, 0x38, 0x06, 0x01, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x40, 0x70, 0x3C, 0x0E, 0x07, 0x07,
  0x1E, 0x78, 0xE0, 0x80, 0x3C, 0x7E, 0xC7, 0x46, 0x0E, 0x38, 0x30, 0x00,
  0x00, 0x70, 0x70, 0x60, 0x1E, 0x1F, 0x98, 0x6D, 0xFD, 0xFE, 0xCF, 0x45,
  0xA6, 0x9F, 0x4F, 0xB0, 0x18, 0x0F, 0xC1, 0xE0, 0x03, 0x81, 0xE0, 0x78,
  0x36, 0x0D, 0x86, 0x71, 0x8C, 0x7F, 0x3F, 0xCC, 0x36, 0x0F, 0x83, 0x3F,
  0x3F, 0x98, 0xEC, 0x76, 0x33, 0xF1, 0xF9, 0xC6, 0xC3, 0x61, 0xBF, 0xDF,
  0x80, 0x1F, 0x1F, 0xDC, 0x6C, 0x3E, 0x07, 0x03, 0x01, 0x80, 0xC3, 0x73,
  0x9F, 0x87, 0x80, 0x7E, 0x3F, 0x98, 0xEC, 0x36, 0x1B, 0x0F, 0x8F, 0x87,
  0xC3, 0x63, 0xBF, 0x9F, 0x80, 0x3F, 0xBF, 0xD8, 0x0C, 0x06, 0x03, 0xF9,
  0xFD, 0xC0, 0xC0, 0x60, 0x3F, 0x9F, 0xC0, 0x3F, 0xBF, 0xD8, 0x0C, 0x06,
  0x03, 0xF9, 0xFD, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x00, 0x1E, 0x1F, 0x9C,
  0xEC, 0x3E, 0x06, 0x7B, 0x3D, 0x86, 0xC3, 0x73, 0xBE, 0xCE, 0xE0, 0x38,
  0xCC, 0x33, 0x0C, 0xC3, 0x31, 0xCF, 0xE7, 0xF9, 0x86, 0x61, 0x98, 0x66,
  0x3B, 0x8C, 0x7F, 0xBF, 0xC3, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18,
  0x0C, 0x3F, 0x9F, 0xC0, 0x3F, 0x9F, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x1C,
  0x0C, 0xC6, 0x63, 0x3F, 0x8F, 0x00, 0x71, 0xD8, 0xE6, 0x71, 0x98, 0x6C,
  0x1F, 0x0F, 0xC3, 0xB8, 0xC6, 0x31, 0x8C, 0x73, 0x0C, 0x30, 0x30, 0x30,
  0x70, 0x60, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xFF, 0xFF, 0x38, 0xE7, 0x38,
  0xE7, 0x15, 0xE6, 0xEC, 0xDD, 0x9B, 0x33, 0x2C, 0x69, 0x88, 0x33, 0x06,
  0x60, 0xC0, 0x38, 0xCE, 0x33, 0xCC, 0xF3, 0x3C, 0xCB, 0x66, 0x59, 0x9E,
  0x67, 0x99, 0xE6, 0x7B, 0x0C, 0x1E, 0x1F, 0x9C, 0xFC, 0x3E, 0x1E, 0x0F,
  0x0F, 0x87, 0xC3, 0x63, 0xBF, 0x8F, 0x80, 0x3F, 0x3F, 0xD8, 0x6C, 0x36,
  0x1B, 0x1D, 0xFD, 0xFC, 0xE0, 0x60, 0x30, 0x18, 0x00, 0x1E, 0x1F, 0x9C,
  0xFC, 0x3E, 0x1E, 0x0F, 0x0F, 0x87, 0xC3, 0x63, 0xBF, 0x8F, 0x81, 0x80,
  0x6C, 0x3C, 0x0C, 0x3F, 0x3F, 0xD8, 0x6C, 0x36, 0x1B, 0x1D, 0xFD, 0xFC,
  0xEC, 0x63, 0x31, 0x98, 0xE0, 0x0F, 0x0F, 0xF3, 0x08, 0xC0, 0x38, 0x0F,
  0xC1, 0xF8, 0x06, 0x01, 0x98, 0xEF, 0xF0, 0xF8, 0x7F, 0xFF, 0xF0, 0xC0,
  0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x61,
  0xB0, 0xD8, 0x6C, 0x36, 0x3F, 0x1B, 0x0D, 0x86, 0xC3, 0x63, 0xBF, 0x8F,
  0x80, 0xC1, 0xE1, 0xB0, 0xD8, 0xEC, 0x66, 0x33, 0x31, 0x98, 0xF8, 0x3C,
  0x1E, 0x0E, 0x00, 0x60, 0x6C, 0x0D, 0x81, 0xB3, 0x26, 0xEC, 0xD5, 0x9A,
  0xB3, 0xD4, 0x73, 0x8A, 0x71, 0xDE, 0x73, 0x80, 0x30, 0xE7, 0x18, 0x66,
  0x0D, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x33, 0x0E, 0x61, 0x8E, 0x60,
  0xC0, 0xE1, 0xD8, 0x67, 0x38, 0xDC, 0x36, 0x0F, 0x01, 0xC0, 0x60, 0x18,
  0x06, 0x01, 0x80, 0xE0, 0x3F, 0xCF, 0xF0, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0x60, 0x30, 0x18, 0x0F, 0xFB, 0xFE, 0x1F, 0x1F, 0x30, 0x30, 0x30,
  0x30, 0x20, 0x60, 0x60, 0x60, 0x60, 0x40, 0x40, 0xFC, 0xFC, 0xC6, 0x30,
  0x84, 0x31, 0x8C, 0x21, 0x0C, 0x63, 0x08, 0x60, 0x1F, 0x1F, 0x03, 0x03,
  0x02, 0x02, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x7C, 0xFC, 0x0E,
  0x0F, 0x0F, 0x86, 0x66, 0x37, 0x1B, 0x06, 0xFF, 0xFF, 0x5D, 0x90, 0x3B,
  0xBF, 0xB8, 0xD8, 0x6C, 0x36, 0x3B, 0x39, 0xFE, 0x73, 0x00, 0x30, 0x70,
  0x60, 0x60, 0x6E, 0x7F, 0x73, 0xE3, 0xC3, 0xC3, 0xC7, 0xFE, 0xDC, 0x1E,
  0x7F, 0x63, 0xE0, 0xC0, 0xC2, 0xE7, 0x7E, 0x3C, 0x01, 0x80, 0xC0, 0x60,
  0x33, 0x9B, 0xFB, 0x8D, 0x86, 0xC3, 0x63, 0xB1, 0xDF, 0xC7, 0x60, 0x1E,
  0x7F, 0x63, 0xE3, 0xFC, 0xC2, 0xE3, 0x7E, 0x3C, 0x03, 0xE0, 0x7C, 0x18,
  0x03, 0x03, 0xFC, 0x7F, 0x81, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x0C, 0xC1, 0xF8, 0x1E, 0x01, 0xC0, 0x1D, 0xCF, 0xE7, 0x19, 0x86, 0x61,
  0x98, 0x66, 0x39, 0xFC, 0x3B, 0x11, 0xCF, 0xE1, 0xF0, 0x30, 0x70, 0x60,
  0x60, 0x6E, 0x6F, 0x73, 0xE3, 0xE3, 0xC3, 0xC3, 0xC6, 0xC6, 0x0C, 0x0C,
  0x1C, 0x00, 0xFC, 0xF8, 0x18, 0x18, 0x18, 0x33, 0x37, 0x3E, 0x1C, 0x03,
  0x81, 0xC0, 0xE0, 0x01, 0xF1, 0xF8, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x88,
  0xC6, 0xE7, 0xE0, 0xF0, 0x38, 0x30, 0x38, 0x18, 0x0C, 0x06, 0xF3, 0x79,
  0xCD, 0xC6, 0xEE, 0x6C, 0x37, 0x79, 0xEC, 0xE0, 0xF9, 0xE0, 0xC1, 0x83,
  0x06, 0x1C, 0x30, 0x64, 0xCD, 0xB3, 0xC7, 0x00, 0x6D, 0xDF, 0x76, 0x6D,
  0xB3, 0x4C, 0xF3, 0x2C, 0xDB, 0x36, 0xD9, 0x80, 0x6E, 0x6F, 0x73, 0xE3,
  0xE3, 0xC3, 0xC3, 0xC6, 0xC6, 0x3E, 0x7F, 0xE3, 0xC3, 0xC3, 0xC3, 0xC7,
  0xFE, 0x7C, 0x37, 0x1F, 0xCE, 0x6E, 0x36, 0x1B, 0x0D, 0x8E, 0xFE, 0x6E,
  0x60, 0x30, 0x18, 0x00, 0x3B, 0xBF, 0xB8, 0xD8, 0x6C, 0x36, 0x3B, 0x1D,
  0xFC, 0x76, 0x03, 0x01, 0x80, 0xC0, 0xF3, 0xF7, 0x38, 0x30, 0x60, 0x60,
  0x60, 0x60, 0x60, 0x3E, 0x7F, 0x62, 0x78, 0x7E, 0x0F, 0x87, 0xFE, 0x7C,
  0x18, 0x18, 0x18, 0xFF, 0xFF, 0x38, 0x30, 0x30, 0x33, 0x37, 0x3E, 0x38,
  0x63, 0xB1, 0x98, 0xDC, 0x6C, 0x36, 0x3B, 0x1D, 0xFC, 0x76, 0x00, 0xF3,
  0xF3, 0x63, 0x63, 0x63, 0x67, 0x6E, 0x7C, 0x78, 0x66, 0x99, 0x36, 0x4D,
  0xB3, 0x4C, 0xD3, 0x2C, 0xDB, 0xF4, 0x66, 0x00, 0x19, 0xCF, 0xF6, 0xED,
  0x33, 0x0C, 0x33, 0x2D, 0xDF, 0xFE, 0x67, 0x00, 0x31, 0xCC, 0x63, 0x19,
  0xC6, 0x61, 0x98, 0xE6, 0x31, 0xFC, 0x3B, 0x11, 0xCF, 0xE1, 0xF0, 0x3C,
  0xCF, 0xF6, 0x38, 0x1C, 0x0C, 0x0E, 0x67, 0x99, 0xFE, 0xCF, 0x80, 0x1F,
  0x1F, 0x18, 0x10, 0x08, 0x18, 0xF8, 0xF0, 0x18, 0x10, 0x30, 0x60, 0x60,
  0x7C, 0x7C, 0x13, 0x33, 0x33, 0x26, 0x66, 0x64, 0x4C, 0xC0, 0x1E, 0x0F,
  0x80, 0x80, 0xC0, 0xC0, 0x60, 0x3E, 0x1F, 0x18, 0x0C, 0x02, 0x01, 0x80,
  0xC3, 0xE3, 0xE0, 0x38, 0xDF, 0x36, 0xFB, 0x1C,
};

const GFXglyph IBMPlexMono_SemiBoldItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 12, 10, 3, -12 },
  { 9, 6, 5, 10, 3, -13 },
  { 13, 11, 12, 10, 0, -12 },
  { 30, 10, 16, 10, 0, -14 },
  { 50, 12, 12, 10, -1, -12 },
  { 68, 10, 12, 10, 0, -12 },
  { 83, 2, 5, 10, 5, -13 },
  { 85, 7, 15, 10, 3, -13 },
  { 99, 6, 15, 10, 1, -13 },
  { 111, 9, 9, 10, 1, -9 },
  { 122, 8, 8, 10, 1, -9 },
  { 130, 5, 6, 10, 2, -3 },
  { 134, 6, 2, 10, 2, -6 },
  { 136, 3, 3, 10, 3, -3 },
  { 138, 10, 15, 10, 0, -13 },
  { 157, 9, 12, 10, 1, -12 },
  { 171, 8, 12, 10, 1, -12 },
  { 183, 10, 12, 10, 0, -12 },
  { 198, 10, 12, 10, 0, -12 },
  { 213, 10, 12, 10, 0, -12 },
  { 228, 10, 12, 10, 0, -12 },
  { 243, 8, 12, 10, 1, -12 },
  { 255, 9, 12, 10, 1, -12 },
  { 269, 10, 12, 10, 0, -12 },
  { 284, 9, 12, 10, 1, -12 },
  { 298, 4, 9, 10, 3, -9 },
  { 303, 5, 12, 10, 2, -9 },
  { 311, 9, 10, 10, 1, -10 },
  { 323, 9, 6, 10, 1, -8 },
  { 330, 8, 10, 10, 1, -10 },
  { 340, 8, 12, 10, 2, -12 },
  { 352, 9, 14, 10, 1, -12 },
  { 368, 10, 12, 10, -1, -12 },
  { 383, 9, 12, 10, 1, -12 },
  { 397, 9, 12, 10, 1, -12 },
  { 411, 9, 12, 10, 1, -12 },
  { 425, 9, 12, 10, 1, -12 },
  { 439, 9, 12, 10, 1, -12 },
  { 453, 9, 12, 10, 1, -12 },
  { 467, 10, 12, 10, 0, -12 },
  { 482, 9, 12, 10, 1, -12 },
  { 496, 9, 12, 10, 1, -12 },
  { 510, 10, 12, 10, 1, -12 },
  { 525, 8, 12, 10, 1, -12 },
  { 537, 11, 12, 10, 0, -12 },
  { 554, 10, 12, 10, 0, -12 },
  { 569, 9, 12, 10, 1, -12 },
  { 583, 9, 12, 10, 1, -12 },
  { 597, 9, 16, 10, 1, -12 },
  { 615, 9, 12, 10, 1, -12 },
  { 629, 10, 12, 10, 0, -12 },
  { 644, 10, 12, 10, 1, -12 },
  { 659, 9, 12, 10, 1, -12 },
  { 673, 9, 12, 10, 2, -12 },
  { 687, 11, 12, 10, 0, -12 },
  { 704, 11, 12, 10, 0, -12 },
  { 721, 10, 12, 10, 1, -12 },
  { 736, 10, 12, 10, 0, -12 },
  { 751, 8, 15, 10, 2, -13 },
  { 766, 5, 15, 10, 3, -13 },
  { 776, 8, 15, 10, 0, -13 },
  { 791, 9, 7, 10, 1, -12 },
  { 799, 8, 2, 10, 0, 1 },
  { 801, 3, 4, 10, 3, -14 },
  { 803, 9, 9, 10, 1, -9 },
  { 814, 8, 13, 10, 1, -13 },
  { 827, 8, 9, 10, 1, -9 },
  { 836, 9, 13, 10, 1, -13 },
  { 851, 8, 9, 10, 1, -9 },
  { 860, 11, 16, 10, 0, -13 },
  { 882, 10, 12, 10, 0, -9 },
  { 897, 8, 13, 10, 1, -13 },
  { 910, 8, 13, 10, 1, -13 },
  { 923, 9, 16, 10, 0, -13 },
  { 941, 9, 13, 10, 1, -13 },
  { 956, 7, 13, 10, 2, -13 },
  { 968, 10, 9, 10, 0, -9 },
  { 980, 8, 9, 10, 1, -9 },
  { 989, 8, 9, 10, 1, -9 },
  { 998, 9, 12, 10, 0, -9 },
  { 1012, 9, 12, 10, 1, -9 },
  { 1026, 8, 9, 10, 2, -9 },
  { 1035, 8, 9, 10, 1, -9 },
  { 1044, 8, 12, 10, 1, -12 },
  { 1056, 9, 9, 10, 1, -9 },
  { 1067, 8, 9, 10, 1, -9 },
  { 1076, 10, 9, 10, 0, -9 },
  { 1088, 10, 9, 10, 0, -9 },
  { 1100, 10, 12, 10, 0, -9 },
  { 1115, 10, 9, 10, 0, -9 },
  { 1127, 8, 15, 10, 2, -13 },
  { 1142, 4, 15, 10, 3, -13 },
  { 1150, 9, 15, 10, 0, -13 },
  { 1167, 10, 4, 10, 0, -7 },
};

const GFXfont IBMPlexMono_SemiBoldItalic17pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic17pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC17PT7B_H_
