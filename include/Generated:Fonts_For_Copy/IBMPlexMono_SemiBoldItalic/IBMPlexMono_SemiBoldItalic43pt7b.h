#ifndef _IBMPLEXMONO_SEMIBOLDITALIC43PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x07, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE0, 0xF0, 0x00, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E,
  0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x7C, 0xF8, 0x7C, 0x00, 0x0F, 0x8F,
  0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x01,
  0xE1, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xE1, 0xF0,
  0x00, 0x3C, 0x3C, 0x01, 0xFF, 0x8F, 0xFC, 0x7F, 0xE1, 0xFF, 0x8F, 0xFC,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x01, 0xE1, 0xF0, 0x00, 0x7C, 0x3C, 0x00,
  0x0F, 0x8F, 0x80, 0x01, 0xE1, 0xE0, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F,
  0xFC, 0x7F, 0xE1, 0xFF, 0x8F, 0xFC, 0x3F, 0xF0, 0x0F, 0x0F, 0x80, 0x01,
  0xE1, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE1, 0xE0,
  0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xE7, 0x3E, 0x1F, 0x87, 0x1C,
  0x1F, 0x8F, 0x08, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x8E, 0x00,
  0x1F, 0xEE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3C, 0xFE,
  0x00, 0x3C, 0x7E, 0x00, 0x3C, 0x7E, 0x20, 0x38, 0x7E, 0x30, 0x38, 0x7E,
  0x78, 0x38, 0xFC, 0xFE, 0x79, 0xFC, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x7C, 0x07, 0xF8, 0x03, 0xE0, 0x7F, 0xF0, 0x0F, 0x01, 0xFF, 0xE0, 0x78,
  0x0F, 0x87, 0x83, 0xE0, 0x3C, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x78, 0x07,
  0xC1, 0xE3, 0xE0, 0x1E, 0x07, 0x8F, 0x00, 0x78, 0x3C, 0x78, 0x01, 0xF1,
  0xF3, 0xE0, 0x03, 0xFF, 0x8F, 0x00, 0x0F, 0xFE, 0x78, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xEF, 0xFE, 0x00, 0x1F, 0x3F, 0xFC, 0x00, 0x79, 0xF1, 0xF0,
  0x03, 0xC7, 0x83, 0xC0, 0x1F, 0x1E, 0x0F, 0x00, 0x78, 0xF0, 0x3C, 0x03,
  0xC3, 0xC1, 0xF0, 0x1E, 0x0F, 0x07, 0x80, 0x78, 0x3E, 0x3E, 0x03, 0xC0,
  0x7F, 0xF0, 0x1E, 0x01, 0xFF, 0xC0, 0x78, 0x03, 0xFE, 0x03, 0xC0, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x03,
  0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x0F,
  0x83, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x7F, 0x7E, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xC3, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x03,
  0xE0, 0x0F, 0xC0, 0xF8, 0x3B, 0xF0, 0x3F, 0x1F, 0xFC, 0x1F, 0xCF, 0x9F,
  0x8C, 0xFB, 0xC7, 0xFF, 0x3F, 0xF0, 0xFF, 0xC7, 0xF8, 0x3F, 0xE1, 0xFC,
  0x03, 0xE0, 0x1E, 0x00, 0x3E, 0x7D, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0xF9,
  0xF3, 0xE7, 0xCF, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x08, 0x07, 0x80,
  0x9E, 0x1F, 0x07, 0x3F, 0x3E, 0x7E, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0xC0, 0x07, 0xEF, 0x80, 0x1F, 0x9F, 0x80, 0x7E, 0x1F, 0x00, 0xF8,
  0x1F, 0x03, 0xF0, 0x3E, 0x01, 0xC0, 0x30, 0x01, 0x00, 0x40, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x83,
  0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x00,
  0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x3F, 0x9F,
  0xEF, 0xFF, 0xFF, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC3, 0xFC, 0x1F, 0x87, 0xE0, 0x1F, 0x9F, 0x80, 0x3F,
  0x3F, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7,
  0xC0, 0x03, 0xFF, 0x87, 0x8F, 0xFF, 0x1F, 0x1F, 0xFE, 0x3E, 0x3F, 0xFC,
  0x7C, 0x7F, 0xF8, 0xF0, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0x80,
  0x0F, 0xDF, 0x00, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x01, 0xF8, 0x7E, 0x0F,
  0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x01, 0xF9,
  0xF0, 0x1F, 0x8F, 0x81, 0xFC, 0x7C, 0x1F, 0xC7, 0xE0, 0x7C, 0x3F, 0x01,
  0xC1, 0xF8, 0x0E, 0x0F, 0x80, 0x20, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x3F, 0x07,
  0x00, 0x3F, 0x01, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x07,
  0x80, 0x7F, 0x03, 0x00, 0x3F, 0x02, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x10, 0x00, 0xFC, 0x38,
  0x01, 0xFC, 0xF8, 0x01, 0xF8, 0xFE, 0x07, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xFC, 0x01, 0xF0, 0xFC, 0x01,
  0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F,
  0x01, 0xF8, 0x1E, 0x01, 0xF8, 0x3C, 0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x0F, 0xC0, 0x0F, 0x3F, 0xF0, 0x1F, 0x7F, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x08, 0x00, 0xFC, 0x38,
  0x00, 0xFC, 0x7C, 0x01, 0xFC, 0xFF, 0x07, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xF8, 0x3F, 0x7F, 0xF1, 0xFB,
  0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xE0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xEF,
  0xC0, 0x1F, 0xBF, 0x00, 0xFE, 0x7E, 0x07, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0xFC, 0xF8, 0x03, 0xE3, 0xC0,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0xFC, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x3F, 0x81, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFF, 0x03, 0xFC,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFE, 0x0F, 0xE7, 0xF0, 0x0F, 0xDF, 0x80,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0x9F, 0xFF, 0xFE, 0x7F,
  0xFD, 0xF8, 0xFF, 0xEF, 0xC1, 0xFF, 0x3F, 0x01, 0xF9, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xC1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF0,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x7F, 0x0F, 0xF1, 0xFE, 0x7F, 0xCF, 0xF0, 0xFE, 0x0F, 0x80, 0x01, 0xF0,
  0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x07,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF,
  0xE7, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0x01, 0xFB, 0xC0, 0x3F, 0x10, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xFE,
  0x01, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x7E, 0x07, 0xC1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F,
  0x80, 0x0F, 0x3E, 0x0F, 0x1E, 0x7C, 0x3F, 0x3C, 0xF0, 0xFF, 0xFB, 0xE3,
  0xFF, 0xF7, 0xCF, 0xC7, 0xEF, 0x1F, 0x07, 0x9E, 0x3C, 0x0F, 0x7C, 0x78,
  0x1E, 0xF9, 0xF0, 0x7D, 0xF3, 0xE0, 0xFB, 0xE7, 0xC1, 0xE7, 0x8F, 0x83,
  0xCF, 0x1F, 0x0F, 0x9E, 0x3E, 0x1F, 0x3C, 0x7F, 0xFE, 0x78, 0x7F, 0xFC,
  0xF0, 0xFE, 0xF1, 0xE0, 0xF9, 0xE3, 0xC0, 0x40, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01,
  0xF8, 0x7C, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xE0, 0x7E, 0x07,
  0xE0, 0x3E, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xF0, 0x1F, 0x83, 0xE0, 0x1F, 0x8F, 0xC0,
  0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x0F,
  0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x3E, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7,
  0xE0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7E, 0x3E, 0x01, 0xFC, 0x7C,
  0x07, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC0, 0x7E, 0x1F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x30, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x70, 0x7C, 0x00, 0xFC, 0x7C,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x07, 0xC0, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x1F,
  0x00, 0x3F, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x3E, 0x00, 0xFC, 0x3E, 0x01, 0xFC, 0x3E, 0x01, 0xF8, 0x7E,
  0x07, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFC, 0x1F, 0x87, 0xF0,
  0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x41, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x87, 0xFF,
  0x7E, 0x0F, 0xFE, 0xFC, 0x1F, 0xFD, 0xF8, 0x3F, 0xF3, 0xF0, 0x7F, 0xE7,
  0xE0, 0x07, 0xCF, 0xC0, 0x0F, 0x9F, 0x80, 0x1F, 0x3F, 0x00, 0x7E, 0x3F,
  0x01, 0xF8, 0x7F, 0x07, 0xF0, 0xFF, 0xFB, 0xE0, 0xFF, 0xF7, 0xC1, 0xFF,
  0xCF, 0x81, 0xFF, 0x1F, 0x00, 0xFC, 0x7C, 0x00, 0x07, 0xE0, 0x1F, 0x83,
  0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xF0,
  0x7E, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3F,
  0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x83, 0xE0,
  0x0F, 0xC1, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0x7E,
  0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3E, 0x0F,
  0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x7E, 0x07,
  0xF0, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0xFC,
  0x03, 0xF8, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x07, 0xE0,
  0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0x87,
  0xF0, 0x01, 0xF1, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x01,
  0xFB, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFD, 0xF8, 0x00, 0xFF, 0x3F, 0x00, 0x1F,
  0xC7, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x80, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF0,
  0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x83,
  0xF8, 0x0F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F,
  0xF0, 0x7F, 0xC7, 0xFE, 0x0F, 0xF8, 0xF7, 0xC1, 0xEF, 0xBE, 0xF0, 0x7C,
  0xF7, 0xBE, 0x0F, 0x9F, 0xE7, 0xC1, 0xF3, 0xFC, 0xF8, 0x3E, 0x7F, 0x1F,
  0x07, 0xCF, 0xE3, 0xE0, 0xF8, 0xF8, 0xF8, 0x3E, 0x1F, 0x1F, 0x07, 0xC3,
  0xC3, 0xE0, 0xF8, 0x78, 0x7C, 0x1F, 0x06, 0x0F, 0x83, 0xE0, 0xC1, 0xF0,
  0x7C, 0x10, 0x7C, 0x1F, 0x02, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0x83, 0xF8,
  0x07, 0xC1, 0xFC, 0x03, 0xE0, 0xFF, 0x01, 0xE0, 0xFF, 0x81, 0xF0, 0x7F,
  0xC0, 0xF8, 0x3F, 0xE0, 0x7C, 0x1F, 0xF0, 0x3E, 0x0F, 0xFC, 0x1F, 0x07,
  0xBE, 0x0F, 0x07, 0xDF, 0x0F, 0x83, 0xE7, 0x87, 0xC1, 0xF3, 0xC3, 0xE0,
  0xF9, 0xF1, 0xF0, 0x7C, 0xF8, 0xF8, 0x3C, 0x7C, 0x78, 0x3E, 0x1E, 0x7C,
  0x1F, 0x0F, 0x3E, 0x0F, 0x87, 0xDF, 0x07, 0xC3, 0xEF, 0x83, 0xE1, 0xF7,
  0xC1, 0xE0, 0x7B, 0xC1, 0xF0, 0x3F, 0xE0, 0xF8, 0x1F, 0xF0, 0x7C, 0x0F,
  0xF8, 0x3E, 0x07, 0xFC, 0x1F, 0x01, 0xFE, 0x0F, 0x00, 0xFE, 0x0F, 0x80,
  0x7F, 0x07, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFC, 0x1F, 0x87, 0xE0,
  0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0xFC, 0x00, 0x7D, 0xF8, 0x01,
  0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7,
  0xE0, 0x07, 0xEF, 0x80, 0x0F, 0xDF, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E,
  0x01, 0xF8, 0x7E, 0x0F, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xF0,
  0x0F, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x3F, 0x00,
  0x7C, 0x7E, 0x01, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x0F, 0xE7, 0xE0, 0x3F,
  0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC3, 0xFC, 0x1F, 0x87, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00,
  0x7E, 0xFC, 0x00, 0x7D, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0x80, 0x0F, 0xDF,
  0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x01, 0xF8, 0x7E, 0x0F, 0xF0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0x80, 0x00, 0x3E, 0x04, 0x00, 0x7E, 0x0C, 0x00, 0x7E, 0x3C, 0x00, 0x7C,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xF0, 0x1F, 0xC3, 0xE0, 0x1F,
  0x8F, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x7C, 0x01, 0xF8,
  0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xE7, 0xE0, 0x3F, 0x8F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xF0,
  0xF8, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x83, 0xE0, 0x3E, 0x07,
  0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x87, 0xE0, 0x3F,
  0x0F, 0x80, 0x3F, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xE0,
  0x7F, 0x0F, 0xC0, 0x1E, 0x1F, 0x80, 0x0C, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x20, 0x00,
  0x7C, 0x30, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0xFF, 0x03, 0xF8, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF4, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x7E,
  0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7C,
  0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x7E,
  0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7E,
  0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x3F,
  0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x0F, 0x8F, 0x00, 0x01,
  0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0,
  0xFC, 0x3C, 0x3E, 0x1F, 0x87, 0x87, 0xC7, 0xF1, 0xF0, 0xF8, 0xFE, 0x3E,
  0x1E, 0x1F, 0xC7, 0x83, 0xC7, 0xF8, 0xF0, 0x78, 0xFF, 0x3E, 0x1F, 0x1D,
  0xE7, 0xC3, 0xE7, 0xBC, 0xF8, 0x7C, 0xF7, 0x9E, 0x0F, 0x9C, 0xF3, 0xC1,
  0xF7, 0x9E, 0xF8, 0x3E, 0xF3, 0xDF, 0x07, 0x9C, 0x7B, 0xC0, 0xF7, 0x8F,
  0x78, 0x1E, 0xF1, 0xEF, 0x03, 0xDC, 0x3F, 0xE0, 0xFF, 0x87, 0xF8, 0x1F,
  0xF0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x1F,
  0x80, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E,
  0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF8, 0xFC,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x07, 0xE0,
  0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xBF, 0x00, 0x1F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x87,
  0xE0, 0x07, 0xE7, 0xE0, 0x01, 0xF3, 0xF0, 0x00, 0xFB, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFE, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xC0,
  0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x0F,
  0x00, 0xF0, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x7C, 0xF8,
  0x01, 0xF1, 0xF0, 0x07, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x3E, 0x07, 0xE0,
  0xFC, 0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x9F, 0x80, 0x1F, 0x3E,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0x70, 0x00, 0x70, 0x40, 0x01, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x08, 0x18,
  0xFC, 0x7C, 0x3E, 0x3E, 0x1E, 0x1F, 0x0F, 0x0C, 0x01, 0xF8, 0x7C, 0x1F,
  0xF3, 0xF0, 0xFF, 0xEF, 0xC7, 0xFF, 0xBE, 0x3F, 0x83, 0xF8, 0xFC, 0x07,
  0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xCF,
  0xC0, 0x1F, 0x3F, 0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0xCF, 0x80,
  0x3F, 0x3E, 0x01, 0xF8, 0xFC, 0x0F, 0xE3, 0xF8, 0x6F, 0x87, 0xFF, 0x3F,
  0xDF, 0xFC, 0xFE, 0x3F, 0xE3, 0xF8, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x0F, 0x80, 0x7C, 0x7F, 0xC0, 0xF9, 0xFF, 0xC3, 0xF7,
  0xFF, 0x87, 0xFC, 0x3F, 0x0F, 0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00,
  0xFC, 0x7C, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F,
  0xCF, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0xFC, 0x01, 0xF9,
  0xF8, 0x07, 0xE3, 0xF8, 0x3F, 0xC7, 0xDF, 0xFF, 0x0F, 0xBF, 0xFC, 0x1F,
  0x3F, 0xF0, 0x7E, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x3F, 0x83, 0xF3, 0xF0, 0x1E, 0x7E, 0x01, 0x87, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x08, 0xF8, 0x01, 0xCF, 0x80, 0x3F, 0xFC, 0x07, 0xEF,
  0xE0, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x7C, 0x07, 0xFE, 0x7C,
  0x0F, 0xFE, 0x7C, 0x1F, 0xFF, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0x01, 0xFC,
  0x7E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0,
  0xF8, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xF0, 0xFE, 0x1F, 0xF0,
  0x7F, 0xFB, 0xE0, 0x7F, 0xF3, 0xE0, 0x3F, 0xE3, 0xE0, 0x0F, 0x87, 0xE0,
  0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x3F, 0x83,
  0xF3, 0xE0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x8F, 0x80, 0x1E, 0xFC, 0x03, 0xFF, 0xE0, 0xFE, 0x7F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x06,
  0x07, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x8F,
  0x80, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x3F, 0x03, 0xFF, 0x3E, 0x07, 0xFF, 0x3E, 0x0F, 0xFF, 0xBE,
  0x1F, 0xC1, 0xFE, 0x1F, 0x80, 0xFE, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8,
  0x7E, 0x07, 0xF8, 0x7F, 0x0F, 0xF8, 0x3F, 0xFD, 0xF0, 0x3F, 0xF9, 0xF0,
  0x1F, 0xF1, 0xF0, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x30, 0x07, 0xE0, 0x7C, 0x1F, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x3E, 0x03, 0xE3, 0xFE, 0x0F, 0x9F, 0xF8, 0x3E, 0xFF, 0xF1,
  0xFB, 0x0F, 0xC7, 0xF8, 0x3F, 0x1F, 0xC0, 0x7C, 0x7E, 0x01, 0xF1, 0xF8,
  0x07, 0xC7, 0xC0, 0x1F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F,
  0x80, 0x7E, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x3F, 0x00,
  0xFC, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x0C, 0x07, 0xE0, 0xF0, 0x3F, 0x1F, 0xC1, 0xF1, 0xF8,
  0x0F, 0x9F, 0x80, 0x7D, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F,
  0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x02, 0x03, 0xE0, 0x38, 0x3F, 0x07, 0xC1, 0xF8, 0x1F, 0x0F, 0xC0,
  0xFC, 0x7C, 0x03, 0xF3, 0xE0, 0x0F, 0xDF, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC3, 0xE0, 0x0F, 0x8F, 0xF8, 0x0F, 0x9F, 0xFC, 0x0F, 0xBF,
  0xFC, 0x1F, 0xF0, 0xFC, 0x1F, 0xE0, 0x7C, 0x1F, 0xC0, 0x7C, 0x1F, 0x80,
  0x7C, 0x1F, 0x80, 0xF8, 0x1F, 0x01, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x7F, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x3E, 0x04, 0x3E, 0x3E,
  0x0E, 0x7E, 0x3F, 0x1F, 0x7E, 0x1F, 0x3E, 0x7E, 0x1F, 0xFC, 0x7C, 0x0F,
  0xF8, 0x7C, 0x0F, 0xF0, 0xFC, 0x07, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x02, 0x07,
  0xE0, 0xE0, 0xFC, 0x3E, 0x1F, 0x8F, 0xE3, 0xE3, 0xF0, 0x7C, 0xFC, 0x0F,
  0xBF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x1C, 0x1F, 0x0F, 0xBF, 0x1F, 0xC7, 0xDF, 0xDF, 0xE3, 0xFF, 0xEF, 0xF1,
  0xE9, 0xFC, 0xF8, 0xF8, 0xFC, 0x7C, 0xF8, 0x7C, 0x3E, 0x7C, 0x3E, 0x1F,
  0x3E, 0x1F, 0x0F, 0x9E, 0x0F, 0x07, 0x8F, 0x07, 0x83, 0xC7, 0x83, 0xC1,
  0xE7, 0xC3, 0xE1, 0xF3, 0xE1, 0xF0, 0xF9, 0xF0, 0xF8, 0x7C, 0xF0, 0x78,
  0x3C, 0x78, 0x3C, 0x1E, 0x3C, 0x1E, 0x0F, 0x3E, 0x1F, 0x0F, 0x9F, 0x0F,
  0x87, 0xCF, 0x87, 0xC3, 0xE7, 0x83, 0xC1, 0xE0, 0x0F, 0xC3, 0xE0, 0x3E,
  0x3F, 0xE0, 0xF9, 0xFF, 0x83, 0xEF, 0xFF, 0x1F, 0xB0, 0xFC, 0x7F, 0x83,
  0xF1, 0xFC, 0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x80, 0x7C, 0x7C, 0x01, 0xF3,
  0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0,
  0x0F, 0x8F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F,
  0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF3, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0x83, 0xF8, 0xFC,
  0x03, 0xE7, 0xE0, 0x0F, 0x9F, 0x80, 0x3F, 0x7C, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFB, 0xF0, 0x07, 0xEF,
  0xC0, 0x1F, 0xBF, 0x00, 0x7C, 0x7C, 0x03, 0xF1, 0xF8, 0x3F, 0x83, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC1,
  0xF0, 0x07, 0xC7, 0xFC, 0x07, 0xCF, 0xFE, 0x0F, 0xDF, 0xFE, 0x0F, 0xF8,
  0x7E, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80,
  0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0xFC, 0x3F, 0x83, 0xFC, 0x3E, 0xFF, 0xF8, 0x3E, 0xFF, 0xF0, 0x3E, 0x7F,
  0xE0, 0x7E, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x7C, 0x1F, 0xF9,
  0xF0, 0xFF, 0xE7, 0xC7, 0xFF, 0xFF, 0x3F, 0x83, 0xFC, 0xFC, 0x07, 0xF7,
  0xE0, 0x0F, 0x9F, 0x80, 0x3E, 0x7C, 0x00, 0xFB, 0xF0, 0x07, 0xEF, 0xC0,
  0x1F, 0xBF, 0x00, 0x7E, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3F,
  0x3F, 0x01, 0xFC, 0xFC, 0x0F, 0xF3, 0xF8, 0x7F, 0xC7, 0xFF, 0xBE, 0x1F,
  0xFC, 0xF8, 0x3F, 0xE3, 0xE0, 0x3E, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x7D,
  0xFF, 0xC7, 0xE7, 0xFE, 0x3F, 0xBF, 0xF9, 0xFE, 0x03, 0xEF, 0xF8, 0x1F,
  0xB0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xF8, 0x1F, 0x0F,
  0x80, 0x30, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xC4, 0x00, 0x7E, 0x30, 0x03, 0xF3, 0xE0, 0x3F, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x08, 0x07, 0xE0, 0x60, 0x3F, 0x07, 0x81, 0xF0, 0xFE, 0x0F,
  0x8F, 0xC0, 0x7C, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0xFC,
  0x03, 0xF7, 0xE0, 0x1F, 0xBE, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E,
  0x7C, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF0, 0x07, 0xCF, 0x80,
  0x3E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x9F, 0x01, 0xFC, 0xF8, 0x1F, 0xE7,
  0xE1, 0xBE, 0x3F, 0xF9, 0xF1, 0xFF, 0xCF, 0x87, 0xFC, 0xFC, 0x0F, 0x87,
  0xE0, 0x7F, 0xC0, 0x33, 0xFF, 0x07, 0xEF, 0xFC, 0x1F, 0xBF, 0xE0, 0x3E,
  0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F,
  0x80, 0xFC, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x01,
  0xF8, 0x7C, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x1F, 0xC0,
  0xF9, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x3F,
  0x00, 0x00, 0x1E, 0x1F, 0x06, 0x3E, 0x1F, 0x3E, 0x3E, 0x1E, 0x1E, 0x3C,
  0x1E, 0x1E, 0x3C, 0x1E, 0x1F, 0x3C, 0x1E, 0x1F, 0x3C, 0x3E, 0x1F, 0x7C,
  0x3E, 0x1F, 0x7C, 0x3C, 0x1F, 0x78, 0x3C, 0x1F, 0x78, 0x3C, 0x1E, 0x78,
  0x3C, 0x1E, 0x78, 0x7C, 0x1E, 0xF8, 0x7C, 0x3E, 0xF8, 0x7C, 0x3C, 0xF0,
  0x78, 0x3C, 0xF0, 0xF8, 0x78, 0xF9, 0xB8, 0x78, 0xFF, 0xBC, 0xF0, 0xFF,
  0x3F, 0xE0, 0x7E, 0x3F, 0xC0, 0x3C, 0x1F, 0x00, 0x00, 0xF8, 0x1E, 0x00,
  0xFF, 0x0F, 0xE0, 0x7F, 0xC7, 0xF8, 0x7F, 0xFB, 0xFF, 0x3F, 0xBE, 0xC7,
  0xCF, 0xCF, 0xE1, 0xF1, 0xC1, 0xF8, 0x7C, 0x60, 0xFC, 0x1F, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x87, 0xE0, 0x63, 0xC1, 0xF8, 0x38,
  0xF8, 0xDE, 0x3F, 0x3E, 0x37, 0xDF, 0xCF, 0xFD, 0xFF, 0xC1, 0xFE, 0x3F,
  0xE0, 0x7F, 0x0F, 0xF0, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0x7C, 0x3E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0,
  0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x7E, 0x01,
  0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x3F,
  0x0F, 0x80, 0x7E, 0x1F, 0x01, 0xFC, 0x3E, 0x07, 0xF8, 0x7E, 0x1B, 0xE0,
  0xFF, 0xF7, 0xC0, 0xFF, 0xCF, 0x81, 0xFF, 0x3F, 0x00, 0xF8, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x60, 0x1F, 0x81, 0xE0,
  0x7F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x1F, 0x07, 0xFF, 0x1E, 0x0F, 0xFF, 0x9E, 0x1F,
  0xFF, 0xFE, 0x1F, 0x07, 0xFE, 0x1E, 0x01, 0xFC, 0x1E, 0x03, 0xF8, 0x1E,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x10, 0x03, 0xF0, 0x78, 0x0F, 0xE0, 0x78, 0x1F,
  0xC0, 0x3C, 0x3F, 0xC0, 0x3C, 0x7F, 0xFE, 0x3C, 0x7F, 0xFF, 0xFC, 0x79,
  0xFF, 0xFC, 0xF8, 0x7F, 0xF8, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0,
  0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78,
  0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x01, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x0E, 0x0F, 0xF0, 0x0F, 0x1F, 0xF8,
  0x1F, 0x3F, 0xFC, 0x1E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x78, 0x3F,
  0xFC, 0x78, 0x1F, 0xF8, 0xF0, 0x0F, 0xF0, 0x30, 0x07, 0xC0,
};

const GFXglyph IBMPlexMono_SemiBoldItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 11, 30, 26, 8, -30 },
  { 43, 16, 13, 26, 7, -32 },
  { 69, 27, 30, 26, 0, -30 },
  { 171, 24, 38, 26, 1, -34 },
  { 285, 30, 30, 26, -1, -30 },
  { 398, 26, 30, 26, 0, -30 },
  { 496, 7, 13, 26, 12, -32 },
  { 508, 17, 39, 26, 8, -33 },
  { 591, 18, 39, 26, 1, -33 },
  { 679, 23, 22, 26, 2, -24 },
  { 743, 21, 20, 26, 3, -23 },
  { 796, 12, 13, 26, 5, -7 },
  { 816, 14, 5, 26, 6, -16 },
  { 825, 9, 8, 26, 7, -8 },
  { 834, 26, 39, 26, 0, -33 },
  { 961, 23, 30, 26, 2, -30 },
  { 1048, 21, 30, 26, 2, -30 },
  { 1127, 24, 30, 26, 1, -30 },
  { 1217, 24, 30, 26, 1, -30 },
  { 1307, 24, 30, 26, 0, -30 },
  { 1397, 24, 30, 26, 1, -30 },
  { 1487, 22, 30, 26, 2, -30 },
  { 1570, 22, 30, 26, 4, -30 },
  { 1653, 24, 30, 26, 1, -30 },
  { 1743, 22, 30, 26, 3, -30 },
  { 1826, 11, 23, 26, 7, -23 },
  { 1858, 13, 29, 26, 5, -23 },
  { 1906, 21, 25, 26, 4, -26 },
  { 1972, 23, 14, 26, 2, -20 },
  { 2013, 21, 25, 26, 2, -26 },
  { 2079, 19, 30, 26, 5, -30 },
  { 2151, 23, 35, 26, 2, -30 },
  { 2252, 24, 30, 26, -1, -30 },
  { 2342, 23, 30, 26, 2, -30 },
  { 2429, 24, 30, 26, 2, -30 },
  { 2519, 24, 30, 26, 1, -30 },
  { 2609, 24, 30, 26, 2, -30 },
  { 2699, 24, 30, 26, 2, -30 },
  { 2789, 23, 30, 26, 2, -30 },
  { 2876, 25, 30, 26, 1, -30 },
  { 2970, 25, 30, 26, 1, -30 },
  { 3064, 23, 30, 26, 2, -30 },
  { 3151, 27, 30, 26, 1, -30 },
  { 3253, 19, 30, 26, 3, -30 },
  { 3325, 27, 30, 26, 0, -30 },
  { 3427, 25, 30, 26, 1, -30 },
  { 3521, 23, 30, 26, 2, -30 },
  { 3608, 23, 30, 26, 2, -30 },
  { 3695, 23, 39, 26, 2, -30 },
  { 3808, 23, 30, 26, 2, -30 },
  { 3895, 24, 30, 26, 1, -30 },
  { 3985, 25, 30, 26, 3, -30 },
  { 4079, 24, 30, 26, 2, -30 },
  { 4169, 24, 30, 26, 4, -30 },
  { 4259, 27, 30, 26, 1, -30 },
  { 4361, 29, 30, 26, -1, -30 },
  { 4470, 25, 30, 26, 4, -30 },
  { 4564, 26, 30, 26, 0, -30 },
  { 4662, 19, 39, 26, 6, -33 },
  { 4755, 12, 39, 26, 7, -33 },
  { 4814, 20, 39, 26, 1, -33 },
  { 4912, 23, 19, 26, 2, -30 },
  { 4967, 21, 4, 26, 0, 4 },
  { 4978, 8, 10, 26, 8, -35 },
  { 4988, 22, 22, 26, 2, -22 },
  { 5049, 23, 32, 26, 1, -32 },
  { 5141, 20, 22, 26, 3, -22 },
  { 5196, 24, 32, 26, 2, -32 },
  { 5292, 20, 22, 26, 3, -22 },
  { 5347, 29, 41, 26, -1, -32 },
  { 5496, 24, 31, 26, 1, -22 },
  { 5589, 22, 32, 26, 1, -32 },
  { 5677, 21, 33, 26, 3, -33 },
  { 5764, 21, 42, 26, 1, -33 },
  { 5875, 24, 32, 26, 1, -32 },
  { 5971, 19, 32, 26, 4, -32 },
  { 6047, 25, 22, 26, 0, -22 },
  { 6116, 22, 22, 26, 1, -22 },
  { 6177, 22, 22, 26, 2, -22 },
  { 6238, 24, 31, 26, 0, -22 },
  { 6331, 22, 31, 26, 2, -22 },
  { 6417, 22, 22, 26, 4, -22 },
  { 6478, 21, 22, 26, 2, -22 },
  { 6536, 21, 30, 26, 3, -30 },
  { 6615, 21, 22, 26, 3, -22 },
  { 6673, 22, 22, 26, 2, -22 },
  { 6734, 24, 22, 26, 1, -22 },
  { 6800, 26, 22, 26, 0, -22 },
  { 6872, 23, 31, 26, 1, -22 },
  { 6962, 24, 22, 26, 1, -22 },
  { 7028, 21, 39, 26, 4, -33 },
  { 7131, 11, 39, 26, 8, -33 },
  { 7185, 21, 39, 26, 1, -33 },
  { 7288, 24, 10, 26, 1, -18 },
};

const GFXfont IBMPlexMono_SemiBoldItalic43pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic43pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic43pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC43PT7B_H_
