#ifndef _IBMPLEXMONO_SEMIBOLDITALIC63PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0xFF, 0x07, 0xF9, 0xFC, 0x0F,
  0xF3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE,
  0x7F, 0x83, 0xFC, 0xFF, 0x07, 0xF9, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7,
  0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x3F, 0xC0, 0xFE, 0x7F, 0x83, 0xFC, 0xFE,
  0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x08, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xF9, 0xF3, 0xFE, 0x03, 0xFE, 0x1F, 0x0F, 0xC0, 0x3F,
  0xC1, 0xF0, 0x78, 0x07, 0xF8, 0x1F, 0x03, 0x00, 0x7F, 0x81, 0xF0, 0x00,
  0x07, 0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x83, 0xE0, 0x00, 0x07, 0xF8, 0x3E,
  0x00, 0x00, 0x7F, 0x83, 0xE0, 0x00, 0x07, 0xFC, 0x3E, 0x00, 0x00, 0x7F,
  0xF3, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x9F, 0xF8,
  0x00, 0x00, 0xF8, 0xFF, 0xC0, 0x00, 0x0F, 0x87, 0xFC, 0x00, 0x01, 0xF8,
  0x3F, 0xC0, 0x00, 0x1F, 0x03, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0xC0, 0x00,
  0x1F, 0x03, 0xFC, 0x0C, 0x01, 0xF0, 0x3F, 0xC1, 0xE0, 0x1F, 0x07, 0xF8,
  0x3F, 0x03, 0xF0, 0xFF, 0x87, 0xFC, 0x3E, 0x1F, 0xF8, 0xFF, 0xF3, 0xE7,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x1F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0x80,
  0x7E, 0x00, 0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x81, 0xFC,
  0x00, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x00,
  0x7E, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x00, 0x7E,
  0x03, 0xF0, 0xFC, 0x00, 0x03, 0xE0, 0x3F, 0x1F, 0xC0, 0x00, 0x3F, 0x0F,
  0xE1, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xC7,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xE3, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x7F, 0xFF, 0xC0, 0x00, 0x1F,
  0x87, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x0F,
  0xC0, 0x7C, 0x00, 0x07, 0xE1, 0xF8, 0x07, 0xC0, 0x00, 0xFE, 0x1F, 0x80,
  0x7C, 0x00, 0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0xFC,
  0x00, 0x3F, 0x81, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x00,
  0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x00, 0xFC,
  0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x00, 0x7F, 0xF3, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x03, 0xFC, 0xFF, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x83, 0xFC, 0x01, 0xFE, 0x03, 0x8F, 0xF0, 0x03, 0xFC, 0x1F, 0xBF,
  0xC0, 0x1F, 0xF0, 0x7F, 0x7F, 0x80, 0x7F, 0xC3, 0xF9, 0xFE, 0x03, 0xFF,
  0x9F, 0xC7, 0xFC, 0x1E, 0xFE, 0x7F, 0x1F, 0xFF, 0xF3, 0xFF, 0xF8, 0x7F,
  0xFF, 0xCF, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x7F,
  0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F,
  0x8F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0xC7, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x1F, 0xE3, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x10, 0x03, 0xF8, 0x01, 0x1F, 0x01, 0xFC,
  0x07, 0x8F, 0xE0, 0xFE, 0x1F, 0xCF, 0xFE, 0xFE, 0x7F, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x0F,
  0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x04, 0x00, 0x10, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0,
  0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x0F, 0xC3, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE7, 0xFC, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x3F,
  0xCF, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x81, 0xF0, 0x7F, 0xFF, 0xE1,
  0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0x87, 0xFF, 0xFE, 0x1F, 0xE1, 0xFE, 0xFF,
  0x07, 0xF8, 0x7F, 0xBF, 0xC1, 0xFC, 0x3F, 0xEF, 0xF0, 0x3E, 0x0F, 0xFB,
  0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x1F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFE, 0x07, 0xFE,
  0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xDF, 0xE0, 0x01, 0xFF, 0x3F, 0xC0, 0x07, 0xFE, 0x7F, 0x80,
  0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x03,
  0xFE, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F,
  0xC0, 0x7F, 0x80, 0x1F, 0x01, 0xFE, 0x00, 0x1C, 0x03, 0xFC, 0x00, 0x10,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0xFF,
  0x81, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0x00, 0x03, 0xFE, 0x00, 0x20, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFC, 0x0F, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0x00, 0x07,
  0xFC, 0x01, 0xC0, 0x00, 0xFF, 0x80, 0x10, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x80, 0x00, 0x1F, 0xE0, 0x38, 0x00,
  0x07, 0xFC, 0x0F, 0x00, 0x00, 0xFF, 0x87, 0xF0, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xE0,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x0F,
  0xF0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x07,
  0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x07, 0xE1, 0xFF, 0xE0, 0x00, 0xFC, 0x7F, 0xFF, 0x00, 0x3F,
  0x9F, 0xFF, 0xF0, 0x07, 0xF7, 0xFF, 0xFF, 0x00, 0xFD, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0x80, 0x1F,
  0xF8, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x04, 0x00, 0x01, 0xFF, 0x01, 0xC0, 0x00, 0x3F, 0xE0, 0x78, 0x00, 0x0F,
  0xF8, 0x3F, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0xC0,
  0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x7F,
  0x00, 0x0F, 0xF1, 0xFF, 0xE0, 0x1F, 0xF3, 0xFF, 0xF0, 0x1F, 0xE7, 0xFF,
  0xF8, 0x3F, 0xCF, 0xFF, 0xFC, 0x3F, 0xDF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xF8, 0x0F, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03,
  0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x0F,
  0xFC, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x01, 0xFF, 0x1F,
  0xC0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xF0,
  0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFE, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC,
  0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0,
  0x0F, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xFC,
  0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x80,
  0x0F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F,
  0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x3F, 0xCF,
  0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x7F,
  0xF8, 0xFF, 0xFF, 0xFB, 0xFC, 0x3F, 0xFF, 0xFD, 0xFE, 0x0F, 0xFF, 0xFD,
  0xFE, 0x07, 0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xFC, 0xFF, 0x00, 0x3F, 0xF8,
  0xFF, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFE,
  0x07, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE,
  0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0x7F, 0xF0, 0xFF, 0xF0,
  0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x02, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE7, 0xFE, 0x07, 0xFF,
  0x7F, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0x00, 0x0F, 0xF1, 0xE0,
  0x00, 0xFF, 0x06, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xE0, 0x7F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x0F, 0x87,
  0xF1, 0xF8, 0x0F, 0xF9, 0xFC, 0xFE, 0x07, 0xFF, 0x7E, 0x3F, 0x83, 0xFF,
  0xDF, 0x8F, 0xC1, 0xFF, 0xF7, 0xE3, 0xF0, 0x7F, 0x87, 0xF9, 0xFC, 0x3F,
  0x80, 0xFE, 0x7F, 0x0F, 0xE0, 0x3F, 0x9F, 0xC3, 0xF0, 0x0F, 0xC7, 0xE1,
  0xFC, 0x03, 0xF1, 0xF8, 0x7F, 0x00, 0xFC, 0xFE, 0x1F, 0xC0, 0x3F, 0x3F,
  0x87, 0xE0, 0x1F, 0xCF, 0xE1, 0xF8, 0x07, 0xF3, 0xF8, 0xFE, 0x01, 0xF8,
  0xFC, 0x3F, 0x80, 0x7E, 0x3F, 0x0F, 0xE0, 0x1F, 0x8F, 0xC3, 0xF8, 0x0F,
  0xE3, 0xF0, 0xFE, 0x03, 0xF8, 0xFC, 0x3F, 0x81, 0xFE, 0x3F, 0x07, 0xE0,
  0xFF, 0x0F, 0xC1, 0xFC, 0x6F, 0xC3, 0xF0, 0x7F, 0xFB, 0xF0, 0xFC, 0x1F,
  0xFC, 0xFC, 0x3F, 0x03, 0xFF, 0x7F, 0x0F, 0xC0, 0x7F, 0x9F, 0xC3, 0xF0,
  0x07, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00,
  0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x0F, 0xF7, 0xFC,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF,
  0x81, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFC,
  0x01, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F,
  0xC3, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x07,
  0xFE, 0x1F, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xE0,
  0x00, 0x3F, 0x8F, 0xF8, 0x00, 0x0E, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x02, 0x00, 0xFF,
  0x00, 0x01, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC3,
  0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xFC, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x87, 0xF8,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x7F,
  0xC3, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x01, 0xFF, 0x0F, 0xF0, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xE0, 0x07, 0xFE,
  0x07, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x3F, 0x87, 0xFC, 0x00, 0x0E, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0xF1, 0xFE, 0x03, 0xFF,
  0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0x3F, 0xE0, 0x3F, 0xFF, 0xCF, 0xF8, 0x0F,
  0xFF, 0xE3, 0xFE, 0x03, 0xFF, 0xF8, 0xFF, 0x80, 0x00, 0xFE, 0x3F, 0xE0,
  0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0xFF,
  0x80, 0x01, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF8, 0x03, 0xFF,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xEF, 0xE0, 0x3F, 0xFF, 0xF3,
  0xF8, 0x07, 0xFF, 0xFC, 0xFE, 0x00, 0xFF, 0xFE, 0x7F, 0x80, 0x1F, 0xFF,
  0x1F, 0xE0, 0x03, 0xFF, 0x87, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x10, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x04, 0x00, 0x1F, 0xE0, 0x3F, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFC,
  0x03, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xF8, 0x00, 0x07,
  0xF8, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0xFF,
  0xC0, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00,
  0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x0F, 0xF7, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x7F,
  0xC0, 0x00, 0x1F, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFC,
  0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFF, 0x87, 0xEF,
  0xE0, 0x3F, 0x3F, 0x1F, 0x9F, 0x80, 0xFE, 0x7E, 0x7F, 0x7F, 0x01, 0xFC,
  0xFC, 0xFC, 0xFE, 0x03, 0xF9, 0xFF, 0xF9, 0xFC, 0x07, 0xF3, 0xFF, 0xE3,
  0xF8, 0x0F, 0xE3, 0xFF, 0xC7, 0xF0, 0x1F, 0xC7, 0xFF, 0x1F, 0xC0, 0x7F,
  0x0F, 0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0xE0,
  0xFE, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF0,
  0x3F, 0x80, 0xFE, 0x03, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0x00, 0xFE, 0x03,
  0xF8, 0x0E, 0x03, 0xFC, 0x07, 0xF0, 0x18, 0x07, 0xF0, 0x1F, 0xE0, 0x10,
  0x0F, 0xE0, 0x3F, 0x80, 0x40, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0x01, 0xFF,
  0xC0, 0x07, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xE0,
  0x3F, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x3F, 0xFC, 0x00,
  0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xE0, 0x7F, 0xFE, 0x01, 0xFE, 0x07, 0xFF,
  0xE0, 0x1F, 0xC0, 0x7F, 0xFE, 0x01, 0xFC, 0x07, 0xF7, 0xE0, 0x1F, 0xC0,
  0x7F, 0x7F, 0x01, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xC0, 0xFE, 0x7F, 0x03,
  0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x80, 0xFE, 0x3F, 0x03, 0xF8, 0x0F, 0xE3,
  0xF8, 0x3F, 0x80, 0xFE, 0x3F, 0x83, 0xF8, 0x0F, 0xE3, 0xF8, 0x3F, 0x81,
  0xFC, 0x3F, 0x87, 0xF8, 0x1F, 0xC1, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xC7,
  0xF0, 0x1F, 0xC1, 0xFC, 0x7F, 0x01, 0xFC, 0x1F, 0xC7, 0xF0, 0x1F, 0xC1,
  0xFC, 0x7F, 0x03, 0xF8, 0x0F, 0xC7, 0xF0, 0x3F, 0x80, 0xFE, 0xFE, 0x03,
  0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0x80, 0xFE, 0xFE, 0x03, 0xF8, 0x0F, 0xEF,
  0xE0, 0x3F, 0x80, 0x7F, 0xFE, 0x07, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0x00,
  0x7F, 0xFC, 0x07, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0x00, 0x7F, 0xFC, 0x07,
  0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0x3F, 0xFC, 0x0F, 0xF0, 0x03, 0xFF,
  0xC0, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xE0, 0x03, 0xFF, 0x80, 0xFE, 0x00,
  0x1F, 0xF8, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x01,
  0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xEF, 0xF0, 0x00,
  0x0F, 0xFB, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x07, 0xFC, 0xFF,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xC3,
  0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFE,
  0x07, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0x07, 0xFC, 0x00,
  0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xC3,
  0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xC0, 0x0F, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x01, 0xFE,
  0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x0F,
  0xFB, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0x7F, 0xCF, 0xF0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x00,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xC3, 0xFE,
  0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFE, 0x07,
  0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0xC0, 0x00, 0x3F, 0xC0, 0x78, 0x00, 0x07, 0xF8, 0x3F, 0x00, 0x01,
  0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x07, 0xFF,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x1F,
  0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x00, 0x78, 0x03,
  0xFC, 0x00, 0x03, 0x00, 0x7F, 0xC0, 0x00, 0x20, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x0C,
  0x00, 0x00, 0xFF, 0x81, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0x00, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F,
  0xF1, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFE, 0x0F,
  0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x01,
  0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0x80,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x3F,
  0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0,
  0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x1F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F,
  0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x07, 0xF7, 0xF8, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xC0, 0xFF, 0x81, 0xFC,
  0x1F, 0xC0, 0xFF, 0x81, 0xF8, 0x1F, 0xC0, 0xFF, 0x83, 0xF8, 0x1F, 0xC1,
  0xFF, 0x83, 0xF8, 0x1F, 0xC1, 0xFF, 0x83, 0xF8, 0x1F, 0xC1, 0xFF, 0x83,
  0xF0, 0x1F, 0xC3, 0xFF, 0x87, 0xF0, 0x1F, 0xC3, 0xFF, 0x87, 0xF0, 0x1F,
  0xC3, 0xEF, 0x87, 0xF0, 0x1F, 0xC3, 0xEF, 0x87, 0xE0, 0x1F, 0x87, 0xCF,
  0x87, 0xE0, 0x3F, 0x87, 0xCF, 0x8F, 0xE0, 0x3F, 0x87, 0xCF, 0x8F, 0xE0,
  0x3F, 0x8F, 0x8F, 0x8F, 0xE0, 0x3F, 0x8F, 0x8F, 0x8F, 0xC0, 0x3F, 0x8F,
  0x8F, 0x9F, 0xC0, 0x3F, 0x9F, 0x0F, 0x9F, 0xC0, 0x3F, 0x9F, 0x1F, 0x9F,
  0xC0, 0x3F, 0x9F, 0x1F, 0x9F, 0x80, 0x3F, 0x3E, 0x1F, 0x9F, 0x80, 0x3F,
  0x3E, 0x1F, 0xBF, 0x80, 0x7F, 0x3E, 0x1F, 0xBF, 0x80, 0x7F, 0x7C, 0x1F,
  0xBF, 0x00, 0x7F, 0x7C, 0x1F, 0xBF, 0x00, 0x7F, 0x7C, 0x1F, 0xBF, 0x00,
  0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFE,
  0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xF0,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x07,
  0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0x00, 0x00, 0x1F,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x02, 0x00, 0xF0,
  0x7F, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFE,
  0x07, 0xE0, 0x7E, 0x03, 0xD0, 0x30, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0xFF,
  0xF0, 0xFF, 0x01, 0xFF, 0xF8, 0xFF, 0x03, 0xFF, 0xFC, 0xFF, 0x07, 0xFF,
  0xFC, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xF0,
  0x07, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0,
  0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80,
  0x03, 0xFC, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00,
  0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x00,
  0x3F, 0xF0, 0xFF, 0x80, 0x6F, 0xF0, 0xFF, 0xC1, 0xEF, 0xF0, 0x7F, 0xFF,
  0xCF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFE, 0x3F, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x80,
  0x0F, 0xF0, 0x7F, 0xF0, 0x07, 0xF8, 0xFF, 0xFC, 0x03, 0xFC, 0xFF, 0xFF,
  0x01, 0xFE, 0x7F, 0xFF, 0x81, 0xFE, 0x7F, 0xFF, 0xE0, 0xFF, 0x78, 0x3F,
  0xF0, 0x7F, 0xB8, 0x07, 0xFC, 0x3F, 0xF8, 0x03, 0xFE, 0x1F, 0xF8, 0x00,
  0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x3F, 0xC7, 0xFC, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xC0,
  0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF1, 0xFF,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F,
  0xF8, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xF7, 0xFF, 0xFE, 0x0F,
  0xF3, 0xFF, 0xFE, 0x07, 0xF8, 0xFF, 0xFE, 0x03, 0xFC, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x1F, 0xE0,
  0x03, 0xF0, 0xFF, 0x80, 0x07, 0x03, 0xFC, 0x00, 0x10, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x06, 0x0F, 0xF0, 0x00, 0x1E, 0x3F, 0xC0, 0x00, 0xFC, 0xFF, 0x80,
  0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xC7, 0xFC, 0x01, 0xFE, 0x1F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x03, 0xFF, 0x83, 0xFC, 0x01, 0xFF,
  0xFC, 0x7F, 0x00, 0x7F, 0xFF, 0x9F, 0xE0, 0x1F, 0xFF, 0xFB, 0xFC, 0x07,
  0xFF, 0xFF, 0x7F, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xE0, 0x07, 0xFE,
  0x0F, 0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x01,
  0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xC1, 0xFF, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0,
  0x07, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0x80, 0x77, 0xF8, 0x1F,
  0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0xBF, 0xC0, 0x3F, 0xFF, 0xE7, 0xF8,
  0x03, 0xFF, 0xF8, 0xFF, 0x00, 0x3F, 0xFF, 0x1F, 0xE0, 0x03, 0xFF, 0x83,
  0xFC, 0x00, 0x1F, 0xC0, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xC7, 0xFC, 0x00, 0xFF,
  0x1F, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xFD, 0xFE, 0x00, 0xFF, 0xEF, 0xF8,
  0x3F, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x08, 0x3F, 0xC0, 0x00, 0x78,
  0xFF, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0xFF, 0x1F,
  0xF8, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x08, 0x03, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x7F,
  0x80, 0x00, 0x01, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xF7, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x03, 0xFF, 0xC3, 0xFC, 0x01, 0xFF,
  0xFC, 0x7F, 0x80, 0x7F, 0xFF, 0x9F, 0xE0, 0x1F, 0xFF, 0xFB, 0xFC, 0x07,
  0xFF, 0xFF, 0x7F, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xE0, 0x07, 0xFE,
  0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x01,
  0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x03, 0xF8, 0x3F,
  0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xE0,
  0x0F, 0xFE, 0x07, 0xFC, 0x03, 0xBF, 0xC0, 0x7F, 0xE0, 0xF7, 0xF8, 0x0F,
  0xFF, 0xFC, 0xFE, 0x00, 0xFF, 0xFF, 0xBF, 0xC0, 0x1F, 0xFF, 0xE7, 0xF8,
  0x01, 0xFF, 0xF8, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x18, 0x00, 0x3F, 0xE0, 0x07,
  0x80, 0x0F, 0xF8, 0x01, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x07,
  0xF8, 0x3F, 0xF8, 0x07, 0xF8, 0x7F, 0xFC, 0x07, 0xF8, 0xFF, 0xFE, 0x07,
  0xF9, 0xFF, 0xFE, 0x07, 0xFB, 0xFF, 0xFE, 0x07, 0xFB, 0x83, 0xFF, 0x0F,
  0xFF, 0x01, 0xFF, 0x0F, 0xF6, 0x00, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x0F,
  0xF8, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x1F,
  0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x1F,
  0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x3F,
  0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F,
  0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x7F,
  0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0xFF,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x02, 0x00, 0x7F,
  0x80, 0x38, 0x03, 0xFC, 0x03, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x03,
  0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0,
  0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x04, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0xFF,
  0x00, 0x3F, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x1F, 0xF1, 0xFE,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x3F, 0xC1, 0xFF, 0xC0, 0x07, 0xF8, 0x7F, 0xFC, 0x00,
  0xFF, 0x1F, 0xFF, 0xC0, 0x1F, 0xE7, 0xFF, 0xFC, 0x03, 0xFD, 0xFF, 0xFF,
  0x80, 0x7F, 0xB8, 0x3F, 0xF0, 0x1F, 0xEE, 0x03, 0xFE, 0x03, 0xFF, 0x80,
  0x3F, 0xC0, 0x7F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC,
  0x00, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xE3, 0xFF, 0x00, 0x07, 0xF9, 0xFF,
  0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFC,
  0x7F, 0xC0, 0x20, 0x7F, 0x87, 0xF8, 0x0E, 0x0F, 0xF0, 0xFF, 0x03, 0xE3,
  0xFC, 0x0F, 0xF0, 0xFF, 0x7F, 0x81, 0xFE, 0x3F, 0xCF, 0xF0, 0x3F, 0xEF,
  0xF1, 0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0xC0, 0x7F, 0xFF, 0x07, 0xF8, 0x07,
  0xFF, 0xC1, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x02, 0x00, 0xFF, 0x00, 0xE0, 0x1F, 0xE0,
  0x3E, 0x03, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x03,
  0xFC, 0x3F, 0xE0, 0x7F, 0x8F, 0xF8, 0x0F, 0xF3, 0xFE, 0x01, 0xFC, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xF8,
  0x07, 0xC0, 0x3F, 0x1F, 0xE0, 0xFF, 0x01, 0xF9, 0xFF, 0x8F, 0xFC, 0x0F,
  0xCF, 0xFC, 0xFF, 0xF0, 0xFE, 0xFF, 0xE7, 0xFF, 0x87, 0xF4, 0x7F, 0x63,
  0xFC, 0x3F, 0xC1, 0xFA, 0x0F, 0xE1, 0xFC, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x1F, 0xC7, 0xF0, 0x1F, 0x80, 0xFC,
  0x3F, 0x81, 0xFC, 0x07, 0xE1, 0xFC, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F,
  0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x1F, 0xC3, 0xF0, 0x1F, 0x80, 0xFE, 0x3F,
  0x80, 0xFC, 0x07, 0xE1, 0xFC, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x7E, 0x03, 0xF8, 0x1F, 0xC3, 0xF0, 0x1F, 0xC0, 0xFE, 0x1F, 0x80,
  0xFC, 0x07, 0xF1, 0xFC, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x7F, 0x01, 0xF8,
  0x7F, 0x03, 0xF8, 0x1F, 0xC3, 0xF0, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFE,
  0x07, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x8F, 0xE0, 0x3F, 0x01, 0xF8, 0x7F,
  0x03, 0xF8, 0x0F, 0xC3, 0xF8, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0xFE, 0x07,
  0xF0, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF8,
  0x3F, 0xF8, 0x07, 0xF8, 0x7F, 0xFC, 0x07, 0xF8, 0xFF, 0xFE, 0x07, 0xF9,
  0xFF, 0xFE, 0x07, 0xFB, 0xFF, 0xFE, 0x07, 0xFB, 0x83, 0xFF, 0x0F, 0xFF,
  0x01, 0xFF, 0x0F, 0xF6, 0x00, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x0F, 0xF8,
  0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xF0,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0,
  0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0,
  0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0,
  0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80,
  0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80,
  0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFE, 0x3F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xF0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x03, 0xF8, 0x00, 0x3F, 0xC1, 0xFF, 0xC0, 0x07, 0xF8, 0xFF, 0xFC, 0x00,
  0xFF, 0x3F, 0xFF, 0xC0, 0x1F, 0xE7, 0xFF, 0xF8, 0x07, 0xF9, 0xFF, 0xFF,
  0x80, 0xFF, 0x78, 0x3F, 0xF0, 0x1F, 0xEE, 0x01, 0xFF, 0x03, 0xFF, 0x80,
  0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F,
  0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x87, 0xF8, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xDF, 0xFF, 0xF8, 0x0F, 0xF3, 0xFF,
  0xFE, 0x01, 0xFE, 0x3F, 0xFF, 0x80, 0x3F, 0xC3, 0xFF, 0xC0, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x7F,
  0x80, 0x3F, 0xF8, 0x3F, 0xC0, 0x7F, 0xFF, 0x1F, 0xC0, 0x7F, 0xFF, 0x9F,
  0xE0, 0x7F, 0xFF, 0xEF, 0xF0, 0x7F, 0xFF, 0xF7, 0xF8, 0x7F, 0xF0, 0x3F,
  0xFC, 0x3F, 0xE0, 0x07, 0xFE, 0x3F, 0xE0, 0x01, 0xFE, 0x1F, 0xF0, 0x00,
  0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xF1, 0xFF, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0xC7, 0xF8,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xFC, 0x3F, 0xE0, 0x1D, 0xFE, 0x1F,
  0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xFE, 0xFF, 0x03, 0xFF, 0xFE, 0x7F, 0x80,
  0xFF, 0xFE, 0x3F, 0xC0, 0x3F, 0xFE, 0x1F, 0xE0, 0x0F, 0xFE, 0x0F, 0xF0,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7E, 0xFF, 0xFF,
  0x07, 0xFD, 0xFF, 0xFE, 0x1F, 0xFB, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x80, 0x3F, 0xDF, 0xFF, 0x00, 0x7F, 0xBC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFF, 0x81, 0xFE, 0x00, 0x3E, 0x07, 0xF8, 0x00, 0x38, 0x0F, 0xF0, 0x00,
  0x20, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x08,
  0x00, 0x07, 0xF8, 0x30, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x18, 0x00, 0xFF, 0x00, 0xF0, 0x03, 0xFC, 0x03, 0xF0, 0x07, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0xF0, 0x1F, 0xE1, 0xFF, 0xC0, 0x3F, 0xC7,
  0xFE, 0x00, 0x7F, 0xBF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01,
  0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01,
  0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03,
  0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03,
  0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07,
  0xF8, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x00, 0x3F,
  0xF0, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0xDF, 0xE0, 0xFF, 0xC3, 0xDF,
  0xE0, 0xFF, 0xFF, 0x9F, 0xE0, 0x7F, 0xFF, 0x9F, 0xE0, 0x7F, 0xFF, 0x1F,
  0xE0, 0x3F, 0xFE, 0x3F, 0xC0, 0x1F, 0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x18, 0x7F, 0xFC, 0x00, 0x7C, 0xFF, 0xFC, 0x03,
  0xFC, 0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0xFC, 0x01,
  0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x01,
  0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01,
  0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x07,
  0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF,
  0xC0, 0x1F, 0xE1, 0xFF, 0x80, 0x1F, 0xC7, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x81, 0xF8, 0x0F,
  0xC1, 0xF8, 0x3F, 0x01, 0xF8, 0x7F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0xFC,
  0x07, 0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F, 0x81, 0xF8,
  0xFE, 0x07, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x80,
  0xFC, 0x7E, 0x03, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x03, 0xF3, 0xF8, 0x1F,
  0xC0, 0x7E, 0x7F, 0x03, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x01, 0xF9, 0xF8,
  0x0F, 0xC0, 0x7F, 0x3F, 0x01, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F, 0x01, 0xFD,
  0xFC, 0x0F, 0xE0, 0x3F, 0x3F, 0x81, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x01,
  0xFC, 0xFC, 0x07, 0xE0, 0x3F, 0x9F, 0x80, 0xFC, 0x07, 0xE3, 0xF0, 0x3F,
  0x80, 0xFC, 0x7E, 0x07, 0xF0, 0x3F, 0x1F, 0xC1, 0xFE, 0x07, 0xE3, 0xF8,
  0x3F, 0xC1, 0xF8, 0x7F, 0x8E, 0xF8, 0x7F, 0x0F, 0xFF, 0xDF, 0x1F, 0xC0,
  0xFF, 0xF3, 0xFF, 0xF0, 0x1F, 0xFE, 0x7F, 0xFC, 0x03, 0xFF, 0x8F, 0xFF,
  0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFF, 0x07, 0xFF,
  0x80, 0x7F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xF7,
  0xE3, 0x8F, 0xF3, 0xFF, 0x1F, 0xDC, 0x1F, 0xC7, 0xF8, 0x7F, 0x70, 0x7F,
  0x0F, 0x81, 0xFD, 0x81, 0xFC, 0x1C, 0x07, 0xFE, 0x07, 0xF0, 0x40, 0x1F,
  0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x40, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x20, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x20, 0xFE, 0x07, 0xFC, 0x03, 0xC3, 0xF8, 0x1B, 0xF0,
  0x1F, 0x0F, 0xE0, 0xEF, 0xC1, 0xFE, 0x3F, 0x83, 0xBF, 0x8F, 0xFC, 0xFF,
  0x1C, 0x7E, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFE, 0x07, 0xFF, 0x87, 0xFF,
  0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x3F,
  0xF0, 0x1F, 0xE0, 0x0D, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0xEF, 0xF0, 0x07, 0xFF, 0xFD, 0xFE, 0x00, 0xFF, 0xFF, 0x3F, 0xC0, 0x0F,
  0xFF, 0xC7, 0xF8, 0x01, 0xFF, 0xF0, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xC0,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x10, 0x00,
  0x3F, 0xC0, 0x07, 0x80, 0x0F, 0xF8, 0x01, 0xFC, 0x07, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F, 0xFE, 0x07, 0xF0, 0x3F,
  0xFF, 0xE1, 0xFC, 0x1F, 0xFF, 0xFE, 0x7F, 0x07, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0x00, 0x7F, 0xFE,
  0x1F, 0xC0, 0x07, 0xFF, 0x07, 0xF0, 0x01, 0xFF, 0x01, 0xF8, 0x00, 0xFF,
  0x80, 0x7E, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x70, 0x00, 0xFF, 0xC0, 0x7C, 0x00, 0x7F, 0xC0, 0x3F, 0x00,
  0x3F, 0xE0, 0x07, 0xE0, 0x1F, 0xF0, 0x01, 0xF8, 0x1F, 0xF8, 0x00, 0x7F,
  0x0F, 0xFE, 0x00, 0x0F, 0xC7, 0xFF, 0xFC, 0x03, 0xF1, 0xFF, 0xFF, 0xF8,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x8F, 0xFF, 0xFF, 0x8F, 0xE0, 0x7F,
  0xFF, 0xE3, 0xF8, 0x07, 0xFF, 0xF0, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x40, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x06,
  0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0x03, 0xFF, 0xE0,
  0x07, 0xE0, 0xFF, 0xFE, 0x01, 0xFC, 0x3F, 0xFF, 0xE0, 0x3F, 0x07, 0xFF,
  0xFC, 0x0F, 0xE1, 0xFE, 0x7F, 0xC1, 0xFC, 0x3F, 0x87, 0xFC, 0x7F, 0x0F,
  0xE0, 0x7F, 0xFF, 0xE1, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0x00, 0xFF, 0xFF,
  0x0F, 0xE0, 0x0F, 0xFF, 0xC1, 0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0x00, 0x0F,
  0xFC, 0x00, 0xE0, 0x00, 0x7E, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 17, 45, 38, 11, -44 },
  { 97, 23, 20, 38, 11, -47 },
  { 155, 40, 44, 38, 0, -44 },
  { 375, 36, 58, 38, 1, -51 },
  { 636, 44, 46, 38, -2, -45 },
  { 889, 38, 46, 38, 0, -45 },
  { 1108, 11, 20, 38, 17, -47 },
  { 1136, 26, 57, 38, 11, -48 },
  { 1322, 26, 57, 38, 2, -48 },
  { 1508, 33, 32, 38, 3, -35 },
  { 1640, 31, 30, 38, 4, -34 },
  { 1757, 17, 19, 38, 7, -10 },
  { 1798, 21, 7, 38, 9, -23 },
  { 1817, 12, 11, 38, 11, -10 },
  { 1834, 38, 57, 38, 0, -48 },
  { 2105, 34, 46, 38, 3, -45 },
  { 2301, 31, 44, 38, 3, -44 },
  { 2472, 35, 45, 38, 1, -45 },
  { 2669, 35, 46, 38, 1, -45 },
  { 2871, 35, 44, 38, 1, -44 },
  { 3064, 35, 45, 38, 2, -44 },
  { 3261, 32, 45, 38, 3, -44 },
  { 3441, 34, 44, 38, 5, -44 },
  { 3628, 35, 46, 38, 2, -45 },
  { 3830, 33, 45, 38, 4, -45 },
  { 4016, 16, 33, 38, 11, -32 },
  { 4082, 20, 41, 38, 7, -32 },
  { 4185, 31, 37, 38, 5, -38 },
  { 4329, 33, 20, 38, 3, -29 },
  { 4412, 31, 37, 38, 3, -38 },
  { 4556, 28, 46, 38, 7, -45 },
  { 4717, 34, 52, 38, 3, -45 },
  { 4938, 36, 44, 38, -2, -44 },
  { 5136, 34, 44, 38, 2, -44 },
  { 5323, 34, 46, 38, 4, -45 },
  { 5519, 35, 44, 38, 2, -44 },
  { 5712, 35, 44, 38, 3, -44 },
  { 5905, 36, 44, 38, 3, -44 },
  { 6103, 34, 46, 38, 3, -45 },
  { 6299, 36, 44, 38, 2, -44 },
  { 6497, 35, 44, 38, 2, -44 },
  { 6690, 34, 45, 38, 2, -44 },
  { 6882, 40, 44, 38, 2, -44 },
  { 7102, 29, 44, 38, 4, -44 },
  { 7262, 39, 44, 38, 0, -44 },
  { 7477, 36, 44, 38, 2, -44 },
  { 7675, 34, 46, 38, 3, -45 },
  { 7871, 34, 44, 38, 3, -44 },
  { 8058, 34, 58, 38, 3, -45 },
  { 8305, 35, 44, 38, 2, -44 },
  { 8498, 36, 46, 38, 1, -45 },
  { 8705, 36, 44, 38, 5, -44 },
  { 8903, 34, 45, 38, 4, -44 },
  { 9095, 35, 44, 38, 6, -44 },
  { 9288, 40, 44, 38, 1, -44 },
  { 9508, 43, 44, 38, -2, -44 },
  { 9745, 37, 44, 38, 5, -44 },
  { 9949, 39, 44, 38, 0, -44 },
  { 10164, 29, 57, 38, 8, -48 },
  { 10371, 17, 57, 38, 11, -48 },
  { 10493, 28, 57, 38, 2, -48 },
  { 10693, 33, 27, 38, 3, -44 },
  { 10805, 32, 7, 38, -1, 5 },
  { 10833, 12, 14, 38, 12, -50 },
  { 10854, 32, 34, 38, 3, -33 },
  { 10990, 33, 48, 38, 2, -47 },
  { 11188, 30, 34, 38, 4, -33 },
  { 11316, 35, 48, 38, 3, -47 },
  { 11526, 30, 34, 38, 4, -33 },
  { 11654, 43, 60, 38, -2, -47 },
  { 11977, 35, 46, 38, 1, -33 },
  { 12179, 32, 47, 38, 2, -47 },
  { 12367, 29, 49, 38, 5, -48 },
  { 12545, 32, 61, 38, 1, -48 },
  { 12789, 35, 48, 38, 2, -47 },
  { 12999, 27, 48, 38, 6, -47 },
  { 13161, 37, 33, 38, 0, -33 },
  { 13314, 32, 33, 38, 2, -33 },
  { 13446, 32, 34, 38, 3, -33 },
  { 13582, 35, 46, 38, 0, -33 },
  { 13784, 33, 46, 38, 3, -33 },
  { 13974, 31, 33, 38, 6, -33 },
  { 14102, 31, 34, 38, 3, -33 },
  { 14234, 31, 45, 38, 4, -44 },
  { 14409, 32, 34, 38, 4, -33 },
  { 14545, 32, 34, 38, 3, -33 },
  { 14681, 35, 34, 38, 1, -33 },
  { 14830, 38, 34, 38, 0, -33 },
  { 14992, 35, 46, 38, 1, -33 },
  { 15194, 34, 34, 38, 2, -33 },
  { 15339, 31, 57, 38, 6, -48 },
  { 15560, 17, 57, 38, 11, -48 },
  { 15682, 30, 57, 38, 2, -48 },
  { 15896, 35, 16, 38, 2, -27 },
};

const GFXfont IBMPlexMono_SemiBoldItalic63pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic63pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic63pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC63PT7B_H_
