#ifndef _IBMPLEXMONO_SEMIBOLDITALIC69PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8,
  0x1F, 0xE3, 0xF8, 0x0F, 0xF3, 0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xF8, 0xFF,
  0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x9F,
  0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1,
  0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFE,
  0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xE7, 0xEF, 0xFE, 0x01, 0xFF, 0x87, 0xE3, 0xFC,
  0x03, 0xFF, 0x07, 0xE0, 0xF8, 0x03, 0xFE, 0x07, 0xC0, 0x60, 0x03, 0xFE,
  0x07, 0xC0, 0x40, 0x03, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x0F, 0xC0,
  0x00, 0x07, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xFC, 0x0F, 0xC0, 0x00, 0x03,
  0xFC, 0x0F, 0x80, 0x00, 0x03, 0xFE, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0x1F,
  0x80, 0x00, 0x03, 0xFF, 0xDF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x7F, 0xF0, 0x00, 0x00, 0x7E,
  0x3F, 0xF8, 0x00, 0x00, 0x7E, 0x1F, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xF8,
  0x00, 0x00, 0x7E, 0x0F, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xF8, 0x00, 0x00,
  0x7C, 0x0F, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xF8, 0x04, 0x00, 0xFC, 0x0F,
  0xF8, 0x06, 0x00, 0xFC, 0x0F, 0xF8, 0x0F, 0x00, 0xFC, 0x1F, 0xF0, 0x3F,
  0x80, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xF8, 0x7F, 0xE0, 0xFF, 0xF8, 0xF9,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xF0,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80,
  0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x7F, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0xFC, 0x00,
  0x03, 0xF0, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC3, 0xF8, 0x00,
  0x03, 0xF0, 0x1F, 0xC3, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x87, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x0F, 0xC0, 0x00,
  0x00, 0xFF, 0xFC, 0x10, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF1, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC3, 0xF8, 0x1F, 0xC0,
  0x00, 0x1F, 0xC3, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x0F, 0xC0,
  0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xC0,
  0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0,
  0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0x80,
  0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80,
  0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x7F, 0xF3, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xFE, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x01, 0xC7, 0xFC, 0x00,
  0xFF, 0x80, 0xF3, 0xFE, 0x00, 0x7F, 0xC0, 0xFE, 0xFF, 0x00, 0x3F, 0xF0,
  0xFF, 0x7F, 0xC0, 0x3F, 0xF8, 0x7F, 0x3F, 0xE0, 0x19, 0xFC, 0x7F, 0x1F,
  0xFC, 0x3C, 0xFF, 0x7F, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0x83, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xC0, 0x07, 0xF0, 0x03, 0x07, 0xC0, 0x7F, 0x80, 0xFC, 0x7F,
  0xC3, 0xFC, 0x3F, 0xE3, 0xFF, 0x9F, 0xEF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x87, 0xF8,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0x0F, 0xE1, 0xFF, 0x9F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0x9F, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x03, 0xFC, 0x7F,
  0xC0, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x07,
  0xF9, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0xC0,
  0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x7E, 0x07, 0xFD,
  0xFF, 0x07, 0xF8, 0x3F, 0xEF, 0xF8, 0x3F, 0xC1, 0xFF, 0x7F, 0xC3, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0x87, 0xFF, 0xFF,
  0x03, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0x81, 0xFF, 0x7F, 0xC0, 0x00, 0x0F,
  0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x07, 0xFE, 0xFF, 0x80,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xF9,
  0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00,
  0x3F, 0xE1, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F,
  0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0xCF, 0xF8,
  0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xFC, 0x7F,
  0xC0, 0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xF0,
  0x0F, 0xF8, 0x00, 0x38, 0x03, 0xFE, 0x00, 0x04, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFE,
  0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xE0,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x60, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xF8,
  0x00, 0x3F, 0xF0, 0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x0E, 0x00, 0x01, 0xFF,
  0x00, 0x10, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x18,
  0x00, 0x00, 0xFF, 0x80, 0xF0, 0x00, 0x07, 0xFE, 0x07, 0xC0, 0x00, 0x1F,
  0xF8, 0x7F, 0x80, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFF,
  0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00,
  0xFF, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F,
  0xC1, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x00, 0x7F, 0x87, 0xFF, 0xC0, 0x01, 0xFC, 0x7F, 0xFF, 0x80,
  0x07, 0xF3, 0xFF, 0xFF, 0x80, 0x1F, 0xDF, 0xFF, 0xFE, 0x00, 0xFF, 0x7F,
  0xFF, 0xFC, 0x03, 0xFB, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0x3F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x08, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x02, 0x00, 0x00, 0x3F, 0xE0, 0x3C, 0x00, 0x01,
  0xFF, 0x81, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF,
  0xE0, 0x03, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x83, 0xFC,
  0x00, 0x3F, 0xE1, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xFF, 0x01, 0xFF, 0x3F,
  0xFF, 0xF0, 0x3F, 0xEF, 0xFF, 0xFF, 0x0F, 0xFB, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFE, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x1F, 0xFD,
  0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFD,
  0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x0F,
  0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0xC7, 0xF0, 0x00,
  0x0F, 0xFC, 0x7F, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF,
  0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0x00, 0x03, 0xFE,
  0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F,
  0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F,
  0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xFC,
  0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x3F,
  0xF3, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x07, 0xFF,
  0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0,
  0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFE,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x1F, 0xFE,
  0x7F, 0xF8, 0x0F, 0xFF, 0xCF, 0xFF, 0xFF, 0xEF, 0xF8, 0xFF, 0xFF, 0xFB,
  0xFE, 0x1F, 0xFF, 0xFE, 0x7F, 0xC1, 0xFF, 0xFF, 0x9F, 0xF0, 0x1F, 0xFF,
  0xE3, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF,
  0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x81,
  0xFF, 0x80, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x0F,
  0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xF8, 0x1F, 0xFE, 0x7F, 0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xF9, 0xF8, 0x00, 0x3F, 0xF0, 0xE0, 0x00, 0x7F,
  0xE0, 0x40, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xE3, 0xFC, 0x07,
  0xFC, 0x7F, 0x1F, 0xC0, 0x7F, 0xF3, 0xF8, 0xFE, 0x07, 0xFF, 0xDF, 0xCF,
  0xF0, 0x7F, 0xFE, 0xFE, 0x7F, 0x03, 0xFC, 0x3F, 0xE3, 0xF8, 0x3F, 0xC0,
  0xFF, 0x1F, 0xC1, 0xFC, 0x03, 0xF9, 0xFE, 0x1F, 0xE0, 0x1F, 0xCF, 0xF0,
  0xFE, 0x00, 0xFE, 0x7F, 0x07, 0xF0, 0x07, 0xF3, 0xF8, 0x7F, 0x80, 0x3F,
  0x9F, 0xC3, 0xF8, 0x03, 0xF8, 0xFE, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0xFE,
  0x00, 0xFE, 0x7F, 0x87, 0xF0, 0x07, 0xF3, 0xF8, 0x3F, 0x80, 0x3F, 0x9F,
  0xC1, 0xFC, 0x03, 0xFC, 0xFE, 0x0F, 0xE0, 0x1F, 0xC7, 0xF0, 0x7F, 0x00,
  0xFE, 0x3F, 0x83, 0xF8, 0x0F, 0xF1, 0xFC, 0x1F, 0xC0, 0x7F, 0x8F, 0xE0,
  0xFE, 0x07, 0xFC, 0x7F, 0x07, 0xF8, 0xEF, 0xE3, 0xF8, 0x3F, 0xFF, 0xFE,
  0x1F, 0xC0, 0xFF, 0xF7, 0xF0, 0xFE, 0x07, 0xFF, 0xBF, 0x87, 0xF0, 0x1F,
  0xF9, 0xFC, 0x3F, 0x80, 0x7F, 0x8F, 0xE1, 0xFC, 0x01, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xDF, 0xE0, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x00, 0xFF, 0x9F, 0xE0,
  0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0x07, 0xFF,
  0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFE,
  0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0x7F, 0xC3, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF8,
  0x7F, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF,
  0x8F, 0xFC, 0x00, 0x03, 0xE0, 0x7F, 0xC0, 0x00, 0x10, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x08, 0x01, 0xFF, 0x00, 0x00, 0x78, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xC0,
  0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0xC1, 0xFE, 0x00,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00,
  0xFC, 0x3F, 0xF0, 0x00, 0x08, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xFC, 0xFF, 0xC0,
  0x7F, 0xFF, 0xCF, 0xF8, 0x07, 0xFF, 0xFC, 0xFF, 0x80, 0x7F, 0xFF, 0xCF,
  0xF8, 0x07, 0xFF, 0xFC, 0xFF, 0x80, 0x7F, 0xFF, 0xCF, 0xF8, 0x07, 0xFF,
  0xF8, 0xFF, 0x80, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x80,
  0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0x8F,
  0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xC0,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x1E, 0xFE, 0x03,
  0xFF, 0xFF, 0xDF, 0xE0, 0x3F, 0xFF, 0xFD, 0xFE, 0x01, 0xFF, 0xFF, 0x9F,
  0xE0, 0x0F, 0xFF, 0xF1, 0xFE, 0x00, 0x7F, 0xFE, 0x1F, 0xE0, 0x03, 0xFF,
  0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1E, 0x00, 0x07, 0xFC, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x83, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xC1, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC3,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xCF, 0xFC,
  0x00, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xBF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xBF, 0xF0, 0x00, 0x01, 0xFF, 0xF1, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x01,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x3F, 0xDF, 0xC3, 0xFB, 0xF8, 0x07, 0xFB,
  0xF8, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x1F, 0xDF, 0xE0, 0x1F, 0xCF, 0xE7,
  0xF3, 0xFC, 0x03, 0xF9, 0xFC, 0xFE, 0x7F, 0x00, 0xFF, 0x1F, 0xFF, 0x8F,
  0xE0, 0x1F, 0xE3, 0xFF, 0xF3, 0xFC, 0x03, 0xFC, 0x7F, 0xFC, 0x7F, 0x80,
  0x7F, 0x8F, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0xE1, 0xFE, 0x01, 0xFC,
  0x1F, 0xF8, 0x3F, 0x80, 0x7F, 0x83, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7F,
  0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0xFE, 0x07,
  0xF8, 0x07, 0xF8, 0x1F, 0x80, 0xFF, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x7C, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0x80, 0xFF, 0x00, 0xFF,
  0x00, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1C, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x60, 0x0F, 0xE0, 0x1F, 0xE0, 0x08, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0xF0,
  0x01, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFE,
  0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x03, 0xFF,
  0xF0, 0x01, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFC, 0x03, 0xFF, 0xF8, 0x03,
  0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFC, 0x03,
  0xFB, 0xF8, 0x03, 0xFC, 0x07, 0xFB, 0xFC, 0x03, 0xF8, 0x07, 0xFB, 0xFC,
  0x07, 0xF8, 0x07, 0xF9, 0xFC, 0x07, 0xF8, 0x07, 0xF9, 0xFC, 0x07, 0xF8,
  0x07, 0xF9, 0xFC, 0x07, 0xF8, 0x07, 0xF1, 0xFE, 0x07, 0xF8, 0x0F, 0xF1,
  0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x0F,
  0xF0, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x0F,
  0xE0, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F,
  0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x9F, 0xE0,
  0x1F, 0xE0, 0x7F, 0x9F, 0xE0, 0x1F, 0xC0, 0x3F, 0x9F, 0xE0, 0x3F, 0xC0,
  0x3F, 0x9F, 0xC0, 0x3F, 0xC0, 0x3F, 0xBF, 0xC0, 0x3F, 0xC0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F,
  0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0x80, 0x1F,
  0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xFF, 0x80,
  0x7F, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFC, 0x7F,
  0xC0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x0F,
  0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0xC0,
  0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x07, 0xFD,
  0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x0F,
  0xFB, 0xFE, 0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x07, 0xFE, 0xFF, 0x80,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xF9,
  0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00,
  0x7F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F,
  0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFE,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x00,
  0x03, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07,
  0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xFC,
  0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF,
  0x3F, 0xF0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xBF,
  0xF0, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x00,
  0x07, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF8,
  0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x20, 0x00, 0x0F, 0xF8, 0x03, 0x80, 0x00,
  0x3F, 0xE0, 0x3E, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x7F,
  0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00,
  0xFF, 0xC1, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x07,
  0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00,
  0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x01,
  0xFF, 0x80, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0x00,
  0x00, 0x60, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x04, 0x00, 0x00, 0x1F, 0xF0,
  0x0E, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0x80,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x83,
  0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFC, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00,
  0x3F, 0xF3, 0xFE, 0x00, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x00, 0xFF, 0x8F,
  0xF8, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x7F, 0xC1,
  0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0xFF, 0x80, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xFC,
  0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0x01, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x03, 0xF8, 0x0F,
  0xF0, 0x3F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0xE0,
  0x7F, 0x01, 0xFE, 0x0F, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0xE0, 0xFE,
  0x01, 0xFE, 0x1F, 0xBE, 0x0F, 0xE0, 0x1F, 0xE1, 0xF3, 0xE0, 0xFE, 0x01,
  0xFC, 0x1F, 0x3E, 0x1F, 0xE0, 0x1F, 0xC3, 0xF3, 0xE1, 0xFC, 0x01, 0xFC,
  0x3E, 0x3E, 0x1F, 0xC0, 0x1F, 0xC3, 0xE3, 0xE1, 0xFC, 0x03, 0xFC, 0x7E,
  0x3E, 0x3F, 0xC0, 0x3F, 0xC7, 0xC7, 0xE3, 0xF8, 0x03, 0xFC, 0x7C, 0x7E,
  0x3F, 0x80, 0x3F, 0xCF, 0xC7, 0xE3, 0xF8, 0x03, 0xFC, 0xFC, 0x7E, 0x3F,
  0x80, 0x3F, 0x8F, 0x87, 0xE7, 0xF8, 0x03, 0xF9, 0xF8, 0x7E, 0x7F, 0x00,
  0x3F, 0x9F, 0x87, 0xE7, 0xF0, 0x03, 0xF9, 0xF0, 0x7E, 0x7F, 0x00, 0x3F,
  0xBF, 0x07, 0xE7, 0xF0, 0x07, 0xFB, 0xF0, 0x7E, 0xFE, 0x00, 0x7F, 0xBE,
  0x07, 0xEF, 0xE0, 0x07, 0xFF, 0xE0, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE3, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xDF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00,
  0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x03,
  0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x87, 0xFC,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F,
  0xBF, 0xE0, 0x00, 0x03, 0xFE, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0xE0, 0x00,
  0x00, 0x78, 0x01, 0x00, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0x00, 0x7C, 0x1F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF,
  0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xF0,
  0x06, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0xC1, 0xFE, 0x00,
  0xFF, 0xFE, 0x3F, 0xE0, 0x1F, 0xFF, 0xF3, 0xFE, 0x03, 0xFF, 0xFF, 0x3F,
  0xE0, 0x7F, 0xFF, 0xFB, 0xFE, 0x0F, 0xFF, 0xFF, 0xBF, 0xE0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x3F,
  0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0x87, 0xFC, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0xFF,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF,
  0x80, 0x0F, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0xFE,
  0x07, 0xFE, 0x0F, 0xBF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xFF,
  0x3F, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x03, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0xF8, 0x03, 0xFC,
  0x7F, 0xFF, 0xC0, 0x7F, 0xC7, 0xFF, 0xFC, 0x07, 0xFC, 0xFF, 0xFF, 0xE0,
  0x7F, 0xDF, 0xFF, 0xFE, 0x07, 0xFD, 0xE0, 0x7F, 0xF0, 0x7F, 0xBC, 0x03,
  0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0x0F, 0xFE,
  0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0xFF, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xF3,
  0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xE0,
  0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0x87,
  0xFD, 0xFF, 0xFF, 0xF0, 0x7F, 0xDF, 0xFF, 0xFE, 0x07, 0xF9, 0xFF, 0xFF,
  0xC0, 0x7F, 0x8F, 0xFF, 0xF8, 0x0F, 0xF8, 0x7F, 0xFF, 0x00, 0xFF, 0x83,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x3F,
  0x07, 0xFC, 0x00, 0x1E, 0x07, 0xFE, 0x00, 0x04, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x81, 0xFF, 0x00, 0x00, 0x70, 0xFF, 0x80,
  0x00, 0x7C, 0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x3F,
  0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0xFE, 0x3F, 0xE0, 0x07, 0xFF, 0xFC, 0x7F,
  0xC0, 0x1F, 0xFF, 0xFC, 0xFF, 0x80, 0x7F, 0xFF, 0xF9, 0xFE, 0x01, 0xFF,
  0xFF, 0xFB, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF,
  0x80, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFE, 0x00,
  0xEF, 0xF8, 0x07, 0xFF, 0x07, 0xDF, 0xE0, 0x0F, 0xFF, 0xFF, 0x3F, 0xC0,
  0x1F, 0xFF, 0xFE, 0xFF, 0x80, 0x1F, 0xFF, 0xF9, 0xFF, 0x00, 0x1F, 0xFF,
  0xE3, 0xFE, 0x00, 0x3F, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x1F,
  0xF1, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFE, 0x3F, 0xE0, 0x00,
  0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x7F, 0xF1, 0xFF, 0x03,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x30, 0x3F, 0xE0, 0x00, 0x1F, 0x07, 0xF8, 0x00, 0x0F,
  0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x03, 0xFE, 0x0F, 0xFE, 0x03,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x38, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x1F, 0xF0, 0x03, 0xFF,
  0xFC, 0x7F, 0xC0, 0x1F, 0xFF, 0xF1, 0xFF, 0x00, 0xFF, 0xFF, 0xE7, 0xFC,
  0x07, 0xFF, 0xFF, 0xDF, 0xE0, 0x3F, 0xFF, 0xFF, 0x7F, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00,
  0x7F, 0x83, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07,
  0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF,
  0x80, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0xF0, 0x1F, 0xFC, 0x1F, 0x7F, 0xC0, 0x7F, 0xFF, 0xFD, 0xFF, 0x00, 0xFF,
  0xFF, 0xE7, 0xF8, 0x03, 0xFF, 0xFF, 0x1F, 0xE0, 0x07, 0xFF, 0xF8, 0xFF,
  0x80, 0x0F, 0xFF, 0xC3, 0xFE, 0x00, 0x1F, 0xFE, 0x0F, 0xF8, 0x00, 0x1F,
  0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x04, 0x00,
  0x03, 0xFE, 0x00, 0x38, 0x00, 0x1F, 0xF8, 0x01, 0xF0, 0x00, 0xFF, 0xC0,
  0x0F, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x1F,
  0xC0, 0x03, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0xF0, 0x0F, 0xF8,
  0xFF, 0xFE, 0x01, 0xFF, 0x3F, 0xFF, 0xE0, 0x7F, 0xCF, 0xFF, 0xFC, 0x0F,
  0xF9, 0xFF, 0xFF, 0xC1, 0xFF, 0x78, 0x3F, 0xF8, 0x3F, 0xEE, 0x01, 0xFF,
  0x07, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xE0, 0x07, 0xFC, 0x3F, 0xF8, 0x00,
  0x7F, 0x87, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0xC0, 0x03, 0xFE, 0x1F, 0xF0,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xE0,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x1F,
  0xE0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x01, 0xFE,
  0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01,
  0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x02, 0x00, 0x07, 0xF8, 0x01, 0x80, 0x03, 0xFC, 0x01, 0xE0,
  0x03, 0xFE, 0x01, 0xF8, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x81, 0xFF,
  0x80, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0xC0, 0x07, 0xF8, 0x00, 0x3C, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x3F,
  0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF8,
  0x1F, 0xF0, 0x01, 0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03,
  0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x00,
  0x03, 0xFE, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xFE, 0x00, 0x3F, 0xE3,
  0xFF, 0xFC, 0x00, 0xFF, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0xFF, 0xFF, 0xE0,
  0x1F, 0xF3, 0xFF, 0xFF, 0x80, 0x7F, 0xDE, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0x80,
  0xFF, 0xE0, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xFC, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F,
  0xF0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0xF0, 0x00, 0x1F,
  0xF7, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x18, 0x3F, 0xE1, 0xFF, 0x00, 0xF0, 0xFF,
  0x83, 0xFE, 0x07, 0xE3, 0xFE, 0x0F, 0xF8, 0x3F, 0xCF, 0xF0, 0x1F, 0xF1,
  0xFF, 0x7F, 0xC0, 0x7F, 0xCF, 0xF9, 0xFF, 0x01, 0xFF, 0xFF, 0xC7, 0xFC,
  0x03, 0xFF, 0xFE, 0x1F, 0xF0, 0x0F, 0xFF, 0xF0, 0x7F, 0xC0, 0x1F, 0xFF,
  0x81, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x30, 0x03, 0xFE, 0x01, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC1, 0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC7, 0xFE, 0x01, 0xFE, 0x3F, 0xF0,
  0x07, 0xF9, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x7E, 0x01, 0xF8, 0x07,
  0xF8, 0xFF, 0x03, 0xFE, 0x07, 0xF1, 0xFF, 0x8F, 0xFE, 0x07, 0xF3, 0xFF,
  0x8F, 0xFF, 0x07, 0xF7, 0xFF, 0x9F, 0xFF, 0x07, 0xF7, 0xFF, 0xBF, 0xFF,
  0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0x0F, 0xF8,
  0x3F, 0xF0, 0x7F, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x0F, 0xF0, 0x3F, 0xC0,
  0x7F, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x1F,
  0xE0, 0x3F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F,
  0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x80, 0xFE,
  0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x3F, 0xC0,
  0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x01,
  0xFC, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x7F,
  0x80, 0xFE, 0x03, 0xFC, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE,
  0x03, 0xF8, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x03, 0xF8,
  0x7F, 0x01, 0xFC, 0x03, 0xF8, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0xFE, 0x01,
  0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0x7F,
  0xC1, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xFE, 0x01, 0xFF, 0x1F, 0xFF, 0xC0,
  0x3F, 0xC7, 0xFF, 0xFC, 0x0F, 0xF9, 0xFF, 0xFF, 0x81, 0xFF, 0x3F, 0xFF,
  0xF8, 0x3F, 0xEF, 0x07, 0xFF, 0x07, 0xFD, 0xC0, 0x3F, 0xE0, 0xFF, 0xF0,
  0x07, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xF0, 0xFF,
  0xC0, 0x01, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFE,
  0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x1F, 0xF8, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x8F, 0xF0, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x83, 0xFE,
  0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xFF, 0x00,
  0x0F, 0xF0, 0x7F, 0xFE, 0x00, 0x7F, 0xC7, 0xFF, 0xFC, 0x01, 0xFF, 0x1F,
  0xFF, 0xF0, 0x07, 0xFC, 0xFF, 0xFF, 0xE0, 0x1F, 0xF7, 0xFF, 0xFF, 0x80,
  0x7F, 0xDE, 0x07, 0xFF, 0x01, 0xFE, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x00,
  0x1F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0x03,
  0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00,
  0x3F, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0xFF,
  0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFE,
  0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x81, 0xFF, 0x7F, 0xFF, 0xFC, 0x07, 0xFD, 0xFF, 0xFF, 0xE0, 0x1F, 0xE7,
  0xFF, 0xFF, 0x00, 0x7F, 0x8F, 0xFF, 0xF8, 0x03, 0xFE, 0x1F, 0xFF, 0xC0,
  0x0F, 0xF8, 0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0xFF,
  0x1F, 0xF0, 0x1F, 0xFF, 0xF1, 0xFF, 0x03, 0xFF, 0xFF, 0x9F, 0xF0, 0x7F,
  0xFF, 0xF9, 0xFE, 0x0F, 0xFF, 0xFF, 0xDF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE,
  0x1F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xF0, 0x00,
  0x7F, 0xE3, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xC7, 0xFC,
  0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x07, 0xFC,
  0x7F, 0xC0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00,
  0x7F, 0x8F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x07,
  0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xC0, 0x1D, 0xFF, 0x07, 0xFF,
  0x07, 0xDF, 0xE0, 0x7F, 0xFF, 0xF9, 0xFE, 0x07, 0xFF, 0xFF, 0xBF, 0xE0,
  0x3F, 0xFF, 0xF3, 0xFE, 0x01, 0xFF, 0xFE, 0x3F, 0xE0, 0x1F, 0xFF, 0xC3,
  0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xDF, 0xFF, 0xF0, 0x3F, 0xF7, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xBF, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF,
  0xF9, 0xFF, 0xF8, 0x03, 0xFE, 0x7F, 0xFE, 0x00, 0xFF, 0xBF, 0xFF, 0x80,
  0x3F, 0xEF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x1E, 0x01, 0xFE, 0x00, 0x03,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x40, 0x00, 0x1F,
  0xF0, 0x38, 0x00, 0x07, 0xFC, 0x3F, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x03,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x08, 0x00, 0x7F, 0x80, 0x1E, 0x00, 0x7F, 0xC0, 0x1F,
  0x80, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F,
  0xF8, 0x07, 0xFC, 0x3F, 0xF8, 0x03, 0xFC, 0x3F, 0xF8, 0x01, 0xFE, 0x7F,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE1,
  0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F,
  0xE1, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x1F, 0xF0, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x0F, 0xF8, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xF8,
  0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF0, 0x01, 0xFF,
  0xC3, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xC0, 0x0D, 0xFE, 0x0F, 0xFC, 0x03,
  0xFF, 0xC1, 0xFF, 0xC1, 0xEF, 0xF8, 0x1F, 0xFF, 0xFD, 0xFF, 0x03, 0xFF,
  0xFF, 0x3F, 0xE0, 0x7F, 0xFF, 0xC7, 0xFC, 0x07, 0xFF, 0xF0, 0xFF, 0x00,
  0x7F, 0xFE, 0x1F, 0xE0, 0x07, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0x0F, 0xFF, 0xE0, 0x03, 0xF1, 0xFF, 0xFC,
  0x03, 0xFE, 0x3F, 0xFF, 0x80, 0x7F, 0xE7, 0xFF, 0xF0, 0x07, 0xFD, 0xFF,
  0xFC, 0x00, 0xFF, 0xBF, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xE0, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F, 0xF0,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x3F, 0xF0, 0x07,
  0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xE7, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x30,
  0x3F, 0x80, 0xFE, 0x07, 0xC0, 0xFC, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x0F,
  0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x0F, 0xE1,
  0xFC, 0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x1F, 0xC0, 0xFF, 0x1F, 0x80, 0x7F,
  0x03, 0xFC, 0xFE, 0x01, 0xF8, 0x07, 0xF3, 0xF8, 0x0F, 0xE0, 0x1F, 0xCF,
  0xE0, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8,
  0x0F, 0xF3, 0xF0, 0x0F, 0xE0, 0x3F, 0xDF, 0xC0, 0x3F, 0x80, 0xFE, 0x7F,
  0x01, 0xFC, 0x03, 0xF9, 0xFC, 0x07, 0xF0, 0x0F, 0xE7, 0xF0, 0x1F, 0xC0,
  0x3F, 0x9F, 0xC0, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFC, 0x03, 0xFB, 0xF8,
  0x07, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0xFE, 0x01,
  0xFC, 0xFE, 0x03, 0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0,
  0x7F, 0x80, 0xFE, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF8, 0x3F,
  0xC3, 0xF8, 0x7F, 0xE0, 0xFE, 0x0F, 0xFF, 0xDF, 0xC7, 0xF0, 0x3F, 0xFF,
  0x7F, 0xFF, 0xC0, 0xFF, 0xF9, 0xFF, 0xFE, 0x03, 0xFF, 0xE3, 0xFF, 0xF0,
  0x07, 0xFF, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x03, 0xFE, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x7F, 0xFC,
  0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xF9, 0xFD, 0xF1, 0xFE, 0x3F, 0xF8, 0x7F,
  0x78, 0x3F, 0x87, 0xFC, 0x1F, 0xDC, 0x0F, 0xF0, 0xFC, 0x07, 0xFE, 0x03,
  0xFC, 0x1E, 0x01, 0xFF, 0x80, 0xFF, 0x06, 0x00, 0x7F, 0xC0, 0x3F, 0x80,
  0x00, 0x1F, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x00, 0x40, 0xFE, 0x01, 0xFF,
  0x80, 0x30, 0x3F, 0x80, 0x7F, 0xE0, 0x3E, 0x0F, 0xE0, 0x3B, 0xF8, 0x1F,
  0xC3, 0xF8, 0x0E, 0xFE, 0x1F, 0xF8, 0xFF, 0x07, 0xBF, 0x8F, 0xFE, 0x3F,
  0xC3, 0xCF, 0xE7, 0xFE, 0x0F, 0xFF, 0xF3, 0xFF, 0xFF, 0x03, 0xFF, 0xF8,
  0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01,
  0xFE, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xC0,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0x80,
  0x37, 0xFC, 0x07, 0xFE, 0x01, 0xDF, 0xE0, 0x0F, 0xFC, 0x1E, 0x7F, 0x80,
  0x3F, 0xFF, 0xFB, 0xFE, 0x00, 0xFF, 0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0xFF,
  0x3F, 0xE0, 0x07, 0xFF, 0xF8, 0xFF, 0x80, 0x0F, 0xFF, 0xC3, 0xFC, 0x00,
  0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x08, 0x00, 0x07, 0xFE, 0x00, 0x30, 0x00, 0x1F,
  0xF0, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x1F, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x03, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xE0, 0x1F, 0xFF, 0xF8, 0x3F, 0x80,
  0xFF, 0xFF, 0xF9, 0xFE, 0x03, 0xFF, 0xFF, 0xF7, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xFF, 0xFE, 0x0F,
  0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0xFE, 0x00, 0x1F,
  0xFC, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x01,
  0x00, 0x00, 0xFF, 0xC0, 0x1E, 0x00, 0x07, 0xFE, 0x01, 0xF8, 0x00, 0x7F,
  0xF0, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x1F, 0xF8, 0x00, 0x3F,
  0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x0F, 0xFF, 0x80, 0x03, 0xF8, 0x7F, 0xFF,
  0xF0, 0x07, 0xE1, 0xFF, 0xFF, 0xFF, 0x1F, 0x87, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFC, 0x07,
  0xFF, 0xFF, 0x0F, 0xF0, 0x07, 0xFF, 0xF8, 0x3F, 0xC0, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x3F,
  0xFE, 0x00, 0x1F, 0xC1, 0xFF, 0xFC, 0x00, 0x7F, 0x07, 0xFF, 0xF8, 0x03,
  0xF8, 0x3F, 0xFF, 0xE0, 0x0F, 0xE1, 0xFF, 0xFF, 0xC0, 0x3F, 0x87, 0xF8,
  0xFF, 0x81, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xFC, 0x7F,
  0x87, 0xF0, 0x0F, 0xFF, 0xFE, 0x1F, 0xC0, 0x1F, 0xFF, 0xF0, 0x7F, 0x00,
  0x7F, 0xFF, 0x83, 0xF8, 0x00, 0xFF, 0xFE, 0x0F, 0xE0, 0x01, 0xFF, 0xF0,
  0x3F, 0x80, 0x03, 0xFF, 0x00, 0x0C, 0x00, 0x03, 0xF0, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 18, 49, 41, 12, -48 },
  { 112, 25, 21, 41, 12, -51 },
  { 178, 43, 48, 41, 0, -48 },
  { 436, 40, 64, 41, 1, -56 },
  { 756, 48, 50, 41, -2, -49 },
  { 1056, 41, 50, 41, 0, -49 },
  { 1313, 11, 21, 41, 19, -51 },
  { 1342, 29, 62, 41, 12, -52 },
  { 1567, 28, 62, 41, 2, -52 },
  { 1784, 37, 35, 41, 3, -38 },
  { 1946, 34, 33, 41, 4, -38 },
  { 2087, 19, 21, 41, 8, -11 },
  { 2137, 23, 8, 41, 10, -25 },
  { 2160, 13, 12, 41, 12, -11 },
  { 2180, 40, 62, 41, 1, -52 },
  { 2490, 37, 50, 41, 3, -49 },
  { 2722, 34, 48, 41, 3, -48 },
  { 2926, 38, 49, 41, 1, -49 },
  { 3159, 38, 50, 41, 1, -49 },
  { 3397, 38, 48, 41, 1, -48 },
  { 3625, 38, 49, 41, 2, -48 },
  { 3858, 35, 49, 41, 3, -48 },
  { 4073, 36, 48, 41, 6, -48 },
  { 4289, 38, 50, 41, 2, -49 },
  { 4527, 35, 49, 41, 5, -49 },
  { 4742, 17, 37, 41, 12, -36 },
  { 4821, 21, 46, 41, 8, -36 },
  { 4942, 33, 41, 41, 6, -42 },
  { 5112, 36, 22, 41, 3, -32 },
  { 5211, 34, 41, 41, 3, -42 },
  { 5386, 31, 50, 41, 8, -49 },
  { 5580, 37, 57, 41, 3, -49 },
  { 5844, 40, 48, 41, -2, -48 },
  { 6084, 36, 48, 41, 3, -48 },
  { 6300, 37, 50, 41, 4, -49 },
  { 6532, 38, 48, 41, 2, -48 },
  { 6760, 38, 48, 41, 3, -48 },
  { 6988, 39, 48, 41, 3, -48 },
  { 7222, 36, 50, 41, 4, -49 },
  { 7447, 40, 48, 41, 2, -48 },
  { 7687, 39, 48, 41, 2, -48 },
  { 7921, 37, 49, 41, 3, -48 },
  { 8148, 44, 48, 41, 2, -48 },
  { 8412, 32, 48, 41, 4, -48 },
  { 8604, 43, 48, 41, 0, -48 },
  { 8862, 40, 48, 41, 2, -48 },
  { 9102, 37, 50, 41, 3, -49 },
  { 9334, 38, 48, 41, 3, -48 },
  { 9562, 37, 63, 41, 3, -49 },
  { 9854, 38, 48, 41, 3, -48 },
  { 10082, 40, 50, 41, 1, -49 },
  { 10332, 39, 48, 41, 6, -48 },
  { 10566, 38, 49, 41, 4, -48 },
  { 10799, 39, 48, 41, 6, -48 },
  { 11033, 44, 48, 41, 1, -48 },
  { 11297, 47, 48, 41, -2, -48 },
  { 11579, 40, 48, 41, 6, -48 },
  { 11819, 42, 48, 41, 0, -48 },
  { 12071, 32, 62, 41, 9, -52 },
  { 12319, 19, 62, 41, 12, -52 },
  { 12467, 31, 62, 41, 2, -52 },
  { 12708, 37, 30, 41, 3, -48 },
  { 12847, 34, 7, 41, -1, 6 },
  { 12877, 13, 15, 41, 13, -55 },
  { 12902, 36, 37, 41, 3, -36 },
  { 13069, 36, 52, 41, 2, -51 },
  { 13303, 33, 37, 41, 4, -36 },
  { 13456, 39, 52, 41, 3, -51 },
  { 13710, 34, 37, 41, 4, -36 },
  { 13868, 47, 66, 41, -2, -51 },
  { 14256, 38, 51, 41, 1, -36 },
  { 14499, 35, 51, 41, 2, -51 },
  { 14723, 33, 53, 41, 5, -52 },
  { 14942, 35, 67, 41, 1, -52 },
  { 15236, 38, 52, 41, 2, -51 },
  { 15483, 30, 52, 41, 6, -51 },
  { 15678, 40, 36, 41, 0, -36 },
  { 15858, 35, 36, 41, 2, -36 },
  { 16016, 35, 37, 41, 3, -36 },
  { 16178, 38, 50, 41, 0, -36 },
  { 16416, 36, 50, 41, 3, -36 },
  { 16641, 34, 36, 41, 7, -36 },
  { 16794, 34, 37, 41, 3, -36 },
  { 16952, 33, 49, 41, 5, -48 },
  { 17155, 35, 37, 41, 4, -36 },
  { 17317, 35, 37, 41, 3, -36 },
  { 17479, 38, 37, 41, 2, -36 },
  { 17655, 42, 37, 41, 0, -36 },
  { 17850, 38, 51, 41, 1, -36 },
  { 18093, 38, 37, 41, 2, -36 },
  { 18269, 34, 62, 41, 7, -52 },
  { 18533, 18, 62, 41, 12, -52 },
  { 18673, 34, 62, 41, 2, -52 },
  { 18937, 38, 17, 41, 2, -29 },
};

const GFXfont IBMPlexMono_SemiBoldItalic69pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic69pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic69pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC69PT7B_H_
