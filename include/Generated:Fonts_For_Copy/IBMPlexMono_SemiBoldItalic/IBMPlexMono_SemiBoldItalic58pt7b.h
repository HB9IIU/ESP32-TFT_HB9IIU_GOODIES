#ifndef _IBMPLEXMONO_SEMIBOLDITALIC58PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0x00, 0x1F,
  0x81, 0xF8, 0xFC, 0x0F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F,
  0x9F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x7F, 0x07, 0xF3, 0xF8,
  0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xE0, 0x7E, 0x3F, 0x03, 0xF3,
  0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x00, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F,
  0xFF, 0x83, 0xFF, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F,
  0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xF3, 0xCF, 0xF0, 0x3F, 0xE3, 0xE1, 0xF0, 0x1F, 0xE1, 0xF0,
  0x70, 0x0F, 0xE0, 0xF8, 0x10, 0x07, 0xF0, 0x7C, 0x00, 0x07, 0xF8, 0x3E,
  0x00, 0x03, 0xFC, 0x1E, 0x00, 0x01, 0xFE, 0x1F, 0x00, 0x00, 0x7F, 0x0F,
  0x80, 0x00, 0x3F, 0xC7, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xC7, 0xFC, 0x00,
  0x03, 0xE1, 0xFE, 0x00, 0x01, 0xF0, 0x7F, 0x00, 0x00, 0xF8, 0x3F, 0x80,
  0x00, 0x7C, 0x1F, 0xC0, 0x00, 0x3C, 0x0F, 0xE0, 0x40, 0x1E, 0x0F, 0xF0,
  0x70, 0x1F, 0x07, 0xF8, 0x7C, 0x0F, 0x87, 0xF8, 0x7F, 0x87, 0xC7, 0xFC,
  0x7F, 0xF3, 0xEF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xC0, 0x1F, 0xFF,
  0x80, 0x0F, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x03,
  0xE0, 0x3E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x01, 0xF8, 0x0F,
  0x83, 0xF0, 0x00, 0xFC, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x07, 0xE1, 0xF8,
  0x00, 0x3E, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x81, 0xF0, 0xF8, 0x00, 0x0F,
  0xC3, 0xF8, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x7C, 0x00, 0x00, 0x7F, 0xFC, 0x40, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xCF,
  0xFF, 0xC0, 0x00, 0x0F, 0xCF, 0xFF, 0xF0, 0x00, 0x0F, 0xC7, 0xE1, 0xF8,
  0x00, 0x0F, 0xC7, 0xE0, 0x7C, 0x00, 0x07, 0xC3, 0xF0, 0x3F, 0x00, 0x07,
  0xE1, 0xF0, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0xFC,
  0x07, 0xC0, 0x03, 0xF0, 0x7E, 0x03, 0xE0, 0x03, 0xF0, 0x3F, 0x01, 0xF0,
  0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0xF8, 0x01, 0xF8,
  0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03,
  0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x1F, 0xEF, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xE0,
  0x01, 0xFE, 0x01, 0xFC, 0x04, 0x3F, 0xC0, 0x3F, 0x81, 0xC7, 0xF8, 0x07,
  0xF8, 0x3E, 0xFF, 0x00, 0xFF, 0x0F, 0xFF, 0xE0, 0x17, 0xF3, 0xF9, 0xFE,
  0x06, 0xFE, 0xFE, 0x3F, 0xE1, 0xDF, 0xFF, 0xC7, 0xFF, 0xF9, 0xFF, 0xF0,
  0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xF0, 0x7F,
  0xE0, 0x0F, 0xFC, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x9F,
  0xCF, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xC7,
  0xE3, 0xF3, 0xF9, 0xFC, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x08, 0x01, 0xF8,
  0x02, 0x38, 0x0F, 0xE0, 0x39, 0xFC, 0x3F, 0x87, 0xF7, 0xFE, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0x3F,
  0x80, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xE8,
  0x07, 0x80, 0x0F, 0x00, 0x06, 0x00, 0x10, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x07,
  0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0,
  0x1F, 0x87, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0x87, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x01,
  0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x07,
  0xF3, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x01, 0xFF, 0xFE, 0x0F, 0x83, 0xFF,
  0xFC, 0x3F, 0x87, 0xFF, 0xF8, 0x7F, 0x0F, 0xFF, 0xF0, 0xFE, 0x1F, 0xFF,
  0xE3, 0xFC, 0x3F, 0xBF, 0xC3, 0xF0, 0xFF, 0x7F, 0x07, 0xC1, 0xFE, 0xFE,
  0x00, 0x03, 0xFD, 0xFC, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFF, 0x3F, 0x80,
  0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xDF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x03, 0xFC, 0x3F,
  0x80, 0x3F, 0xE1, 0xFC, 0x03, 0xFE, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x00,
  0xFE, 0x07, 0xF0, 0x03, 0xE0, 0x3F, 0x80, 0x0E, 0x01, 0xFC, 0x00, 0x30,
  0x0F, 0xE0, 0x01, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0x07, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0xFF, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x60, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xF8,
  0x01, 0xFF, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0xE0, 0x00, 0xFF, 0x00, 0x40,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x0C, 0x00,
  0x07, 0xF8, 0x1C, 0x00, 0x07, 0xF8, 0x7E, 0x00, 0x0F, 0xF8, 0xFF, 0x00,
  0x1F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F,
  0xC7, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE,
  0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF0,
  0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x7E, 0x00,
  0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xC7,
  0xFF, 0x80, 0x0F, 0xCF, 0xFF, 0xE0, 0x0F, 0xDF, 0xFF, 0xF0, 0x0F, 0xBF,
  0xFF, 0xF0, 0x1F, 0xBF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xE0,
  0x0F, 0xFC, 0x07, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x0C, 0x00,
  0x07, 0xF8, 0x1C, 0x00, 0x07, 0xF8, 0x7E, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x1F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x83, 0xF0,
  0x03, 0xFC, 0xFF, 0xF0, 0x3F, 0xCF, 0xFF, 0xC1, 0xFE, 0xFF, 0xFF, 0x1F,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0x7F, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xDF, 0xC0,
  0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0x80,
  0x00, 0xFE, 0x3F, 0x00, 0x03, 0xFC, 0x7E, 0x00, 0x0F, 0xF1, 0xFC, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x87, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xF0,
  0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0,
  0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFE, 0x00,
  0x03, 0xFC, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0x81, 0xFF,
  0x0F, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xE7,
  0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x07,
  0xFE, 0x7F, 0xE0, 0x7F, 0xF9, 0xFF, 0xFF, 0xDF, 0xC3, 0xFF, 0xFE, 0xFF,
  0x0F, 0xFF, 0xFB, 0xF8, 0x1F, 0xFF, 0xDF, 0xE0, 0x1F, 0xFC, 0x7F, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x0F,
  0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF,
  0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x20, 0x1F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xE7, 0xFC, 0x1F, 0xFB, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0xDF, 0x00,
  0x0F, 0xF1, 0xC0, 0x03, 0xFC, 0x20, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0,
  0x7C, 0x3F, 0x1F, 0x81, 0xFF, 0x3F, 0x1F, 0x83, 0xFF, 0x3F, 0x1F, 0x83,
  0xFF, 0xBE, 0x3F, 0x07, 0xFF, 0xFE, 0x3F, 0x0F, 0xF0, 0xFE, 0x3F, 0x0F,
  0xE0, 0xFE, 0x3F, 0x0F, 0xC0, 0x7E, 0x7F, 0x1F, 0x80, 0x7E, 0x7F, 0x1F,
  0x80, 0x7C, 0x7E, 0x1F, 0x80, 0xFC, 0x7E, 0x1F, 0x80, 0xFC, 0x7E, 0x3F,
  0x80, 0xFC, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x3F,
  0x01, 0xF8, 0x7C, 0x3F, 0x01, 0xF8, 0xFC, 0x3F, 0x03, 0xF8, 0xFC, 0x3F,
  0x87, 0xF8, 0xFC, 0x1F, 0xCF, 0xF8, 0xFC, 0x1F, 0xFD, 0xF8, 0xFC, 0x1F,
  0xF9, 0xF0, 0x7C, 0x0F, 0xFB, 0xF0, 0x7C, 0x07, 0xF3, 0xF0, 0x7C, 0x03,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xE7,
  0xF0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xF0,
  0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0xC0,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0x9F,
  0xE0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFE, 0x00, 0xFF, 0x81, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F,
  0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x7F,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8,
  0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x07,
  0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFE,
  0x1F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0xE1,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xF8, 0x1F,
  0xE0, 0x00, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0x80, 0x7F,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F,
  0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xF8, 0x0F, 0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x0F,
  0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F,
  0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x1F,
  0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x3F,
  0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F,
  0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x01,
  0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x07,
  0x83, 0xFC, 0x00, 0x10, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xFF, 0x9F,
  0xE0, 0x3F, 0xFF, 0x3F, 0xC0, 0x7F, 0xFE, 0x7F, 0x80, 0xFF, 0xFC, 0xFF,
  0x03, 0xFF, 0xF9, 0xFE, 0x07, 0xFF, 0xE3, 0xFC, 0x00, 0x0F, 0xC7, 0xF8,
  0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0,
  0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xFE,
  0xFE, 0x07, 0xFF, 0xF9, 0xF8, 0x07, 0xFF, 0xF3, 0xF0, 0x07, 0xFF, 0xCF,
  0xE0, 0x07, 0xFF, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0,
  0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xC0, 0xFF,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x07, 0xF8, 0x1F,
  0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0x07, 0xF0,
  0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F,
  0x81, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x0F, 0xF8,
  0x03, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x7F,
  0x01, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00, 0xFE,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xDF, 0xE0, 0x00, 0x3F, 0xF9, 0xFE, 0x00, 0x03, 0xFF,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x7F, 0x80, 0x03, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07,
  0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x3F,
  0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x7E,
  0xFC, 0x7E, 0xFC, 0x07, 0xE7, 0xEF, 0xEF, 0xC0, 0x7E, 0x7E, 0xFC, 0xFC,
  0x07, 0xE7, 0xFF, 0x8F, 0xC0, 0xFE, 0x7F, 0xF9, 0xFC, 0x0F, 0xE3, 0xFF,
  0x1F, 0xC0, 0xFE, 0x3F, 0xF1, 0xF8, 0x0F, 0xC3, 0xFE, 0x1F, 0x80, 0xFC,
  0x3F, 0xE1, 0xF8, 0x0F, 0xC3, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0x83, 0xF8,
  0x1F, 0xC1, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0x03, 0xF0, 0x1F, 0xC1, 0xF0,
  0x3F, 0x01, 0xF8, 0x0E, 0x07, 0xF0, 0x1F, 0x80, 0xE0, 0x7F, 0x03, 0xF8,
  0x0C, 0x07, 0xF0, 0x3F, 0x80, 0x80, 0x7F, 0x03, 0xF8, 0x08, 0x07, 0xE0,
  0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00,
  0x3F, 0x81, 0xFF, 0x80, 0x1F, 0xC0, 0xFF, 0xC0, 0x0F, 0xE0, 0x7F, 0xE0,
  0x07, 0xF0, 0x7F, 0xF0, 0x03, 0xF0, 0x3F, 0xFC, 0x01, 0xF8, 0x1F, 0xFE,
  0x01, 0xFC, 0x0F, 0xFF, 0x00, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0x03, 0xFF,
  0xC0, 0x3F, 0x83, 0xFF, 0xF0, 0x1F, 0x81, 0xFD, 0xF8, 0x0F, 0xC0, 0xFE,
  0xFC, 0x0F, 0xE0, 0x7F, 0x7E, 0x07, 0xF0, 0x3F, 0x3F, 0x03, 0xF8, 0x1F,
  0x9F, 0xC1, 0xFC, 0x1F, 0xC7, 0xE0, 0xFC, 0x0F, 0xE3, 0xF0, 0x7E, 0x07,
  0xF1, 0xF8, 0x7F, 0x03, 0xF8, 0xFC, 0x3F, 0x81, 0xF8, 0x7F, 0x1F, 0xC0,
  0xFC, 0x1F, 0x8F, 0xE0, 0xFE, 0x0F, 0xC7, 0xE0, 0x7F, 0x07, 0xE3, 0xF0,
  0x3F, 0x83, 0xF3, 0xF8, 0x1F, 0xC1, 0xFD, 0xFC, 0x0F, 0xC0, 0xFE, 0xFE,
  0x07, 0xE0, 0x3F, 0x7F, 0x07, 0xF0, 0x1F, 0xBF, 0x03, 0xF8, 0x0F, 0xFF,
  0x81, 0xFC, 0x07, 0xFF, 0xC0, 0xFE, 0x03, 0xFF, 0xE0, 0x7E, 0x00, 0xFF,
  0xF0, 0x3F, 0x00, 0x7F, 0xF8, 0x3F, 0x80, 0x3F, 0xF8, 0x1F, 0xC0, 0x1F,
  0xFC, 0x0F, 0xE0, 0x0F, 0xFE, 0x07, 0xF0, 0x03, 0xFF, 0x03, 0xF0, 0x01,
  0xFF, 0x81, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x01,
  0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x07,
  0xF9, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0x7F,
  0x80, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0x9F, 0xC0,
  0x00, 0xFF, 0x3F, 0x80, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xF8, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x03,
  0xFE, 0x0F, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x01, 0xFE,
  0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF9,
  0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0x80,
  0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x07, 0xFB, 0xF8, 0x00,
  0x1F, 0xE7, 0xF0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0x9F, 0xC0, 0x01,
  0xFE, 0x3F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x80, 0x00, 0xFF, 0x03, 0x80, 0x00, 0xFE, 0x0F, 0x80,
  0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x03, 0xFF, 0x03,
  0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F,
  0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFE, 0x0F, 0xE0, 0x07, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x7F,
  0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFC, 0x07, 0xFC, 0x00, 0x1C,
  0x03, 0xFC, 0x00, 0x04, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x10, 0x00, 0x07, 0xF8, 0x1C,
  0x00, 0x03, 0xFC, 0x1F, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x1F,
  0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xF0,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xE0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0,
  0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0,
  0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0,
  0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80,
  0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x80,
  0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xBF, 0x80, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x3F, 0xCF, 0xE0,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xE1, 0xFE,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x3F,
  0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xF0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x03, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFF, 0x3F,
  0x80, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x7F, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x3F,
  0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0xFE, 0x0F, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x83, 0xF0, 0x3F, 0x03,
  0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0xE0, 0xFC, 0x0F, 0xC1, 0xFF, 0x07, 0xE0,
  0x7E, 0x0F, 0xF8, 0x7F, 0x03, 0xF0, 0xFF, 0xC3, 0xF0, 0x1F, 0x87, 0xFE,
  0x1F, 0x81, 0xFC, 0x3D, 0xF0, 0xFC, 0x0F, 0xE3, 0xEF, 0x8F, 0xE0, 0x7F,
  0x1F, 0x7C, 0x7E, 0x03, 0xF0, 0xF3, 0xE3, 0xF0, 0x1F, 0x8F, 0x9F, 0x1F,
  0x80, 0xFC, 0x7C, 0xF8, 0xFC, 0x07, 0xE3, 0xC7, 0xCF, 0xC0, 0x3F, 0x3E,
  0x3E, 0x7E, 0x01, 0xF9, 0xF1, 0xF3, 0xF0, 0x0F, 0xCF, 0x0F, 0x9F, 0x80,
  0xFE, 0xF8, 0x7D, 0xF8, 0x07, 0xF7, 0xC3, 0xEF, 0xC0, 0x3F, 0x3C, 0x1F,
  0x7E, 0x01, 0xFB, 0xE0, 0xFB, 0xF0, 0x0F, 0xDF, 0x07, 0xDF, 0x80, 0x7E,
  0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x07, 0xF1, 0xFE, 0x00,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8,
  0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x1F,
  0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC,
  0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF1,
  0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0x8F, 0x00, 0x00, 0x3C, 0x04, 0x00, 0x00, 0x60, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x02, 0x03, 0xC1, 0xF8,
  0x7F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x03,
  0xF0, 0x20, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0x87, 0xF0, 0x1F, 0xFF,
  0x1F, 0xC0, 0xFF, 0xFE, 0x7F, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x7F,
  0xF0, 0xFF, 0x00, 0xFF, 0xC7, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF8,
  0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFE, 0x7F,
  0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x1F, 0xE0,
  0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0xFF, 0x3F, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7F,
  0x87, 0xF0, 0x03, 0xFE, 0x1F, 0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0xE1,
  0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x3D, 0xFF, 0xCF, 0xFF, 0xE7, 0xFE, 0x3F,
  0xFF, 0x9F, 0xF8, 0x7F, 0xFC, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0x80, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x1F, 0xC3, 0xFF, 0x80, 0x7F, 0x1F, 0xFF, 0x03, 0xFC,
  0xFF, 0xFC, 0x0F, 0xE7, 0xFF, 0xF8, 0x3F, 0xBC, 0x3F, 0xE0, 0xFE, 0xC0,
  0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFC, 0x7F, 0xC0, 0x07,
  0xF1, 0xFE, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC,
  0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F,
  0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0xCF, 0xE0,
  0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFF, 0x00, 0x7F,
  0x87, 0xFE, 0x07, 0xFC, 0x3F, 0xDF, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF, 0x83,
  0xF8, 0xFF, 0xFC, 0x0F, 0xE1, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0xC7, 0xF8, 0x03, 0xF8, 0xFE,
  0x00, 0x7C, 0x3F, 0x80, 0x06, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x41, 0xFC, 0x00,
  0x0E, 0x3F, 0x80, 0x03, 0xE7, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xCF,
  0xF0, 0x0F, 0xF1, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xFF, 0x8F, 0xF0, 0x07, 0xFF, 0xE7,
  0xF8, 0x07, 0xFF, 0xFB, 0xFC, 0x07, 0xFF, 0xFD, 0xFC, 0x07, 0xFE, 0x07,
  0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x07, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x0F,
  0xE0, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0x7F, 0x01,
  0xFF, 0x07, 0xBF, 0x80, 0x7F, 0xFF, 0xBF, 0xC0, 0x3F, 0xFF, 0x9F, 0xC0,
  0x0F, 0xFF, 0x8F, 0xE0, 0x03, 0xFF, 0x87, 0xF0, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0x81, 0xFE, 0x1F, 0xE0,
  0x0F, 0xE1, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF,
  0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xEF, 0xF0,
  0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x60, 0xFE, 0x00, 0x07, 0x8F, 0xE0, 0x00,
  0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x03, 0xF8, 0x7F, 0xC0, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x08, 0x03, 0xFC, 0x00, 0x00, 0x0C,
  0x03, 0xF8, 0x00, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x7F,
  0x00, 0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xFE, 0xFF, 0x03, 0xFF, 0xFE, 0xFE,
  0x07, 0xFE, 0x07, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFE,
  0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC,
  0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xF8,
  0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF8,
  0x3F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF8, 0x3F, 0x80, 0x0F, 0xF0,
  0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x37, 0xF0, 0x1F, 0xF0, 0xF7, 0xF0,
  0x1F, 0xFF, 0xE7, 0xF0, 0x0F, 0xFF, 0xEF, 0xF0, 0x0F, 0xFF, 0xCF, 0xE0,
  0x03, 0xFF, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x08, 0x00, 0x3F, 0x80, 0x1C, 0x00, 0x7F, 0x80, 0x3F, 0x01, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF8, 0x7F, 0xE0, 0x1F,
  0xC7, 0xFF, 0x80, 0xFE, 0x7F, 0xFE, 0x0F, 0xF7, 0xFF, 0xF8, 0x7F, 0xB8,
  0x7F, 0xC3, 0xFB, 0x01, 0xFE, 0x1F, 0xD0, 0x07, 0xF0, 0xFF, 0x80, 0x3F,
  0x87, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F,
  0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFE, 0x3F, 0x80,
  0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x9F,
  0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x18,
  0x01, 0xFE, 0x03, 0xC0, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x1F,
  0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xC7, 0xF0, 0x03, 0xFC, 0xFE,
  0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0x00, 0x7F, 0x00, 0x7C, 0x07,
  0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x0F, 0xE0,
  0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03,
  0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x07, 0xF0, 0xFF, 0xE0, 0x07, 0xF1, 0xFF, 0xF0, 0x07, 0xF3, 0xFF,
  0xF8, 0x0F, 0xF7, 0xFF, 0xF8, 0x0F, 0xEF, 0x0F, 0xF8, 0x0F, 0xEC, 0x07,
  0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x03,
  0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07,
  0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x3F, 0x9F, 0xF0,
  0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x8F, 0xF0,
  0x10, 0x7F, 0x87, 0xF0, 0x1C, 0x7F, 0x87, 0xF0, 0x3E, 0x7F, 0x07, 0xF8,
  0x7F, 0x7F, 0x03, 0xF8, 0xFC, 0x7F, 0x03, 0xFD, 0xF8, 0x7F, 0x01, 0xFF,
  0xF0, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0xC0, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x10, 0x0F, 0xE0, 0x1E, 0x07, 0xF0, 0x1F,
  0x83, 0xF8, 0x1F, 0xC3, 0xFC, 0x1F, 0xC1, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x3E, 0x01, 0xF9, 0xFC, 0x1F, 0xE0, 0xFC, 0xFF, 0x8F, 0xF8,
  0x3F, 0x7F, 0xE7, 0xFF, 0x0F, 0xDF, 0xFB, 0xFF, 0xC3, 0xFC, 0x7E, 0xC7,
  0xF0, 0xFE, 0x1F, 0xE0, 0xFC, 0x3F, 0x07, 0xF0, 0x3F, 0x1F, 0xC1, 0xFC,
  0x0F, 0xC7, 0xE0, 0x7F, 0x03, 0xF1, 0xF8, 0x1F, 0x81, 0xF8, 0x7E, 0x07,
  0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x07, 0xE3, 0xF0,
  0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC0, 0x7E, 0x3F, 0x03, 0xF0, 0x3F, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x7E, 0x03, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0x0F, 0xC7, 0xE0, 0x7E, 0x07,
  0xF1, 0xF8, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE0, 0x7E, 0x1F, 0x81, 0xF8,
  0x1F, 0x8F, 0xC0, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x81, 0xF8, 0xFC, 0x0F,
  0xC0, 0xFE, 0x3F, 0x03, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x3F, 0x87, 0xFE, 0x01, 0xFC, 0x7F, 0xF8, 0x0F, 0xE7,
  0xFF, 0xE0, 0xFF, 0x7F, 0xFF, 0x87, 0xFB, 0x87, 0xFC, 0x3F, 0xB0, 0x1F,
  0xE1, 0xFD, 0x00, 0x7F, 0x0F, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xC7,
  0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0,
  0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07,
  0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0x8F, 0xF0,
  0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x07,
  0xF8, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xE3,
  0xF8, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xC3, 0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x07,
  0xF1, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFB,
  0xF8, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x3F, 0xC3, 0xFC,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0xF8, 0x01, 0xFC, 0x7F, 0xFC,
  0x03, 0xFC, 0xFF, 0xFC, 0x03, 0xF9, 0xFF, 0xFE, 0x03, 0xFB, 0xC3, 0xFE,
  0x03, 0xFB, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F,
  0x07, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F,
  0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC,
  0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xDF, 0xFF, 0xF0, 0x3F, 0xDF, 0xFF, 0xE0, 0x3F, 0x8F, 0xFF, 0xC0,
  0x3F, 0x87, 0xFF, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xE1, 0xFC,
  0x07, 0xFF, 0xE7, 0xF8, 0x1F, 0xFF, 0xEF, 0xF0, 0x7F, 0xFF, 0xDF, 0xC1,
  0xFF, 0x81, 0xFF, 0x83, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F,
  0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x7F, 0x1F, 0xE0,
  0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0xFF, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x1F,
  0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x01, 0xDF, 0xC1, 0xFF, 0x07, 0xBF,
  0x81, 0xFF, 0xFE, 0xFF, 0x03, 0xFF, 0xF9, 0xFC, 0x03, 0xFF, 0xE3, 0xF8,
  0x03, 0xFF, 0x87, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xBF, 0xFF,
  0x87, 0xFD, 0xFF, 0xFC, 0x7F, 0xEF, 0xFF, 0xE7, 0xFF, 0x00, 0xFE, 0x7F,
  0xF8, 0x07, 0xF7, 0xFF, 0x80, 0x3F, 0xBC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x83, 0xFE,
  0x03, 0xF8, 0x1F, 0xC0, 0x07, 0x81, 0xFE, 0x00, 0x18, 0x0F, 0xE0, 0x00,
  0x80, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x81, 0x00, 0x01, 0xFC, 0x1C, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0xFF, 0x1F, 0xF0, 0x1F, 0xF1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x01, 0x00, 0x3F, 0x80, 0x38, 0x07, 0xF8, 0x0F,
  0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xF0, 0x07,
  0xF1, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x0F,
  0xF1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8,
  0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFE, 0x1F,
  0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0,
  0x07, 0xFC, 0x3F, 0xC0, 0x37, 0xF0, 0x7F, 0x81, 0xFF, 0xC1, 0xFF, 0x0E,
  0xFF, 0x07, 0xFF, 0xF3, 0xF8, 0x0F, 0xFF, 0xCF, 0xE0, 0x3F, 0xFE, 0x3F,
  0x80, 0x7F, 0xF0, 0xFE, 0x00, 0x7F, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x67, 0xFF, 0xC0, 0x1F, 0x3F, 0xFE, 0x03, 0xFD, 0xFF, 0xF0, 0x1F, 0xEF,
  0xFF, 0x80, 0xFF, 0x7F, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0xFE,
  0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xC3, 0xFC, 0x01,
  0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xFC,
  0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFF,
  0x00, 0x7F, 0x87, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0xC1, 0xFC, 0x01,
  0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x1F, 0xE0,
  0x1F, 0xC1, 0xFF, 0x00, 0xFE, 0x1F, 0xF0, 0x07, 0xE3, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x06, 0x0F, 0xC0, 0xF8,
  0x3E, 0x0F, 0x80, 0xF8, 0x7E, 0x1F, 0x81, 0xF8, 0x3F, 0x1F, 0x81, 0xF8,
  0x3F, 0x1F, 0x81, 0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0x3F, 0x1F, 0x81, 0xF8,
  0x3F, 0x1F, 0x01, 0xF0, 0x3F, 0x3F, 0x03, 0xF0, 0x3F, 0x3F, 0x03, 0xF0,
  0x3F, 0x3F, 0x03, 0xF0, 0x3F, 0x3F, 0x03, 0xF0, 0x3F, 0x3F, 0x03, 0xF0,
  0x3F, 0x3F, 0x03, 0xE0, 0x3F, 0x7E, 0x07, 0xE0, 0x3F, 0x7E, 0x07, 0xE0,
  0x3F, 0x7E, 0x07, 0xE0, 0x3E, 0x7E, 0x07, 0xE0, 0x7E, 0x7E, 0x07, 0xE0,
  0x7E, 0x7E, 0x07, 0xE0, 0x7C, 0xFC, 0x0F, 0xC0, 0xFC, 0xFC, 0x0F, 0xC0,
  0xFC, 0xFC, 0x0F, 0xC0, 0xF8, 0xFC, 0x1F, 0xC1, 0xF8, 0xFE, 0x3F, 0xC3,
  0xF0, 0xFF, 0xF3, 0xE7, 0xE0, 0x7F, 0xE3, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF,
  0x80, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF,
  0xF0, 0xFF, 0xE0, 0x7F, 0xFF, 0x3F, 0xFE, 0x3F, 0xE7, 0xE7, 0x1F, 0xCF,
  0xF8, 0xFD, 0xC3, 0xF8, 0xFC, 0x1F, 0xB0, 0x3F, 0x0F, 0x03, 0xF6, 0x07,
  0xE1, 0x80, 0x7F, 0xC0, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x0F, 0xF0, 0x08, 0x3F, 0x03, 0xFE,
  0x03, 0x87, 0xE0, 0x6F, 0xC0, 0xF0, 0xFC, 0x1D, 0xF8, 0x7F, 0x1F, 0x83,
  0xBF, 0x1F, 0xF3, 0xF8, 0xE7, 0xEF, 0xFC, 0x7F, 0xFC, 0xFF, 0xFE, 0x07,
  0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01,
  0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x01,
  0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03,
  0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03,
  0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x07,
  0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xF0, 0x1F, 0xC0, 0x17,
  0xF0, 0x1F, 0xE0, 0x37, 0xF0, 0x1F, 0xF0, 0xEF, 0xF0, 0x1F, 0xFF, 0xEF,
  0xF0, 0x0F, 0xFF, 0xCF, 0xE0, 0x07, 0xFF, 0x8F, 0xE0, 0x03, 0xFF, 0x0F,
  0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x08, 0x00, 0x7F,
  0x80, 0x1C, 0x00, 0xFF, 0x80, 0x3F, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0xFC, 0x1F, 0xFF, 0xC1, 0xF8, 0x3F, 0xFF, 0xE7, 0xF0, 0xFF, 0xFF, 0xEF,
  0xE1, 0xF8, 0x3F, 0xFF, 0x87, 0xE0, 0x0F, 0xFF, 0x0F, 0xC0, 0x0F, 0xFC,
  0x1F, 0x80, 0x1F, 0xF0, 0x3E, 0x00, 0x7F, 0xC0, 0x7C, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x01, 0x80, 0x0F, 0xF8, 0x1F, 0x80, 0x3F,
  0xE0, 0x3F, 0x00, 0xFF, 0x80, 0x3E, 0x03, 0xFE, 0x00, 0x7E, 0x0F, 0xF8,
  0x00, 0xFC, 0x3F, 0xF0, 0x00, 0xF8, 0xFF, 0xFF, 0x01, 0xF3, 0xFF, 0xFF,
  0xE3, 0xE7, 0xF3, 0xFF, 0xFF, 0xCF, 0xC1, 0xFF, 0xFF, 0x1F, 0x80, 0xFF,
  0xFE, 0x3F, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x38, 0x03, 0xFE, 0x00, 0x3F, 0x07,
  0xFF, 0x00, 0x3E, 0x0F, 0xFF, 0x80, 0x7E, 0x1F, 0xFF, 0xC0, 0x7E, 0x3F,
  0xFF, 0xC0, 0xFC, 0x3F, 0x9F, 0xE0, 0xFC, 0x7F, 0x0F, 0xF1, 0xF8, 0x7E,
  0x07, 0xFF, 0xF8, 0x7C, 0x03, 0xFF, 0xF0, 0xFC, 0x03, 0xFF, 0xF0, 0xFC,
  0x01, 0xFF, 0xE0, 0xF8, 0x00, 0xFF, 0xC0, 0x38, 0x00, 0x3F, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 16, 41, 35, 10, -40 },
  { 83, 21, 18, 35, 10, -43 },
  { 131, 36, 40, 35, 0, -40 },
  { 311, 33, 54, 35, 1, -47 },
  { 534, 41, 42, 35, -2, -41 },
  { 750, 35, 42, 35, 0, -41 },
  { 934, 9, 18, 35, 16, -43 },
  { 955, 24, 52, 35, 10, -44 },
  { 1111, 24, 52, 35, 2, -44 },
  { 1267, 30, 29, 35, 3, -32 },
  { 1376, 28, 27, 35, 4, -31 },
  { 1471, 16, 18, 35, 7, -9 },
  { 1507, 19, 7, 35, 8, -21 },
  { 1524, 11, 10, 35, 10, -9 },
  { 1538, 35, 52, 35, 0, -44 },
  { 1766, 31, 42, 35, 3, -41 },
  { 1929, 29, 40, 35, 3, -40 },
  { 2074, 32, 41, 35, 1, -41 },
  { 2238, 32, 42, 35, 1, -41 },
  { 2406, 32, 40, 35, 1, -40 },
  { 2566, 32, 41, 35, 2, -40 },
  { 2730, 29, 41, 35, 3, -40 },
  { 2879, 31, 40, 35, 5, -40 },
  { 3034, 32, 42, 35, 2, -41 },
  { 3202, 30, 41, 35, 4, -41 },
  { 3356, 15, 31, 35, 10, -30 },
  { 3415, 18, 39, 35, 7, -30 },
  { 3503, 28, 34, 35, 5, -35 },
  { 3622, 30, 18, 35, 3, -27 },
  { 3690, 28, 34, 35, 3, -35 },
  { 3809, 26, 42, 35, 7, -41 },
  { 3946, 32, 48, 35, 2, -41 },
  { 4138, 34, 40, 35, -2, -40 },
  { 4308, 31, 40, 35, 2, -40 },
  { 4463, 32, 42, 35, 3, -41 },
  { 4631, 32, 40, 35, 2, -40 },
  { 4791, 33, 40, 35, 2, -40 },
  { 4956, 34, 40, 35, 2, -40 },
  { 5126, 31, 42, 35, 3, -41 },
  { 5289, 33, 40, 35, 2, -40 },
  { 5454, 33, 40, 35, 2, -40 },
  { 5619, 31, 41, 35, 2, -40 },
  { 5778, 36, 40, 35, 2, -40 },
  { 5958, 27, 40, 35, 3, -40 },
  { 6093, 36, 40, 35, 0, -40 },
  { 6273, 33, 40, 35, 2, -40 },
  { 6438, 31, 42, 35, 3, -41 },
  { 6601, 32, 40, 35, 2, -40 },
  { 6761, 31, 53, 35, 3, -41 },
  { 6967, 32, 40, 35, 2, -40 },
  { 7127, 33, 42, 35, 1, -41 },
  { 7301, 33, 40, 35, 5, -40 },
  { 7466, 32, 41, 35, 3, -40 },
  { 7630, 33, 40, 35, 5, -40 },
  { 7795, 37, 40, 35, 1, -40 },
  { 7980, 40, 40, 35, -2, -40 },
  { 8180, 34, 40, 35, 5, -40 },
  { 8350, 35, 40, 35, 0, -40 },
  { 8525, 26, 52, 35, 8, -44 },
  { 8694, 16, 52, 35, 10, -44 },
  { 8798, 27, 52, 35, 1, -44 },
  { 8974, 31, 25, 35, 2, -40 },
  { 9071, 28, 6, 35, 0, 5 },
  { 9092, 11, 13, 35, 11, -46 },
  { 9110, 30, 32, 35, 2, -31 },
  { 9230, 30, 44, 35, 2, -43 },
  { 9395, 27, 32, 35, 4, -31 },
  { 9503, 33, 44, 35, 2, -43 },
  { 9685, 28, 32, 35, 4, -31 },
  { 9797, 40, 55, 35, -2, -43 },
  { 10072, 32, 43, 35, 1, -31 },
  { 10244, 29, 43, 35, 2, -43 },
  { 10400, 28, 45, 35, 4, -44 },
  { 10558, 29, 56, 35, 1, -44 },
  { 10761, 32, 44, 35, 2, -43 },
  { 10937, 25, 44, 35, 5, -43 },
  { 11075, 34, 31, 35, 0, -31 },
  { 11207, 29, 31, 35, 2, -31 },
  { 11320, 29, 32, 35, 3, -31 },
  { 11436, 32, 43, 35, 0, -31 },
  { 11608, 31, 43, 35, 2, -31 },
  { 11775, 29, 30, 35, 6, -30 },
  { 11884, 29, 32, 35, 2, -31 },
  { 12000, 28, 41, 35, 4, -40 },
  { 12144, 30, 31, 35, 3, -30 },
  { 12261, 29, 32, 35, 3, -31 },
  { 12377, 32, 31, 35, 1, -30 },
  { 12501, 35, 32, 35, 0, -31 },
  { 12641, 32, 42, 35, 1, -30 },
  { 12809, 31, 32, 35, 2, -31 },
  { 12933, 28, 52, 35, 6, -44 },
  { 13115, 15, 52, 35, 10, -44 },
  { 13213, 28, 52, 35, 2, -44 },
  { 13395, 32, 14, 35, 2, -25 },
};

const GFXfont IBMPlexMono_SemiBoldItalic58pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic58pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic58pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC58PT7B_H_
