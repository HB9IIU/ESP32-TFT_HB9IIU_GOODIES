#ifndef _IBMPLEXMONO_SEMIBOLDITALIC23PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xCF, 0x38, 0xE3, 0x8C, 0x30, 0x80, 0x00, 0x73, 0xCF,
  0x3C, 0x73, 0x63, 0x67, 0xE7, 0xE7, 0xE7, 0xE6, 0x03, 0x98, 0x0C, 0x60,
  0x33, 0x80, 0xCC, 0x06, 0x70, 0xF9, 0xF3, 0xE7, 0xC3, 0x38, 0x0C, 0xC3,
  0xF3, 0xEF, 0x9F, 0x86, 0x60, 0x39, 0x80, 0xCE, 0x03, 0x30, 0x1C, 0xC0,
  0x00, 0xC0, 0x03, 0x00, 0x7E, 0x03, 0xFE, 0x1D, 0xBC, 0xE6, 0x43, 0x98,
  0x0E, 0x60, 0x1F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0xDC, 0x03, 0x38, 0x0C,
  0xE2, 0x33, 0x1C, 0x9C, 0xFF, 0xE0, 0x7E, 0x00, 0x60, 0x01, 0x80, 0x0F,
  0x03, 0x1F, 0x86, 0x19, 0x8E, 0x39, 0xCC, 0x31, 0x98, 0x31, 0xB8, 0x1F,
  0x30, 0x1E, 0x40, 0x00, 0x78, 0x06, 0xFC, 0x0D, 0xCC, 0x19, 0x8C, 0x19,
  0x8C, 0x31, 0x8C, 0x61, 0xF8, 0xE0, 0xF0, 0x03, 0xE0, 0x1F, 0xC0, 0xE7,
  0x03, 0x8C, 0x0C, 0x30, 0x38, 0xC0, 0xE7, 0x07, 0xB8, 0x77, 0x01, 0x9C,
  0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x9F, 0x8F, 0x67, 0xCF, 0x0E, 0x18, 0x77,
  0x76, 0x66, 0xE0, 0x03, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x07, 0x01,
  0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x70,
  0x0C, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x1C, 0x0C, 0x0C,
  0x0C, 0x1C, 0x00, 0x03, 0x00, 0x70, 0x07, 0x06, 0x73, 0xFF, 0xF7, 0xFE,
  0x0F, 0x81, 0xF0, 0x3B, 0x87, 0x1C, 0x61, 0x82, 0x10, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x7F, 0xF7, 0xFE, 0x86, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x3C, 0xE7, 0x1C, 0xE3, 0x8C, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0,
  0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x07, 0xC1, 0xFE,
  0x38, 0x73, 0x07, 0x70, 0x37, 0x03, 0xF7, 0x7E, 0x77, 0xE6, 0x7E, 0x07,
  0xE0, 0x7E, 0x0E, 0xE0, 0xE7, 0x1C, 0x7F, 0x81, 0xF0, 0x07, 0xC1, 0xF8,
  0x77, 0x1C, 0xC7, 0x38, 0x47, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x3F, 0xFF, 0xFF, 0x07, 0xE0, 0xFF, 0x87, 0x1E,
  0x70, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x01, 0xFF, 0xDF, 0xFE, 0x07, 0xE0, 0xFF,
  0x8F, 0x1E, 0x10, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0xFC, 0x07, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xE2, 0x07, 0x78, 0x79, 0xFF, 0x83, 0xF0, 0x00,
  0x78, 0x07, 0x80, 0x7C, 0x07, 0xE0, 0x77, 0x03, 0x38, 0x39, 0xC3, 0x8C,
  0x38, 0xE3, 0x87, 0x1C, 0x39, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x07, 0x00,
  0x38, 0x1F, 0xF1, 0xFF, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x77, 0xC7,
  0xFE, 0x70, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x40, 0xEE, 0x1E, 0xFF, 0xC3,
  0xF0, 0x01, 0xF0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x77, 0xC7,
  0xFE, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xE7, 0x1E, 0x7F, 0xC1,
  0xF0, 0x7F, 0xF7, 0xFF, 0xE0, 0xFE, 0x0E, 0xE1, 0xE0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07,
  0x00, 0x07, 0xC1, 0xFF, 0x38, 0x73, 0x07, 0x70, 0x73, 0x07, 0x38, 0xE1,
  0xFC, 0x3F, 0xC7, 0x0E, 0xE0, 0x7E, 0x0F, 0xE0, 0xEE, 0x1E, 0x7F, 0xC3,
  0xF0, 0x1F, 0x87, 0xF9, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F,
  0xFE, 0xE7, 0xB8, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x07, 0xC0, 0x39,
  0xF7, 0xCE, 0x00, 0x00, 0x00, 0x73, 0xCF, 0x3C, 0x1C, 0x7C, 0xF8, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x71, 0xC3, 0x8E, 0x1C, 0x30, 0x00, 0x00, 0x20,
  0x1C, 0x0F, 0x87, 0xE3, 0xF0, 0xF8, 0x3C, 0x07, 0x00, 0xF8, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x38, 0x01, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x20, 0x07, 0x00, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x38, 0x0F, 0x07, 0xE1, 0xF0, 0xF8, 0x7C, 0x0E, 0x01,
  0x00, 0x00, 0x3F, 0x1F, 0xEE, 0x3F, 0x07, 0x01, 0xC0, 0xF0, 0xF8, 0xFC,
  0x38, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x07, 0xC1,
  0xFE, 0x38, 0x73, 0x03, 0x70, 0x36, 0x3B, 0x67, 0xFE, 0x67, 0xEE, 0x3E,
  0xC7, 0xCC, 0x6C, 0xC6, 0xCF, 0xEC, 0xF6, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0x70,
  0x1C, 0xC0, 0x63, 0x03, 0x8E, 0x0C, 0x38, 0x7F, 0xE1, 0xFF, 0x8E, 0x0E,
  0x38, 0x39, 0xC0, 0xE7, 0x03, 0xBC, 0x0F, 0x3F, 0xC3, 0xFE, 0x38, 0x73,
  0x87, 0x38, 0x73, 0x87, 0x70, 0xE7, 0xFC, 0x7F, 0xC7, 0x0E, 0x70, 0xE7,
  0x0E, 0xE0, 0xEE, 0x1E, 0xFF, 0xCF, 0xF8, 0x07, 0xE0, 0x7F, 0x87, 0x1C,
  0x70, 0x77, 0x04, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x87, 0x0F, 0x38, 0x70, 0xFF, 0x03, 0xE0, 0x3F, 0xC3, 0xFE,
  0x38, 0xF3, 0x87, 0x38, 0x73, 0x07, 0x70, 0x77, 0x07, 0x70, 0x77, 0x07,
  0x70, 0x77, 0x0E, 0xE0, 0xEE, 0x1C, 0xFF, 0x8F, 0xF0, 0x1F, 0xF9, 0xFF,
  0x8E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0F, 0xFC, 0x7F, 0xE3,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0xFF, 0x1F, 0xF8, 0x1F,
  0xF9, 0xFF, 0xCE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0F, 0xFC,
  0x7F, 0xE3, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0x07, 0xC1, 0xFF, 0x3C, 0x73, 0x87, 0x70, 0x47, 0x00, 0x70, 0x0F,
  0x00, 0xE3, 0xFE, 0x3F, 0xE0, 0x6E, 0x06, 0xE0, 0xE7, 0x1E, 0x7E, 0xE3,
  0xCE, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0xE3, 0x87, 0x38, 0x39, 0xC1,
  0xCF, 0xFE, 0x7F, 0xF3, 0x87, 0x18, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x73,
  0x83, 0x9C, 0x38, 0x3F, 0xF9, 0xFF, 0x80, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xF1, 0xFF, 0x00, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0xE1,
  0xCE, 0x3C, 0x7F, 0x83, 0xE0, 0x38, 0x3C, 0xE1, 0xE3, 0x8F, 0x0E, 0x38,
  0x39, 0xC1, 0xCE, 0x07, 0x70, 0x1F, 0xC0, 0x7F, 0x81, 0xEE, 0x07, 0x38,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x8E, 0x0E, 0x38, 0x3C, 0x1C, 0x03, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0x1C, 0x1C, 0x78, 0xF3, 0xE3,
  0xCF, 0x9F, 0x3E, 0xFC, 0xDB, 0x63, 0x7D, 0x8C, 0xE6, 0x73, 0xB9, 0xCC,
  0xE7, 0x23, 0x98, 0x8C, 0x60, 0x31, 0x80, 0xCE, 0x07, 0x38, 0x1C, 0x3C,
  0x39, 0xE1, 0xCF, 0x0E, 0x7C, 0x63, 0xE3, 0x3B, 0x39, 0xD9, 0xCE, 0xCE,
  0x67, 0x73, 0x3B, 0x18, 0xD9, 0xC7, 0xCE, 0x3E, 0x71, 0xF3, 0x0F, 0x98,
  0x78, 0x07, 0xC1, 0xFE, 0x38, 0x73, 0x87, 0x70, 0x77, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0xE0, 0xE7, 0x1C, 0x7F, 0x81,
  0xF0, 0x1F, 0xE1, 0xFF, 0x8E, 0x1C, 0x70, 0x73, 0x87, 0x9C, 0x38, 0xC1,
  0xCF, 0xFC, 0x7F, 0xC3, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x07, 0xC1, 0xFE, 0x38, 0x73, 0x87, 0x70, 0x77, 0x07,
  0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0xE0, 0xE7, 0x1C,
  0x7F, 0x83, 0xF0, 0x0E, 0x20, 0x77, 0x03, 0xE0, 0x1C, 0x3F, 0xE1, 0xFF,
  0x8E, 0x1C, 0x70, 0x73, 0x87, 0x9C, 0x39, 0xC1, 0xCF, 0xFC, 0x7F, 0xC3,
  0x9C, 0x1C, 0xE0, 0xE7, 0x0E, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x1C, 0x07,
  0xE0, 0x3F, 0xE1, 0xC3, 0xCF, 0x04, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0xF0, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x20, 0x71, 0xC3, 0xCF,
  0xFE, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x67,
  0x07, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0x38, 0x39, 0xC1,
  0xCE, 0x0E, 0x38, 0xE1, 0xFF, 0x07, 0xE0, 0xE0, 0x3F, 0x03, 0xB8, 0x1D,
  0xE1, 0xC7, 0x0E, 0x38, 0x71, 0xC7, 0x0E, 0x38, 0x73, 0x83, 0x9C, 0x1C,
  0xC0, 0xEE, 0x07, 0x70, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x38, 0x0E, 0x60,
  0x1C, 0xC0, 0x31, 0x80, 0x63, 0x38, 0xC6, 0x73, 0x9C, 0xE7, 0x3B, 0x4C,
  0x76, 0x98, 0xED, 0x71, 0xF6, 0xE3, 0x6D, 0x86, 0xDB, 0x0F, 0x3E, 0x1E,
  0x7C, 0x7C, 0xF0, 0x1E, 0x0F, 0x0E, 0x0E, 0x0F, 0x1C, 0x07, 0x38, 0x07,
  0x78, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0E, 0x70, 0x1C, 0x70, 0x38, 0x78, 0x78, 0x38, 0xF0, 0x3C, 0xE0,
  0x3F, 0x83, 0x9C, 0x3C, 0xE1, 0xC7, 0x1C, 0x1D, 0xC0, 0xEE, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01,
  0xC0, 0x0F, 0xFF, 0x3F, 0xFC, 0x1F, 0xE3, 0xF8, 0x60, 0x0C, 0x01, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0xF8, 0x7F, 0x00, 0xC3, 0x8E, 0x18,
  0x61, 0x87, 0x1C, 0x30, 0xC3, 0x0E, 0x38, 0x61, 0x86, 0x1C, 0x70, 0xC3,
  0x1F, 0xC7, 0xF0, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x8F, 0xE3,
  0xF8, 0x03, 0x80, 0x7C, 0x0F, 0xC0, 0xCC, 0x1C, 0xE3, 0x8E, 0x30, 0x67,
  0x07, 0xE0, 0x74, 0x02, 0xFF, 0xFF, 0xFC, 0x27, 0x9C, 0x61, 0x80, 0x1E,
  0x73, 0xF7, 0x78, 0xE7, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1,
  0xCE, 0x3C, 0x7F, 0xF7, 0x8E, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0xBC, 0x77, 0xE7, 0xCF, 0x78, 0x77, 0x07, 0x70, 0x77, 0x07, 0xE0,
  0xEE, 0x0E, 0xF1, 0xEF, 0xFC, 0xEF, 0x00, 0x0F, 0xC3, 0xFC, 0xE3, 0xB8,
  0x47, 0x00, 0xE0, 0x38, 0x07, 0x04, 0x60, 0xEE, 0x39, 0xFF, 0x0F, 0x80,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x0F, 0xB8, 0xFD, 0xCF,
  0x1E, 0x70, 0x77, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0xF3, 0x8B,
  0x8F, 0xF8, 0x39, 0xC0, 0x0F, 0xC1, 0xFE, 0x38, 0xE7, 0x07, 0x71, 0xE7,
  0xFC, 0xFF, 0x0E, 0x00, 0x60, 0x67, 0x0E, 0x7F, 0xC1, 0xF0, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE,
  0x11, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x63, 0x80, 0xF3, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x0F, 0xB8, 0xFD, 0xCF, 0x1E, 0x70,
  0x77, 0x03, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0xF3, 0xCB, 0x8F, 0xD8,
  0x3D, 0xC0, 0x0E, 0x00, 0x71, 0x87, 0x1F, 0xF0, 0x3F, 0x00, 0x1C, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x77, 0x8D, 0xFB, 0xA7, 0x78, 0x6E, 0x1D,
  0xC3, 0xB8, 0x76, 0x0F, 0xC1, 0xF8, 0x3F, 0x0E, 0xE1, 0xC0, 0x07, 0x01,
  0xE0, 0x3C, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC8, 0x71, 0x8E, 0x79, 0xDC, 0x3F, 0x03, 0x80, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03,
  0x82, 0x38, 0xE3, 0x87, 0x38, 0x3B, 0x81, 0xF0, 0x0E, 0x00, 0x1C, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xBC, 0x37, 0xE7, 0x4F, 0x78, 0x67,
  0x0E, 0x71, 0xC7, 0x78, 0x6E, 0x0E, 0x73, 0xE7, 0x7E, 0x3E, 0xE3, 0xC0,
  0xFE, 0x3F, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E,
  0x03, 0x80, 0xE4, 0x39, 0xCE, 0xE3, 0x70, 0xF8, 0x3C, 0x00, 0x37, 0x39,
  0xBB, 0xDE, 0xE6, 0xE7, 0x37, 0x31, 0xB1, 0x8D, 0x8C, 0xEC, 0xE7, 0xE7,
  0x3F, 0x39, 0xB9, 0x8D, 0x8C, 0x60, 0x3B, 0xC6, 0xFD, 0xD3, 0xBC, 0x37,
  0x0E, 0xE1, 0xDC, 0x3B, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0x70, 0xE0, 0x0F,
  0x83, 0xFE, 0x78, 0xE7, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0E, 0xE0,
  0xE7, 0x1C, 0x7F, 0x81, 0xF0, 0x1D, 0xE1, 0xDF, 0x8F, 0x9E, 0x78, 0x73,
  0x83, 0x9C, 0x1C, 0xE0, 0xEE, 0x0E, 0x70, 0x73, 0xC7, 0x9F, 0xF8, 0xEF,
  0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x1F, 0x73, 0xF7,
  0x78, 0xF7, 0x07, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1, 0xEE, 0x2E,
  0x7F, 0xC3, 0xDC, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x7C,
  0xFF, 0xDE, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x0F, 0xC7, 0xFC, 0xE1, 0x38, 0x07, 0x80,
  0x7F, 0x07, 0xF0, 0x0F, 0x40, 0xEC, 0x3B, 0xFF, 0x1F, 0x80, 0x0E, 0x01,
  0x80, 0x30, 0x0E, 0x0F, 0xFF, 0xFF, 0x87, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x63, 0x9C, 0x67, 0x0F, 0x81, 0xE0, 0x38, 0x77, 0x07, 0x70,
  0x77, 0x06, 0x70, 0xE7, 0x0E, 0x60, 0xEE, 0x0E, 0xE1, 0xEF, 0x2C, 0x7F,
  0xC3, 0x9C, 0xF8, 0x6F, 0x8E, 0x38, 0x73, 0x87, 0x38, 0x73, 0x86, 0x30,
  0xE7, 0x0E, 0x71, 0xC7, 0x38, 0x7F, 0x03, 0xC0, 0x31, 0x99, 0x9D, 0xCC,
  0xE6, 0xE6, 0x37, 0x31, 0xB1, 0x8D, 0x8C, 0x6C, 0xE7, 0x67, 0x33, 0x59,
  0xBE, 0xD8, 0xE7, 0x80, 0x0E, 0x38, 0xFD, 0xF7, 0x3D, 0xC8, 0xE7, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0xC7, 0x13, 0xAD, 0xEF, 0xBF, 0x1C,
  0x70, 0x1C, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x63, 0x87, 0x1C, 0x38, 0xE1,
  0xCE, 0x0E, 0x70, 0xF1, 0xCB, 0x0F, 0xF8, 0x3D, 0xC0, 0x0E, 0x00, 0x71,
  0x87, 0x1F, 0xF0, 0x3F, 0x00, 0x1E, 0x37, 0xFF, 0x71, 0xF6, 0x1E, 0x03,
  0x80, 0x70, 0x0E, 0x03, 0xC6, 0x78, 0x6F, 0xE6, 0xDF, 0xEC, 0x7C, 0x03,
  0xF0, 0x7E, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x07,
  0x07, 0xE0, 0xFC, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30,
  0x03, 0x00, 0x3F, 0x03, 0xF0, 0x0C, 0x71, 0xC6, 0x18, 0x63, 0x8E, 0x38,
  0xC3, 0x0C, 0x71, 0xC7, 0x18, 0x61, 0x8E, 0x38, 0x1F, 0x83, 0xF0, 0x06,
  0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x0E, 0x00, 0xFC, 0x1F, 0x86,
  0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x06, 0x01, 0xC3, 0xF0, 0x7E, 0x00,
  0x3C, 0x37, 0xE3, 0xE6, 0x7C, 0x7E, 0xC3, 0xC0,
};

const GFXglyph IBMPlexMono_SemiBoldItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 16, 14, 4, -16 },
  { 13, 8, 7, 14, 4, -17 },
  { 20, 14, 16, 14, 0, -16 },
  { 48, 14, 20, 14, 0, -18 },
  { 83, 16, 16, 14, -1, -16 },
  { 115, 14, 16, 14, 0, -16 },
  { 143, 4, 7, 14, 6, -17 },
  { 147, 10, 20, 14, 4, -17 },
  { 172, 9, 20, 14, 1, -17 },
  { 195, 12, 12, 14, 1, -13 },
  { 213, 12, 10, 14, 1, -12 },
  { 228, 6, 7, 14, 3, -4 },
  { 234, 8, 2, 14, 3, -8 },
  { 236, 4, 4, 14, 4, -4 },
  { 238, 14, 20, 14, 0, -17 },
  { 273, 12, 16, 14, 1, -16 },
  { 297, 11, 16, 14, 1, -16 },
  { 319, 13, 16, 14, 0, -16 },
  { 345, 13, 16, 14, 0, -16 },
  { 371, 13, 16, 14, 0, -16 },
  { 397, 12, 16, 14, 1, -16 },
  { 421, 12, 16, 14, 1, -16 },
  { 445, 12, 16, 14, 2, -16 },
  { 469, 12, 16, 14, 1, -16 },
  { 493, 11, 16, 14, 2, -16 },
  { 515, 6, 12, 14, 4, -12 },
  { 524, 7, 15, 14, 3, -12 },
  { 538, 11, 14, 14, 2, -14 },
  { 558, 12, 8, 14, 1, -11 },
  { 570, 11, 14, 14, 1, -14 },
  { 590, 10, 16, 14, 3, -16 },
  { 610, 12, 19, 14, 1, -16 },
  { 639, 14, 16, 14, -1, -16 },
  { 667, 12, 16, 14, 1, -16 },
  { 691, 13, 16, 14, 1, -16 },
  { 717, 12, 16, 14, 1, -16 },
  { 741, 13, 16, 14, 1, -16 },
  { 767, 13, 16, 14, 1, -16 },
  { 793, 12, 16, 14, 1, -16 },
  { 817, 13, 16, 14, 1, -16 },
  { 843, 13, 16, 14, 1, -16 },
  { 869, 12, 16, 14, 1, -16 },
  { 893, 14, 16, 14, 1, -16 },
  { 921, 11, 16, 14, 1, -16 },
  { 943, 14, 16, 14, 0, -16 },
  { 971, 13, 16, 14, 1, -16 },
  { 997, 12, 16, 14, 1, -16 },
  { 1021, 13, 16, 14, 1, -16 },
  { 1047, 12, 20, 14, 1, -16 },
  { 1077, 13, 16, 14, 1, -16 },
  { 1103, 14, 16, 14, 0, -16 },
  { 1131, 13, 16, 14, 2, -16 },
  { 1157, 13, 16, 14, 1, -16 },
  { 1183, 13, 16, 14, 2, -16 },
  { 1209, 15, 16, 14, 0, -16 },
  { 1239, 16, 16, 14, -1, -16 },
  { 1271, 13, 16, 14, 2, -16 },
  { 1297, 14, 16, 14, 0, -16 },
  { 1325, 11, 20, 14, 3, -17 },
  { 1353, 6, 20, 14, 4, -17 },
  { 1368, 10, 20, 14, 1, -17 },
  { 1393, 12, 10, 14, 1, -16 },
  { 1408, 11, 2, 14, 0, 2 },
  { 1411, 5, 5, 14, 4, -18 },
  { 1415, 12, 12, 14, 1, -12 },
  { 1433, 12, 17, 14, 1, -17 },
  { 1459, 11, 12, 14, 1, -12 },
  { 1476, 13, 17, 14, 1, -17 },
  { 1504, 12, 12, 14, 1, -12 },
  { 1522, 16, 22, 14, -1, -17 },
  { 1566, 13, 17, 14, 0, -12 },
  { 1594, 11, 17, 14, 1, -17 },
  { 1618, 11, 18, 14, 2, -18 },
  { 1643, 12, 23, 14, 0, -18 },
  { 1678, 12, 17, 14, 1, -17 },
  { 1704, 10, 17, 14, 2, -17 },
  { 1726, 13, 12, 14, 0, -12 },
  { 1746, 11, 12, 14, 1, -12 },
  { 1763, 12, 12, 14, 1, -12 },
  { 1781, 13, 17, 14, 0, -12 },
  { 1809, 12, 17, 14, 1, -12 },
  { 1835, 12, 12, 14, 2, -12 },
  { 1853, 11, 12, 14, 1, -12 },
  { 1870, 11, 16, 14, 2, -16 },
  { 1892, 12, 12, 14, 1, -12 },
  { 1910, 12, 12, 14, 1, -12 },
  { 1928, 13, 12, 14, 0, -12 },
  { 1948, 14, 12, 14, 0, -12 },
  { 1969, 13, 17, 14, 0, -12 },
  { 1997, 12, 12, 14, 1, -12 },
  { 2015, 12, 20, 14, 2, -17 },
  { 2045, 6, 20, 14, 4, -17 },
  { 2060, 11, 20, 14, 1, -17 },
  { 2088, 12, 5, 14, 1, -10 },
};

const GFXfont IBMPlexMono_SemiBoldItalic23pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic23pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC23PT7B_H_
