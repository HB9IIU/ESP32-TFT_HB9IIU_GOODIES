#ifndef _IBMPLEXMONO_SEMIBOLDITALIC60PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F,
  0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7,
  0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0x8F, 0xE0,
  0xFE, 0x3F, 0x83, 0xF8, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE,
  0x7F, 0x03, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0xFE,
  0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE,
  0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x01, 0xF8,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x3E, 0x7F, 0x80,
  0xFF, 0x0F, 0x87, 0xC0, 0x7F, 0x83, 0xE0, 0xE0, 0x1F, 0xE0, 0xF8, 0x10,
  0x07, 0xF0, 0x3E, 0x00, 0x01, 0xFC, 0x1F, 0x00, 0x00, 0x7F, 0x07, 0xC0,
  0x00, 0x1F, 0xC1, 0xF0, 0x00, 0x07, 0xF0, 0x7C, 0x00, 0x01, 0xFE, 0x1F,
  0x00, 0x00, 0x7F, 0xC7, 0xC0, 0x00, 0x1F, 0xFD, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xF3, 0xFF,
  0x00, 0x00, 0x7C, 0x3F, 0xC0, 0x00, 0x1F, 0x0F, 0xF0, 0x00, 0x07, 0xC1,
  0xFC, 0x00, 0x03, 0xE0, 0x7F, 0x00, 0x00, 0xF8, 0x1F, 0xC0, 0x00, 0x3E,
  0x0F, 0xF0, 0x30, 0x0F, 0x83, 0xFC, 0x1C, 0x03, 0xE0, 0xFF, 0x0F, 0x80,
  0xF8, 0x7F, 0x87, 0xF8, 0x3E, 0x3F, 0xE3, 0xFF, 0x9F, 0x3F, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x03,
  0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x01,
  0xF8, 0x00, 0xF8, 0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x3F, 0x00,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x01, 0xF8,
  0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x81, 0xF8,
  0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0x1F, 0x80,
  0x00, 0x3F, 0xFF, 0x8F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xF1, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0xFF, 0xFF, 0x00,
  0x00, 0xFC, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x81, 0xF8, 0x00, 0x1F,
  0x87, 0xC0, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0xFC,
  0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x7E,
  0x00, 0x3F, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x0F,
  0xC0, 0x3E, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0x81, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0xFF,
  0xC0, 0x1F, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xFE, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x3F,
  0xC0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x07, 0xF0, 0x18, 0xFF, 0x00, 0x7F, 0x03, 0xCF, 0xF0, 0x07,
  0xF8, 0x7F, 0xFF, 0x00, 0xFF, 0x87, 0xE7, 0xF8, 0x0F, 0xFC, 0xFE, 0x7F,
  0xC3, 0xDF, 0xDF, 0xC7, 0xFF, 0xFD, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF,
  0x83, 0xFF, 0xF8, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF9, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x3F, 0x8F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x38, 0x07, 0xF0, 0x0E, 0x7E, 0x0F,
  0xE0, 0xFD, 0xFF, 0x1F, 0x8F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xBF, 0x80,
  0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x00,
  0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFA, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFE,
  0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF0, 0x0F, 0xC3, 0xFE, 0x7F, 0xF7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xE7, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x00,
  0x7F, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x83, 0xE0,
  0xFF, 0xFF, 0x87, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0,
  0xFF, 0xFF, 0x0F, 0xE0, 0xFF, 0xFF, 0x0F, 0xE1, 0xFE, 0xFF, 0x07, 0xC1,
  0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01,
  0xFE, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03,
  0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x3F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x03,
  0xFC, 0x7F, 0x00, 0x1F, 0xF1, 0xFC, 0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xFC,
  0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xF8, 0x0F,
  0xE0, 0x03, 0xC0, 0x3F, 0x80, 0x06, 0x01, 0xFE, 0x00, 0x10, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC,
  0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F,
  0xC2, 0xFC, 0x00, 0x1F, 0xE0, 0x0E, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xF8,
  0x01, 0xFF, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x70, 0x00, 0x3F, 0xC0, 0x10,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x06, 0x00, 0x01,
  0xFE, 0x07, 0x80, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00,
  0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0,
  0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC1, 0xFE, 0x00, 0x0F, 0xE3, 0xFF, 0xC0, 0x07,
  0xE3, 0xFF, 0xF0, 0x03, 0xF3, 0xFF, 0xFC, 0x01, 0xFB, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0x80, 0x1F, 0xF8,
  0x1F, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x0C, 0x00, 0x03, 0xFC, 0x0F, 0x00, 0x03, 0xFE, 0x1F, 0xC0, 0x03,
  0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0x80, 0x1F,
  0xE3, 0xFF, 0x80, 0xFF, 0x3F, 0xFF, 0x83, 0xFD, 0xFF, 0xFF, 0x0F, 0xEF,
  0xFF, 0xFC, 0x7F, 0xBF, 0xFF, 0xF9, 0xFF, 0xE0, 0x7F, 0xEF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x1F, 0xE0,
  0x07, 0xFC, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0x00, 0x03, 0xFE, 0x7F, 0x00, 0x03,
  0xFC, 0x7F, 0x00, 0x07, 0xFC, 0x7E, 0x00, 0x07, 0xF8, 0x7E, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x07,
  0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x01,
  0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00,
  0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x0F, 0xF8,
  0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xF9, 0xFE, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x9F, 0xFF, 0xFE, 0xFE,
  0x1F, 0xFF, 0xFB, 0xFC, 0x1F, 0xFF, 0xE7, 0xF8, 0x1F, 0xFF, 0x9F, 0xE0,
  0x1F, 0xFE, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x1F, 0xF8,
  0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFC, 0x0F,
  0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F,
  0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x0F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x9F, 0xF0, 0x3F, 0xF7,
  0xFC, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xEF, 0xC0, 0x07, 0xFC, 0x70, 0x00,
  0x7F, 0x82, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x7C, 0x3F, 0x1F, 0x81, 0xFF,
  0x3F, 0x3F, 0x03, 0xFF, 0x3F, 0x3F, 0x07, 0xFF, 0xBF, 0x3F, 0x07, 0xFF,
  0xFE, 0x7F, 0x0F, 0xF1, 0xFE, 0x7E, 0x0F, 0xC0, 0xFE, 0x7E, 0x1F, 0xC0,
  0x7E, 0x7E, 0x1F, 0x80, 0x7E, 0x7E, 0x1F, 0x80, 0x7E, 0xFE, 0x3F, 0x80,
  0xFC, 0xFE, 0x3F, 0x00, 0xFC, 0xFC, 0x3F, 0x00, 0xFC, 0xFC, 0x3F, 0x00,
  0xFC, 0xFC, 0x3F, 0x00, 0xFC, 0xFC, 0x3F, 0x01, 0xFC, 0xFC, 0x3F, 0x01,
  0xF8, 0xFC, 0x3F, 0x01, 0xF8, 0xFC, 0x3F, 0x03, 0xF8, 0xF8, 0x3F, 0x07,
  0xF8, 0xF8, 0x3F, 0x8D, 0xF8, 0xF8, 0x3F, 0xFD, 0xF8, 0xF8, 0x1F, 0xFB,
  0xF0, 0xF8, 0x1F, 0xF3, 0xF0, 0xF8, 0x0F, 0xF3, 0xF0, 0xFC, 0x03, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFC, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x03,
  0xFC, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xE0, 0x03,
  0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01,
  0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03,
  0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xFC, 0x3F, 0x80, 0x0F,
  0xF8, 0x7F, 0x80, 0x3F, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x07, 0xFC,
  0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xC1, 0xFE, 0x00, 0x06, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x01,
  0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x01,
  0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8,
  0x07, 0xF0, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07,
  0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x1F, 0xE1, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x87, 0xF0, 0x00, 0x7F, 0xC7, 0xF8,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x3F,
  0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xFC, 0x07,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x01, 0xFE,
  0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0xFC, 0x1F, 0xE0, 0x00, 0x40, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xFC, 0xFF, 0x80, 0xFF, 0xFC,
  0xFF, 0x81, 0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xFC,
  0xFF, 0x01, 0xFF, 0xFC, 0xFF, 0x00, 0x01, 0xF8, 0xFF, 0x00, 0x03, 0xF8,
  0xFF, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x03, 0xF8,
  0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xF0,
  0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x77, 0xF0,
  0x3F, 0xFF, 0xF7, 0xF0, 0x1F, 0xFF, 0xE7, 0xE0, 0x1F, 0xFF, 0xCF, 0xE0,
  0x0F, 0xFF, 0xCF, 0xE0, 0x07, 0xFF, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F,
  0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07,
  0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x0F, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0xC0,
  0x3F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00,
  0xFE, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x3F,
  0xE0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x7F, 0xE0, 0x00, 0x1F, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x3F,
  0xDF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0xFF, 0x00,
  0x00, 0x7F, 0xF3, 0xFC, 0x00, 0x03, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xFC,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0x7E, 0x1F, 0xFF,
  0x01, 0xFD, 0xF8, 0xFD, 0xFC, 0x07, 0xF7, 0xE3, 0xF7, 0xF0, 0x1F, 0xDF,
  0x9F, 0x9F, 0x80, 0x7E, 0x7E, 0x7E, 0x7E, 0x01, 0xF8, 0xFF, 0xF3, 0xF8,
  0x07, 0xE3, 0xFF, 0xCF, 0xE0, 0x3F, 0x8F, 0xFE, 0x3F, 0x80, 0xFE, 0x3F,
  0xF0, 0xFE, 0x03, 0xF8, 0xFF, 0xC3, 0xF0, 0x0F, 0xE1, 0xFE, 0x1F, 0xC0,
  0x3F, 0x87, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x1F, 0xC0, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xE0, 0x7E, 0x01,
  0xFC, 0x0F, 0x03, 0xF8, 0x07, 0xF0, 0x3C, 0x0F, 0xE0, 0x1F, 0x80, 0xE0,
  0x3F, 0x80, 0xFE, 0x01, 0x00, 0xFE, 0x03, 0xF8, 0x04, 0x03, 0xF8, 0x0F,
  0xE0, 0x20, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xC0, 0x07,
  0xF0, 0x3F, 0xF8, 0x01, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0x03, 0xFF, 0x80,
  0x1F, 0xC0, 0xFF, 0xE0, 0x07, 0xE0, 0x7F, 0xF8, 0x03, 0xF8, 0x1F, 0xFF,
  0x00, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0x81, 0xFF, 0xF0, 0x0F, 0xE0, 0x7F,
  0xFC, 0x03, 0xF8, 0x1F, 0xBF, 0x00, 0xFC, 0x0F, 0xEF, 0xE0, 0x3F, 0x03,
  0xFB, 0xF8, 0x1F, 0xC0, 0xFE, 0x7E, 0x07, 0xF0, 0x3F, 0x9F, 0x81, 0xFC,
  0x0F, 0xE7, 0xE0, 0x7F, 0x03, 0xF1, 0xF8, 0x1F, 0x81, 0xFC, 0x7F, 0x07,
  0xE0, 0x7F, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF0, 0xFE, 0x07, 0xF0, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0x0F, 0xE0, 0x7E, 0x0F, 0xE3, 0xF0, 0x3F, 0x83,
  0xF8, 0xFC, 0x0F, 0xE0, 0x7E, 0x7F, 0x03, 0xF8, 0x1F, 0x9F, 0xC0, 0xFE,
  0x07, 0xE7, 0xF0, 0x3F, 0x81, 0xFD, 0xFC, 0x0F, 0xC0, 0x7F, 0x7E, 0x07,
  0xF0, 0x0F, 0xDF, 0x81, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xF8,
  0x1F, 0xC0, 0x3F, 0xFE, 0x07, 0xF0, 0x0F, 0xFF, 0x81, 0xF8, 0x01, 0xFF,
  0xE0, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0x80, 0x1F, 0xFC, 0x0F, 0xE0, 0x07,
  0xFF, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x0F,
  0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFE, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xE0,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFE,
  0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00,
  0x03, 0xFE, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00,
  0x07, 0xFC, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00,
  0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0xE0,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x10, 0x00, 0x0F,
  0xE0, 0x3C, 0x00, 0x0F, 0xF0, 0x7E, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x07, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC,
  0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x07,
  0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0x01, 0xFF,
  0x00, 0x01, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x02, 0x00, 0x00, 0x7F, 0x81, 0xC0, 0x00, 0x1F,
  0xE0, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x3F, 0xFC, 0x07,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x3F, 0xEF, 0xF0, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xC0,
  0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x07,
  0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF8, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x00,
  0x01, 0xFC, 0x7F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0xC0,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x0F, 0xC1, 0xFC,
  0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xFE, 0x07,
  0xE0, 0x7F, 0x07, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0xF0, 0x7E, 0x07, 0xE0,
  0xFF, 0xC3, 0xF8, 0x1F, 0x83, 0xFF, 0x0F, 0xC0, 0x7E, 0x0F, 0xFC, 0x3F,
  0x01, 0xF8, 0x7D, 0xF0, 0xFC, 0x0F, 0xE1, 0xF7, 0xC7, 0xF0, 0x3F, 0x87,
  0x9F, 0x1F, 0x80, 0xFE, 0x3E, 0x7C, 0x7E, 0x03, 0xF8, 0xF9, 0xF1, 0xF8,
  0x0F, 0xE3, 0xC7, 0xC7, 0xE0, 0x3F, 0x1F, 0x1F, 0x3F, 0x80, 0xFC, 0x7C,
  0x7C, 0xFC, 0x03, 0xF1, 0xF1, 0xF3, 0xF0, 0x0F, 0xCF, 0x87, 0xCF, 0xC0,
  0x3F, 0x3E, 0x1F, 0x7F, 0x01, 0xFC, 0xF8, 0x7D, 0xF8, 0x07, 0xF7, 0xC3,
  0xF7, 0xE0, 0x1F, 0xDF, 0x0F, 0xDF, 0x80, 0x7F, 0x7C, 0x3F, 0x7E, 0x01,
  0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xEF, 0x83, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x9F,
  0xF0, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F,
  0x87, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x3F,
  0xC0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x7F, 0x1F,
  0xE0, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x07,
  0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x01,
  0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x3C, 0x00, 0x00,
  0x78, 0x0C, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF8, 0x0E, 0x0F, 0x8F, 0xE3, 0xFC, 0x7F, 0x1F, 0xC3, 0xF8,
  0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1E, 0x06, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFF, 0xC3, 0xFC, 0x0F, 0xFF, 0xC7, 0xF0, 0x3F, 0xFF, 0xDF, 0xE0,
  0xFF, 0xFF, 0xBF, 0xC1, 0xFF, 0x03, 0xFF, 0x87, 0xF8, 0x03, 0xFF, 0x1F,
  0xF0, 0x03, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x80, 0x03, 0xF8, 0xFF, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x00,
  0x7F, 0x8F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x07,
  0xF8, 0x7F, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0xE1, 0xFE, 0x01, 0xFF,
  0xC3, 0xFC, 0x07, 0x7F, 0x03, 0xFE, 0x1E, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF,
  0xCF, 0xFF, 0xE3, 0xFF, 0x0F, 0xFF, 0x83, 0xFE, 0x0F, 0xFE, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFE, 0x0F, 0xFE, 0x01, 0xFC,
  0x7F, 0xFE, 0x03, 0xF9, 0xFF, 0xFC, 0x0F, 0xF7, 0xFF, 0xFC, 0x1F, 0xEE,
  0x0F, 0xF8, 0x3F, 0xB8, 0x0F, 0xF8, 0x7F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80,
  0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xC7, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07,
  0xF8, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x01, 0xFC,
  0x7F, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xC7,
  0xF8, 0x00, 0x7F, 0x8F, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0x3F,
  0xF8, 0x3F, 0xF0, 0xFF, 0x7F, 0xFF, 0xC1, 0xFE, 0xFF, 0xFF, 0x83, 0xFC,
  0xFF, 0xFC, 0x07, 0xF8, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x1F, 0xF1,
  0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xC3, 0xFC, 0x00, 0x30, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x02,
  0x0F, 0xE0, 0x00, 0x38, 0xFF, 0x00, 0x07, 0xCF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x1F,
  0xE0, 0x07, 0xFF, 0x8F, 0xF0, 0x07, 0xFF, 0xE7, 0xF8, 0x0F, 0xFF, 0xFB,
  0xFC, 0x0F, 0xFF, 0xFD, 0xFE, 0x07, 0xFC, 0x0F, 0xFE, 0x07, 0xFC, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFC, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x03, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x0F,
  0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xBF, 0x80,
  0xFF, 0x87, 0xBF, 0xC0, 0x7F, 0xFF, 0xDF, 0xE0, 0x1F, 0xFF, 0xCF, 0xE0,
  0x0F, 0xFF, 0xC7, 0xF0, 0x03, 0xFF, 0xC3, 0xF8, 0x00, 0x7F, 0x02, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x3F,
  0xC0, 0x1F, 0xC3, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFC, 0x00,
  0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xE7, 0xF0, 0x01, 0xFF,
  0x7F, 0x80, 0x3F, 0xF3, 0xFC, 0x1F, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0C,
  0x1F, 0xC0, 0x00, 0x78, 0xFF, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x7F, 0x9F,
  0xE0, 0x07, 0xF0, 0xFF, 0xC0, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0x80, 0x00, 0x03, 0xE0,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x00,
  0x0F, 0xF1, 0xFC, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x1F, 0xC0, 0x3F, 0xFF, 0x9F, 0xE0, 0x3F, 0xFF, 0xEF, 0xF0, 0x3F,
  0xFF, 0xF7, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x1F,
  0xF0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC,
  0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F,
  0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xF8, 0x3F, 0xC0, 0x1F,
  0xF8, 0x1F, 0xF0, 0x1D, 0xFC, 0x07, 0xFC, 0x1E, 0xFE, 0x03, 0xFF, 0xFE,
  0xFF, 0x00, 0xFF, 0xFE, 0x7F, 0x80, 0x3F, 0xFE, 0x3F, 0xC0, 0x0F, 0xFE,
  0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x40, 0x01, 0xFE, 0x00, 0x78, 0x01, 0xFF, 0x00, 0x7F,
  0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x1F,
  0x80, 0x1F, 0xE1, 0xFF, 0x80, 0x7F, 0x8F, 0xFF, 0x01, 0xFC, 0x7F, 0xFE,
  0x07, 0xF3, 0xFF, 0xFC, 0x1F, 0xDC, 0x1F, 0xF0, 0xFF, 0x60, 0x3F, 0xC3,
  0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x01, 0xFC, 0x3F, 0xE0, 0x07, 0xF0, 0xFF,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x1F, 0xE0, 0x01, 0xFC, 0x7F, 0x80,
  0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFF, 0x1F, 0xC0, 0x03,
  0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFE,
  0x3F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x8F,
  0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x3F, 0x8F, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x10, 0x00, 0xFF, 0x00, 0xC0, 0x07, 0xF0, 0x0F,
  0x80, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00,
  0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x01, 0x00, 0x7F, 0x80, 0x1C, 0x01, 0xFE, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x7F, 0x0F, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x07,
  0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0x3F, 0xC3, 0xFF, 0x80, 0x1F, 0xC3, 0xFF, 0xE0,
  0x0F, 0xE3, 0xFF, 0xF8, 0x07, 0xF3, 0xFF, 0xFC, 0x03, 0xFB, 0x83, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x1F,
  0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x07,
  0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x03,
  0xFC, 0x03, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x0F, 0xF8, 0x00, 0xFE, 0x1F,
  0xF0, 0x00, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x04, 0x0F, 0xE1, 0xFE, 0x03, 0x87, 0xF0,
  0xFF, 0x03, 0xE7, 0xF8, 0x3F, 0xC3, 0xFB, 0xFC, 0x1F, 0xE3, 0xF9, 0xFE,
  0x07, 0xF3, 0xF8, 0xFE, 0x03, 0xFF, 0xF8, 0x7F, 0x01, 0xFF, 0xF8, 0x7F,
  0x80, 0x7F, 0xF8, 0x3F, 0xC0, 0x1F, 0xF8, 0x1F, 0xE0, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x1C, 0x0F, 0xF0, 0x1F, 0x07,
  0xF8, 0x1F, 0xC3, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFE, 0x1F, 0xE0,
  0xFF, 0x1F, 0xE0, 0x7F, 0x9F, 0xE0, 0x3F, 0xDF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0xFC, 0xFF, 0x07, 0xF8, 0x1F, 0x9F,
  0xE1, 0xFF, 0x07, 0xF7, 0xFE, 0x7F, 0xF0, 0xFD, 0xFF, 0xDF, 0xFE, 0x1F,
  0xA3, 0xFB, 0x1F, 0xC3, 0xF8, 0x3F, 0x43, 0xF8, 0x7F, 0x07, 0xF0, 0x3F,
  0x0F, 0xC0, 0xFE, 0x07, 0xE3, 0xF8, 0x1F, 0x81, 0xFC, 0x7E, 0x03, 0xF0,
  0x3F, 0x8F, 0xC0, 0x7E, 0x07, 0xF1, 0xF8, 0x1F, 0xC0, 0xFC, 0x3F, 0x03,
  0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x03, 0xF1, 0xFC, 0x0F, 0xC0, 0x7E, 0x3F,
  0x01, 0xF8, 0x1F, 0xC7, 0xE0, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xE0, 0x7E,
  0x1F, 0x81, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x01, 0xF8, 0xFE, 0x07, 0xE0,
  0x3F, 0x1F, 0x80, 0xFC, 0x0F, 0xE3, 0xF0, 0x1F, 0x81, 0xFC, 0x7E, 0x07,
  0xF0, 0x3F, 0x0F, 0xC0, 0xFE, 0x07, 0xE1, 0xF8, 0x1F, 0x80, 0xFC, 0x7F,
  0x03, 0xF0, 0x1F, 0x8F, 0xE0, 0x7E, 0x07, 0xF1, 0xF8, 0x0F, 0xC0, 0xFE,
  0x3F, 0x01, 0xF8, 0x1F, 0x87, 0xE0, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x1F, 0xE1, 0xFF, 0x80, 0x7F, 0x8F, 0xFF, 0x01, 0xFC, 0x7F, 0xFE,
  0x07, 0xF3, 0xFF, 0xFC, 0x3F, 0xDC, 0x1F, 0xF0, 0xFF, 0x60, 0x3F, 0xC3,
  0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x01, 0xFC, 0x3F, 0xE0, 0x07, 0xF0, 0xFF,
  0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x1F, 0xE0, 0x01, 0xFC, 0x7F, 0x80,
  0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFF, 0x1F, 0xC0, 0x03,
  0xFC, 0xFF, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFE,
  0x3F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x9F,
  0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x3F, 0x8F, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xF3, 0xF8,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFD, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE,
  0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0x3F,
  0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x87, 0xF8,
  0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0x1F,
  0xFF, 0x80, 0x3F, 0x9F, 0xFF, 0xC0, 0x3F, 0xDF, 0xFF, 0xF0, 0x1F, 0xEE,
  0x0F, 0xF8, 0x0F, 0xEE, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xC1, 0xFF, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x1F,
  0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0,
  0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC,
  0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFF,
  0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x03, 0xFD, 0xFF, 0xFF,
  0x01, 0xFE, 0xFF, 0xFF, 0x80, 0xFF, 0x3F, 0xFF, 0x00, 0x7F, 0x8F, 0xFF,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xE3, 0xFC, 0x07,
  0xFF, 0xE7, 0xF8, 0x3F, 0xFF, 0xEF, 0xF0, 0xFF, 0xFF, 0xDF, 0xE1, 0xFF,
  0x03, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xC0,
  0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x01,
  0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F,
  0xE3, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0xFF,
  0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xFC, 0x7F, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0xC3, 0xFE, 0x03, 0xFF, 0x83,
  0xFE, 0x1E, 0xFF, 0x07, 0xFF, 0xFD, 0xFE, 0x07, 0xFF, 0xF3, 0xF8, 0x0F,
  0xFF, 0xC7, 0xF0, 0x0F, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0x01, 0xFD, 0xFF, 0xFC,
  0x1F, 0xEF, 0xFF, 0xF0, 0xFF, 0xBF, 0xFF, 0xC7, 0xFE, 0xFF, 0xFE, 0x3F,
  0xF8, 0x07, 0xF9, 0xFF, 0xE0, 0x1F, 0xE7, 0xFF, 0x80, 0x7F, 0xBF, 0xFE,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFE, 0x07,
  0xF8, 0x3F, 0xC0, 0x0F, 0x81, 0xFC, 0x00, 0x18, 0x1F, 0xE0, 0x00, 0x80,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x18, 0x00, 0x0F, 0xE1, 0xE0, 0x00,
  0xFF, 0x1F, 0x80, 0x0F, 0xF1, 0xFF, 0x80, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x40, 0x0F, 0xF0, 0x0F, 0x00, 0x7F, 0x80, 0xFC, 0x03,
  0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF1,
  0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF8, 0xFF, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x07,
  0xF9, 0xFE, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x1F, 0xE0, 0x01, 0xFC,
  0x7F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFF, 0x3F,
  0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0x8F, 0xF0,
  0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0xFF, 0x0F, 0xE0, 0x07, 0xFC, 0x3F, 0x80, 0x1F, 0xF0, 0xFF, 0x00, 0xFF,
  0xC3, 0xFC, 0x06, 0xFF, 0x0F, 0xF8, 0x3B, 0xFC, 0x3F, 0xFF, 0xCF, 0xE0,
  0x7F, 0xFE, 0x3F, 0x80, 0xFF, 0xF1, 0xFE, 0x01, 0xFF, 0x87, 0xF8, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x31, 0xFF, 0xF0, 0x07, 0xCF, 0xFF,
  0xC0, 0xFF, 0xBF, 0xFE, 0x01, 0xFE, 0xFF, 0xF8, 0x07, 0xFB, 0xFF, 0xE0,
  0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03,
  0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0xFF,
  0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0xFE,
  0x00, 0x7F, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80,
  0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F,
  0x80, 0x7F, 0x03, 0xFC, 0x01, 0xFC, 0x3F, 0xF0, 0x07, 0xF3, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x03, 0x03,
  0xF0, 0x3F, 0x07, 0xC0, 0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0x03, 0xF0, 0x7E,
  0x1F, 0x80, 0xFC, 0x1F, 0x87, 0xE0, 0x3F, 0x07, 0xE1, 0xF8, 0x1F, 0x81,
  0xF8, 0x7E, 0x07, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x1F, 0x87, 0xE0, 0x7E,
  0x07, 0xF3, 0xF0, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0xE0, 0x7E, 0x3F, 0x03,
  0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x01, 0xF8, 0xFC,
  0x0F, 0xC0, 0x7E, 0x7E, 0x03, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0x0F, 0xE7,
  0xE0, 0x7F, 0x03, 0xF1, 0xF8, 0x1F, 0x80, 0xFC, 0x7E, 0x07, 0xE0, 0x3F,
  0x1F, 0x81, 0xF8, 0x1F, 0x8F, 0xE0, 0xFE, 0x07, 0xE3, 0xF8, 0x3F, 0x81,
  0xF8, 0xFE, 0x1F, 0xE0, 0xFC, 0x3F, 0x8E, 0xF8, 0x7F, 0x0F, 0xFF, 0xBE,
  0x3F, 0x83, 0xFF, 0xCF, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0xE0, 0x1F, 0xF8,
  0x7F, 0xF0, 0x03, 0xFC, 0x1F, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x3F, 0xFF, 0x1F, 0xFE, 0x07, 0xFF, 0xF1, 0xFF, 0xF1, 0xFF, 0xBF,
  0x3C, 0x7F, 0x3F, 0xE1, 0xFB, 0x87, 0xF1, 0xFC, 0x1F, 0xB0, 0x3F, 0x0F,
  0x01, 0xFF, 0x03, 0xF0, 0xE0, 0x1F, 0xE0, 0x3F, 0x08, 0x01, 0xFE, 0x03,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFC, 0x07, 0xF8, 0x02, 0x0F, 0xC0, 0x7F, 0x80, 0x70, 0xFC,
  0x0F, 0xF8, 0x0F, 0x8F, 0xC0, 0xDF, 0x83, 0xF8, 0xFE, 0x1C, 0xFC, 0x7F,
  0xCF, 0xE3, 0xCF, 0xDF, 0xF8, 0xFF, 0xF8, 0xFF, 0xFE, 0x07, 0xFF, 0x8F,
  0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x07,
  0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x01,
  0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0,
  0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x7F, 0x81, 0xFC, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xE0, 0x3F, 0xF8, 0x0F,
  0xF8, 0x3B, 0xFC, 0x03, 0xFF, 0xF9, 0xFE, 0x01, 0xFF, 0xFC, 0xFE, 0x00,
  0x7F, 0xFC, 0x7F, 0x00, 0x1F, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x80, 0x03, 0xFC,
  0x00, 0xE0, 0x03, 0xFC, 0x00, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x1F, 0xC0, 0xFF, 0xFE, 0x0F, 0xC0, 0xFF, 0xFF, 0x8F, 0xE0, 0xFF,
  0xFF, 0xF7, 0xF0, 0x7F, 0x07, 0xFF, 0xF8, 0x3F, 0x00, 0xFF, 0xF8, 0x3F,
  0x00, 0x1F, 0xF8, 0x1F, 0x80, 0x0F, 0xF8, 0x0F, 0xC0, 0x0F, 0xF8, 0x07,
  0xE0, 0x0F, 0xF8, 0x03, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x04,
  0x00, 0x1F, 0xF0, 0x0E, 0x00, 0x1F, 0xF0, 0x1F, 0x80, 0x1F, 0xF0, 0x0F,
  0xC0, 0x1F, 0xF0, 0x03, 0xF0, 0x1F, 0xF0, 0x01, 0xF8, 0x1F, 0xF0, 0x00,
  0xFC, 0x1F, 0xFC, 0x00, 0x7E, 0x1F, 0xFF, 0xF0, 0x1F, 0x0F, 0xFF, 0xFF,
  0x8F, 0x8F, 0xE7, 0xFF, 0xFF, 0xC7, 0xF0, 0x7F, 0xFF, 0xC3, 0xF8, 0x0F,
  0xFF, 0xE1, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x1C, 0x01, 0xFF, 0x80, 0x0F, 0xC1, 0xFF, 0xE0,
  0x07, 0xE1, 0xFF, 0xF0, 0x07, 0xE1, 0xFF, 0xFC, 0x03, 0xF0, 0xFF, 0xFF,
  0x01, 0xF8, 0xFE, 0x3F, 0x81, 0xF8, 0x7E, 0x0F, 0xE1, 0xFC, 0x7E, 0x07,
  0xF8, 0xFC, 0x3F, 0x01, 0xFF, 0xFE, 0x1F, 0x00, 0xFF, 0xFE, 0x1F, 0x80,
  0x3F, 0xFE, 0x0F, 0xC0, 0x0F, 0xFE, 0x07, 0xC0, 0x03, 0xFE, 0x00, 0x60,
  0x00, 0x7C, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 16, 43, 36, 10, -42 },
  { 87, 22, 19, 36, 10, -44 },
  { 140, 38, 42, 36, 0, -42 },
  { 340, 34, 56, 36, 1, -49 },
  { 578, 42, 44, 36, -2, -43 },
  { 809, 36, 44, 36, 0, -43 },
  { 1007, 10, 19, 36, 16, -44 },
  { 1031, 24, 54, 36, 11, -46 },
  { 1193, 24, 54, 36, 2, -46 },
  { 1355, 31, 30, 36, 3, -33 },
  { 1472, 29, 29, 36, 4, -32 },
  { 1578, 16, 19, 36, 7, -10 },
  { 1616, 19, 7, 36, 9, -22 },
  { 1633, 12, 11, 36, 10, -10 },
  { 1650, 36, 54, 36, 0, -46 },
  { 1893, 32, 44, 36, 3, -43 },
  { 2069, 30, 42, 36, 3, -42 },
  { 2227, 33, 43, 36, 1, -43 },
  { 2405, 33, 44, 36, 1, -43 },
  { 2587, 33, 42, 36, 1, -42 },
  { 2761, 33, 43, 36, 2, -42 },
  { 2939, 30, 43, 36, 3, -42 },
  { 3101, 32, 42, 36, 5, -42 },
  { 3269, 33, 44, 36, 2, -43 },
  { 3451, 31, 43, 36, 4, -43 },
  { 3618, 15, 32, 36, 10, -31 },
  { 3678, 18, 40, 36, 7, -31 },
  { 3768, 29, 35, 36, 5, -36 },
  { 3895, 31, 18, 36, 3, -28 },
  { 3965, 29, 35, 36, 3, -36 },
  { 4092, 27, 44, 36, 7, -43 },
  { 4241, 32, 50, 36, 3, -43 },
  { 4441, 35, 42, 36, -2, -42 },
  { 4625, 32, 42, 36, 2, -42 },
  { 4793, 33, 44, 36, 3, -43 },
  { 4975, 33, 42, 36, 2, -42 },
  { 5149, 34, 42, 36, 2, -42 },
  { 5328, 35, 42, 36, 2, -42 },
  { 5512, 32, 44, 36, 3, -43 },
  { 5688, 34, 42, 36, 2, -42 },
  { 5867, 34, 42, 36, 2, -42 },
  { 6046, 32, 43, 36, 2, -42 },
  { 6218, 38, 42, 36, 2, -42 },
  { 6418, 27, 42, 36, 4, -42 },
  { 6560, 38, 42, 36, 0, -42 },
  { 6760, 34, 42, 36, 2, -42 },
  { 6939, 32, 44, 36, 3, -43 },
  { 7115, 34, 42, 36, 2, -42 },
  { 7294, 32, 55, 36, 3, -43 },
  { 7514, 33, 42, 36, 2, -42 },
  { 7688, 34, 44, 36, 1, -43 },
  { 7875, 34, 42, 36, 5, -42 },
  { 8054, 34, 43, 36, 3, -42 },
  { 8237, 33, 42, 36, 6, -42 },
  { 8411, 38, 42, 36, 1, -42 },
  { 8611, 41, 42, 36, -2, -42 },
  { 8827, 35, 42, 36, 5, -42 },
  { 9011, 37, 42, 36, 0, -42 },
  { 9206, 27, 54, 36, 8, -46 },
  { 9389, 17, 54, 36, 10, -46 },
  { 9504, 28, 54, 36, 1, -46 },
  { 9693, 32, 26, 36, 3, -42 },
  { 9797, 29, 6, 36, 0, 5 },
  { 9819, 10, 13, 36, 12, -48 },
  { 9836, 31, 33, 36, 3, -32 },
  { 9964, 31, 45, 36, 2, -44 },
  { 10139, 28, 33, 36, 4, -32 },
  { 10255, 33, 45, 36, 3, -44 },
  { 10441, 29, 33, 36, 4, -32 },
  { 10561, 41, 57, 36, -2, -44 },
  { 10854, 33, 45, 36, 1, -32 },
  { 11040, 30, 44, 36, 2, -44 },
  { 11205, 29, 46, 36, 4, -45 },
  { 11372, 30, 58, 36, 1, -45 },
  { 11590, 33, 45, 36, 2, -44 },
  { 11776, 25, 45, 36, 6, -44 },
  { 11917, 35, 32, 36, 0, -32 },
  { 12057, 30, 32, 36, 2, -32 },
  { 12177, 30, 33, 36, 3, -32 },
  { 12301, 33, 44, 36, 0, -32 },
  { 12483, 31, 44, 36, 3, -32 },
  { 12654, 30, 31, 36, 6, -31 },
  { 12771, 29, 33, 36, 3, -32 },
  { 12891, 29, 43, 36, 4, -42 },
  { 13047, 30, 32, 36, 4, -31 },
  { 13167, 30, 33, 36, 3, -32 },
  { 13291, 34, 32, 36, 1, -31 },
  { 13427, 36, 33, 36, 0, -32 },
  { 13576, 33, 44, 36, 1, -31 },
  { 13758, 33, 33, 36, 2, -32 },
  { 13895, 29, 54, 36, 6, -46 },
  { 14091, 15, 54, 36, 11, -46 },
  { 14193, 29, 54, 36, 2, -46 },
  { 14389, 33, 15, 36, 2, -26 },
};

const GFXfont IBMPlexMono_SemiBoldItalic60pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic60pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic60pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC60PT7B_H_
