#ifndef _IBMPLEXMONO_SEMIBOLDITALIC37PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x7E, 0x1F, 0x87, 0xE3, 0xF8, 0x7E, 0x1F, 0x00, 0x3C, 0x3C,
  0xF0, 0xF3, 0xC7, 0xCF, 0x1E, 0x7C, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1E,
  0x78, 0xF9, 0xE3, 0xCF, 0x8F, 0x3C, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x78,
  0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E,
  0x00, 0x1C, 0x38, 0x00, 0x78, 0xF0, 0x1F, 0xF1, 0xFE, 0x3F, 0xC3, 0xFC,
  0x7F, 0x8F, 0xF8, 0x0F, 0x1E, 0x00, 0x3C, 0x38, 0x00, 0x78, 0xF0, 0x00,
  0xF1, 0xE0, 0x3F, 0xC7, 0xFC, 0xFF, 0x8F, 0xF1, 0xFF, 0x1F, 0xE0, 0x3C,
  0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F,
  0x00, 0x0E, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0x9D, 0xF0, 0xF8, 0xE3,
  0x07, 0x8F, 0x10, 0x7C, 0x70, 0x03, 0xE3, 0x80, 0x0F, 0x9C, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0xEF, 0xC0, 0x07, 0x3E, 0x00, 0x38, 0xF0, 0x03, 0x87, 0xC4, 0x1C,
  0x3C, 0x70, 0xE3, 0xE7, 0xE7, 0x3F, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x01,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0xFF, 0x01, 0xE0, 0x7F,
  0xC0, 0xF0, 0x3C, 0x70, 0x38, 0x1E, 0x1E, 0x1E, 0x07, 0x87, 0x8F, 0x01,
  0xE1, 0xE3, 0x80, 0x70, 0x71, 0xE0, 0x1C, 0x1C, 0xF0, 0x07, 0x8F, 0x38,
  0x00, 0xFF, 0x9E, 0x00, 0x3F, 0xC8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xBF, 0xF0, 0x03, 0xCF, 0x1C, 0x00,
  0xE7, 0x87, 0x00, 0x79, 0xE1, 0xC0, 0x3C, 0x70, 0x70, 0x1E, 0x1C, 0x1C,
  0x07, 0x07, 0x0F, 0x03, 0xC1, 0xE3, 0x81, 0xE0, 0x7F, 0xE0, 0x70, 0x0F,
  0xF0, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x7C, 0x78, 0x03, 0xE1, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F,
  0x00, 0xF0, 0x3C, 0x03, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00,
  0x7C, 0xF0, 0x0F, 0xFF, 0x00, 0x7B, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x1E,
  0x00, 0x78, 0x7C, 0x03, 0xE0, 0xF0, 0x0F, 0x83, 0xE1, 0x3E, 0x0F, 0x8F,
  0xF8, 0x3E, 0x3F, 0xE0, 0xBD, 0xE7, 0xC6, 0xFF, 0x9F, 0xF3, 0xFC, 0x3F,
  0x87, 0xE0, 0x7C, 0x0F, 0x00, 0x3C, 0xF3, 0xDF, 0x79, 0xE7, 0x9E, 0x7B,
  0xEF, 0x3C, 0x00, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xE1, 0xE1, 0xDF, 0x3D, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x3E, 0xF8, 0x0F, 0x8F, 0x03, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0x03,
  0x80, 0x40, 0x40, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xFF, 0xFF, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC3, 0xE1,
  0xF8, 0x7C, 0x3F, 0x0F, 0x83, 0xE1, 0xF0, 0x78, 0x1E, 0x0F, 0x00, 0x7F,
  0xF7, 0xFF, 0x7F, 0xFF, 0xFF, 0x3E, 0x7E, 0x7F, 0xFE, 0xFE, 0x7E, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0x87, 0xE3, 0xE0, 0x3E, 0x3E, 0x01,
  0xE7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x8F,
  0x1F, 0xF9, 0xF3, 0xEF, 0x9F, 0x3E, 0xF8, 0xE3, 0xEF, 0x00, 0x3E, 0xF0,
  0x03, 0xEF, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x7C, 0xF8, 0x0F, 0x8F,
  0xC3, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07,
  0xEF, 0x83, 0xF3, 0xE0, 0xF8, 0xF8, 0x7C, 0x3C, 0x0E, 0x0F, 0x01, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x83, 0xF1,
  0xF0, 0x1F, 0x3E, 0x01, 0xF0, 0x60, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0,
  0xFF, 0xFF, 0x1F, 0x83, 0xF0, 0xE0, 0x1F, 0x04, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x07, 0xE3, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0xC1, 0xFC, 0xFF,
  0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1E,
  0xF0, 0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x00, 0xF3, 0xE0, 0x0F, 0x1F, 0x00,
  0xF0, 0xF8, 0x0F, 0x87, 0x80, 0xF8, 0x3C, 0x07, 0x83, 0xE0, 0x78, 0x1F,
  0x07, 0x80, 0xF8, 0x78, 0x07, 0xC3, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF1, 0xF0, 0x07, 0xBF, 0xE0, 0x3B,
  0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0x83, 0xF0, 0xF0, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x20, 0x07, 0xC7, 0x80,
  0x7C, 0x7E, 0x07, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xCF, 0xC1, 0xF3, 0xFC, 0x3E, 0xFF, 0xC7, 0xBF, 0xFD, 0xFC, 0x1F,
  0xBF, 0x01, 0xF7, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x1F,
  0x7C, 0x03, 0xEF, 0x80, 0xFD, 0xF8, 0x3F, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0,
  0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x78, 0x03, 0xE7, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x00,
  0xF8, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFC, 0x1F, 0x0F,
  0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF8, 0x0F,
  0x83, 0xE0, 0xF8, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x7F,
  0xFF, 0x07, 0xC0, 0xFC, 0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9,
  0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7E, 0x07, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0,
  0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0xBE, 0x00, 0xF7,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x07, 0xEF,
  0xC1, 0xFD, 0xFF, 0xEF, 0x9F, 0xFF, 0xE1, 0xFF, 0x7C, 0x1F, 0x9F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x0F, 0x87, 0xF1,
  0xFC, 0x7F, 0x3F, 0x87, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x87, 0xE1, 0xFC, 0xFE, 0x3F, 0x87, 0xE1, 0xF0, 0x03, 0xE0,
  0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7E, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x1F, 0x81,
  0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00,
  0x00, 0x80, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03,
  0xE0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x0F,
  0xFF, 0xCF, 0xFF, 0xE7, 0xC1, 0xFF, 0xC0, 0x7C, 0xC0, 0x3E, 0x20, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xF8,
  0x3E, 0x1E, 0x01, 0xE1, 0xE0, 0x0E, 0x3C, 0x00, 0xE3, 0xC3, 0xCF, 0x78,
  0x7E, 0xE7, 0x8F, 0xEE, 0x79, 0xF1, 0xEF, 0x1E, 0x1E, 0xF3, 0xC1, 0xEF,
  0x3C, 0x1E, 0xF3, 0xC1, 0xEF, 0x3C, 0x1C, 0xF3, 0xC3, 0xCE, 0x3C, 0x3C,
  0xE3, 0xC3, 0xCE, 0x3C, 0x7C, 0xE3, 0xFB, 0xCE, 0x1F, 0xB8, 0xE1, 0xF7,
  0x8F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xEF,
  0x80, 0x1F, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x78, 0x78, 0x07,
  0xC3, 0xC0, 0x3C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3E, 0x01, 0xE3, 0xE0,
  0x0F, 0x9F, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFF,
  0xC0, 0x07, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F,
  0x01, 0xF1, 0xF0, 0x1E, 0x1F, 0x07, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xE0, 0x7C, 0x3E, 0x03, 0xE3, 0xE0, 0x3E,
  0x3C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xE7, 0xC0, 0xFC, 0x7F, 0xFF,
  0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x83, 0xF1, 0xF0, 0x1F, 0x3E,
  0x01, 0xF3, 0xE0, 0x1E, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x20, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0x7C, 0x0F,
  0xC7, 0xE1, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xF8, 0x3F, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x1E, 0x1F, 0x00,
  0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x3C, 0x3C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F,
  0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xE0, 0x1F,
  0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3E, 0x0F, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0x87, 0xE3, 0xF0, 0x3E, 0x3E, 0x01,
  0xE7, 0xE0, 0x1D, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x7F, 0xEF, 0x87, 0xFC, 0xF8, 0x7F, 0xCF, 0x87, 0xFC, 0xF8,
  0x03, 0xCF, 0x80, 0x3C, 0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x87,
  0xC1, 0xF8, 0x7F, 0xF7, 0x83, 0xFE, 0xF8, 0x3F, 0xEF, 0x80, 0xF8, 0xF0,
  0x0F, 0x80, 0x78, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1E, 0x01, 0xF1, 0xF0,
  0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0,
  0xF0, 0x0F, 0x87, 0x80, 0x7C, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x87, 0x80, 0x7C, 0x3C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F,
  0x00, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3C, 0x03, 0xE1, 0xE0, 0x1F,
  0x1F, 0x00, 0xF8, 0xF8, 0x07, 0x87, 0xC0, 0x7C, 0x00, 0x07, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x18, 0x0F, 0x8F, 0x80, 0xF8, 0x78, 0x0F, 0x87, 0xC3,
  0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0x80, 0x7E, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0,
  0x3E, 0x01, 0xE0, 0xFC, 0x07, 0xC3, 0xF0, 0x0F, 0x8F, 0xC0, 0x1F, 0x3F,
  0x00, 0x3E, 0xFC, 0x00, 0x79, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xDF, 0x00, 0x3F, 0x3F, 0x00,
  0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F,
  0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0xF8, 0x03, 0xE1, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0,
  0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x1F,
  0xC1, 0xFC, 0x3F, 0x87, 0xB8, 0xFF, 0x0F, 0x79, 0xDE, 0x1E, 0xF7, 0xBC,
  0x3D, 0xEE, 0x78, 0x79, 0xFD, 0xE0, 0xF3, 0xF3, 0xC3, 0xE7, 0xE7, 0x87,
  0x8F, 0x8F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1C, 0x7C, 0x3C, 0x30, 0xF0, 0x78,
  0x61, 0xE1, 0xF0, 0x83, 0xC3, 0xC1, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00,
  0x3E, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF8, 0x01, 0xE1, 0xE0, 0x03,
  0xC0, 0x0F, 0xC0, 0x78, 0x7E, 0x03, 0xC3, 0xF8, 0x1E, 0x1F, 0xC0, 0xF1,
  0xFE, 0x0F, 0x8F, 0xF0, 0x7C, 0x7F, 0x83, 0xC3, 0xDE, 0x1E, 0x1E, 0xF0,
  0xF0, 0xF7, 0x87, 0x87, 0xBC, 0x3C, 0x7D, 0xE3, 0xE3, 0xC7, 0x9E, 0x1E,
  0x3C, 0xF0, 0xF1, 0xE7, 0x87, 0x8F, 0x3C, 0x3C, 0x79, 0xE3, 0xE1, 0xFF,
  0x1E, 0x0F, 0xF0, 0xF0, 0x7F, 0x87, 0x83, 0xFC, 0x3C, 0x1F, 0xE1, 0xE0,
  0x7F, 0x1F, 0x03, 0xF8, 0xF0, 0x1F, 0x87, 0x80, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0x87, 0xE3, 0xF0,
  0x3E, 0x3E, 0x01, 0xE7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x80, 0xFC,
  0xF8, 0x0F, 0x8F, 0xC3, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC,
  0x00, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xF8, 0x1F, 0x87, 0xC0, 0x7C, 0x3C, 0x03, 0xE1, 0xE0, 0x1F,
  0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0x87,
  0xE3, 0xF0, 0x3E, 0x3E, 0x01, 0xE7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8,
  0x03, 0xEF, 0x80, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x7C, 0xF0, 0x07, 0xCF,
  0x80, 0xFC, 0xF8, 0x0F, 0x8F, 0xC3, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x80, 0x1F, 0x1C, 0x00, 0xFB,
  0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xF8, 0x1F,
  0x87, 0xC0, 0x7C, 0x3C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x0F, 0xC7, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x07,
  0x80, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x0F,
  0x81, 0xF0, 0x78, 0x07, 0xC7, 0xC0, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFC, 0x1F, 0x0F, 0x80, 0x30,
  0x7C, 0x01, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x40, 0x07,
  0xC7, 0x00, 0x7E, 0x7E, 0x07, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0x87, 0x80, 0x7C, 0x7C, 0x03,
  0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0x87, 0xC0, 0x3C, 0x3C,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3C,
  0x3E, 0x01, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x3E, 0x3E, 0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7E, 0x0F, 0x81,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0xF8,
  0x00, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x3E,
  0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0x83, 0xE0,
  0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x3E, 0x03, 0xC1, 0xF0, 0x1F, 0x0F, 0x00,
  0xF8, 0xF8, 0x07, 0xC7, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9E,
  0x00, 0x7D, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x78,
  0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80,
  0x07, 0x8F, 0x1F, 0x0F, 0x1E, 0x3E, 0x1C, 0x7C, 0x7C, 0x78, 0xF1, 0xF8,
  0xF1, 0xE3, 0xF1, 0xE3, 0xC7, 0xE3, 0xC7, 0x9D, 0xCF, 0x0F, 0x3B, 0x9E,
  0x1E, 0x77, 0x3C, 0x3D, 0xCE, 0x78, 0x7B, 0x9C, 0xE0, 0xF7, 0x3B, 0xC1,
  0xDC, 0x77, 0x87, 0xB8, 0xEF, 0x0F, 0x71, 0xDC, 0x1F, 0xC3, 0xB8, 0x3F,
  0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x00, 0x07,
  0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0x80,
  0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xC0, 0x01, 0xF7, 0xE0,
  0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xF3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0xF8,
  0xFC, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFD,
  0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0xF8, 0x3E, 0x07, 0xE0, 0xF8,
  0x1F, 0x03, 0xE0, 0xF8, 0x07, 0x83, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0xF8,
  0x00, 0xF3, 0xE0, 0x03, 0xDF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xF0,
  0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0x9E, 0x01, 0xE3,
  0xE0, 0x7C, 0x7C, 0x1F, 0x07, 0x83, 0xC0, 0xF8, 0xF8, 0x0F, 0x3E, 0x01,
  0xE7, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x79, 0x00, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x19, 0xF1, 0xE3, 0xE3, 0xC7, 0x87, 0x84,
  0x07, 0xE3, 0xE1, 0xFE, 0x78, 0x7F, 0xEF, 0x1F, 0x87, 0xE7, 0xC0, 0x7C,
  0xF8, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3C, 0xF8, 0x07, 0x9F, 0x01, 0xF3,
  0xE0, 0x3E, 0x78, 0x07, 0xCF, 0x00, 0xF9, 0xE0, 0x3F, 0x3E, 0x0F, 0xC7,
  0xC3, 0xF8, 0xFF, 0xDF, 0xCF, 0xF1, 0xF8, 0xFC, 0x1F, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x1F, 0x81, 0xF3, 0xFC, 0x1F,
  0x7F, 0xE1, 0xEC, 0x3E, 0x1F, 0x83, 0xE3, 0xF0, 0x1F, 0x3E, 0x01, 0xF3,
  0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x1E, 0x3C, 0x03, 0xE7, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xE0, 0xF8, 0x7B, 0xFF,
  0x0F, 0xBF, 0xE0, 0xF8, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF,
  0xF8, 0x7C, 0x3F, 0x3E, 0x07, 0x8F, 0x01, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0x3E,
  0x01, 0xE7, 0xC0, 0xF9, 0xF8, 0x7C, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x03, 0xE3, 0xE0,
  0xFF, 0xBE, 0x1F, 0xFB, 0xE3, 0xF0, 0xFE, 0x7C, 0x07, 0xC7, 0xC0, 0x7C,
  0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x07,
  0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x01, 0xF8, 0xF8, 0x3F, 0x8F, 0xC6,
  0xF0, 0x7F, 0xEF, 0x07, 0xFD, 0xF0, 0x1F, 0x1F, 0x00, 0x00, 0xFC, 0x01,
  0xFF, 0xC0, 0xFF, 0xF8, 0x7E, 0x1F, 0x3E, 0x07, 0xCF, 0x00, 0xF7, 0xC0,
  0x7D, 0xF0, 0x3F, 0xF8, 0x7F, 0xBF, 0xFF, 0xCF, 0xFF, 0xC3, 0xFF, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0xC7, 0x80, 0x7D, 0xF0, 0x7E, 0x3F, 0xFF, 0x07,
  0xFF, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x0C, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xE7,
  0xC0, 0x00, 0xFB, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x7F, 0xDF, 0x0F, 0xFD, 0xF1, 0xF8,
  0x7F, 0x3F, 0x03, 0xE3, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0x80, 0x7C, 0x7C, 0x07, 0xC7,
  0xC0, 0xFC, 0x7C, 0x0F, 0xC7, 0xE3, 0x78, 0x3F, 0xF7, 0x83, 0xFE, 0x78,
  0x0F, 0x8F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x02, 0x01, 0xF0, 0x70, 0x3E,
  0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x1F, 0x03, 0xE7, 0xF8, 0x7D, 0xFF, 0x0F, 0xE3,
  0xF1, 0xF8, 0x3E, 0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03,
  0xE7, 0xC0, 0x7C, 0xF0, 0x0F, 0x1E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F,
  0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x78, 0x07, 0x8F, 0x01, 0xF3, 0xE0, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x20, 0x7C, 0x3C,
  0x3E, 0x3E, 0x1F, 0x3E, 0x0F, 0x3E, 0x07, 0xBE, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x81, 0xF0, 0xF0, 0x78, 0x3E, 0x1E, 0x07, 0xCF,
  0x80, 0xF3, 0xE0, 0x3E, 0xF8, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x1F, 0x80,
  0xF9, 0xFE, 0x07, 0xDF, 0xF8, 0x3F, 0x8F, 0xC1, 0xF8, 0x3E, 0x0F, 0x81,
  0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x78, 0x3E, 0x07, 0x81, 0xF0, 0xF8, 0x0F,
  0x3F, 0x00, 0x7B, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x39, 0xF1, 0xF3,
  0xEF, 0x8F, 0xBC, 0x78, 0x3F, 0xC3, 0xC1, 0xFC, 0x3E, 0x07, 0xC0, 0x7F,
  0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x83, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F,
  0x04, 0x1F, 0x07, 0x1F, 0x0F, 0x1F, 0x1E, 0x1F, 0x7C, 0x1E, 0xF8, 0x1F,
  0xF0, 0x1F, 0xE0, 0x0F, 0x80, 0x1E, 0x70, 0xF0, 0x7B, 0xE7, 0xE1, 0xFF,
  0xDF, 0xCF, 0x8F, 0x9F, 0x3E, 0x3C, 0x3C, 0xF0, 0xF0, 0xF3, 0xC3, 0xC7,
  0x8F, 0x1E, 0x1E, 0x38, 0x78, 0x79, 0xE1, 0xE1, 0xE7, 0x87, 0x87, 0x9E,
  0x1E, 0x1E, 0x78, 0x78, 0xF1, 0xE3, 0xC3, 0xC7, 0x0F, 0x0F, 0x3C, 0x3C,
  0x3C, 0xF0, 0xF0, 0xF3, 0xC3, 0xC3, 0x8F, 0x0F, 0x1E, 0x00, 0x1F, 0x1F,
  0x03, 0xE7, 0xF8, 0x7D, 0xFF, 0x0F, 0xE3, 0xF1, 0xE8, 0x3E, 0x3E, 0x07,
  0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF0, 0x0F,
  0x1E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E,
  0x78, 0x07, 0x8F, 0x01, 0xF3, 0xE0, 0x3E, 0x00, 0x01, 0xFC, 0x01, 0xFF,
  0xC1, 0xFF, 0xF8, 0xFC, 0x3E, 0x3E, 0x07, 0xDF, 0x00, 0xF7, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0,
  0x07, 0xFE, 0x03, 0xEF, 0x80, 0xF9, 0xF0, 0xFC, 0x3F, 0xFE, 0x07, 0xFF,
  0x00, 0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x7C, 0xFF, 0x03, 0xEF, 0xFC, 0x1E,
  0xC3, 0xE0, 0xFC, 0x1F, 0x0F, 0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F,
  0x1F, 0x00, 0xF8, 0xF0, 0x07, 0x87, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0,
  0x1F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xE0, 0xF8, 0x7D, 0xFF, 0x83,
  0xEF, 0xF8, 0x1F, 0x1F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE3, 0xE1, 0xFF, 0x7C, 0x7F, 0xEF, 0x9F, 0x87, 0xE7, 0xC0, 0x7C,
  0xF8, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xF3,
  0xE0, 0x1E, 0x78, 0x07, 0xCF, 0x00, 0xF9, 0xE0, 0x3F, 0x3E, 0x0F, 0xE7,
  0xE3, 0x78, 0x7F, 0xEF, 0x0F, 0xFB, 0xE0, 0x7C, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xFB, 0xFC, 0x3E, 0xFE, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x03,
  0xFF, 0xE1, 0xFF, 0xFC, 0x7C, 0x1E, 0x3E, 0x01, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0x90, 0x03, 0xE6, 0x00, 0xFB, 0xE0, 0x7C, 0xFF, 0xFE, 0x1F,
  0xFF, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC3, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x83, 0xE0, 0xE1, 0xF1,
  0xF8, 0xF9, 0xF0, 0x79, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x03, 0xC0, 0x00,
  0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9E, 0x01, 0xE3, 0xC0, 0x7C,
  0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x00, 0xF3,
  0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3F, 0x3E, 0x0B, 0xC7,
  0xE3, 0x78, 0x7F, 0xDF, 0x0F, 0xF3, 0xE0, 0x7C, 0x7C, 0x00, 0xFF, 0x01,
  0xBF, 0xC3, 0xFF, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0x80, 0xF1,
  0xE0, 0x3C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x78, 0xF8,
  0x3E, 0x3C, 0x0F, 0x0F, 0x07, 0xC3, 0xC3, 0xE0, 0xF3, 0xF0, 0x3F, 0xF8,
  0x0F, 0xF8, 0x01, 0xF8, 0x00, 0x3C, 0x38, 0x63, 0xC3, 0x8F, 0x38, 0x78,
  0xF3, 0x87, 0x8F, 0x78, 0x78, 0xF7, 0x87, 0x8F, 0x78, 0x70, 0xF7, 0x87,
  0x0F, 0x78, 0xF0, 0xF7, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0E, 0xF0,
  0xF0, 0xEF, 0x1E, 0x1E, 0xF1, 0xE1, 0xCF, 0x3E, 0x3C, 0xFE, 0xE3, 0x8F,
  0xE7, 0xF0, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x1F, 0xC7, 0xF1, 0xFF,
  0x3F, 0xCF, 0xDE, 0xCF, 0x7C, 0x7E, 0x3C, 0x61, 0xF0, 0xF0, 0x07, 0xC3,
  0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x70, 0xF8, 0x23, 0xC3, 0xE1, 0xCF, 0x1F, 0x8F, 0xBC, 0x6E,
  0x7C, 0xFF, 0x3F, 0xE1, 0xF8, 0xFF, 0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x80,
  0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x0F,
  0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0xF0, 0x0F,
  0x07, 0x80, 0x78, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xF0, 0xF8,
  0x2F, 0x03, 0xE3, 0x78, 0x1F, 0xF7, 0xC0, 0x7F, 0x3E, 0x01, 0xF1, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x08, 0x07, 0xC0, 0xE0, 0xFC, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0xF0, 0xFF, 0xCF,
  0x1F, 0xFE, 0xF1, 0xE1, 0xFF, 0x3C, 0x07, 0xE3, 0xC0, 0xFC, 0x3C, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x80, 0x7E,
  0x1C, 0x0F, 0x83, 0xC1, 0xF0, 0x1E, 0x3F, 0x01, 0xE7, 0xFF, 0x8E, 0xFF,
  0xFF, 0xEF, 0x0F, 0xFC, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x00,
  0x03, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xFF,
  0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0x80, 0x70, 0xFF, 0x03, 0xCF, 0xF8, 0x3C, 0x79,
  0xE1, 0xC7, 0x8F, 0x9E, 0x38, 0x3F, 0xE3, 0xC0, 0xFE, 0x0C, 0x03, 0xE0,
};

const GFXglyph IBMPlexMono_SemiBoldItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 10, 26, 22, 6, -26 },
  { 34, 14, 12, 22, 6, -27 },
  { 55, 23, 26, 22, 0, -26 },
  { 130, 21, 34, 22, 1, -30 },
  { 220, 26, 26, 22, -1, -26 },
  { 305, 22, 26, 22, 0, -26 },
  { 377, 6, 12, 22, 10, -27 },
  { 386, 15, 33, 22, 7, -28 },
  { 448, 15, 33, 22, 1, -28 },
  { 510, 19, 19, 22, 2, -20 },
  { 556, 19, 17, 22, 2, -20 },
  { 597, 10, 11, 22, 4, -6 },
  { 611, 12, 4, 22, 5, -13 },
  { 617, 8, 7, 22, 6, -7 },
  { 624, 22, 33, 22, 0, -28 },
  { 715, 20, 26, 22, 2, -26 },
  { 780, 18, 26, 22, 2, -26 },
  { 839, 20, 26, 22, 1, -26 },
  { 904, 20, 26, 22, 1, -26 },
  { 969, 21, 26, 22, 0, -26 },
  { 1038, 21, 26, 22, 1, -26 },
  { 1107, 19, 26, 22, 2, -26 },
  { 1169, 20, 26, 22, 3, -26 },
  { 1234, 21, 26, 22, 1, -26 },
  { 1303, 19, 26, 22, 3, -26 },
  { 1365, 10, 20, 22, 6, -20 },
  { 1390, 12, 25, 22, 4, -20 },
  { 1428, 18, 22, 22, 3, -22 },
  { 1478, 19, 11, 22, 2, -17 },
  { 1505, 18, 22, 22, 2, -22 },
  { 1555, 17, 26, 22, 4, -26 },
  { 1611, 20, 30, 22, 2, -26 },
  { 1686, 21, 26, 22, -1, -26 },
  { 1755, 20, 26, 22, 1, -26 },
  { 1820, 20, 26, 22, 2, -26 },
  { 1885, 21, 26, 22, 1, -26 },
  { 1954, 21, 26, 22, 1, -26 },
  { 2023, 22, 26, 22, 1, -26 },
  { 2095, 20, 26, 22, 2, -26 },
  { 2160, 21, 26, 22, 1, -26 },
  { 2229, 21, 26, 22, 1, -26 },
  { 2298, 20, 26, 22, 1, -26 },
  { 2363, 23, 26, 22, 1, -26 },
  { 2438, 17, 26, 22, 2, -26 },
  { 2494, 23, 26, 22, 0, -26 },
  { 2569, 21, 26, 22, 1, -26 },
  { 2638, 20, 26, 22, 2, -26 },
  { 2703, 21, 26, 22, 1, -26 },
  { 2772, 20, 33, 22, 2, -26 },
  { 2855, 21, 26, 22, 1, -26 },
  { 2924, 21, 26, 22, 1, -26 },
  { 2993, 21, 26, 22, 3, -26 },
  { 3062, 21, 26, 22, 2, -26 },
  { 3131, 21, 26, 22, 3, -26 },
  { 3200, 23, 26, 22, 1, -26 },
  { 3275, 25, 26, 22, -1, -26 },
  { 3357, 22, 26, 22, 3, -26 },
  { 3429, 23, 26, 22, 0, -26 },
  { 3504, 17, 33, 22, 5, -28 },
  { 3575, 11, 33, 22, 6, -28 },
  { 3621, 17, 33, 22, 1, -28 },
  { 3692, 19, 16, 22, 2, -26 },
  { 3730, 18, 3, 22, 0, 3 },
  { 3737, 7, 8, 22, 7, -29 },
  { 3744, 19, 19, 22, 2, -19 },
  { 3790, 20, 27, 22, 1, -27 },
  { 3858, 18, 19, 22, 2, -19 },
  { 3901, 20, 27, 22, 2, -27 },
  { 3969, 18, 19, 22, 2, -19 },
  { 4012, 25, 34, 22, -1, -27 },
  { 4119, 20, 26, 22, 1, -19 },
  { 4184, 19, 27, 22, 1, -27 },
  { 4249, 17, 29, 22, 3, -29 },
  { 4311, 18, 36, 22, 1, -29 },
  { 4392, 21, 27, 22, 1, -27 },
  { 4463, 16, 27, 22, 3, -27 },
  { 4517, 22, 19, 22, 0, -19 },
  { 4570, 19, 19, 22, 1, -19 },
  { 4616, 18, 19, 22, 2, -19 },
  { 4659, 21, 26, 22, 0, -19 },
  { 4728, 19, 26, 22, 2, -19 },
  { 4790, 18, 19, 22, 4, -19 },
  { 4833, 18, 19, 22, 2, -19 },
  { 4876, 17, 26, 22, 3, -26 },
  { 4932, 19, 19, 22, 2, -19 },
  { 4978, 18, 19, 22, 2, -19 },
  { 5021, 20, 19, 22, 1, -19 },
  { 5069, 22, 19, 22, 0, -19 },
  { 5122, 21, 26, 22, 0, -19 },
  { 5191, 20, 19, 22, 1, -19 },
  { 5239, 18, 33, 22, 4, -28 },
  { 5314, 9, 33, 22, 7, -28 },
  { 5352, 18, 33, 22, 1, -28 },
  { 5427, 21, 8, 22, 1, -15 },
};

const GFXfont IBMPlexMono_SemiBoldItalic37pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic37pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic37pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC37PT7B_H_
