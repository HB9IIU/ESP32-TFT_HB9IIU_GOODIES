#ifndef _IBMPLEXMONO_SEMIBOLDITALIC51PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFE, 0x07,
  0xE0, 0x00, 0x3F, 0x07, 0xE7, 0xE0, 0xF8, 0xFC, 0x3F, 0x1F, 0x07, 0xE7,
  0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7C, 0x7E, 0x1F, 0x8F,
  0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3E, 0x3F,
  0x0F, 0xC7, 0xE1, 0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x1F, 0x07, 0xC0,
  0x0F, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFF,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0,
  0xFF, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xE0, 0xF8, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0x7D, 0xFC, 0x0F, 0xE3, 0xC3, 0xC0,
  0xFE, 0x1E, 0x0C, 0x07, 0xE0, 0xF0, 0x40, 0x3F, 0x07, 0x80, 0x01, 0xF8,
  0x3C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7F, 0x1E, 0x00, 0x03, 0xF8, 0xF0,
  0x00, 0x1F, 0xF7, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0x3F, 0xC0, 0x00, 0xF8,
  0xFE, 0x00, 0x07, 0x83, 0xF0, 0x00, 0x3C, 0x1F, 0x80, 0x01, 0xE0, 0xFC,
  0x00, 0x0F, 0x07, 0xE0, 0xC0, 0x78, 0x7F, 0x0F, 0x03, 0xC3, 0xF0, 0xFC,
  0x3E, 0x3F, 0x8F, 0xF9, 0xE7, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x07, 0xFE, 0x00, 0x3E, 0x00, 0xFF, 0xE0, 0x07, 0xC0, 0x1F, 0xFF, 0x00,
  0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0x80, 0x3E, 0x0F, 0x81, 0xF0, 0x07, 0xC0,
  0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x7E, 0x00,
  0x7C, 0x0F, 0x87, 0xC0, 0x07, 0xC0, 0xF8, 0xF8, 0x00, 0x78, 0x0F, 0x0F,
  0x80, 0x07, 0x81, 0xF1, 0xF0, 0x00, 0x7C, 0x1F, 0x3E, 0x00, 0x07, 0xC3,
  0xE3, 0xE0, 0x00, 0x3F, 0xFE, 0x7C, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF3, 0xFF, 0xE0, 0x00, 0x3E,
  0x7C, 0x3E, 0x00, 0x07, 0xC7, 0x81, 0xE0, 0x00, 0xF8, 0xF8, 0x1E, 0x00,
  0x0F, 0x8F, 0x81, 0xF0, 0x01, 0xF0, 0xF0, 0x1F, 0x00, 0x3E, 0x1F, 0x01,
  0xE0, 0x07, 0xE1, 0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x03, 0xE0, 0x0F, 0x81,
  0xF0, 0x3E, 0x01, 0xF0, 0x0F, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0xFC, 0x03,
  0xE0, 0x0F, 0xFF, 0x80, 0x7C, 0x00, 0x7F, 0xF0, 0x07, 0xC0, 0x03, 0xFE,
  0x00, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0x0F,
  0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xFF, 0x7F, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x0F, 0xC0,
  0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x03, 0x3F,
  0x80, 0xFE, 0x1E, 0xFE, 0x03, 0xF8, 0x7F, 0xF8, 0x1B, 0xF3, 0xF7, 0xF0,
  0xEF, 0xDF, 0x9F, 0xFF, 0xBF, 0xFE, 0x7F, 0xFE, 0x7F, 0xF0, 0xFF, 0xF1,
  0xFF, 0x83, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xE0, 0x0F,
  0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7C, 0xFC, 0xFC, 0xFC, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x01, 0xC0, 0x7C, 0x0F, 0x3F, 0x1F, 0x8F, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF1, 0xF8, 0x01, 0xFC, 0x3F, 0x80,
  0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x0E, 0x00,
  0x60, 0x00, 0x80, 0x08, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC,
  0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xE7, 0xFF, 0xF7, 0xFF, 0xF8, 0x1F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFB, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0xFE,
  0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x07,
  0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F,
  0x00, 0x07, 0xF7, 0xF0, 0xF0, 0x7F, 0x7F, 0x1F, 0x87, 0xF7, 0xF1, 0xF8,
  0x7F, 0x7E, 0x1F, 0x87, 0xEF, 0xE1, 0xF8, 0xFE, 0xFE, 0x1F, 0x0F, 0xEF,
  0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF8,
  0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x03, 0xF8,
  0x1F, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0xC7, 0xE0, 0x0F, 0xE1,
  0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x7C, 0x0F, 0xE0, 0x0E,
  0x03, 0xF0, 0x01, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xC1, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x07,
  0xF0, 0x1C, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xE0, 0x0F, 0xF0,
  0x1C, 0x00, 0x7F, 0x01, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x04, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x80, 0x01,
  0xFC, 0x18, 0x00, 0x3F, 0xC3, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x8F,
  0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0,
  0x03, 0xF0, 0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F,
  0x80, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x40, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE1, 0xFC, 0x00, 0x3F,
  0x3F, 0xF8, 0x01, 0xF3, 0xFF, 0xE0, 0x0F, 0xBF, 0xFF, 0x80, 0x7D, 0xFF,
  0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0x18, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x08, 0x00,
  0x3F, 0x80, 0xC0, 0x01, 0xFC, 0x1F, 0x00, 0x1F, 0xE1, 0xFC, 0x01, 0xFE,
  0x1F, 0xF8, 0x1F, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0xFF, 0xC0,
  0xFE, 0x7F, 0xFC, 0x3F, 0xBF, 0xFF, 0x8F, 0xDF, 0xFF, 0xE7, 0xFE, 0x07,
  0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x9F, 0x80, 0x0F,
  0xE7, 0xF0, 0x07, 0xF0, 0xFF, 0x07, 0xFC, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xF3,
  0xF0, 0x01, 0xFC, 0x7C, 0x00, 0x3F, 0x8F, 0x80, 0x0F, 0xE3, 0xF0, 0x03,
  0xFC, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFE, 0x07, 0xF8,
  0x1F, 0xC0, 0x1F, 0xE0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF8, 0x7F,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0x7E, 0x00,
  0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00,
  0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F,
  0x1F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xFE, 0x3F,
  0x80, 0x0F, 0xE1, 0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xF8, 0x3F,
  0xC7, 0xF8, 0x03, 0xF9, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x7F,
  0xBF, 0xE0, 0x7F, 0xE7, 0xFF, 0xFB, 0xF9, 0xFF, 0xFD, 0xFC, 0x3F, 0xFE,
  0x7F, 0x07, 0xFF, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0xFE, 0x3F, 0xF1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0x0F, 0xFC,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x1F, 0x80, 0x00, 0x7C,
  0x01, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x80, 0x04, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xCF, 0xF0, 0xFF, 0xBF, 0x80, 0x7F, 0x7E, 0x00, 0xFF, 0x3C,
  0x00, 0xFE, 0x10, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x03, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0,
  0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0x01,
  0xF1, 0xF1, 0xF0, 0x7F, 0xBF, 0x3F, 0x0F, 0xFB, 0xE3, 0xE1, 0xFF, 0xFE,
  0x3E, 0x1F, 0x87, 0xE3, 0xE3, 0xF0, 0x7E, 0x7E, 0x3E, 0x03, 0xE7, 0xE3,
  0xE0, 0x7E, 0x7C, 0x7E, 0x07, 0xC7, 0xC7, 0xE0, 0x7C, 0x7C, 0x7C, 0x07,
  0xC7, 0xC7, 0xC0, 0x7C, 0xFC, 0x7C, 0x07, 0xCF, 0xC7, 0xC0, 0xFC, 0xF8,
  0x7C, 0x0F, 0x8F, 0x87, 0xC1, 0xF8, 0xF8, 0x7C, 0x1F, 0x8F, 0x87, 0xF6,
  0xF8, 0xF8, 0x3F, 0xEF, 0x8F, 0x83, 0xFD, 0xF8, 0xF8, 0x1F, 0x9F, 0x0F,
  0x80, 0x20, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0xFE, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF0,
  0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x83, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x1F,
  0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7E, 0x7F, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xC0, 0x3F, 0xC1, 0xF8, 0x03,
  0xF8, 0x3F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F,
  0x80, 0x3F, 0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x87, 0xF0, 0x1F, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x83, 0xF8, 0x07, 0xF0,
  0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0xC7, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xC7,
  0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFF, 0x1F, 0x80, 0x3F, 0xC3, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF0, 0x7F, 0xC3,
  0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xE3, 0xF8, 0x00,
  0xFC, 0xFE, 0x00, 0x10, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x70, 0x7F, 0x00,
  0x0F, 0xCF, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x7E, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE,
  0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC,
  0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07,
  0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0xFE, 0x1F,
  0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00,
  0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC7,
  0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x07, 0xE0, 0x0F, 0xF0, 0x7E, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0xC0,
  0x0F, 0xE7, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x30, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0xF3, 0xF8, 0x1F, 0xFE, 0x7F,
  0x03, 0xFF, 0xCF, 0xE0, 0xFF, 0xF9, 0xFC, 0x1F, 0xFF, 0x3F, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0,
  0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x01, 0xFC,
  0x3F, 0xC0, 0x3F, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0x7E, 0x07, 0xFF,
  0xEF, 0xC0, 0x7F, 0xF9, 0xF8, 0x07, 0xFE, 0x3E, 0x00, 0x3F, 0x08, 0x00,
  0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80,
  0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07,
  0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00,
  0x7F, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0,
  0x7E, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x3F,
  0x80, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x1E, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC1, 0xFC,
  0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0,
  0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xE0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0,
  0xFF, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x0F, 0xC3,
  0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x1F, 0xDF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x3F, 0xF7, 0xF0, 0x00, 0x3F, 0xE3, 0xF8, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0xC0, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFE,
  0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE,
  0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xDF,
  0x1F, 0x7C, 0x0F, 0xDF, 0x1F, 0x7C, 0x0F, 0xDF, 0x3E, 0xFC, 0x0F, 0xDF,
  0xFE, 0xFC, 0x0F, 0xCF, 0xFC, 0xFC, 0x0F, 0x8F, 0xF8, 0xFC, 0x0F, 0x8F,
  0xF8, 0xF8, 0x1F, 0x8F, 0xF1, 0xF8, 0x1F, 0x87, 0xF1, 0xF8, 0x1F, 0x87,
  0xE1, 0xF8, 0x1F, 0x87, 0xE1, 0xF8, 0x1F, 0x87, 0xC1, 0xF8, 0x1F, 0x07,
  0xC1, 0xF0, 0x1F, 0x03, 0x83, 0xF0, 0x3F, 0x03, 0x03, 0xF0, 0x3F, 0x03,
  0x03, 0xF0, 0x3F, 0x02, 0x03, 0xF0, 0x3F, 0x02, 0x03, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xFE,
  0x00, 0xFC, 0x0F, 0xF8, 0x03, 0xF0, 0x3F, 0xE0, 0x0F, 0xC0, 0xFF, 0x80,
  0x3E, 0x07, 0xFE, 0x01, 0xF8, 0x1F, 0xF8, 0x07, 0xE0, 0x7F, 0xF0, 0x1F,
  0x81, 0xFF, 0xC0, 0x7E, 0x07, 0xFF, 0x01, 0xF8, 0x1F, 0xFC, 0x07, 0xC0,
  0xFD, 0xF0, 0x3F, 0x03, 0xF7, 0xE0, 0xFC, 0x0F, 0xDF, 0x83, 0xF0, 0x3F,
  0x3E, 0x0F, 0xC0, 0xFC, 0xF8, 0x3F, 0x03, 0xE3, 0xE0, 0xF8, 0x0F, 0x8F,
  0xC7, 0xE0, 0x7E, 0x3F, 0x1F, 0x81, 0xF8, 0x7C, 0x7E, 0x07, 0xE1, 0xF1,
  0xF8, 0x1F, 0x87, 0xC7, 0xE0, 0x7C, 0x1F, 0x1F, 0x01, 0xF0, 0x7E, 0xFC,
  0x0F, 0xC1, 0xFB, 0xF0, 0x3F, 0x03, 0xEF, 0xC0, 0xFC, 0x0F, 0xBF, 0x03,
  0xF0, 0x3F, 0xFC, 0x0F, 0x80, 0xFF, 0xE0, 0x3E, 0x03, 0xFF, 0x81, 0xF8,
  0x07, 0xFE, 0x07, 0xE0, 0x1F, 0xF8, 0x1F, 0x80, 0x7F, 0xE0, 0x7E, 0x01,
  0xFF, 0x81, 0xF8, 0x07, 0xFC, 0x07, 0xC0, 0x0F, 0xF0, 0x3F, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x7F,
  0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF8,
  0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x01,
  0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF,
  0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0x7F, 0x00,
  0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0x07, 0xE0, 0x07, 0xF0,
  0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7F,
  0x0F, 0xC0, 0x0F, 0xE1, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xC1, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0x81, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x07,
  0xE1, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F,
  0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x0F, 0xEF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC,
  0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xF0,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x18, 0x00, 0x1F, 0x83, 0xC0, 0x01, 0xFC,
  0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0xFF, 0x07, 0xE0, 0x07, 0xF0, 0x7E,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07,
  0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x0F,
  0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0xC1, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x03,
  0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0x80,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0,
  0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7F,
  0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0x80, 0xFE, 0x00, 0x18, 0x0F, 0xE0, 0x00,
  0x80, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x81, 0x80, 0x01,
  0xFC, 0x1E, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0xFE, 0x1F, 0xF8, 0x1F, 0xF0,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00,
  0x7F, 0x0F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xE1,
  0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0xFE, 0x1F, 0x80,
  0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC7, 0xF0,
  0x01, 0xFC, 0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x1F,
  0x87, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE,
  0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01,
  0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x87,
  0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00,
  0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x03, 0xF0, 0x03, 0xF0,
  0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x3F,
  0x9F, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x07, 0xF0, 0x7C, 0x1F, 0x07,
  0xF0, 0x7C, 0x1F, 0x07, 0xF0, 0x7C, 0x3F, 0x0F, 0xF0, 0xFC, 0x3F, 0x0F,
  0xF0, 0xF8, 0x3F, 0x0F, 0xF0, 0xF8, 0x3F, 0x1F, 0xF0, 0xF8, 0x3F, 0x1E,
  0xF1, 0xF8, 0x3F, 0x1E, 0xF1, 0xF8, 0x3E, 0x3E, 0xF1, 0xF0, 0x3E, 0x3C,
  0xF1, 0xF0, 0x3E, 0x3C, 0xF1, 0xF0, 0x3E, 0x3C, 0xF3, 0xF0, 0x7E, 0x78,
  0xF3, 0xE0, 0x7E, 0x78, 0xF3, 0xE0, 0x7E, 0x78, 0xF3, 0xE0, 0x7E, 0xF0,
  0xF7, 0xE0, 0x7E, 0xF0, 0xF7, 0xC0, 0x7C, 0xF0, 0xF7, 0xC0, 0x7D, 0xE0,
  0xF7, 0xC0, 0x7D, 0xE0, 0xF7, 0xC0, 0x7D, 0xE1, 0xFF, 0xC0, 0x7F, 0xC1,
  0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFD, 0xFC,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xE0,
  0x03, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xF3,
  0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x01,
  0xF8, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xF0, 0x07,
  0xE0, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xFD, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x3C, 0x10, 0x00, 0x04,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x1C, 0x3E, 0x3F, 0x8F, 0xC7, 0xE1, 0xF8,
  0xFC, 0x3E, 0x0F, 0x87, 0xC1, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xF1,
  0xFC, 0x0F, 0xFF, 0x3F, 0x03, 0xFF, 0xE7, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F,
  0xC0, 0xFF, 0x87, 0xF0, 0x0F, 0xF1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x1F,
  0x8F, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xE0,
  0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xF8,
  0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xFC, 0x7F, 0x00,
  0x7F, 0x8F, 0xE0, 0x1F, 0xE0, 0xFE, 0x06, 0xFC, 0x1F, 0xE1, 0xFF, 0x83,
  0xFF, 0xF7, 0xFE, 0x3F, 0xFE, 0x7F, 0xC7, 0xFF, 0x8F, 0xF0, 0x7F, 0xC0,
  0x7E, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x0F, 0xC3, 0xFE, 0x03,
  0xF3, 0xFF, 0xC1, 0xFC, 0xFF, 0xF8, 0x7F, 0x7F, 0xFE, 0x1F, 0xF8, 0x3F,
  0xC7, 0xEC, 0x07, 0xF1, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x3F, 0xC0,
  0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F,
  0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F,
  0x7F, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xE7, 0xE0, 0x03, 0xF9, 0xFC, 0x01,
  0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0xE0, 0x7F, 0x8F, 0xFF, 0xFF, 0xE3, 0xF3,
  0xFF, 0xF0, 0xFC, 0xFF, 0xF8, 0x3F, 0x1F, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x3F, 0x3F, 0x80, 0x1C,
  0x3F, 0x00, 0x10, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x10, 0xFE, 0x00, 0x1C, 0xFE, 0x00, 0x3E,
  0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x7F, 0x83, 0xFC, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xF8, 0xFE, 0x01,
  0xFF, 0xE7, 0xF0, 0x1F, 0xFF, 0xBF, 0x81, 0xFF, 0xFD, 0xF8, 0x1F, 0xF0,
  0x7F, 0xC0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F,
  0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x7E, 0x0F,
  0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80,
  0x0F, 0xE1, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F,
  0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x01, 0xFF, 0x03,
  0xFC, 0x3B, 0xF0, 0x1F, 0xFF, 0xDF, 0x80, 0x7F, 0xFC, 0xFC, 0x03, 0xFF,
  0xCF, 0xE0, 0x0F, 0xFC, 0x7F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF,
  0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F,
  0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x1F, 0xCF, 0xC0, 0x3F, 0xEF,
  0xE0, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x04, 0x1F, 0xC0, 0x03,
  0x87, 0xE0, 0x03, 0xE3, 0xF0, 0x03, 0xF9, 0xFC, 0x03, 0xF8, 0x7F, 0x03,
  0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x06, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03,
  0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0x03, 0xF9, 0xF8, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xFC, 0x3F, 0x01, 0xFF, 0xE7, 0xF0, 0x3F, 0xFF, 0x7F, 0x07, 0xFF, 0xF7,
  0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F,
  0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00,
  0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0xC7,
  0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0x83, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0xFF, 0x83, 0xFC, 0x3F, 0xF8,
  0x3F, 0xFF, 0xBF, 0x81, 0xFF, 0xF3, 0xF0, 0x1F, 0xFE, 0x3F, 0x00, 0xFF,
  0xC3, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x10, 0x00, 0xFE, 0x01, 0x80, 0x1F, 0xC0, 0x3E,
  0x07, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x0F,
  0xC7, 0xFE, 0x03, 0xF3, 0xFF, 0xC0, 0xFD, 0xFF, 0xF8, 0x7F, 0x70, 0xFE,
  0x1F, 0xF0, 0x1F, 0x87, 0xF8, 0x07, 0xF1, 0xFE, 0x01, 0xFC, 0x7F, 0x00,
  0x7F, 0x1F, 0x80, 0x1F, 0x8F, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xFC,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF0, 0x03, 0xF9,
  0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07,
  0xF1, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x8F, 0xE0,
  0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x08,
  0x03, 0xF8, 0x1C, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0xFE,
  0x07, 0xF1, 0xFC, 0x07, 0xF3, 0xF8, 0x07, 0xE7, 0xF0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x01, 0x80, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0xFE, 0x0F,
  0xE0, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0xCF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x0F, 0xC3, 0xFF, 0x00, 0xFC, 0xFF, 0xF8, 0x0F, 0xDF, 0xFF, 0x81,
  0xFD, 0xC3, 0xFC, 0x1F, 0xF0, 0x1F, 0xC1, 0xFE, 0x01, 0xFC, 0x1F, 0xC0,
  0x1F, 0xC1, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x03, 0xF8,
  0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x03, 0xFC, 0x03, 0xF0,
  0xFF, 0x00, 0x3F, 0x7F, 0xC0, 0x07, 0xF3, 0xF0, 0x00, 0x7F, 0x3F, 0x80,
  0x07, 0xF1, 0xF8, 0x08, 0x7E, 0x1F, 0xC1, 0xC7, 0xE1, 0xFC, 0x3E, 0x7E,
  0x0F, 0xC7, 0xF7, 0xE0, 0xFE, 0xFC, 0xFE, 0x07, 0xFF, 0x8F, 0xE0, 0x7F,
  0xF0, 0xFC, 0x07, 0xFE, 0x0F, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x02, 0x03, 0xF0, 0x1C, 0x0F, 0xC0, 0xF8, 0x7F, 0x07, 0xF1, 0xFC,
  0x3F, 0x07, 0xF1, 0xFC, 0x1F, 0x8F, 0xE0, 0x7E, 0x7F, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0x81, 0xF0, 0x3E, 0x7F, 0x0F, 0xE0, 0xF9, 0xFC, 0x7F, 0x83,
  0xEF, 0xFB, 0xFF, 0x0F, 0xC7, 0xE8, 0xFC, 0x7E, 0x0F, 0xC3, 0xF1, 0xF8,
  0x3F, 0x0F, 0xC7, 0xC0, 0xF8, 0x3F, 0x1F, 0x07, 0xE0, 0xFC, 0x7C, 0x1F,
  0x83, 0xE1, 0xF0, 0x7C, 0x0F, 0x8F, 0xC1, 0xF0, 0x3E, 0x3E, 0x07, 0xC1,
  0xF8, 0xF8, 0x1F, 0x07, 0xE3, 0xE0, 0xFC, 0x1F, 0x8F, 0x83, 0xF0, 0x7C,
  0x7E, 0x0F, 0x81, 0xF1, 0xF8, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0x1F, 0x1F,
  0x03, 0xE0, 0xFC, 0x7C, 0x1F, 0x83, 0xF1, 0xF0, 0x7E, 0x0F, 0x8F, 0xC1,
  0xF0, 0x3E, 0x3F, 0x07, 0xC0, 0xF8, 0xF8, 0x1F, 0x03, 0xE3, 0xE0, 0x7C,
  0x1F, 0x8F, 0x83, 0xF0, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF9, 0xFF,
  0x80, 0xFC, 0xFF, 0xF0, 0x3F, 0x7F, 0xFE, 0x0F, 0xDC, 0x3F, 0x87, 0xFC,
  0x07, 0xE1, 0xFE, 0x01, 0xFC, 0x7F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7,
  0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0x8F, 0xC0, 0x0F, 0xE3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00,
  0x3F, 0x1F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xFC, 0x7E,
  0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8,
  0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07,
  0xF0, 0x7F, 0x03, 0xF8, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0x7F,
  0x3F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0xFD, 0xFC, 0x00,
  0x3F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xE0, 0x01, 0xFD, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xF9,
  0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x1F, 0xC0, 0x1F, 0xC3, 0xF0, 0x0F,
  0xE0, 0xFF, 0x07, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x0F, 0xF8,
  0x03, 0xF3, 0xFF, 0xC0, 0x3F, 0x3F, 0xFE, 0x07, 0xF7, 0xFF, 0xE0, 0x7F,
  0xE0, 0xFF, 0x07, 0xEC, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF0, 0x03,
  0xF0, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF1, 0xFC, 0x00,
  0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE1,
  0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x3F, 0xE0,
  0x7F, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0x3F, 0xFF, 0x03, 0xF3, 0xFF, 0xE0,
  0x3F, 0x1F, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xF1, 0xFC, 0x0F, 0xFF,
  0x3F, 0x83, 0xFF, 0xF7, 0xF0, 0xFF, 0xFE, 0xFC, 0x3F, 0xE0, 0xFF, 0x87,
  0xF0, 0x0F, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x03,
  0xF9, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xFC,
  0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F,
  0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x8F, 0xE0,
  0x0F, 0xF0, 0xFE, 0x03, 0xFE, 0x1F, 0xE1, 0xDF, 0x83, 0xFF, 0xFB, 0xF0,
  0x3F, 0xFE, 0x7E, 0x07, 0xFF, 0x9F, 0xC0, 0x7F, 0xE3, 0xF8, 0x03, 0xF0,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0xFC, 0x0F, 0xBF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xF8,
  0x1F, 0xDF, 0xF8, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0x00,
  0x78, 0x3F, 0x00, 0x18, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE1, 0x00, 0x07, 0xF1,
  0xC0, 0x03, 0xF1, 0xF0, 0x03, 0xF9, 0xFF, 0x03, 0xFC, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFD, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x04, 0x00, 0xFC, 0x07, 0x00, 0xFE,
  0x07, 0xC0, 0x7F, 0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x1F, 0x8F, 0xF0, 0x0F,
  0xCF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x07,
  0xF3, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x8F, 0xC0,
  0x07, 0xE3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x1F,
  0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7F,
  0x1F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xFE, 0x00,
  0x7E, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xF8, 0xFE,
  0x03, 0xFC, 0x3F, 0x81, 0xFF, 0x0F, 0xF0, 0xEF, 0xC1, 0xFF, 0xF3, 0xF0,
  0x7F, 0xF9, 0xFC, 0x0F, 0xFC, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x1F, 0xFC, 0x03, 0xE7, 0xFF, 0x03, 0xF9, 0xFF, 0xC0, 0xFE, 0x7F,
  0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x7F,
  0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F,
  0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x07, 0xF0,
  0x7E, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0xFF, 0x01, 0xF8, 0x7F,
  0x80, 0x7E, 0x7F, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x61, 0xF0, 0x3E, 0x3E,
  0x1F, 0x03, 0xE3, 0xF1, 0xF0, 0x7E, 0x1F, 0x1F, 0x07, 0xC1, 0xF1, 0xF0,
  0x7C, 0x1F, 0x3F, 0x07, 0xC1, 0xF3, 0xE0, 0x7C, 0x1F, 0x3E, 0x07, 0xC1,
  0xF3, 0xE0, 0xFC, 0x1F, 0x3E, 0x0F, 0x81, 0xF3, 0xE0, 0xF8, 0x1F, 0x7E,
  0x0F, 0x81, 0xF7, 0xC0, 0xF8, 0x1F, 0x7C, 0x0F, 0x81, 0xF7, 0xC1, 0xF8,
  0x3F, 0x7C, 0x1F, 0x83, 0xE7, 0xC1, 0xF0, 0x3E, 0xFC, 0x1F, 0x03, 0xEF,
  0x81, 0xF0, 0x7C, 0xF8, 0x3F, 0x07, 0xCF, 0x83, 0xF0, 0xF8, 0xFC, 0x6F,
  0x0F, 0x8F, 0xFE, 0xF1, 0xF0, 0xFF, 0xCF, 0xFE, 0x07, 0xFC, 0xFF, 0xC0,
  0x7F, 0x87, 0xF8, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x01,
  0xFE, 0x0F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF0, 0x7F, 0xFC, 0x7F, 0xE1, 0xFE,
  0xF9, 0xC7, 0xE7, 0xF1, 0xF3, 0x0F, 0xC7, 0xC3, 0xFC, 0x1F, 0x86, 0x07,
  0xF8, 0x3F, 0x08, 0x0F, 0xF0, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0xFE, 0x01,
  0x0F, 0x81, 0xFC, 0x0E, 0x1F, 0x06, 0xF8, 0x3E, 0x3F, 0x0D, 0xF1, 0xFE,
  0x7E, 0x3B, 0xE7, 0xF8, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0x87, 0xFF, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0xF0,
  0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0,
  0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE,
  0x1F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8,
  0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F,
  0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x07, 0xF8, 0x3F,
  0x80, 0x7F, 0x83, 0xF8, 0x0F, 0xF8, 0x3F, 0xC3, 0xBF, 0x01, 0xFF, 0xFB,
  0xF0, 0x1F, 0xFF, 0x3F, 0x00, 0xFF, 0xE7, 0xF0, 0x07, 0xFC, 0x7F, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x01, 0x00, 0x1F, 0xC0, 0x38, 0x01, 0xFC, 0x07, 0xE0, 0x7F, 0x80,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x1F, 0x07, 0xFF, 0xE3, 0xF0, 0x7F, 0xFF, 0x3F, 0x0F, 0xC3, 0xFB, 0xF0,
  0xF8, 0x0F, 0xFE, 0x1F, 0x80, 0x3F, 0xC1, 0xF0, 0x07, 0xF8, 0x1F, 0x00,
  0xFF, 0x01, 0xF0, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x10, 0x00, 0xFF, 0x03, 0x80, 0x1F, 0xE0, 0xF8, 0x03, 0xF8, 0x07,
  0xC0, 0x7F, 0x00, 0x7C, 0x0F, 0xE0, 0x07, 0xC1, 0xFE, 0x00, 0x7C, 0x3F,
  0xFE, 0x03, 0xC7, 0xEF, 0xFE, 0x3C, 0x7C, 0x3F, 0xFF, 0xC7, 0xC0, 0xFF,
  0xF8, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0xC0, 0x1F, 0xE0, 0x07, 0xC3, 0xFF, 0x80, 0x7C, 0x1F, 0xFE,
  0x03, 0xE1, 0xFF, 0xF8, 0x3F, 0x1F, 0x8F, 0xC1, 0xF0, 0xF8, 0x3F, 0x1F,
  0x8F, 0xC1, 0xFF, 0xF8, 0x7C, 0x07, 0xFF, 0x83, 0xE0, 0x1F, 0xFC, 0x3E,
  0x00, 0x7F, 0x80, 0x30, 0x01, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 13, 37, 31, 9, -36 },
  { 62, 19, 16, 31, 9, -38 },
  { 100, 32, 36, 31, 0, -36 },
  { 244, 29, 47, 31, 1, -41 },
  { 415, 36, 37, 31, -2, -36 },
  { 582, 30, 37, 31, 0, -36 },
  { 721, 8, 16, 31, 14, -38 },
  { 737, 21, 46, 31, 9, -39 },
  { 858, 20, 46, 31, 2, -39 },
  { 973, 27, 26, 31, 2, -28 },
  { 1061, 25, 25, 31, 3, -28 },
  { 1140, 14, 16, 31, 6, -8 },
  { 1168, 17, 6, 31, 7, -19 },
  { 1181, 10, 9, 31, 9, -8 },
  { 1193, 30, 46, 31, 0, -39 },
  { 1366, 28, 37, 31, 2, -36 },
  { 1496, 26, 36, 31, 2, -36 },
  { 1613, 28, 36, 31, 1, -36 },
  { 1739, 28, 37, 31, 1, -36 },
  { 1869, 29, 36, 31, 0, -36 },
  { 2000, 29, 37, 31, 1, -36 },
  { 2135, 26, 37, 31, 2, -36 },
  { 2256, 27, 36, 31, 4, -36 },
  { 2378, 29, 37, 31, 1, -36 },
  { 2513, 26, 36, 31, 4, -36 },
  { 2630, 13, 27, 31, 9, -26 },
  { 2674, 16, 34, 31, 6, -26 },
  { 2742, 25, 30, 31, 4, -31 },
  { 2836, 27, 17, 31, 2, -24 },
  { 2894, 25, 30, 31, 2, -31 },
  { 2988, 23, 37, 31, 6, -36 },
  { 3095, 28, 42, 31, 2, -36 },
  { 3242, 29, 36, 31, -1, -36 },
  { 3373, 27, 36, 31, 2, -36 },
  { 3495, 27, 37, 31, 3, -36 },
  { 3620, 28, 36, 31, 2, -36 },
  { 3746, 28, 36, 31, 2, -36 },
  { 3872, 29, 36, 31, 2, -36 },
  { 4003, 27, 37, 31, 3, -36 },
  { 4128, 30, 36, 31, 1, -36 },
  { 4263, 28, 36, 31, 2, -36 },
  { 4389, 27, 37, 31, 2, -36 },
  { 4514, 32, 36, 31, 2, -36 },
  { 4658, 23, 36, 31, 3, -36 },
  { 4762, 32, 36, 31, 0, -36 },
  { 4906, 30, 36, 31, 1, -36 },
  { 5041, 28, 37, 31, 2, -36 },
  { 5171, 28, 36, 31, 2, -36 },
  { 5297, 28, 46, 31, 2, -36 },
  { 5458, 28, 36, 31, 2, -36 },
  { 5584, 29, 37, 31, 1, -36 },
  { 5719, 29, 36, 31, 4, -36 },
  { 5850, 28, 37, 31, 3, -36 },
  { 5980, 28, 36, 31, 5, -36 },
  { 6106, 32, 36, 31, 1, -36 },
  { 6250, 34, 36, 31, -1, -36 },
  { 6403, 30, 36, 31, 4, -36 },
  { 6538, 31, 36, 31, 0, -36 },
  { 6678, 23, 46, 31, 7, -39 },
  { 6811, 14, 46, 31, 9, -39 },
  { 6892, 24, 46, 31, 1, -39 },
  { 7030, 27, 22, 31, 2, -36 },
  { 7105, 25, 5, 31, 0, 4 },
  { 7121, 9, 11, 31, 10, -40 },
  { 7134, 27, 28, 31, 2, -27 },
  { 7229, 26, 39, 31, 2, -38 },
  { 7356, 24, 28, 31, 3, -27 },
  { 7440, 29, 39, 31, 2, -38 },
  { 7582, 25, 28, 31, 3, -27 },
  { 7670, 34, 49, 31, -1, -38 },
  { 7879, 28, 38, 31, 1, -27 },
  { 8012, 26, 38, 31, 2, -38 },
  { 8136, 24, 40, 31, 4, -39 },
  { 8256, 26, 50, 31, 1, -39 },
  { 8419, 28, 39, 31, 2, -38 },
  { 8556, 22, 39, 31, 5, -38 },
  { 8664, 30, 27, 31, 0, -27 },
  { 8766, 26, 27, 31, 2, -27 },
  { 8854, 26, 28, 31, 2, -27 },
  { 8945, 28, 37, 31, 0, -27 },
  { 9075, 27, 37, 31, 2, -27 },
  { 9200, 25, 26, 31, 5, -26 },
  { 9282, 25, 28, 31, 2, -27 },
  { 9370, 25, 37, 31, 3, -36 },
  { 9486, 26, 27, 31, 3, -26 },
  { 9574, 26, 28, 31, 2, -27 },
  { 9665, 28, 28, 31, 1, -27 },
  { 9763, 31, 28, 31, 0, -27 },
  { 9872, 28, 37, 31, 1, -26 },
  { 10002, 28, 28, 31, 1, -27 },
  { 10100, 25, 46, 31, 5, -39 },
  { 10244, 13, 46, 31, 9, -39 },
  { 10319, 25, 46, 31, 1, -39 },
  { 10463, 29, 12, 31, 1, -22 },
};

const GFXfont IBMPlexMono_SemiBoldItalic51pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic51pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic51pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC51PT7B_H_
