#ifndef _IBMPLEXMONO_SEMIBOLDITALIC10PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x38, 0xB6, 0x80, 0x14, 0xA6, 0xCA, 0xDD, 0x4F, 0x00, 0x10,
  0xE5, 0xD4, 0x38, 0xBA, 0x9E, 0x20, 0x66, 0xB2, 0x43, 0xC1, 0x4E, 0xA6,
  0x00, 0x38, 0xA2, 0x9C, 0x92, 0x5F, 0x80, 0xE0, 0x34, 0xC8, 0x88, 0x88,
  0x40, 0x21, 0x11, 0x11, 0x12, 0xC0, 0x11, 0x5F, 0x8C, 0x48, 0x21, 0x3E,
  0x84, 0x00, 0x6A, 0x00, 0xF0, 0xE0, 0x04, 0x21, 0x84, 0x30, 0x86, 0x10,
  0x80, 0x39, 0x35, 0x7F, 0xCD, 0x27, 0x00, 0x3B, 0xD4, 0x21, 0x0B, 0xE0,
  0x39, 0x30, 0xC6, 0x31, 0x0F, 0x80, 0x39, 0x30, 0x8C, 0x0A, 0x27, 0x00,
  0x0C, 0x62, 0x92, 0xCB, 0xF1, 0x00, 0x3D, 0x07, 0x92, 0x0D, 0x2F, 0x00,
  0x18, 0x87, 0x93, 0xCD, 0x27, 0x00, 0xFC, 0xC4, 0x62, 0x23, 0x00, 0x39,
  0x14, 0xCC, 0x4B, 0x37, 0x80, 0x74, 0xE3, 0x3F, 0x13, 0x00, 0xF0, 0xE0,
  0x6C, 0x06, 0xA0, 0x09, 0xB1, 0x86, 0x08, 0x7C, 0x00, 0x3E, 0x41, 0x86,
  0x36, 0x40, 0x74, 0xC4, 0xC0, 0x21, 0x00, 0x39, 0x15, 0xD9, 0xAA, 0xE4,
  0x1C, 0x19, 0x4A, 0x97, 0xE6, 0x20, 0x79, 0xB4, 0xDC, 0x49, 0x2F, 0x80,
  0x76, 0x61, 0x08, 0x4F, 0xC0, 0x79, 0xB4, 0x53, 0x4D, 0x2F, 0x00, 0x7D,
  0x84, 0x1E, 0x41, 0x0F, 0x80, 0x7D, 0x84, 0x1E, 0x41, 0x0C, 0x00, 0x76,
  0xE1, 0x79, 0x4B, 0xC0, 0x65, 0x14, 0xDE, 0x49, 0x2C, 0x80, 0x7C, 0x41,
  0x04, 0x30, 0x8F, 0x80, 0x3C, 0x20, 0x82, 0x0B, 0x67, 0x00, 0x66, 0xD1,
  0x43, 0x85, 0x0B, 0x33, 0x00, 0x44, 0xC8, 0x88, 0xF0, 0x6D, 0xB7, 0x55,
  0xEE, 0x28, 0x80, 0x65, 0x96, 0x56, 0x59, 0x69, 0x80, 0x39, 0xB4, 0x53,
  0xCD, 0x27, 0x00, 0x79, 0x94, 0xDE, 0x41, 0x0C, 0x00, 0x39, 0xB4, 0x53,
  0xCD, 0x27, 0x05, 0x18, 0x79, 0x94, 0xDE, 0x51, 0x6C, 0x80, 0x39, 0x34,
  0x0E, 0x0A, 0x27, 0x80, 0xF9, 0x08, 0x46, 0x21, 0x00, 0xCC, 0x67, 0x39,
  0x4B, 0x80, 0x8E, 0x29, 0x34, 0xF3, 0x86, 0x00, 0x46, 0x89, 0x53, 0xAF,
  0x9B, 0x36, 0x00, 0x64, 0xA3, 0x8C, 0x31, 0x6C, 0x80, 0x8F, 0x65, 0x18,
  0x61, 0x04, 0x00, 0x7C, 0x31, 0x8C, 0x61, 0x0F, 0x80, 0x39, 0x10, 0x84,
  0x21, 0x08, 0xF0, 0xAA, 0x55, 0x40, 0x38, 0x44, 0x21, 0x08, 0x42, 0xE0,
  0x18, 0xA6, 0xB3, 0xF8, 0x90, 0x7D, 0x2C, 0xB6, 0x68, 0x61, 0x85, 0x9B,
  0x4D, 0x2F, 0x80, 0x79, 0x89, 0xE0, 0x04, 0x17, 0xD2, 0xCB, 0x27, 0x80,
  0x79, 0xF9, 0xE0, 0x1E, 0x21, 0xF0, 0x81, 0x06, 0x08, 0x50, 0x60, 0x7D,
  0x2C, 0xB2, 0x7A, 0x6F, 0x00, 0x63, 0x16, 0xD4, 0xA7, 0x20, 0x22, 0x0E,
  0x64, 0x56, 0x08, 0x40, 0xF1, 0x88, 0x52, 0xD3, 0x00, 0x61, 0x85, 0x9A,
  0x59, 0xDD, 0x80, 0xE6, 0x44, 0x45, 0x60, 0x7D, 0x59, 0x6A, 0xA8, 0x5B,
  0x52, 0x9C, 0x80, 0x39, 0x24, 0xF2, 0x70, 0x59, 0xB4, 0xD2, 0xFA, 0x08,
  0x00, 0x7D, 0x2C, 0xB2, 0x78, 0x61, 0x80, 0xFB, 0x10, 0x84, 0x00, 0x3A,
  0x1F, 0x17, 0x00, 0x23, 0x3E, 0x84, 0x29, 0x80, 0x9C, 0xA5, 0x6D, 0x00,
  0x6F, 0x52, 0xB7, 0x00, 0x55, 0x5B, 0x6A, 0xF8, 0x6F, 0xD3, 0x2E, 0xDC,
  0x4D, 0x24, 0x96, 0x6A, 0x6F, 0x00, 0x75, 0x23, 0x12, 0xB8, 0x39, 0x08,
  0x4C, 0x11, 0x08, 0x70, 0x55, 0x6A, 0x80, 0x30, 0xC4, 0x41, 0x90, 0x84,
  0xE0, 0x66, 0x60,
};

const GFXglyph IBMPlexMono_SemiBoldItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 3, 3, 6, 2, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 6, 9, 6, 0, -8 },
  { 18, 7, 7, 6, 0, -7 },
  { 25, 6, 7, 6, 0, -7 },
  { 31, 1, 3, 6, 3, -7 },
  { 32, 4, 9, 6, 2, -8 },
  { 37, 4, 9, 6, 0, -8 },
  { 42, 6, 5, 6, 0, -5 },
  { 46, 5, 5, 6, 1, -6 },
  { 50, 3, 3, 6, 1, -2 },
  { 52, 4, 1, 6, 1, -4 },
  { 53, 2, 2, 6, 2, -2 },
  { 54, 6, 9, 6, 0, -8 },
  { 61, 6, 7, 6, 0, -7 },
  { 67, 5, 7, 6, 0, -7 },
  { 72, 6, 7, 6, 0, -7 },
  { 78, 6, 7, 6, 0, -7 },
  { 84, 6, 7, 6, 0, -7 },
  { 90, 6, 7, 6, 0, -7 },
  { 96, 6, 7, 6, 0, -7 },
  { 102, 5, 7, 6, 1, -7 },
  { 107, 6, 7, 6, 0, -7 },
  { 113, 5, 7, 6, 1, -7 },
  { 118, 2, 6, 6, 2, -6 },
  { 120, 3, 7, 6, 1, -6 },
  { 123, 5, 6, 6, 1, -6 },
  { 127, 6, 4, 6, 0, -5 },
  { 130, 5, 6, 6, 0, -6 },
  { 134, 5, 7, 6, 1, -7 },
  { 139, 6, 8, 6, 0, -7 },
  { 145, 5, 7, 6, 0, -7 },
  { 150, 6, 7, 6, 0, -7 },
  { 156, 5, 7, 6, 1, -7 },
  { 161, 6, 7, 6, 0, -7 },
  { 167, 6, 7, 6, 0, -7 },
  { 173, 6, 7, 6, 0, -7 },
  { 179, 5, 7, 6, 1, -7 },
  { 184, 6, 7, 6, 0, -7 },
  { 190, 6, 7, 6, 0, -7 },
  { 196, 6, 7, 6, 0, -7 },
  { 202, 7, 7, 6, 0, -7 },
  { 209, 4, 7, 6, 1, -7 },
  { 213, 6, 7, 6, 0, -7 },
  { 219, 6, 7, 6, 0, -7 },
  { 225, 6, 7, 6, 0, -7 },
  { 231, 6, 7, 6, 0, -7 },
  { 237, 6, 9, 6, 0, -7 },
  { 244, 6, 7, 6, 0, -7 },
  { 250, 6, 7, 6, 0, -7 },
  { 256, 5, 7, 6, 1, -7 },
  { 261, 5, 7, 6, 1, -7 },
  { 266, 6, 7, 6, 1, -7 },
  { 272, 7, 7, 6, 0, -7 },
  { 279, 6, 7, 6, 0, -7 },
  { 285, 6, 7, 6, 1, -7 },
  { 291, 6, 7, 6, 0, -7 },
  { 297, 5, 9, 6, 1, -8 },
  { 303, 2, 9, 6, 2, -8 },
  { 306, 5, 9, 6, 0, -8 },
  { 312, 6, 4, 6, 0, -7 },
  { 315, 5, 1, 6, 0, 1 },
  { 316, 2, 2, 6, 2, -8 },
  { 317, 6, 5, 6, 0, -5 },
  { 321, 6, 7, 6, 0, -7 },
  { 327, 4, 5, 6, 1, -5 },
  { 330, 6, 7, 6, 0, -7 },
  { 336, 4, 5, 6, 1, -5 },
  { 339, 7, 9, 6, 0, -7 },
  { 347, 6, 7, 6, 0, -5 },
  { 353, 5, 7, 6, 0, -7 },
  { 358, 4, 8, 6, 1, -8 },
  { 362, 5, 10, 6, 0, -8 },
  { 369, 6, 7, 6, 0, -7 },
  { 375, 4, 7, 6, 1, -7 },
  { 379, 6, 5, 6, 0, -5 },
  { 383, 5, 5, 6, 0, -5 },
  { 387, 6, 5, 6, 0, -5 },
  { 391, 6, 7, 6, 0, -5 },
  { 397, 6, 7, 6, 0, -5 },
  { 403, 5, 5, 6, 1, -5 },
  { 407, 5, 5, 6, 0, -5 },
  { 411, 5, 7, 6, 1, -7 },
  { 416, 5, 5, 6, 1, -5 },
  { 420, 5, 5, 6, 0, -5 },
  { 424, 6, 5, 6, 0, -5 },
  { 428, 6, 5, 6, 0, -5 },
  { 432, 6, 7, 6, 0, -5 },
  { 438, 6, 5, 6, 0, -5 },
  { 442, 5, 9, 6, 1, -8 },
  { 448, 2, 9, 6, 2, -8 },
  { 451, 5, 9, 6, 0, -8 },
  { 457, 6, 2, 6, 0, -4 },
};

const GFXfont IBMPlexMono_SemiBoldItalic10pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic10pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC10PT7B_H_
