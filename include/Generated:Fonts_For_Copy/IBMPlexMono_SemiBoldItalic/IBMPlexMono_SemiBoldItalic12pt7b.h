#ifndef _IBMPLEXMONO_SEMIBOLDITALIC12PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0xA4, 0x36, 0x5E, 0xB5, 0x20, 0x1A, 0x14, 0x77, 0x24, 0x28,
  0xEE, 0x58, 0x50, 0x08, 0x79, 0xBB, 0x43, 0x03, 0x85, 0xAA, 0xF8, 0x60,
  0x73, 0x52, 0x54, 0x78, 0x0E, 0x32, 0x52, 0x9C, 0x1C, 0x48, 0x91, 0xE5,
  0x1B, 0x36, 0xB6, 0x5F, 0x19, 0x18, 0x8C, 0x62, 0x10, 0xC2, 0x18, 0x30,
  0xC2, 0x10, 0x84, 0x23, 0x11, 0x38, 0x30, 0xCF, 0xDC, 0x52, 0x60, 0x30,
  0xCF, 0xC8, 0x20, 0x76, 0x4C, 0xF0, 0xF0, 0x02, 0x08, 0x30, 0x41, 0x82,
  0x0C, 0x10, 0x60, 0x83, 0x00, 0x7B, 0x3C, 0x6F, 0xAE, 0x39, 0xBC, 0x39,
  0xED, 0x24, 0x30, 0xC3, 0x3F, 0x3C, 0xCC, 0x18, 0x20, 0x86, 0x18, 0x7E,
  0x3C, 0xCC, 0x18, 0xC2, 0x40, 0xB3, 0x3C, 0x0E, 0x38, 0xD1, 0x64, 0xDF,
  0xC2, 0x04, 0x3E, 0x41, 0x82, 0xE6, 0x60, 0xD1, 0x7C, 0x1D, 0x84, 0x3E,
  0xCE, 0x38, 0xBC, 0xFF, 0x38, 0x86, 0x30, 0xC6, 0x30, 0x3C, 0xCD, 0x99,
  0xC4, 0x58, 0xF1, 0x3C, 0x7B, 0x38, 0xF3, 0xFC, 0x63, 0x38, 0x6C, 0x0D,
  0x80, 0x33, 0x00, 0x76, 0x4C, 0x04, 0x77, 0x30, 0xE0, 0xE0, 0x80, 0xFC,
  0x0F, 0x80, 0x43, 0x0E, 0x13, 0xF2, 0x00, 0x7B, 0x30, 0xCE, 0x20, 0x06,
  0x18, 0x1C, 0x45, 0x6A, 0xB5, 0x6A, 0xB7, 0x20, 0x78, 0x1C, 0x38, 0xF1,
  0x66, 0x4F, 0xB1, 0x43, 0x3C, 0x4D, 0x9B, 0xC6, 0x48, 0x91, 0x7C, 0x39,
  0x3C, 0x30, 0x82, 0x08, 0xDC, 0x3C, 0x4D, 0x9B, 0x36, 0x68, 0xD3, 0x7C,
  0x3E, 0x41, 0x83, 0xE6, 0x08, 0x10, 0x7E, 0x3E, 0x41, 0x83, 0xE6, 0x08,
  0x10, 0x60, 0x39, 0x3C, 0x20, 0x9E, 0x28, 0xBE, 0x22, 0xCD, 0x9B, 0xF4,
  0x48, 0x91, 0x66, 0x3E, 0x30, 0x60, 0xC1, 0x02, 0x04, 0x7E, 0x3E, 0x0C,
  0x10, 0x20, 0x41, 0xB3, 0x3C, 0x23, 0x26, 0x6C, 0x78, 0x78, 0x6C, 0x4C,
  0xC6, 0x62, 0x11, 0x8C, 0x63, 0x1F, 0x67, 0x76, 0x5E, 0x5A, 0x56, 0x56,
  0xC4, 0xC4, 0x32, 0xE5, 0xDA, 0xB5, 0xCB, 0x93, 0x66, 0x7B, 0x3C, 0xE3,
  0x8E, 0x39, 0xBC, 0x3C, 0x4D, 0x9B, 0x37, 0xC8, 0x10, 0x60, 0x7B, 0x3C,
  0xE3, 0x8E, 0x39, 0xBC, 0x34, 0x60, 0x3C, 0x4D, 0x9B, 0x37, 0xC9, 0x13,
  0x66, 0x3E, 0xC5, 0x81, 0xC0, 0xC0, 0xD1, 0x7C, 0xFE, 0x60, 0xC1, 0x82,
  0x04, 0x08, 0x30, 0x47, 0x1C, 0xF3, 0x8E, 0x29, 0xBC, 0xC7, 0x8B, 0x36,
  0x45, 0x8A, 0x1C, 0x30, 0x43, 0x42, 0x5A, 0x5A, 0x5E, 0x6E, 0xEC, 0xCC,
  0x63, 0x36, 0x3C, 0x18, 0x38, 0x28, 0x6C, 0xC6, 0xC7, 0x99, 0x23, 0xC7,
  0x04, 0x08, 0x30, 0x3E, 0x8C, 0x30, 0xC3, 0x04, 0x18, 0x7E, 0x7A, 0x10,
  0x84, 0x63, 0x10, 0x84, 0x38, 0x9B, 0x24, 0x93, 0x24, 0x80, 0x3C, 0x30,
  0x82, 0x08, 0x21, 0x86, 0x10, 0x4F, 0x00, 0x30, 0xE4, 0xB2, 0x8C, 0xFC,
  0x74, 0x7F, 0x28, 0xA2, 0x9B, 0xF0, 0x20, 0x41, 0x83, 0xE6, 0x6C, 0xD1,
  0xA2, 0xF8, 0x7E, 0x61, 0x08, 0xB8, 0x04, 0x10, 0xDF, 0xCE, 0x28, 0xA6,
  0xF8, 0x7B, 0x3F, 0xA4, 0xC9, 0xC0, 0x0F, 0x08, 0x08, 0x7E, 0x18, 0x18,
  0x10, 0x10, 0x90, 0xF0, 0x60, 0x3E, 0xCD, 0x12, 0x24, 0xCF, 0xA2, 0x7C,
  0x20, 0x86, 0x1B, 0x75, 0x94, 0x51, 0xCC, 0x30, 0xC0, 0x3C, 0x20, 0x86,
  0x9F, 0x70, 0x0C, 0x30, 0x0F, 0x08, 0x20, 0x86, 0x99, 0x63, 0x00, 0x20,
  0x41, 0x83, 0xE6, 0x6C, 0x96, 0x2D, 0xCC, 0xF1, 0x88, 0x46, 0x31, 0xAB,
  0x60, 0x56, 0xF5, 0x4E, 0xB9, 0x56, 0x80, 0x6D, 0xD6, 0x51, 0x47, 0x30,
  0x7B, 0x28, 0xE2, 0x9B, 0xC0, 0x7C, 0xCD, 0x9A, 0x34, 0x5F, 0x30, 0x60,
  0x7F, 0x38, 0xA2, 0x9B, 0xE1, 0x84, 0xEC, 0xC6, 0x18, 0x61, 0x00, 0x7E,
  0x78, 0x78, 0xF8, 0x30, 0x8F, 0xD8, 0x61, 0xA5, 0x9C, 0xCF, 0x38, 0xA2,
  0x9B, 0xE0, 0xC9, 0x3C, 0xF2, 0xDB, 0x80, 0x5E, 0xA5, 0x4E, 0x9D, 0x5F,
  0x00, 0x37, 0xB4, 0x40, 0x8B, 0x7B, 0x80, 0x66, 0xCD, 0x12, 0x24, 0xCF,
  0xA2, 0x7C, 0x3E, 0x98, 0x61, 0xA6, 0x5B, 0x80, 0x1C, 0xC3, 0x04, 0x13,
  0x81, 0x08, 0x61, 0x07, 0x00, 0x24, 0xB6, 0x92, 0x5B, 0x00, 0x38, 0x20,
  0x84, 0x10, 0x33, 0x0C, 0x10, 0x4F, 0x00, 0x72, 0xAF, 0x30,
};

const GFXglyph IBMPlexMono_SemiBoldItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 8, 7, 2, -8 },
  { 4, 5, 4, 7, 2, -9 },
  { 7, 8, 8, 7, 0, -8 },
  { 15, 7, 10, 7, 0, -9 },
  { 24, 8, 8, 7, 0, -8 },
  { 32, 7, 8, 7, 0, -8 },
  { 39, 2, 4, 7, 3, -9 },
  { 40, 5, 11, 7, 2, -9 },
  { 47, 5, 11, 7, 0, -9 },
  { 54, 6, 6, 7, 1, -7 },
  { 59, 6, 5, 7, 1, -6 },
  { 63, 4, 4, 7, 1, -2 },
  { 65, 4, 1, 7, 2, -4 },
  { 66, 2, 2, 7, 2, -2 },
  { 67, 7, 11, 7, 0, -9 },
  { 77, 6, 8, 7, 1, -8 },
  { 83, 6, 8, 7, 1, -8 },
  { 89, 7, 8, 7, 0, -8 },
  { 96, 7, 8, 7, 0, -8 },
  { 103, 7, 8, 7, 0, -8 },
  { 110, 7, 8, 7, 0, -8 },
  { 117, 6, 8, 7, 1, -8 },
  { 123, 6, 8, 7, 1, -8 },
  { 129, 7, 8, 7, 0, -8 },
  { 136, 6, 8, 7, 1, -8 },
  { 142, 3, 6, 7, 2, -6 },
  { 145, 4, 8, 7, 1, -6 },
  { 149, 6, 7, 7, 1, -7 },
  { 155, 6, 3, 7, 1, -5 },
  { 158, 5, 7, 7, 1, -7 },
  { 163, 6, 8, 7, 1, -8 },
  { 169, 7, 9, 7, 0, -8 },
  { 177, 7, 8, 7, 0, -8 },
  { 184, 7, 8, 7, 0, -8 },
  { 191, 6, 8, 7, 1, -8 },
  { 197, 7, 8, 7, 0, -8 },
  { 204, 7, 8, 7, 0, -8 },
  { 211, 7, 8, 7, 0, -8 },
  { 218, 6, 8, 7, 1, -8 },
  { 224, 7, 8, 7, 0, -8 },
  { 231, 7, 8, 7, 0, -8 },
  { 238, 7, 8, 7, 0, -8 },
  { 245, 8, 8, 7, 0, -8 },
  { 253, 5, 8, 7, 1, -8 },
  { 258, 8, 8, 7, 0, -8 },
  { 266, 7, 8, 7, 0, -8 },
  { 273, 6, 8, 7, 1, -8 },
  { 279, 7, 8, 7, 0, -8 },
  { 286, 6, 10, 7, 1, -8 },
  { 294, 7, 8, 7, 0, -8 },
  { 301, 7, 8, 7, 0, -8 },
  { 308, 7, 8, 7, 1, -8 },
  { 315, 6, 8, 7, 1, -8 },
  { 321, 7, 8, 7, 1, -8 },
  { 328, 8, 8, 7, 0, -8 },
  { 336, 8, 8, 7, 0, -8 },
  { 344, 7, 8, 7, 1, -8 },
  { 351, 7, 8, 7, 0, -8 },
  { 358, 5, 11, 7, 2, -9 },
  { 365, 3, 11, 7, 2, -9 },
  { 370, 6, 11, 7, 0, -9 },
  { 379, 6, 5, 7, 1, -8 },
  { 383, 6, 1, 7, 0, 1 },
  { 384, 2, 3, 7, 2, -10 },
  { 385, 6, 6, 7, 1, -6 },
  { 390, 7, 9, 7, 0, -9 },
  { 398, 5, 6, 7, 1, -6 },
  { 402, 6, 9, 7, 1, -9 },
  { 409, 6, 6, 7, 1, -6 },
  { 414, 8, 11, 7, 0, -9 },
  { 425, 7, 8, 7, 0, -6 },
  { 432, 6, 9, 7, 0, -9 },
  { 439, 6, 9, 7, 1, -9 },
  { 446, 6, 11, 7, 0, -9 },
  { 455, 7, 9, 7, 0, -9 },
  { 463, 5, 9, 7, 1, -9 },
  { 469, 7, 6, 7, 0, -6 },
  { 475, 6, 6, 7, 0, -6 },
  { 480, 6, 6, 7, 1, -6 },
  { 485, 7, 8, 7, 0, -6 },
  { 492, 6, 8, 7, 1, -6 },
  { 498, 6, 6, 7, 1, -6 },
  { 503, 5, 6, 7, 1, -6 },
  { 507, 6, 8, 7, 1, -8 },
  { 513, 6, 6, 7, 1, -6 },
  { 518, 6, 6, 7, 1, -6 },
  { 523, 7, 6, 7, 0, -6 },
  { 529, 7, 6, 7, 0, -6 },
  { 535, 7, 8, 7, 0, -6 },
  { 542, 7, 6, 7, 0, -6 },
  { 548, 6, 11, 7, 1, -9 },
  { 557, 3, 11, 7, 2, -9 },
  { 562, 6, 11, 7, 0, -9 },
  { 571, 7, 3, 7, 0, -5 },
};

const GFXfont IBMPlexMono_SemiBoldItalic12pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic12pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC12PT7B_H_
