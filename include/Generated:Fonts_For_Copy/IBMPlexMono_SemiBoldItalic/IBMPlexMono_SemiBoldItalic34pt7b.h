#ifndef _IBMPLEXMONO_SEMIBOLDITALIC34PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F,
  0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x1E, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF0, 0xF0, 0x78, 0xF7, 0x8F, 0x78, 0xF7, 0x8F, 0x78, 0xF7,
  0x0F, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xE0, 0x00, 0x38, 0xF0,
  0x03, 0xC7, 0x00, 0x1C, 0x78, 0x00, 0xE3, 0xC0, 0x0F, 0x1C, 0x00, 0x71,
  0xE0, 0x03, 0x8F, 0x03, 0xFC, 0x7F, 0x1F, 0xC7, 0xF9, 0xFE, 0x3F, 0xC0,
  0xF1, 0xC0, 0x07, 0x1E, 0x00, 0x38, 0xF0, 0x03, 0xC7, 0x01, 0xFC, 0x7F,
  0x9F, 0xE3, 0xFC, 0xFF, 0x1F, 0xE0, 0x71, 0xE0, 0x03, 0x8F, 0x00, 0x3C,
  0x70, 0x01, 0xC7, 0x80, 0x0E, 0x3C, 0x00, 0xF1, 0xC0, 0x07, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0xF8,
  0x1F, 0xFF, 0x87, 0xFF, 0xF8, 0xF9, 0xDE, 0x3E, 0x31, 0x87, 0xCE, 0x00,
  0xF1, 0xC0, 0x1F, 0x38, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x1D, 0xF8, 0x03, 0x9F, 0x00, 0x71, 0xE2,
  0x0C, 0x7C, 0xE3, 0x8F, 0xBE, 0x73, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x07,
  0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x0F, 0x07, 0xF8, 0x1E, 0x0F, 0xF8, 0x1C, 0x0E, 0x38, 0x38,
  0x1E, 0x1C, 0x78, 0x1C, 0x3C, 0xF0, 0x1C, 0x38, 0xE0, 0x1C, 0x39, 0xE0,
  0x1C, 0x7B, 0xC0, 0x1F, 0xF3, 0x80, 0x0F, 0xE4, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x03, 0xDF, 0xF0, 0x03, 0x9C, 0x78,
  0x07, 0x3C, 0x38, 0x0F, 0x38, 0x78, 0x0E, 0x38, 0x78, 0x1C, 0x38, 0x70,
  0x3C, 0x38, 0xF0, 0x38, 0x3F, 0xE0, 0x70, 0x1F, 0xC0, 0xF0, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0x3C, 0x03, 0xC3,
  0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C,
  0x38, 0x01, 0xE7, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0x8F, 0x00, 0x78,
  0xF0, 0x07, 0x87, 0x80, 0xF8, 0x78, 0x0F, 0x87, 0x84, 0xF0, 0x3C, 0x7F,
  0x85, 0xCF, 0x78, 0xDE, 0xE7, 0xF9, 0xFC, 0x3F, 0x8F, 0xC1, 0xE0, 0x78,
  0x3C, 0xF3, 0x9E, 0x79, 0xE7, 0x9E, 0x73, 0xCF, 0x00, 0x00, 0x7C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x04, 0x1E, 0x0B, 0x8F, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFE,
  0x01, 0xEF, 0x81, 0xE3, 0xC1, 0xF1, 0xF1, 0xF0, 0x78, 0x30, 0x10, 0x00,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x8F, 0x87, 0xC7, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0x78, 0x78,
  0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFD,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0x7C, 0x3E, 0x07, 0xCF, 0x80, 0xF9,
  0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x9C, 0x7D, 0xF3, 0xCF, 0xBC, 0x79, 0xF7,
  0x9F, 0x3E, 0xF1, 0xC7, 0xBE, 0x00, 0xF7, 0xC0, 0x3E, 0x78, 0x07, 0xCF,
  0x00, 0xF1, 0xE0, 0x3E, 0x3E, 0x0F, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x07,
  0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x0F, 0xFC, 0x1F, 0x78, 0x3E, 0x78, 0x7C, 0x78, 0x78, 0x78, 0x38, 0xF8,
  0x30, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFF, 0x1F, 0x07, 0xCF, 0x80, 0xF1, 0xC0, 0x3C, 0x10, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0x00, 0xFC,
  0x00, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x07, 0xC3, 0x00, 0xF0,
  0x80, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x88, 0x03, 0xEF, 0x00, 0xFB, 0xE0, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0x83,
  0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x3D, 0xF0, 0x0F, 0x3C, 0x03,
  0xC7, 0x80, 0x70, 0xF0, 0x1E, 0x1E, 0x07, 0x87, 0xC1, 0xE0, 0xF8, 0x78,
  0x1E, 0x1E, 0x03, 0xC3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x7C, 0x03, 0xBF,
  0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xE0, 0xFC, 0x38, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC2, 0x00, 0xF1, 0xC0, 0x3E, 0x7E, 0x0F,
  0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x7C, 0x0F, 0xBF, 0xC3, 0xDF, 0xF9, 0xFF,
  0xFE, 0x7E, 0x0F, 0xDF, 0x01, 0xF7, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xDE, 0x01, 0xE7, 0x80, 0xF9, 0xF0, 0x7E, 0x7F, 0xFF, 0x0F, 0xFF, 0x81,
  0xFF, 0xC0, 0x1F, 0xC0, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF,
  0xFE, 0xF0, 0x0F, 0xBC, 0x03, 0xCF, 0x01, 0xF3, 0xC0, 0x78, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1, 0xF0, 0x3E, 0x3C, 0x07,
  0xC7, 0x80, 0xF8, 0xF0, 0x1E, 0x1F, 0x07, 0xC1, 0xFF, 0xE0, 0x1F, 0xF8,
  0x07, 0xFF, 0x03, 0xFF, 0xF0, 0xFC, 0x1F, 0x1E, 0x01, 0xE7, 0xC0, 0x3E,
  0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x3E, 0x7E, 0x0F, 0xC7, 0xFF, 0xF0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x01, 0xFF, 0x81,
  0xFF, 0xF0, 0xFF, 0xFE, 0x3E, 0x0F, 0x9F, 0x01, 0xF7, 0x80, 0x7D, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFD, 0xF0, 0x7E, 0x7F, 0xFF,
  0x9F, 0xFB, 0xE3, 0xFD, 0xF0, 0x3E, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0x1F, 0x3F, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0xFC, 0xFC, 0xFC, 0xFC, 0x78, 0x07, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x87,
  0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x3C, 0x0E, 0x00,
  0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C,
  0x00, 0x18, 0x00, 0x08, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0xFF, 0xC0, 0x10, 0x00, 0x18, 0x00, 0x3E, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80,
  0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0xF0,
  0xFF, 0xF3, 0xFF, 0xFF, 0x87, 0xFE, 0x07, 0xCC, 0x07, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x3F, 0xE0, 0x7F, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x01, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE,
  0x07, 0xC1, 0xE0, 0xF0, 0x1C, 0x3C, 0x03, 0xC7, 0x00, 0x79, 0xE1, 0xEF,
  0x38, 0x7D, 0xE7, 0x1F, 0xF9, 0xE7, 0x8F, 0x3C, 0xF0, 0xE7, 0x9C, 0x1C,
  0xE7, 0x87, 0x9C, 0xF0, 0xF3, 0x9E, 0x1C, 0xF3, 0xC3, 0x9E, 0x78, 0xF3,
  0xCF, 0xEE, 0x78, 0xFF, 0xCF, 0x1F, 0x78, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x1F, 0x3C, 0x01, 0xE3, 0xC0, 0x3E,
  0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3E, 0x03, 0xE3,
  0xE0, 0x1E, 0x3C, 0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xEF, 0x80, 0x1F,
  0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0x07, 0xC7,
  0xC0, 0xF1, 0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0xC7, 0x83, 0xE3, 0xFF,
  0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xC0, 0xF8, 0xF0, 0x1E,
  0x3C, 0x07, 0x9F, 0x01, 0xE7, 0x80, 0xF9, 0xE0, 0x7E, 0x7F, 0xFF, 0x1F,
  0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0x07, 0xCF, 0x80, 0xF3, 0xE0, 0x3D, 0xF0, 0x0C,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x06, 0x3E, 0x03, 0xEF, 0x81,
  0xF1, 0xF0, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0x80,
  0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE1, 0xF0, 0x7C,
  0x3E, 0x07, 0x87, 0x80, 0xF8, 0xF0, 0x1F, 0x1E, 0x03, 0xE3, 0xC0, 0x7C,
  0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0x8F, 0x01, 0xF1,
  0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x81, 0xF1, 0xE0, 0x3E, 0x3C, 0x1F, 0x87,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFE, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xF0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF8,
  0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF,
  0xF0, 0x7F, 0xFE, 0x3F, 0x0F, 0x8F, 0x81, 0xF7, 0xC0, 0x7D, 0xF0, 0x08,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE1, 0xFE, 0xF8, 0xFF, 0xBC,
  0x3F, 0xEF, 0x0F, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x81,
  0xF3, 0xF0, 0xFC, 0x7F, 0xFE, 0x1F, 0xF7, 0x83, 0xF9, 0xE0, 0x7C, 0x78,
  0x0F, 0x01, 0xF0, 0xF0, 0x1E, 0x1F, 0x01, 0xE1, 0xF0, 0x1E, 0x1E, 0x01,
  0xE1, 0xE0, 0x3E, 0x1E, 0x03, 0xE1, 0xE0, 0x3C, 0x3E, 0x03, 0xC3, 0xE0,
  0x3C, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7C,
  0x07, 0x87, 0xC0, 0x78, 0x7C, 0x07, 0x87, 0x80, 0xF8, 0x78, 0x0F, 0x87,
  0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x01, 0xF0,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x07,
  0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x10,
  0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x78, 0x3E, 0x1F, 0x07, 0xFF, 0xC0, 0x7F,
  0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0xF8, 0x78, 0x0F, 0x83,
  0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xFC, 0x0F, 0x0F, 0xC0, 0x78, 0x7C,
  0x03, 0xC7, 0xC0, 0x1E, 0x7C, 0x01, 0xF7, 0xC0, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFD, 0xF0, 0x0F, 0xC7, 0x80,
  0x7C, 0x3E, 0x03, 0xC1, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x80,
  0xF0, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0x80, 0xF8,
  0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE3,
  0xF8, 0x7F, 0x9D, 0xC3, 0xFD, 0xDE, 0x1C, 0xEE, 0xF0, 0xE7, 0xE7, 0x8F,
  0x3F, 0x3C, 0x79, 0xF1, 0xC3, 0xC7, 0x9E, 0x1E, 0x38, 0xF0, 0xF1, 0xC7,
  0x87, 0x0C, 0x3C, 0x78, 0x61, 0xE3, 0xC2, 0x0E, 0x1E, 0x00, 0xF0, 0xF0,
  0x07, 0x87, 0x80, 0x3C, 0x38, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF0,
  0x0F, 0x80, 0xF0, 0xFC, 0x1E, 0x1F, 0xC1, 0xE1, 0xFC, 0x1E, 0x1F, 0xC1,
  0xE1, 0xFC, 0x1E, 0x1F, 0xE1, 0xE1, 0xDE, 0x1C, 0x3D, 0xE3, 0xC3, 0xDE,
  0x3C, 0x3C, 0xE3, 0xC3, 0xCE, 0x3C, 0x3C, 0xF3, 0xC3, 0x8F, 0x38, 0x78,
  0xF7, 0x87, 0x87, 0x78, 0x78, 0x77, 0x87, 0x87, 0xF8, 0x78, 0x7F, 0x87,
  0x07, 0xF0, 0xF0, 0x3F, 0x0F, 0x03, 0xF0, 0xF0, 0x3F, 0x0F, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0x7C,
  0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D,
  0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0x80, 0x3E, 0xF0, 0x07, 0x9E, 0x01, 0xF7,
  0xC0, 0x3E, 0x78, 0x07, 0xCF, 0x01, 0xF1, 0xE0, 0x3E, 0x3E, 0x0F, 0x83,
  0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xF0, 0x3E, 0x3E, 0x03, 0xC7,
  0xC0, 0x78, 0xF0, 0x1F, 0x1E, 0x03, 0xE3, 0xC0, 0x7C, 0x78, 0x1F, 0x1F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F,
  0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0x7C, 0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xF0,
  0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0x80,
  0x3E, 0xF0, 0x07, 0x9E, 0x01, 0xF7, 0xC0, 0x3E, 0x78, 0x07, 0xCF, 0x01,
  0xF1, 0xE0, 0x3E, 0x3E, 0x0F, 0x87, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF,
  0x00, 0x3F, 0x80, 0x01, 0xE0, 0x80, 0x3E, 0x38, 0x03, 0xEF, 0x00, 0x3F,
  0xF0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0,
  0x78, 0xF0, 0x1F, 0x1E, 0x03, 0xE3, 0xC0, 0x7C, 0x78, 0x1F, 0x1F, 0xFF,
  0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFE, 0x01, 0xE3, 0xC0, 0x3C, 0x7C,
  0x0F, 0x87, 0x81, 0xF0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0xF0, 0x3E,
  0x1E, 0x07, 0xC7, 0xC0, 0x7C, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF,
  0x07, 0xFF, 0xF1, 0xF8, 0x3C, 0x3C, 0x03, 0x0F, 0x80, 0x41, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x84, 0x00, 0xF1,
  0xC0, 0x3E, 0x7E, 0x0F, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00,
  0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78,
  0x0F, 0x8F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0x8F, 0x00, 0xF1, 0xE0,
  0x1E, 0x3C, 0x07, 0xC7, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xC7, 0x80,
  0x78, 0xF0, 0x1F, 0x1E, 0x03, 0xE3, 0xC0, 0x78, 0x7C, 0x1F, 0x0F, 0xFF,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0x7C, 0x03, 0xE7, 0x80, 0x78, 0xF0, 0x1F, 0x1E, 0x03,
  0xC3, 0xC0, 0xF8, 0x78, 0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0xF8, 0x3E, 0x1E,
  0x07, 0xC7, 0xC0, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0xC0, 0x3C, 0xF0,
  0x07, 0xBE, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00,
  0x1E, 0x78, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x79, 0xE1, 0xE3, 0xCF,
  0x1F, 0x1E, 0x78, 0xF8, 0xE3, 0xC7, 0xCF, 0x1E, 0x7E, 0x78, 0xF3, 0xF3,
  0xC7, 0xBB, 0x9C, 0x39, 0xDC, 0xE1, 0xCE, 0xEF, 0x0E, 0xE7, 0x78, 0xF7,
  0x3B, 0x87, 0xB9, 0xDC, 0x3F, 0x8E, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8,
  0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x3C,
  0x7C, 0x00, 0x7C, 0xF0, 0x00, 0xFB, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xCF, 0x80, 0x0F, 0x1F, 0x00,
  0x3E, 0x1E, 0x00, 0xF8, 0x3E, 0x01, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x1F,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0x78, 0x07,
  0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x83, 0xC1, 0xF0, 0x3C, 0x1E, 0x03, 0xE3,
  0xE0, 0x1E, 0x7C, 0x01, 0xE7, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xE0, 0x70,
  0x3C, 0x1E, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0x78, 0x1C, 0x0E, 0x07, 0x03,
  0xC1, 0xE0, 0xF0, 0x38, 0x1C, 0x0F, 0x07, 0x83, 0xC0, 0xE0, 0x70, 0x3C,
  0x1E, 0x0F, 0x03, 0x81, 0xC0, 0xF0, 0x78, 0x3C, 0x0E, 0x07, 0xFE, 0x0F,
  0xFC, 0x3F, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0x9E, 0x01, 0xE3,
  0xC0, 0x7C, 0x7C, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0xF0, 0x0F, 0x1E, 0x01,
  0xE7, 0x80, 0x3D, 0xE0, 0x03, 0xC4, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x21, 0xCF, 0x3C, 0x78, 0xE3, 0xC4, 0x03, 0xE3, 0xC3, 0xFD,
  0xF1, 0xFF, 0xFC, 0xFC, 0x3E, 0x3E, 0x07, 0x9F, 0x01, 0xE7, 0xC0, 0x79,
  0xE0, 0x3E, 0x78, 0x0F, 0x9E, 0x03, 0xEF, 0x80, 0xF3, 0xE0, 0x3C, 0x78,
  0x1F, 0x1E, 0x0F, 0xC7, 0xC7, 0xF1, 0xFF, 0x7F, 0x3F, 0x8F, 0x87, 0xC3,
  0xE0, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0xF8, 0x1E, 0x7F, 0x07, 0xBF, 0xE3,
  0xF8, 0xF8, 0xFC, 0x1F, 0x3E, 0x03, 0xCF, 0x80, 0xF3, 0xC0, 0x3C, 0xF0,
  0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0x80, 0x79, 0xE0, 0x3E, 0x78, 0x0F,
  0x9F, 0x07, 0xCF, 0xFF, 0xE3, 0xEF, 0xF0, 0xF1, 0xF0, 0x00, 0x03, 0xF8,
  0x0F, 0xFE, 0x1F, 0xFF, 0x3E, 0x1F, 0x3C, 0x0E, 0x7C, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x04, 0xF8, 0x0E,
  0xF8, 0x1F, 0x7C, 0x3E, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x3C, 0x0F, 0xF3, 0xC1, 0xFF, 0xBC, 0x3F,
  0x0F, 0xC3, 0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x78, 0x78, 0x07, 0x87,
  0x80, 0x78, 0x78, 0x07, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x87, 0x81, 0xF0,
  0x78, 0x1F, 0x07, 0xC6, 0xF0, 0x7F, 0xEF, 0x03, 0xFD, 0xF0, 0x1F, 0x1F,
  0x00, 0x01, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0xC7, 0xC1, 0xE3, 0xC0, 0xFB,
  0xC0, 0x79, 0xE0, 0x3D, 0xF0, 0xFE, 0xFF, 0xFE, 0x7F, 0xFC, 0x3F, 0xE0,
  0x1E, 0x00, 0x0F, 0x00, 0x47, 0xC0, 0x79, 0xF0, 0xF8, 0xFF, 0xF8, 0x3F,
  0xF8, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x20, 0xF0, 0x01, 0xE1, 0xE0, 0x01, 0xE3, 0xC0, 0x01, 0xE7, 0x80,
  0x03, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE3, 0xC3, 0xFE, 0xF1, 0xFF, 0xBC, 0xFC, 0x3F, 0x3E, 0x07, 0xDF,
  0x01, 0xE7, 0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80,
  0xF9, 0xE0, 0x3E, 0x78, 0x1F, 0x1E, 0x07, 0xC7, 0xC6, 0xF1, 0xFF, 0xBC,
  0x3F, 0xDF, 0x07, 0xC7, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x20, 0x3C, 0x1C,
  0x1F, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x7C, 0x1E, 0x7F, 0x0F, 0x7F, 0xC7, 0xA3, 0xE7, 0xE0, 0xF3, 0xE0,
  0x79, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0xBE, 0x07, 0xDF,
  0x03, 0xEF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3D, 0xF0, 0x3E,
  0xF8, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x10, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE1, 0x81, 0xF1, 0xF0, 0xF9, 0xF0,
  0x79, 0xF0, 0x3D, 0xF0, 0x1F, 0xF0, 0x07, 0xF0, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x20, 0xF8, 0x30, 0x78, 0x3C, 0x3C, 0x0F, 0x1E, 0x07, 0xCF,
  0x01, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0x80, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF1, 0xF0, 0x1E, 0x7F, 0x83, 0xDF, 0xF0, 0x7E, 0x3E,
  0x1F, 0x83, 0xE3, 0xE0, 0x78, 0x7C, 0x0F, 0x0F, 0x03, 0xC1, 0xE0, 0xF8,
  0x3C, 0x7C, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3C, 0x78, 0x47, 0x8F, 0x1E,
  0xF1, 0xF7, 0x9E, 0x1F, 0xE7, 0xC3, 0xF8, 0xF8, 0x3C, 0x00, 0x7F, 0xE1,
  0xFF, 0x83, 0xFF, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x10, 0x78, 0x79, 0xF1, 0xE3,
  0xE7, 0x87, 0x9E, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F, 0x00, 0x1C, 0xE1, 0xE3,
  0xDF, 0x3F, 0x3D, 0xF7, 0xF3, 0xE7, 0xCF, 0x3C, 0x78, 0xF3, 0xC7, 0x8F,
  0x38, 0x70, 0xF3, 0x87, 0x0E, 0x78, 0xF0, 0xE7, 0x8F, 0x1E, 0x78, 0xF1,
  0xE7, 0x0F, 0x1E, 0x70, 0xE1, 0xE7, 0x0E, 0x1C, 0xF0, 0xE1, 0xCF, 0x1E,
  0x3C, 0xF1, 0xE3, 0xCE, 0x1E, 0x3C, 0x1E, 0x3E, 0x0F, 0x3F, 0x87, 0xBF,
  0xE3, 0xD1, 0xF3, 0xF0, 0x79, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x3C,
  0x07, 0x9E, 0x03, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0x80, 0xF3, 0xC0, 0x79,
  0xE0, 0x3C, 0xF0, 0x1E, 0xF8, 0x1F, 0x7C, 0x0F, 0x80, 0x03, 0xF0, 0x07,
  0xFE, 0x07, 0xFF, 0x87, 0xC3, 0xE7, 0xC0, 0xF3, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xDE, 0x01, 0xEF, 0x01,
  0xF7, 0x80, 0xF1, 0xE1, 0xF8, 0xFF, 0xF8, 0x3F, 0xF0, 0x07, 0xE0, 0x00,
  0x0F, 0x1F, 0x01, 0xE7, 0xF0, 0x3D, 0xFF, 0x0F, 0xE3, 0xE1, 0xF8, 0x3E,
  0x3E, 0x03, 0xC7, 0xC0, 0x78, 0xF0, 0x1F, 0x1E, 0x03, 0xE7, 0xC0, 0x7C,
  0xF8, 0x0F, 0x9E, 0x01, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x8F, 0x83, 0xE3,
  0xFF, 0xF8, 0x7D, 0xFE, 0x0F, 0x1F, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xE3, 0xC3, 0xFC, 0xF1, 0xFF, 0xBC, 0xFC, 0x3F, 0x3E, 0x07, 0xDF,
  0x01, 0xE7, 0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xEF, 0x80,
  0xFB, 0xE0, 0x3E, 0x78, 0x1F, 0x1E, 0x07, 0xC7, 0xC6, 0xF1, 0xFF, 0xBC,
  0x3F, 0xDF, 0x07, 0xC7, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x7F, 0xC7, 0xBF,
  0xCF, 0xFF, 0xEF, 0xE0, 0xF7, 0xF0, 0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xE0, 0xE1, 0xE0, 0x20, 0xF0,
  0x00, 0x78, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0,
  0x01, 0xE0, 0x00, 0xF1, 0x80, 0x79, 0xE0, 0x7D, 0xFF, 0xFC, 0x3F, 0xFC,
  0x07, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x04, 0x07, 0x83, 0x07, 0xC7, 0xC3, 0xE7, 0xC1, 0xF7, 0xC0,
  0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x00, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01,
  0xEF, 0x81, 0xF7, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78,
  0x0F, 0x7C, 0x0F, 0xBE, 0x07, 0xDE, 0x03, 0xCF, 0x03, 0xE7, 0x82, 0xF3,
  0xE3, 0xF8, 0xFF, 0x7C, 0x7F, 0x3E, 0x1F, 0x1E, 0x00, 0xFE, 0x02, 0x7F,
  0x0F, 0xBF, 0x83, 0xC3, 0xC1, 0xF1, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E,
  0x78, 0x1F, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0xCF, 0x83, 0xC7, 0xC3,
  0xE3, 0xC3, 0xE1, 0xE7, 0xE0, 0xFF, 0xE0, 0x3F, 0xC0, 0x0F, 0x80, 0x00,
  0x38, 0x70, 0xC7, 0x0E, 0x79, 0xE3, 0xC7, 0x3C, 0x78, 0xE7, 0x8F, 0x1E,
  0xE1, 0xC3, 0xDC, 0x38, 0x7B, 0x87, 0x0E, 0xF0, 0xE1, 0xDE, 0x3C, 0x3B,
  0xC7, 0x87, 0x70, 0xF1, 0xEE, 0x1C, 0x39, 0xC7, 0x87, 0x38, 0xF1, 0xC7,
  0xF6, 0x70, 0xFC, 0xFE, 0x0F, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0xFE, 0x3F,
  0x1F, 0xE7, 0xF3, 0xEF, 0xCF, 0x78, 0xFC, 0x73, 0x0F, 0x87, 0x00, 0xF8,
  0x80, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0x0F,
  0x00, 0xF1, 0xF0, 0xCF, 0x17, 0x1E, 0xF3, 0x77, 0xEF, 0xE7, 0xFC, 0x7E,
  0x7F, 0x03, 0xC3, 0xC0, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x8F,
  0x81, 0xF1, 0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E,
  0x03, 0xC7, 0xC0, 0xF8, 0xF8, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0xF8, 0x7C,
  0x2F, 0x0F, 0x8D, 0xE0, 0xFF, 0x7C, 0x1F, 0xCF, 0x80, 0xF1, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x82, 0x01, 0xE0, 0x70, 0x7C, 0x1F, 0xFF, 0x07, 0xFF,
  0xC0, 0x1F, 0xE0, 0x00, 0x07, 0xE1, 0xE3, 0xFF, 0x38, 0x7F, 0xFF, 0x1E,
  0x1F, 0xE3, 0x80, 0xF8, 0x70, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x0C, 0x07, 0xC3, 0xC1, 0xF0, 0x38, 0xFC,
  0x07, 0x3F, 0xFC, 0xE7, 0xFF, 0xFC, 0xF1, 0xFF, 0x1E, 0x0F, 0xC0, 0x00,
  0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x41,
  0xE0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E,
  0x07, 0x07, 0x83, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xFE,
  0x00, 0x7E, 0x01, 0xFF, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0x00,
  0xC3, 0xF8, 0x3C, 0xFF, 0x07, 0x3C, 0xF1, 0xE7, 0x0F, 0x39, 0xE1, 0xFF,
  0x38, 0x1F, 0xC3, 0x01, 0xF0,
};

const GFXglyph IBMPlexMono_SemiBoldItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 9, 24, 20, 6, -24 },
  { 28, 12, 11, 20, 6, -25 },
  { 45, 21, 24, 20, 0, -24 },
  { 108, 19, 30, 20, 1, -27 },
  { 180, 24, 24, 20, -1, -24 },
  { 252, 20, 24, 20, 0, -24 },
  { 312, 6, 11, 20, 9, -25 },
  { 321, 14, 31, 20, 6, -26 },
  { 376, 14, 31, 20, 1, -26 },
  { 431, 17, 17, 20, 2, -19 },
  { 468, 17, 17, 20, 2, -19 },
  { 505, 9, 11, 20, 4, -6 },
  { 518, 11, 4, 20, 5, -12 },
  { 524, 6, 6, 20, 6, -6 },
  { 529, 20, 31, 20, 0, -26 },
  { 607, 19, 24, 20, 1, -24 },
  { 664, 16, 24, 20, 2, -24 },
  { 712, 18, 24, 20, 1, -24 },
  { 766, 18, 24, 20, 1, -24 },
  { 820, 19, 24, 20, 0, -24 },
  { 877, 19, 24, 20, 1, -24 },
  { 934, 18, 24, 20, 1, -24 },
  { 988, 18, 24, 20, 3, -24 },
  { 1042, 19, 24, 20, 1, -24 },
  { 1099, 18, 24, 20, 2, -24 },
  { 1153, 8, 18, 20, 6, -18 },
  { 1171, 10, 23, 20, 4, -18 },
  { 1200, 16, 20, 20, 3, -20 },
  { 1240, 17, 11, 20, 2, -16 },
  { 1264, 16, 20, 20, 2, -20 },
  { 1304, 15, 24, 20, 4, -24 },
  { 1349, 19, 28, 20, 1, -24 },
  { 1416, 20, 24, 20, -1, -24 },
  { 1476, 18, 24, 20, 1, -24 },
  { 1530, 18, 24, 20, 2, -24 },
  { 1584, 19, 24, 20, 1, -24 },
  { 1641, 19, 24, 20, 1, -24 },
  { 1698, 20, 24, 20, 1, -24 },
  { 1758, 18, 24, 20, 2, -24 },
  { 1812, 20, 24, 20, 1, -24 },
  { 1872, 19, 24, 20, 1, -24 },
  { 1929, 19, 24, 20, 1, -24 },
  { 1986, 21, 24, 20, 1, -24 },
  { 2049, 16, 24, 20, 2, -24 },
  { 2097, 21, 24, 20, 0, -24 },
  { 2160, 20, 24, 20, 1, -24 },
  { 2220, 19, 24, 20, 1, -24 },
  { 2277, 19, 24, 20, 1, -24 },
  { 2334, 19, 31, 20, 1, -24 },
  { 2408, 19, 24, 20, 1, -24 },
  { 2465, 19, 24, 20, 1, -24 },
  { 2522, 19, 24, 20, 3, -24 },
  { 2579, 19, 24, 20, 2, -24 },
  { 2636, 19, 24, 20, 3, -24 },
  { 2693, 21, 24, 20, 1, -24 },
  { 2756, 23, 24, 20, -1, -24 },
  { 2825, 20, 24, 20, 3, -24 },
  { 2885, 21, 24, 20, 0, -24 },
  { 2948, 16, 31, 20, 4, -26 },
  { 3010, 9, 31, 20, 6, -26 },
  { 3045, 15, 31, 20, 1, -26 },
  { 3104, 19, 15, 20, 1, -24 },
  { 3140, 16, 3, 20, 0, 3 },
  { 3146, 6, 8, 20, 7, -28 },
  { 3152, 18, 18, 20, 1, -18 },
  { 3193, 18, 25, 20, 1, -25 },
  { 3250, 16, 18, 20, 2, -18 },
  { 3286, 20, 25, 20, 1, -25 },
  { 3349, 17, 18, 20, 2, -18 },
  { 3388, 23, 32, 20, -1, -25 },
  { 3480, 18, 25, 20, 1, -18 },
  { 3537, 17, 25, 20, 1, -25 },
  { 3591, 17, 26, 20, 2, -26 },
  { 3647, 17, 33, 20, 1, -26 },
  { 3718, 19, 25, 20, 1, -25 },
  { 3778, 15, 25, 20, 3, -25 },
  { 3825, 20, 18, 20, 0, -18 },
  { 3870, 17, 18, 20, 1, -18 },
  { 3909, 17, 18, 20, 2, -18 },
  { 3948, 19, 25, 20, 0, -18 },
  { 4008, 18, 25, 20, 1, -18 },
  { 4065, 17, 18, 20, 3, -18 },
  { 4104, 17, 18, 20, 1, -18 },
  { 4143, 17, 24, 20, 2, -24 },
  { 4194, 17, 18, 20, 2, -18 },
  { 4233, 17, 18, 20, 2, -18 },
  { 4272, 19, 18, 20, 1, -18 },
  { 4315, 20, 18, 20, 0, -18 },
  { 4360, 19, 25, 20, 0, -18 },
  { 4420, 19, 18, 20, 1, -18 },
  { 4463, 17, 31, 20, 3, -26 },
  { 4529, 9, 31, 20, 6, -26 },
  { 4564, 17, 31, 20, 1, -26 },
  { 4630, 19, 8, 20, 1, -14 },
};

const GFXfont IBMPlexMono_SemiBoldItalic34pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic34pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic34pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC34PT7B_H_
