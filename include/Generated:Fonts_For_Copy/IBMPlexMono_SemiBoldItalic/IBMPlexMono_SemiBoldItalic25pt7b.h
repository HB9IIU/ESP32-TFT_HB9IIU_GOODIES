#ifndef _IBMPLEXMONO_SEMIBOLDITALIC25PT7B_H_
#define _IBMPLEXMONO_SEMIBOLDITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBoldItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBoldItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xE1, 0xC3, 0x86, 0x0C, 0x18, 0x20, 0x00, 0x07,
  0x8F, 0x3E, 0x7C, 0x70, 0x71, 0xDC, 0xE7, 0x39, 0xCE, 0x73, 0x98, 0xEE,
  0x33, 0x9C, 0x01, 0xCE, 0x01, 0x9C, 0x03, 0x98, 0x03, 0x98, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3E, 0x06, 0x70, 0x0E, 0x70, 0x0C, 0x60, 0xFC, 0xFC,
  0xFC, 0xFC, 0xF8, 0xFC, 0x19, 0xC0, 0x39, 0xC0, 0x31, 0x80, 0x73, 0x80,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x1F, 0x80, 0xFF, 0xC3, 0xFF, 0xC7,
  0x37, 0x1E, 0x64, 0x3C, 0xC0, 0x3F, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F,
  0x80, 0x37, 0x80, 0xE7, 0x11, 0x8E, 0x73, 0x39, 0xFF, 0xF0, 0xFF, 0xC0,
  0x7E, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x07, 0x81, 0xC3, 0xF0,
  0xE1, 0x8C, 0x70, 0x63, 0x18, 0x38, 0xCC, 0x0E, 0x37, 0x03, 0x9F, 0x80,
  0x7E, 0x00, 0x0F, 0x3C, 0x00, 0x1F, 0x80, 0x7E, 0x60, 0x3B, 0x18, 0x1C,
  0xC6, 0x06, 0x31, 0x83, 0x0C, 0xE1, 0xC3, 0xF0, 0xE0, 0x78, 0x00, 0x01,
  0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0x71, 0xC0, 0xE1, 0x81, 0xC7, 0x01, 0xCE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xE7, 0x03, 0xCE, 0x07, 0x0E, 0x0E, 0x1C, 0xDE,
  0x5D, 0xFF, 0xBF, 0x3F, 0x7C, 0x3C, 0x70, 0x77, 0x7E, 0xEE, 0xEE, 0x03,
  0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0x1E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07,
  0x01, 0x80, 0xE0, 0x70, 0x38, 0x3C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x86, 0x17, 0xB7, 0xFF, 0xFC, 0xFF, 0x81, 0xF0, 0x1F, 0x81, 0xEE, 0x1E,
  0x78, 0xE1, 0x82, 0x08, 0x00, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C,
  0x00, 0x3E, 0x78, 0xE3, 0xC7, 0x0E, 0x38, 0x70, 0xFF, 0xFF, 0xFE, 0x7B,
  0xFF, 0xF7, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xE0, 0x3F,
  0xC1, 0xFF, 0x8F, 0x0E, 0x78, 0x39, 0xC0, 0xF7, 0x03, 0xFC, 0xCF, 0xF7,
  0x3B, 0x9C, 0xEE, 0x03, 0xB8, 0x1E, 0xE0, 0x73, 0xC3, 0xC7, 0xFE, 0x0F,
  0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3F, 0x03, 0xF8, 0x3F, 0x81, 0xDC, 0x1C,
  0xE1, 0xE7, 0x0E, 0x38, 0x23, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x03, 0xC1, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0x03, 0xF0, 0x1F, 0xE0, 0xFF,
  0xC7, 0x8F, 0x3C, 0x1C, 0x20, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0x9F, 0xFE, 0xFF,
  0xF8, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0xC7, 0x0F, 0x08, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0xFC, 0x07, 0xC0, 0x1F, 0xC0, 0x07, 0x80, 0x0E, 0x20, 0x3B,
  0xC1, 0xE7, 0xFF, 0x0F, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x7E, 0x03, 0xB8, 0x1C, 0xE0, 0xE3, 0x83, 0x1C, 0x1C, 0x70, 0xE1,
  0xC7, 0x07, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF, 0x8E, 0x00, 0x38, 0x00, 0xCF, 0x03,
  0x7F, 0x1F, 0xFC, 0x78, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x60, 0x73,
  0xC3, 0xCF, 0xFE, 0x1F, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x1E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x1D, 0xF1, 0xFF, 0xCF, 0xFE, 0x78, 0x7F, 0x83, 0xF8,
  0x0F, 0xC0, 0xFE, 0x07, 0x78, 0x79, 0xFF, 0x87, 0xF8, 0x1F, 0x80, 0x7F,
  0xFB, 0xFF, 0xDF, 0xFF, 0xC0, 0xEE, 0x07, 0x70, 0x70, 0x07, 0x80, 0x38,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x00, 0x07, 0xE0, 0x7F, 0xE3, 0xFF, 0x8F, 0x0F, 0x38, 0x3C,
  0xE0, 0xE3, 0x87, 0x87, 0xFC, 0x0F, 0xC0, 0xFF, 0xC7, 0x07, 0x38, 0x1E,
  0xE0, 0x7B, 0xC3, 0xCF, 0xFF, 0x1F, 0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xFF,
  0x1F, 0xFC, 0xF1, 0xEF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0E, 0xF0, 0xF7,
  0xFB, 0x9F, 0xF8, 0x7B, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0xF8,
  0x00, 0x1C, 0x7C, 0xF9, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0xF1, 0xE7, 0xCF,
  0x8E, 0x00, 0x0E, 0x1F, 0x1F, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x3C, 0x38, 0x78, 0x70, 0x70, 0xE0, 0xE0, 0x00, 0x10, 0x07, 0x01,
  0xF0, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x0E, 0x00, 0xF0, 0x07, 0xC0, 0x3F,
  0x00, 0xF8, 0x03, 0xC0, 0x1C, 0x00, 0x40, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xDF, 0xFE, 0xFF, 0xF0, 0x20, 0x03,
  0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF0, 0x07, 0x01, 0xF0,
  0x7E, 0x1F, 0x87, 0xE0, 0x78, 0x0E, 0x00, 0x80, 0x00, 0x1F, 0x87, 0xF9,
  0xFF, 0xF8, 0xFE, 0x0E, 0x03, 0xC0, 0xF0, 0xFC, 0x1C, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x3F,
  0xC1, 0xFF, 0x8F, 0x0E, 0x38, 0x1D, 0xC7, 0x77, 0x3F, 0x99, 0xCE, 0xE6,
  0x3B, 0xB8, 0xEE, 0xE3, 0xBB, 0x9E, 0xEF, 0xF3, 0x9E, 0xCE, 0x7F, 0x38,
  0x00, 0xF0, 0x01, 0xFF, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0x77, 0x01, 0xCE, 0x03, 0x9C, 0x0E,
  0x1C, 0x1C, 0x38, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0xC7, 0x03, 0x9E, 0x07,
  0x38, 0x0E, 0xF0, 0x1E, 0x1F, 0xE0, 0xFF, 0x8F, 0xFE, 0x78, 0x73, 0x83,
  0x9C, 0x1C, 0xE1, 0xE7, 0xFE, 0x7F, 0xC3, 0xFF, 0x9C, 0x1C, 0xE0, 0xE7,
  0x07, 0xB8, 0x7B, 0xFF, 0xDF, 0xFC, 0xFF, 0x80, 0x03, 0xE0, 0x3F, 0xC1,
  0xFF, 0x8F, 0x0F, 0x38, 0x1D, 0xE0, 0x47, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x0C, 0x70, 0x79, 0xE3, 0xC7, 0xFE, 0x0F, 0xF0,
  0x1F, 0x80, 0x1F, 0xC0, 0xFF, 0xC3, 0xFF, 0x8E, 0x1E, 0x38, 0x38, 0xE0,
  0xF3, 0x83, 0xDE, 0x0E, 0x78, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x1E, 0x70,
  0x73, 0xC3, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xF3,
  0xFF, 0xCF, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFC, 0x7F, 0xF1,
  0xFF, 0xC7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0xFE, 0x3F, 0xF8,
  0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF3, 0xFF, 0xCF, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0xC1,
  0xFF, 0x8F, 0x0E, 0x38, 0x39, 0xE0, 0xD7, 0x00, 0x1C, 0x00, 0xF1, 0xFB,
  0xC7, 0xEF, 0x1F, 0xBC, 0x8C, 0xF0, 0x71, 0xC3, 0xC7, 0xF7, 0x1F, 0xDC,
  0x1E, 0x70, 0x3C, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x0F, 0x38, 0x38, 0xE0,
  0xE7, 0x83, 0x9F, 0xFE, 0x7F, 0xF9, 0xFF, 0xE7, 0x07, 0x1C, 0x1C, 0xF0,
  0x73, 0x81, 0xCE, 0x0F, 0x38, 0x3C, 0xE0, 0xE0, 0x1F, 0xFC, 0x7F, 0xF3,
  0xFF, 0xC0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x0F, 0xFE, 0x3F, 0xF8,
  0xFF, 0xE0, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x41, 0xCE, 0x0E, 0x78,
  0xF1, 0xFF, 0x0F, 0xF8, 0x1F, 0x00, 0x1C, 0x1F, 0x3C, 0x3C, 0x3C, 0x78,
  0x38, 0xF0, 0x38, 0xE0, 0x39, 0xE0, 0x3B, 0xC0, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0xC0, 0x79, 0xC0, 0x79, 0xC0, 0x71, 0xE0, 0xF0, 0xE0, 0xE0, 0xF0,
  0xE0, 0x70, 0xE0, 0x78, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07,
  0x00, 0x7F, 0xF7, 0xFF, 0xFF, 0xF0, 0x1E, 0x0F, 0x1E, 0x1E, 0x1E, 0x3E,
  0x3F, 0x3E, 0x3F, 0x7E, 0x3F, 0x6E, 0x3B, 0xEE, 0x3B, 0xCC, 0x33, 0xDC,
  0x73, 0x9C, 0x71, 0x9C, 0x71, 0x1C, 0x72, 0x1C, 0x70, 0x18, 0x60, 0x38,
  0xE0, 0x38, 0xE0, 0x38, 0x3E, 0x1C, 0xF8, 0x73, 0xE1, 0xCF, 0x87, 0x3E,
  0x18, 0xDC, 0xE7, 0x73, 0x9D, 0xCE, 0x73, 0x39, 0xCC, 0xE7, 0x3B, 0x18,
  0xFC, 0xE3, 0xF3, 0x87, 0xCE, 0x1F, 0x38, 0x7C, 0xE1, 0xE0, 0x07, 0xE0,
  0x3F, 0xC1, 0xFF, 0x8F, 0x0E, 0x78, 0x3D, 0xE0, 0xF7, 0x03, 0xFC, 0x0F,
  0xF0, 0x3B, 0xC0, 0xEE, 0x03, 0xB8, 0x1E, 0xE0, 0x73, 0xC3, 0xC7, 0xFE,
  0x0F, 0xF0, 0x1F, 0x80, 0x1F, 0xF0, 0x7F, 0xE3, 0xFF, 0x8F, 0x0F, 0x38,
  0x3C, 0xE0, 0xF3, 0x83, 0xCE, 0x1E, 0x7F, 0xF9, 0xFF, 0xC7, 0xFC, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0xE0,
  0x3F, 0xC1, 0xFF, 0x8F, 0x0E, 0x78, 0x39, 0xE0, 0xF7, 0x03, 0xFC, 0x0F,
  0xF0, 0x3B, 0xC0, 0xEE, 0x03, 0xB8, 0x1E, 0xE0, 0x73, 0xC3, 0xC7, 0xFE,
  0x1F, 0xF0, 0x1F, 0x80, 0x1C, 0x40, 0x7B, 0x80, 0xFE, 0x01, 0xF0, 0x03,
  0x80, 0x1F, 0xF0, 0x7F, 0xE3, 0xFF, 0x8F, 0x0F, 0x38, 0x3C, 0xE0, 0xF3,
  0x83, 0xCE, 0x1E, 0x7F, 0xF9, 0xFF, 0xC7, 0xFC, 0x1C, 0xF0, 0x71, 0xC1,
  0xC7, 0x0F, 0x0E, 0x38, 0x38, 0xE0, 0xF0, 0x03, 0xF0, 0x1F, 0xF8, 0x7F,
  0xF0, 0xF0, 0xF1, 0xC0, 0x87, 0x80, 0x07, 0x80, 0x0F, 0xF0, 0x0F, 0xF8,
  0x07, 0xF0, 0x01, 0xE0, 0x01, 0xE2, 0x03, 0x8E, 0x0F, 0x3F, 0xFE, 0x1F,
  0xF8, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x3C, 0x1C, 0xE0,
  0x73, 0x81, 0xCE, 0x0F, 0x38, 0x39, 0xE0, 0xE7, 0x03, 0x9C, 0x0E, 0x70,
  0x39, 0xC1, 0xE7, 0x07, 0x3C, 0x1C, 0xF0, 0x73, 0xC3, 0xC7, 0xFE, 0x1F,
  0xF0, 0x1F, 0x80, 0xF0, 0x1F, 0xC0, 0xF7, 0x03, 0x9C, 0x1E, 0x70, 0x71,
  0xC1, 0xC7, 0x0E, 0x1C, 0x38, 0x71, 0xE1, 0xC7, 0x07, 0xBC, 0x0E, 0xE0,
  0x3B, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x70, 0x06, 0xE0,
  0x1D, 0xC0, 0x3B, 0x80, 0x77, 0x38, 0xCC, 0x73, 0x99, 0xE7, 0x73, 0xCE,
  0xE7, 0x99, 0xDB, 0x73, 0xB6, 0xE7, 0x6D, 0xCF, 0x9B, 0x1F, 0x36, 0x3E,
  0x7C, 0x78, 0xF8, 0xF1, 0xE0, 0x1E, 0x07, 0x87, 0x87, 0x81, 0xC3, 0x80,
  0xE3, 0xC0, 0x7B, 0xC0, 0x1D, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x01, 0xFC, 0x01, 0xEE, 0x00, 0xE7, 0x80, 0xE1, 0xC0, 0xF0,
  0xF0, 0xF0, 0x78, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0xE0, 0x79, 0xC1, 0xE3,
  0xC3, 0x83, 0x8F, 0x07, 0x1C, 0x0E, 0x70, 0x0F, 0xE0, 0x1F, 0x80, 0x3E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF8, 0x0F, 0xF0,
  0xFF, 0x0F, 0xE1, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xE1, 0xC1, 0x83, 0x07, 0x0E,
  0x1C, 0x18, 0x30, 0x70, 0xE1, 0xC1, 0x83, 0x07, 0x0E, 0x1C, 0x18, 0x30,
  0x70, 0xE1, 0xC0, 0x1F, 0xE3, 0xFC, 0x7F, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0xE0, 0x1C, 0x7F, 0x8F, 0xF1, 0xFC, 0x00, 0x03, 0xC0,
  0x1E, 0x01, 0xF8, 0x1D, 0xC0, 0xE7, 0x0E, 0x38, 0xE1, 0xCF, 0x07, 0x70,
  0x3F, 0x01, 0xC8, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x2E, 0xE7, 0x33,
  0x0F, 0x39, 0xFD, 0xCF, 0xFE, 0xF0, 0xE7, 0x07, 0x78, 0x3B, 0xC1, 0xDC,
  0x1E, 0xE0, 0xE7, 0x8F, 0x3F, 0xBE, 0xFD, 0xE3, 0xC7, 0x00, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE7, 0x87, 0x7E, 0x7F,
  0xFB, 0xE3, 0xDE, 0x0E, 0xE0, 0x77, 0x07, 0xB8, 0x3F, 0xC1, 0xDE, 0x1E,
  0xEF, 0xE7, 0x7F, 0x39, 0xE0, 0x0F, 0x87, 0xF9, 0xFF, 0xB8, 0x7F, 0x05,
  0xC0, 0x38, 0x07, 0x02, 0xE0, 0xFC, 0x3B, 0xFF, 0x3F, 0xC3, 0xE0, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0xF3, 0x8F,
  0xEE, 0x3F, 0xB9, 0xE1, 0xE7, 0x07, 0x3C, 0x1C, 0xF0, 0x73, 0x81, 0xCE,
  0x0F, 0x3C, 0x7C, 0xFF, 0xF1, 0xFB, 0x83, 0xCE, 0x00, 0x0F, 0xC3, 0xFE,
  0x7F, 0xE7, 0x8F, 0xF0, 0xEE, 0x1E, 0xFF, 0xCF, 0xE0, 0xE0, 0x8E, 0x0E,
  0xFF, 0xE7, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x18, 0xE0, 0x1E, 0x70, 0x07,
  0xB8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x07, 0x9C, 0x7F, 0x71,
  0xFD, 0xCF, 0x0F, 0x38, 0x3D, 0xE0, 0xE7, 0x83, 0x9C, 0x0E, 0x70, 0x79,
  0xE3, 0xE7, 0xFF, 0x8F, 0xDC, 0x1E, 0x70, 0x03, 0xC2, 0x0F, 0x1F, 0xF8,
  0xFF, 0xC0, 0xFC, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x00, 0xE7, 0x87, 0x7E, 0x3F, 0xF3, 0xE3, 0xDE, 0x1C, 0xF0, 0xE7,
  0x07, 0x38, 0x39, 0xC1, 0xDE, 0x0E, 0xE0, 0xF7, 0x07, 0x38, 0x38, 0x07,
  0x00, 0x78, 0x07, 0x80, 0x70, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0xFE,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x41, 0xC6, 0x1C, 0xF1, 0xDE, 0x3F,
  0xC1, 0xF8, 0x1E, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x87, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC1, 0x0E, 0x1C, 0x71, 0xF7,
  0x87, 0xB8, 0x1F, 0xC0, 0x7E, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x9E, 0x0E, 0xFC, 0x3F, 0xF9, 0xF1,
  0xE7, 0x87, 0x1E, 0x1C, 0x71, 0xC1, 0xDC, 0x07, 0x71, 0x3C, 0xEE, 0xE3,
  0xFF, 0x8F, 0xCE, 0x1E, 0x00, 0x7F, 0x0F, 0xE3, 0xFC, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC4, 0x71,
  0x8E, 0x79, 0xDE, 0x3F, 0x87, 0xE0, 0x70, 0x00, 0x3B, 0x9C, 0x6F, 0x7C,
  0xDE, 0xFB, 0xCE, 0x77, 0x18, 0xCE, 0x71, 0x9C, 0xE3, 0x31, 0xCE, 0x63,
  0x9D, 0xC6, 0x3B, 0x8C, 0x67, 0x38, 0xCE, 0x73, 0x80, 0x39, 0xE1, 0xDF,
  0x8F, 0xFC, 0xF8, 0xF7, 0x87, 0x3C, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x77,
  0x83, 0xB8, 0x3D, 0xC1, 0xCE, 0x0E, 0x00, 0x07, 0xC0, 0xFF, 0x0F, 0xFC,
  0xF0, 0xF7, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x77, 0x87, 0x9F,
  0xF8, 0x7F, 0x81, 0xF0, 0x00, 0x1C, 0xF0, 0x77, 0xE3, 0xFF, 0xCF, 0x8F,
  0x3C, 0x1C, 0xE0, 0x73, 0x83, 0xCE, 0x0F, 0x78, 0x39, 0xE1, 0xE7, 0x7F,
  0x1D, 0xFC, 0x73, 0xC1, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x0F, 0x39, 0xFD, 0xCF, 0xEE, 0xF0, 0xF7, 0x07, 0x78, 0x3B, 0xC1,
  0xDC, 0x0E, 0xE0, 0xF7, 0x8F, 0xBF, 0xFC, 0xFD, 0xC3, 0xCE, 0x00, 0x70,
  0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x7E, 0x7B, 0xF7, 0xDF, 0xFD,
  0x1E, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x0F, 0xC1, 0xFF, 0x3F, 0xF3, 0x82, 0x38,
  0x03, 0xFC, 0x3F, 0xE0, 0xFF, 0x00, 0xF6, 0x0F, 0xFF, 0xE7, 0xFC, 0x3F,
  0x80, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1,
  0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x84, 0x38, 0xE3, 0xBE, 0x3F, 0xC3,
  0xF0, 0x1E, 0x00, 0x38, 0x39, 0xC1, 0xDE, 0x0E, 0xE0, 0xF7, 0x07, 0x38,
  0x39, 0xC1, 0xCE, 0x1E, 0xF0, 0xF7, 0x8F, 0x9F, 0xF8, 0xFD, 0xC3, 0xCE,
  0x00, 0xFC, 0x37, 0xE3, 0xBF, 0x1E, 0x70, 0x73, 0x87, 0x9C, 0x3C, 0xE1,
  0xC7, 0x1E, 0x38, 0xF3, 0x9F, 0x1F, 0xF0, 0x7F, 0x03, 0xE0, 0x00, 0x73,
  0x9B, 0x1D, 0xD8, 0xC6, 0xC6, 0x3E, 0x71, 0xF3, 0x8F, 0x9C, 0x78, 0xE7,
  0xC6, 0x3E, 0x71, 0xBF, 0x9D, 0xEF, 0xCE, 0x3C, 0x00, 0x07, 0x1C, 0x3E,
  0x7C, 0xFF, 0xFB, 0xDE, 0x72, 0x3C, 0xE0, 0x71, 0x00, 0xE0, 0x11, 0xC0,
  0xE7, 0x8D, 0xCF, 0x7B, 0xFF, 0xE7, 0xCF, 0x87, 0x1E, 0x00, 0x1C, 0x1C,
  0x70, 0x73, 0xC1, 0xCE, 0x0F, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x8E, 0x1E,
  0x38, 0x78, 0xE3, 0xE3, 0xFF, 0x0F, 0xDC, 0x1E, 0x70, 0x03, 0xC6, 0x1E,
  0x1F, 0xF8, 0xFF, 0xC0, 0xFC, 0x00, 0x1F, 0x39, 0xFF, 0xDF, 0xFE, 0xE1,
  0xF6, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC6, 0x3C, 0x77, 0xF1, 0xBF, 0xFD,
  0xDF, 0xEE, 0x3E, 0x00, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0xE0, 0x0C, 0x00,
  0xE0, 0x06, 0x00, 0x70, 0x07, 0x0F, 0xE0, 0xF8, 0x0F, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0xF0, 0x7F, 0x03,
  0xF0, 0x1C, 0x71, 0xC6, 0x38, 0xE3, 0x8E, 0x38, 0xC7, 0x1C, 0x71, 0xC7,
  0x18, 0xE3, 0x8E, 0x38, 0xC3, 0x00, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0x0C,
  0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x00, 0x7F, 0x01, 0xF0, 0xFF,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x70, 0x06, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC0, 0x1C, 0x18, 0xF8, 0x77, 0xF3, 0x99, 0xCE, 0xE3, 0xF3,
  0x0F, 0xCC, 0x1E, 0x00,
};

const GFXglyph IBMPlexMono_SemiBoldItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 7, 17, 15, 4, -17 },
  { 16, 10, 8, 15, 4, -19 },
  { 26, 16, 17, 15, 0, -17 },
  { 60, 15, 23, 15, 0, -20 },
  { 104, 18, 17, 15, -1, -17 },
  { 143, 15, 17, 15, 0, -17 },
  { 175, 4, 8, 15, 7, -19 },
  { 179, 10, 22, 15, 5, -19 },
  { 207, 10, 22, 15, 1, -19 },
  { 235, 13, 13, 15, 1, -14 },
  { 257, 12, 13, 15, 2, -14 },
  { 277, 7, 8, 15, 3, -4 },
  { 284, 8, 3, 15, 4, -9 },
  { 287, 5, 5, 15, 4, -5 },
  { 291, 15, 22, 15, 0, -19 },
  { 333, 14, 17, 15, 1, -17 },
  { 363, 13, 17, 15, 1, -17 },
  { 391, 14, 17, 15, 0, -17 },
  { 421, 14, 17, 15, 0, -17 },
  { 451, 14, 17, 15, 0, -17 },
  { 481, 14, 17, 15, 1, -17 },
  { 511, 13, 17, 15, 1, -17 },
  { 539, 13, 17, 15, 2, -17 },
  { 567, 14, 17, 15, 1, -17 },
  { 597, 13, 17, 15, 2, -17 },
  { 625, 7, 14, 15, 4, -14 },
  { 638, 8, 18, 15, 3, -14 },
  { 656, 12, 15, 15, 2, -15 },
  { 679, 13, 9, 15, 1, -12 },
  { 694, 12, 15, 15, 1, -15 },
  { 717, 11, 17, 15, 3, -17 },
  { 741, 14, 20, 15, 1, -17 },
  { 776, 15, 17, 15, -1, -17 },
  { 808, 13, 17, 15, 1, -17 },
  { 836, 14, 17, 15, 1, -17 },
  { 866, 14, 17, 15, 1, -17 },
  { 896, 14, 17, 15, 1, -17 },
  { 926, 14, 17, 15, 1, -17 },
  { 956, 14, 17, 15, 1, -17 },
  { 986, 14, 17, 15, 1, -17 },
  { 1016, 14, 17, 15, 1, -17 },
  { 1046, 13, 17, 15, 1, -17 },
  { 1074, 16, 17, 15, 1, -17 },
  { 1108, 12, 17, 15, 1, -17 },
  { 1134, 16, 17, 15, 0, -17 },
  { 1168, 14, 17, 15, 1, -17 },
  { 1198, 14, 17, 15, 1, -17 },
  { 1228, 14, 17, 15, 1, -17 },
  { 1258, 14, 22, 15, 1, -17 },
  { 1297, 14, 17, 15, 1, -17 },
  { 1327, 15, 17, 15, 0, -17 },
  { 1359, 14, 17, 15, 2, -17 },
  { 1389, 14, 17, 15, 1, -17 },
  { 1419, 14, 17, 15, 2, -17 },
  { 1449, 15, 17, 15, 1, -17 },
  { 1481, 17, 17, 15, -1, -17 },
  { 1518, 15, 17, 15, 2, -17 },
  { 1550, 15, 17, 15, 0, -17 },
  { 1582, 12, 22, 15, 3, -19 },
  { 1615, 7, 22, 15, 4, -19 },
  { 1635, 11, 22, 15, 1, -19 },
  { 1666, 13, 11, 15, 1, -17 },
  { 1684, 12, 3, 15, 0, 2 },
  { 1689, 4, 6, 15, 5, -20 },
  { 1692, 13, 13, 15, 1, -13 },
  { 1714, 13, 19, 15, 1, -19 },
  { 1745, 11, 13, 15, 2, -13 },
  { 1763, 14, 19, 15, 1, -19 },
  { 1797, 12, 13, 15, 2, -13 },
  { 1817, 17, 24, 15, -1, -19 },
  { 1868, 14, 18, 15, 0, -13 },
  { 1900, 13, 19, 15, 1, -19 },
  { 1931, 12, 19, 15, 2, -19 },
  { 1960, 13, 24, 15, 0, -19 },
  { 1999, 14, 19, 15, 1, -19 },
  { 2033, 11, 19, 15, 2, -19 },
  { 2060, 15, 13, 15, 0, -13 },
  { 2085, 13, 13, 15, 1, -13 },
  { 2107, 13, 13, 15, 1, -13 },
  { 2129, 14, 18, 15, 0, -13 },
  { 2161, 13, 18, 15, 1, -13 },
  { 2191, 13, 13, 15, 2, -13 },
  { 2213, 12, 13, 15, 1, -13 },
  { 2233, 12, 17, 15, 2, -17 },
  { 2259, 13, 13, 15, 1, -13 },
  { 2281, 13, 13, 15, 1, -13 },
  { 2303, 13, 13, 15, 1, -13 },
  { 2325, 15, 13, 15, 0, -13 },
  { 2350, 14, 18, 15, 0, -13 },
  { 2382, 13, 13, 15, 1, -13 },
  { 2404, 12, 22, 15, 3, -19 },
  { 2437, 6, 22, 15, 5, -19 },
  { 2454, 12, 22, 15, 1, -19 },
  { 2487, 14, 7, 15, 1, -11 },
};

const GFXfont IBMPlexMono_SemiBoldItalic25pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBoldItalic25pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBoldItalic25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _IBMPLEXMONO_SEMIBOLDITALIC25PT7B_H_
