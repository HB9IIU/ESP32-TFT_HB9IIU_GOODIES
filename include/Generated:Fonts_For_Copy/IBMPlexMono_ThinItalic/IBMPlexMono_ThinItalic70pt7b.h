#ifndef _IBMPLEXMONO_THINITALIC70PT7B_H_
#define _IBMPLEXMONO_THINITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x3E, 0x07, 0x80, 0xF0, 0x00, 0x18, 0x0C, 0x60,
  0x31, 0x80, 0xC4, 0x03, 0x10, 0x08, 0xC0, 0x23, 0x01, 0x8C, 0x06, 0x30,
  0x18, 0x80, 0x62, 0x01, 0x18, 0x04, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x10,
  0x0C, 0xC0, 0x23, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x40, 0x06, 0x00, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x80, 0x08, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x00, 0x10, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x40, 0x00, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x20,
  0x02, 0x00, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x04,
  0x00, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00,
  0x40, 0x04, 0x00, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x08, 0x00,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x10, 0x01, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0x02, 0x1E, 0x00, 0x00, 0xC0, 0x10, 0x1C, 0x00, 0x0C, 0x00,
  0x80, 0x30, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x60, 0x03, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x20, 0x00, 0x00, 0x40, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x04, 0x00, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0x06, 0x01, 0x00,
  0x00, 0x00, 0x1C, 0x08, 0x00, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0x0E, 0x00,
  0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x01, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x60, 0x00, 0x00, 0x40, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x40, 0x00, 0x01, 0x80, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x80, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x60, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x10, 0x20, 0x00, 0x40, 0x01, 0x81, 0x80, 0x02, 0x00, 0x08, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x01, 0xC0, 0x60, 0x18, 0x00, 0x03, 0xE3, 0x07, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x30,
  0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x60, 0x00, 0x80, 0x00, 0x30, 0x01, 0x00, 0x03, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x10, 0x00, 0x20, 0x01, 0x80,
  0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x60, 0x00, 0x40, 0x00, 0x10, 0x01, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x20, 0x08, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x04, 0x00, 0x04, 0x03, 0x00, 0x00, 0x18, 0x00, 0x20, 0x18,
  0x00, 0x00, 0x20, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x40, 0x0C, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0xC0, 0x18, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x60, 0x01, 0x00, 0x00, 0x06, 0x01, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x08, 0x00, 0x08, 0x00, 0x00, 0x80, 0x60, 0x00, 0x20, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x08, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x80, 0x01, 0x80, 0x08, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x80, 0x00, 0x60, 0x01, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x04, 0x00, 0x60, 0x00, 0x30, 0x00, 0x20,
  0x01, 0x00, 0x00, 0x40, 0x01, 0x80, 0x08, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x60, 0x03, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x79, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x8C, 0x00, 0x00, 0x06, 0x00, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x80, 0x00, 0x01, 0x40, 0x01, 0xC0, 0x00, 0x01, 0x60, 0x02,
  0xC0, 0x00, 0x03, 0x30, 0x06, 0xC0, 0x00, 0x02, 0x10, 0x04, 0x40, 0x00,
  0x02, 0x18, 0x08, 0x60, 0x00, 0x04, 0x08, 0x18, 0x30, 0x00, 0x0C, 0x0C,
  0x10, 0x18, 0x00, 0x18, 0x06, 0x20, 0x0C, 0x00, 0x30, 0x02, 0x60, 0x07,
  0x01, 0xC0, 0x03, 0x40, 0x00, 0xFE, 0x00, 0x01, 0x80, 0x18, 0x8C, 0x63,
  0x18, 0x84, 0x63, 0x18, 0xC4, 0x23, 0x18, 0xC6, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x17,
  0x00, 0x06, 0x00, 0x0F, 0x9E, 0x00, 0x60, 0x07, 0x80, 0x3C, 0x06, 0x07,
  0xC0, 0x00, 0x78, 0x43, 0xE0, 0x00, 0x00, 0xF5, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x06, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x30,
  0x1C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30,
  0x18, 0x06, 0x01, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x77, 0xFD, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x10, 0x00, 0x00, 0x80, 0x08, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x04, 0x03, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x00, 0x82,
  0x00, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x02,
  0x10, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00,
  0x08, 0xC0, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x00, 0x09, 0x80, 0x03, 0x00, 0x02, 0x60, 0x01,
  0xE0, 0x01, 0x98, 0x00, 0x78, 0x00, 0x64, 0x00, 0x1C, 0x00, 0x19, 0x00,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x18, 0x10, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x02, 0x00, 0x80, 0x00, 0x01, 0x80, 0x20,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x20, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x1C, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x01, 0x00, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0x60, 0x04,
  0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x60, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xE0, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x04, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x00,
  0x58, 0x00, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x00, 0x31, 0x00, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00,
  0x18, 0x02, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0x18, 0x00, 0x30, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x20, 0x3F, 0xE0, 0x00, 0x04, 0x38, 0x07, 0x00,
  0x01, 0x98, 0x00, 0x18, 0x00, 0x34, 0x00, 0x01, 0x80, 0x05, 0x00, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x0F, 0xF8, 0x00, 0x61, 0xE0,
  0x1C, 0x01, 0x1C, 0x00, 0x18, 0x0C, 0xC0, 0x00, 0x10, 0x36, 0x00, 0x00,
  0x20, 0xB0, 0x00, 0x00, 0xC7, 0x80, 0x00, 0x01, 0x94, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x0B, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00,
  0x13, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x10,
  0x60, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x98, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x00, 0x42, 0x00, 0x00, 0x00, 0x61, 0x00, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x02, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x20, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x08, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0x38, 0x03, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x70,
  0x06, 0x00, 0x03, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x03, 0x02, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x06, 0x10, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00,
  0x13, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x01, 0xC8, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0E, 0x10,
  0x00, 0x00, 0x34, 0x30, 0x00, 0x00, 0x58, 0x30, 0x00, 0x01, 0x20, 0x20,
  0x00, 0x0C, 0xC0, 0x30, 0x00, 0x71, 0x00, 0x38, 0x03, 0x86, 0x00, 0x0F,
  0xF8, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xF0, 0x7C,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x3E, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x02, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x0C, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x08, 0x60, 0x00, 0x01, 0x88, 0x00, 0x00, 0x13,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x40, 0x02, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00,
  0x80, 0x30, 0x00, 0x01, 0x80, 0x40, 0x00, 0x01, 0x01, 0x00, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x10,
  0x40, 0x00, 0x00, 0x20, 0x80, 0x00, 0x00, 0x43, 0x00, 0x00, 0x00, 0x84,
  0x00, 0x1F, 0xC1, 0x08, 0x00, 0xE0, 0x62, 0x30, 0x03, 0x00, 0x64, 0x60,
  0x0C, 0x00, 0x58, 0x80, 0x30, 0x00, 0x71, 0x00, 0x40, 0x00, 0xC6, 0x01,
  0x80, 0x01, 0x8C, 0x02, 0x00, 0x03, 0x10, 0x0C, 0x00, 0x06, 0x20, 0x18,
  0x00, 0x0C, 0x40, 0x20, 0x00, 0x19, 0x80, 0x40, 0x00, 0x23, 0x01, 0x80,
  0x00, 0x46, 0x03, 0x00, 0x00, 0x8C, 0x06, 0x00, 0x01, 0x10, 0x08, 0x00,
  0x06, 0x20, 0x10, 0x00, 0x0C, 0x40, 0x20, 0x00, 0x11, 0x80, 0x40, 0x00,
  0x23, 0x00, 0x80, 0x00, 0x46, 0x01, 0x00, 0x01, 0x88, 0x02, 0x00, 0x03,
  0x10, 0x04, 0x00, 0x0E, 0x20, 0x0C, 0x00, 0x18, 0x40, 0x08, 0x00, 0x50,
  0x80, 0x18, 0x01, 0x21, 0x00, 0x18, 0x04, 0x42, 0x00, 0x1C, 0x31, 0x84,
  0x00, 0x0F, 0x80, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x02, 0x60, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x20,
  0x10, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x03, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x20, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x04, 0x00, 0x00, 0x20, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00,
  0x02, 0x30, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x08,
  0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x80, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00,
  0x10, 0x30, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00,
  0x06, 0x04, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x40, 0x20, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x70, 0x02, 0x00,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x04, 0x10,
  0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x10, 0x03,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x3C, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x60, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x40, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x20, 0x0C,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x20, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x00, 0x20, 0x80, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x02, 0x08,
  0x00, 0x00, 0x00, 0x86, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x00, 0x18, 0x20, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x10, 0x10,
  0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0,
  0x02, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00,
  0x0C, 0x02, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xE6, 0x00, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x00, 0x86, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x0A, 0x02, 0x00, 0x00,
  0x0B, 0x01, 0x80, 0x00, 0x05, 0x80, 0x60, 0x00, 0x04, 0xC0, 0x18, 0x00,
  0x0C, 0x40, 0x06, 0x00, 0x0C, 0x20, 0x00, 0xE0, 0x38, 0x30, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x00, 0x20, 0x10,
  0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x20, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x08,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0x10, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x00, 0x30,
  0x08, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x02, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00,
  0x04, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x80,
  0x40, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x1E, 0x00, 0x00, 0x00, 0x80, 0xD8, 0x00, 0x00, 0x02, 0x06,
  0x30, 0x00, 0x00, 0x08, 0x30, 0xC0, 0x00, 0x00, 0x61, 0x81, 0x80, 0x00,
  0x01, 0x8C, 0x06, 0x00, 0x00, 0x06, 0x60, 0x08, 0x00, 0x00, 0x13, 0x00,
  0x30, 0x00, 0x00, 0x58, 0x00, 0x40, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x40, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0x02, 0x00, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x68, 0x00, 0x00, 0x0B, 0x01, 0xB0, 0x00, 0x00, 0x68,
  0x06, 0xC0, 0x00, 0x03, 0x20, 0x11, 0x00, 0x00, 0x08, 0x80, 0x44, 0x00,
  0x00, 0x66, 0x01, 0x18, 0x00, 0x01, 0x18, 0x0C, 0x60, 0x00, 0x08, 0x60,
  0x30, 0x80, 0x00, 0x61, 0x00, 0xC3, 0x00, 0x01, 0x04, 0x02, 0x0C, 0x00,
  0x0C, 0x10, 0x08, 0x10, 0x00, 0x60, 0xC0, 0x20, 0x40, 0x01, 0x03, 0x01,
  0x81, 0x80, 0x0C, 0x0C, 0x06, 0x02, 0x00, 0x20, 0x20, 0x18, 0x08, 0x01,
  0x80, 0x80, 0x40, 0x20, 0x0C, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04,
  0x01, 0x01, 0x80, 0x60, 0x30, 0x04, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x20,
  0x04, 0x03, 0x00, 0x21, 0x80, 0x10, 0x0C, 0x00, 0x84, 0x00, 0x40, 0x20,
  0x02, 0x30, 0x03, 0x00, 0x80, 0x0D, 0x80, 0x0C, 0x06, 0x00, 0x14, 0x00,
  0x30, 0x18, 0x00, 0x70, 0x00, 0x80, 0x60, 0x01, 0x80, 0x02, 0x01, 0x80,
  0x02, 0x00, 0x08, 0x04, 0x00, 0x10, 0x00, 0x60, 0x10, 0x00, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x10, 0x0C, 0x00,
  0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x01, 0x00, 0x80, 0x00, 0x00, 0x0C,
  0x02, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x00, 0x20,
  0x10, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x0E, 0x00,
  0x00, 0x01, 0x00, 0xA0, 0x00, 0x00, 0x30, 0x1A, 0x00, 0x00, 0x03, 0x01,
  0xB0, 0x00, 0x00, 0x30, 0x19, 0x00, 0x00, 0x02, 0x01, 0x18, 0x00, 0x00,
  0x20, 0x11, 0x80, 0x00, 0x02, 0x01, 0x08, 0x00, 0x00, 0x60, 0x30, 0xC0,
  0x00, 0x06, 0x03, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x40, 0x00, 0x04, 0x02,
  0x06, 0x00, 0x00, 0x40, 0x20, 0x60, 0x00, 0x04, 0x02, 0x02, 0x00, 0x00,
  0xC0, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x10,
  0x00, 0x08, 0x04, 0x01, 0x80, 0x00, 0x80, 0x40, 0x08, 0x00, 0x08, 0x04,
  0x00, 0x80, 0x01, 0x80, 0xC0, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x40, 0x01,
  0x80, 0xC0, 0x04, 0x00, 0x10, 0x08, 0x00, 0x60, 0x01, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x08, 0x00, 0x30, 0x03, 0x01, 0x80, 0x03, 0x00, 0x30, 0x18,
  0x00, 0x10, 0x03, 0x01, 0x80, 0x01, 0x80, 0x20, 0x10, 0x00, 0x18, 0x02,
  0x01, 0x00, 0x00, 0x80, 0x20, 0x10, 0x00, 0x0C, 0x06, 0x03, 0x00, 0x00,
  0xC0, 0x60, 0x30, 0x00, 0x04, 0x06, 0x03, 0x00, 0x00, 0x60, 0x40, 0x20,
  0x00, 0x06, 0x04, 0x02, 0x00, 0x00, 0x20, 0x40, 0x20, 0x00, 0x03, 0x0C,
  0x06, 0x00, 0x00, 0x30, 0xC0, 0x60, 0x00, 0x01, 0x0C, 0x06, 0x00, 0x00,
  0x18, 0x80, 0x40, 0x00, 0x00, 0x88, 0x04, 0x00, 0x00, 0x08, 0x80, 0x40,
  0x00, 0x00, 0xD8, 0x0C, 0x00, 0x00, 0x05, 0x80, 0xC0, 0x00, 0x00, 0x78,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x20, 0x00, 0x06, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x08, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x00, 0x82, 0x00, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x00, 0x08, 0x60, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x02, 0x20,
  0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0x09,
  0x80, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00,
  0x64, 0x00, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00,
  0x01, 0x30, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x8C, 0x00,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x04, 0x30,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x81, 0x00, 0x00, 0x00, 0x20,
  0x40, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x20, 0x01, 0x80, 0x00, 0x10, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x80, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0xE0, 0x08, 0x00, 0x00, 0x70,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x20, 0x00, 0x06, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x08, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x00, 0x82, 0x00, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x00, 0x08, 0x60, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x02, 0x20,
  0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0x09,
  0x80, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00,
  0x64, 0x00, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00,
  0x01, 0x30, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x8C, 0x00,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x04, 0x30,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00, 0x20,
  0x40, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x20, 0x01, 0x80, 0x00, 0x10, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0x40, 0x10,
  0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x30, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x40, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0xE0, 0x08, 0x00, 0x00, 0x70, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x40, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x10, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x01, 0x80, 0x08, 0x00, 0x00,
  0x30, 0x01, 0x00, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x08, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00, 0x06, 0x00, 0x40, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x81, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x30, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x20,
  0x40, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x04, 0x08, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x01,
  0x02, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x00, 0x20, 0x40, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x0C,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x40, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x06,
  0x40, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x60, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x60, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x60, 0x00, 0x04, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x02, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00,
  0x08, 0x06, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x00, 0x04, 0x20, 0x00, 0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x00, 0x82, 0x00, 0x00, 0x00,
  0x04, 0x10, 0x00, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x02, 0x06, 0x00, 0x1C,
  0x00, 0x10, 0x20, 0x00, 0xE0, 0x01, 0x81, 0x00, 0x0F, 0x00, 0x08, 0x08,
  0x00, 0x68, 0x00, 0x40, 0x40, 0x02, 0x40, 0x06, 0x02, 0x00, 0x32, 0x00,
  0x30, 0x10, 0x01, 0x10, 0x01, 0x00, 0x80, 0x18, 0xC0, 0x08, 0x04, 0x00,
  0x86, 0x00, 0xC0, 0x60, 0x0C, 0x30, 0x06, 0x03, 0x00, 0x41, 0x80, 0x20,
  0x18, 0x06, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x20, 0x18, 0x06, 0x03, 0x01,
  0x00, 0xC0, 0x30, 0x18, 0x08, 0x04, 0x01, 0x81, 0x80, 0x60, 0x20, 0x08,
  0x0C, 0x03, 0x03, 0x00, 0x40, 0x40, 0x18, 0x18, 0x02, 0x06, 0x00, 0xC0,
  0x80, 0x10, 0x20, 0x02, 0x0C, 0x00, 0x83, 0x00, 0x10, 0x60, 0x04, 0x10,
  0x00, 0x82, 0x00, 0x21, 0x80, 0x04, 0x10, 0x01, 0x08, 0x00, 0x31, 0x80,
  0x18, 0xC0, 0x01, 0x8C, 0x00, 0xC4, 0x00, 0x0C, 0x40, 0x06, 0x60, 0x00,
  0x22, 0x00, 0x32, 0x00, 0x01, 0x30, 0x01, 0xB0, 0x00, 0x09, 0x80, 0x0D,
  0x80, 0x00, 0x48, 0x00, 0x48, 0x00, 0x03, 0x40, 0x02, 0xC0, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x60, 0x02, 0x00,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x00, 0x11, 0x80,
  0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x00, 0x00, 0x61, 0x00, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x00, 0x08,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00,
  0x08, 0x40, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x00, 0x58, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xE0, 0x04,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x01, 0x82, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x02, 0x01, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x18, 0x00, 0x80,
  0x00, 0x10, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x20, 0x01, 0x80, 0x00, 0x30, 0x01, 0x00, 0x00, 0x10,
  0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x08,
  0x08, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x81, 0x81, 0x83, 0x03, 0x02, 0x06,
  0x04, 0x0C, 0x08, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x70, 0x0E, 0x04, 0x01,
  0x80, 0x06, 0x08, 0x04, 0x00, 0x02, 0x30, 0x30, 0x00, 0x02, 0x60, 0x40,
  0x00, 0x02, 0xC1, 0x00, 0x00, 0x05, 0x06, 0x00, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x02, 0x30, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x01,
  0x18, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0x42, 0x00, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0E, 0x08, 0x00, 0x00, 0x1C, 0x10,
  0x00, 0x00, 0x50, 0x30, 0x00, 0x01, 0xA0, 0x20, 0x00, 0x02, 0x40, 0x20,
  0x00, 0x09, 0x80, 0x60, 0x00, 0x23, 0x00, 0x60, 0x01, 0x86, 0x00, 0x38,
  0x0E, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0xFF, 0x00, 0x06, 0x0E, 0x03,
  0x80, 0x0C, 0x30, 0x00, 0x80, 0x18, 0x80, 0x00, 0x80, 0x22, 0x00, 0x00,
  0x80, 0x48, 0x00, 0x00, 0x80, 0xB0, 0x00, 0x01, 0x03, 0x40, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x02, 0x0E, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x00, 0x46, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x03, 0x10,
  0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x03, 0x10, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0x43, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x0C, 0x34, 0x00, 0x00, 0x10, 0x68, 0x00, 0x00,
  0x40, 0xC8, 0x00, 0x01, 0x01, 0x98, 0x00, 0x04, 0x02, 0x0C, 0x00, 0x30,
  0x04, 0x0E, 0x01, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xE0, 0x38, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x00, 0x80,
  0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x4C, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x00, 0x80, 0x00, 0x30,
  0x02, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xE0, 0x08, 0x00,
  0x38, 0x07, 0x02, 0x00, 0x18, 0x00, 0x60, 0x80, 0x08, 0x00, 0x04, 0x60,
  0x0C, 0x00, 0x00, 0x98, 0x02, 0x00, 0x00, 0x16, 0x01, 0x00, 0x00, 0x05,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x0C, 0x04, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x00, 0x20, 0x60, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x80, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x80, 0x40, 0x00,
  0x00, 0xE0, 0x10, 0x00, 0x00, 0x50, 0x06, 0x00, 0x00, 0x34, 0x00, 0x80,
  0x00, 0x09, 0x00, 0x10, 0x00, 0x04, 0xC0, 0x06, 0x00, 0x02, 0x30, 0x00,
  0xC0, 0x03, 0x0C, 0x00, 0x0E, 0x03, 0x02, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x01, 0x01, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x01, 0x08, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x32, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x19, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x03, 0x86, 0x00, 0x00, 0x70, 0x30, 0x00, 0x3C, 0x01, 0x80, 0x7E,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x03, 0x20, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x01, 0x04, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x18, 0x02, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x40, 0x06, 0x00, 0x18, 0x20, 0x04, 0x00, 0x02, 0x30, 0x0C, 0x00, 0x00,
  0x98, 0x04, 0x00, 0x00, 0x2C, 0x04, 0x00, 0x00, 0x14, 0x06, 0x00, 0x00,
  0x06, 0x02, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x00, 0x10, 0x60, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01, 0x06, 0x00,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x08, 0x10,
  0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x80, 0x00, 0x01, 0xC0, 0x40, 0x00, 0x01, 0x40,
  0x30, 0x00, 0x01, 0xA0, 0x08, 0x00, 0x00, 0x90, 0x02, 0x00, 0x00, 0x98,
  0x01, 0x80, 0x00, 0x8C, 0x00, 0x60, 0x01, 0x86, 0x00, 0x0E, 0x03, 0x82,
  0x00, 0x01, 0xFE, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x04, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x3F,
  0xC0, 0x03, 0x07, 0x03, 0x80, 0x10, 0xC0, 0x06, 0x00, 0x8C, 0x00, 0x08,
  0x04, 0xC0, 0x00, 0x60, 0x64, 0x00, 0x01, 0x03, 0x40, 0x00, 0x08, 0x1C,
  0x00, 0x00, 0x60, 0xA0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x41, 0x00, 0x00, 0x02, 0x18,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x20, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x00, 0x00, 0x02, 0x08,
  0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x86, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x30, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x40, 0x02, 0x00, 0x02, 0x00, 0x60, 0x00, 0x30, 0x04, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x41, 0x80, 0x00, 0x02, 0x10,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x08, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x60, 0x06, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x04, 0x00,
  0x04, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C,
  0x08, 0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x58, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x08, 0x03, 0xFC, 0x00, 0x06, 0x07, 0x01, 0xC0, 0x01, 0x86, 0x00, 0x18,
  0x00, 0x62, 0x00, 0x03, 0x00, 0x11, 0x00, 0x00, 0x60, 0x04, 0x80, 0x00,
  0x18, 0x01, 0x40, 0x00, 0x02, 0x00, 0xF0, 0x00, 0x00, 0x80, 0x38, 0x00,
  0x00, 0x20, 0x0C, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x02, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x1C, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x08, 0x06, 0x00,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x60, 0x04,
  0x00, 0x00, 0x98, 0x01, 0x80, 0x00, 0x36, 0x00, 0x20, 0x00, 0x19, 0x00,
  0x0C, 0x00, 0x0C, 0x40, 0x01, 0x80, 0x04, 0x10, 0x00, 0x20, 0x02, 0x0C,
  0x00, 0x0C, 0x01, 0x03, 0x00, 0x01, 0x00, 0x80, 0xC0, 0x00, 0x60, 0x40,
  0x20, 0x00, 0x08, 0x20, 0x08, 0x00, 0x03, 0x10, 0x02, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x02, 0x01, 0x00, 0x01, 0xC0, 0x40, 0x00, 0x80, 0x30,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x60, 0x00, 0x80, 0x30, 0x00,
  0x20, 0x10, 0x00, 0x18, 0x18, 0x00, 0x06, 0x08, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x44, 0x00, 0x00, 0x16, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x0F, 0x80, 0x10, 0xC1, 0x81, 0x83, 0x00, 0x88, 0x04, 0x10,
  0x08, 0x04, 0x80, 0x11, 0x00, 0x20, 0x68, 0x00, 0x90, 0x01, 0x03, 0x80,
  0x05, 0x00, 0x0C, 0x1C, 0x00, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x80, 0x03,
  0x04, 0x00, 0x0C, 0x00, 0x18, 0x20, 0x00, 0x40, 0x00, 0x83, 0x00, 0x06,
  0x00, 0x04, 0x18, 0x00, 0x30, 0x00, 0x20, 0x80, 0x01, 0x80, 0x03, 0x04,
  0x00, 0x08, 0x00, 0x18, 0x20, 0x00, 0x40, 0x00, 0xC1, 0x00, 0x02, 0x00,
  0x04, 0x18, 0x00, 0x30, 0x00, 0x20, 0xC0, 0x01, 0x80, 0x01, 0x04, 0x00,
  0x0C, 0x00, 0x18, 0x20, 0x00, 0x60, 0x00, 0xC1, 0x00, 0x02, 0x00, 0x06,
  0x08, 0x00, 0x10, 0x00, 0x20, 0xC0, 0x01, 0x80, 0x01, 0x06, 0x00, 0x0C,
  0x00, 0x08, 0x20, 0x00, 0x60, 0x00, 0xC1, 0x00, 0x03, 0x00, 0x06, 0x08,
  0x00, 0x10, 0x00, 0x30, 0x40, 0x00, 0x80, 0x01, 0x06, 0x00, 0x04, 0x00,
  0x08, 0x30, 0x00, 0x60, 0x00, 0x41, 0x00, 0x03, 0x00, 0x06, 0x08, 0x00,
  0x18, 0x00, 0x30, 0x40, 0x00, 0x80, 0x01, 0x82, 0x00, 0x04, 0x00, 0x08,
  0x30, 0x00, 0x20, 0x00, 0x41, 0x80, 0x03, 0x00, 0x02, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x18, 0x38, 0x1C, 0x00, 0x86,
  0x00, 0x30, 0x04, 0x60, 0x00, 0x40, 0x26, 0x00, 0x03, 0x03, 0x20, 0x00,
  0x08, 0x1A, 0x00, 0x00, 0x40, 0xE0, 0x00, 0x03, 0x05, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x02, 0x08, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x61, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x82, 0x00, 0x00, 0x04,
  0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x00, 0x82, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x20, 0x18, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x01, 0x82, 0x00, 0x00, 0x02,
  0x18, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x00, 0x50, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x02,
  0x80, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x01, 0x20,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x23, 0x00, 0x00, 0x01, 0x84, 0x00,
  0x00, 0x04, 0x18, 0x00, 0x00, 0x30, 0x20, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x10, 0x70,
  0x1C, 0x00, 0x0C, 0x30, 0x00, 0x80, 0x03, 0x10, 0x00, 0x10, 0x00, 0xC8,
  0x00, 0x02, 0x00, 0x24, 0x00, 0x00, 0x40, 0x0B, 0x00, 0x00, 0x10, 0x02,
  0x80, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x80, 0x70, 0x00, 0x00, 0x20,
  0x18, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x40, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x00, 0x0C, 0x08, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x81, 0x80,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x06, 0x04,
  0x00, 0x00, 0x01, 0x01, 0x00, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x28, 0x00, 0x00, 0x20, 0x1A, 0x00, 0x00,
  0x10, 0x06, 0x40, 0x00, 0x08, 0x01, 0x98, 0x00, 0x04, 0x00, 0x41, 0x80,
  0x06, 0x00, 0x10, 0x38, 0x06, 0x00, 0x04, 0x01, 0xFE, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x70,
  0x0E, 0x04, 0x01, 0x80, 0x06, 0x08, 0x04, 0x00, 0x02, 0x30, 0x30, 0x00,
  0x02, 0x60, 0x40, 0x00, 0x02, 0xC1, 0x00, 0x00, 0x05, 0x06, 0x00, 0x00,
  0x06, 0x08, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x01,
  0x18, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x0C, 0x40,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0E, 0x08, 0x00,
  0x00, 0x1C, 0x10, 0x00, 0x00, 0x50, 0x30, 0x00, 0x01, 0xA0, 0x20, 0x00,
  0x02, 0x40, 0x20, 0x00, 0x09, 0x80, 0x60, 0x00, 0x23, 0x00, 0x60, 0x01,
  0x86, 0x00, 0x38, 0x0E, 0x08, 0x00, 0x1F, 0xE0, 0x10, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x01, 0x0F, 0x00, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x04, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x31, 0x00, 0x00, 0x00, 0x11, 0xC0, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00,
  0x08, 0x08, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x08, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x01, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x06,
  0x02, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x02, 0x30, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x04,
  0x10, 0x00, 0x00, 0x20, 0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x01, 0x04, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x30, 0x80, 0x00, 0x01, 0x04, 0x00, 0x00, 0x08, 0x20,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x01, 0x84, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x41, 0x00, 0x00, 0x02,
  0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x50, 0x60, 0x00,
  0x03, 0x81, 0x00, 0x00, 0x2C, 0x08, 0x00, 0x02, 0x60, 0x60, 0x00, 0x32,
  0x01, 0x00, 0x03, 0x10, 0x06, 0x00, 0x30, 0x80, 0x1C, 0x0E, 0x0C, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x80, 0x00, 0x18,
  0x01, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x80, 0x40, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x02, 0x01, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x08, 0x0C,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0xC0, 0x40,
  0x00, 0x01, 0x00, 0x80, 0x00, 0x02, 0x01, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0xC0, 0x20, 0x00,
  0x01, 0x00, 0x40, 0x00, 0x06, 0x00, 0x80, 0x00, 0x08, 0x01, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x40, 0x00, 0x60, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x20, 0x70, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x08, 0x01, 0x80, 0x80, 0x03, 0x00, 0x30, 0x30, 0x00, 0x60,
  0x02, 0x06, 0x00, 0x0C, 0x00, 0x60, 0xC0, 0x01, 0x00, 0x0C, 0x10, 0x00,
  0x20, 0x01, 0x82, 0x00, 0x04, 0x00, 0x10, 0x40, 0x01, 0x80, 0x02, 0x18,
  0x00, 0x30, 0x00, 0x43, 0x00, 0x06, 0x00, 0x08, 0x60, 0x00, 0x80, 0x01,
  0x88, 0x00, 0x10, 0x00, 0x31, 0x00, 0x02, 0x00, 0x06, 0x20, 0x00, 0xC0,
  0x00, 0xCC, 0x00, 0x18, 0x00, 0x19, 0x80, 0x03, 0x00, 0x03, 0x30, 0x00,
  0x40, 0x00, 0x64, 0x00, 0x08, 0x00, 0x08, 0x80, 0x01, 0x00, 0x01, 0x10,
  0x00, 0x60, 0x00, 0x26, 0x00, 0x0C, 0x00, 0x04, 0xC0, 0x01, 0x80, 0x01,
  0x98, 0x00, 0x20, 0x00, 0x32, 0x00, 0x04, 0x00, 0x06, 0x40, 0x00, 0x80,
  0x00, 0x88, 0x00, 0x30, 0x00, 0x33, 0x00, 0x06, 0x00, 0x06, 0x60, 0x00,
  0xC0, 0x00, 0x8C, 0x00, 0x18, 0x00, 0x31, 0x80, 0x07, 0x00, 0x06, 0x30,
  0x00, 0xE0, 0x01, 0x86, 0x00, 0x2C, 0x00, 0x20, 0xC0, 0x0C, 0x80, 0x0C,
  0x08, 0x01, 0x10, 0x03, 0x01, 0x80, 0x43, 0x00, 0xC0, 0x18, 0x30, 0x30,
  0x70, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00,
  0x73, 0x00, 0x30, 0x70, 0x03, 0x83, 0x00, 0xC0, 0x20, 0x1C, 0x02, 0x03,
  0x00, 0x60, 0xE0, 0x06, 0x0C, 0x00, 0x4E, 0x00, 0x0C, 0x10, 0x00, 0xD0,
  0x00, 0x08, 0x40, 0x01, 0x80, 0x00, 0x10, 0x80, 0x03, 0x00, 0x00, 0x32,
  0x00, 0x06, 0x00, 0x00, 0x24, 0x00, 0x0C, 0x00, 0x00, 0x50, 0x00, 0x18,
  0x00, 0x00, 0xA0, 0x00, 0x20, 0x00, 0x01, 0x40, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x02, 0x00, 0x02, 0xC0, 0x00, 0x04, 0x00, 0x05, 0x80, 0x00, 0x08, 0x00,
  0x09, 0x00, 0x00, 0x10, 0x00, 0x22, 0x00, 0x00, 0x20, 0x00, 0x44, 0x00,
  0x00, 0x40, 0x01, 0x0C, 0x00, 0x0C, 0x80, 0x06, 0x08, 0x00, 0x71, 0x80,
  0x08, 0x10, 0x03, 0x83, 0x00, 0x20, 0x30, 0x1C, 0x03, 0x00, 0x80, 0x30,
  0xE0, 0x03, 0x06, 0x00, 0x27, 0x00, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00,
  0x40, 0x10, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x80, 0x00, 0x01, 0x00, 0x40, 0x00, 0x00, 0x80, 0x60, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x08, 0x00,
  0x00, 0x10, 0x04, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x04, 0x03, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x20, 0x18,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x05, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x10, 0x00, 0x02, 0xC0, 0x08, 0x00, 0x02, 0x60,
  0x06, 0x00, 0x03, 0x20, 0x01, 0x00, 0x03, 0x10, 0x00, 0x60, 0x03, 0x08,
  0x00, 0x1C, 0x0E, 0x0C, 0x00, 0x03, 0xFC, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x30, 0x30, 0x00, 0xE0, 0x0C, 0x08, 0x00, 0x07, 0x02,
  0x04, 0x00, 0x00, 0x30, 0x81, 0x00, 0x00, 0x03, 0xE0, 0xC0, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0x06, 0x00, 0x20, 0x00, 0x03, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x10, 0x00, 0x30, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x20, 0xFC,
  0x00, 0x00, 0x08, 0x30, 0xF8, 0x00, 0x03, 0x0C, 0x01, 0xF0, 0x00, 0xC2,
  0x00, 0x07, 0xE0, 0x30, 0x80, 0x00, 0x0F, 0xC4, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x08, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x20, 0x61, 0x80,
  0x00, 0x04, 0x10, 0x0C, 0x00, 0x01, 0x84, 0x00, 0x80, 0x00, 0x21, 0x80,
  0x08, 0x00, 0x0C, 0x60, 0x01, 0x80, 0x01, 0x08, 0x00, 0x18, 0x00, 0x63,
  0x00, 0x01, 0x00, 0x08, 0x40, 0x00, 0x10, 0x02, 0x08, 0x00, 0x01, 0x00,
  0x83, 0x00, 0x00, 0x18, 0x60, 0x40, 0x00, 0x01, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 11, 49, 42, 16, -49 },
  { 69, 14, 18, 42, 18, -52 },
  { 101, 42, 49, 42, 1, -49 },
  { 359, 37, 65, 42, 3, -57 },
  { 660, 46, 51, 42, -1, -50 },
  { 954, 40, 51, 42, 1, -50 },
  { 1209, 5, 18, 42, 23, -52 },
  { 1221, 21, 63, 42, 17, -53 },
  { 1387, 22, 63, 42, 5, -53 },
  { 1561, 36, 35, 42, 4, -38 },
  { 1719, 33, 33, 42, 5, -38 },
  { 1856, 10, 17, 42, 11, -5 },
  { 1878, 19, 1, 42, 12, -22 },
  { 1881, 5, 4, 42, 16, -4 },
  { 1884, 37, 63, 42, 3, -53 },
  { 2176, 34, 51, 42, 5, -50 },
  { 2393, 32, 49, 42, 3, -49 },
  { 2589, 34, 50, 42, 3, -50 },
  { 2802, 34, 51, 42, 3, -50 },
  { 3019, 36, 49, 42, 2, -49 },
  { 3240, 35, 50, 42, 4, -49 },
  { 3459, 30, 50, 42, 6, -49 },
  { 3647, 33, 49, 42, 8, -49 },
  { 3850, 35, 51, 42, 4, -50 },
  { 4074, 31, 50, 42, 7, -50 },
  { 4268, 10, 36, 42, 16, -36 },
  { 4313, 15, 48, 42, 11, -36 },
  { 4403, 34, 37, 42, 6, -40 },
  { 4561, 35, 13, 42, 4, -28 },
  { 4618, 34, 37, 42, 3, -40 },
  { 4776, 27, 50, 42, 11, -50 },
  { 4945, 31, 57, 42, 6, -50 },
  { 5166, 34, 49, 42, 1, -49 },
  { 5375, 33, 49, 42, 4, -49 },
  { 5578, 33, 51, 42, 6, -50 },
  { 5789, 34, 49, 42, 5, -49 },
  { 5998, 36, 49, 42, 5, -49 },
  { 6219, 36, 49, 42, 5, -49 },
  { 6440, 33, 51, 42, 6, -50 },
  { 6651, 36, 49, 42, 4, -49 },
  { 6872, 38, 49, 42, 3, -49 },
  { 7105, 32, 50, 42, 5, -49 },
  { 7305, 38, 49, 42, 5, -49 },
  { 7538, 27, 49, 42, 7, -49 },
  { 7704, 38, 49, 42, 3, -49 },
  { 7937, 36, 49, 42, 4, -49 },
  { 8158, 34, 51, 42, 5, -50 },
  { 8375, 35, 49, 42, 5, -49 },
  { 8590, 34, 62, 42, 5, -50 },
  { 8854, 35, 49, 42, 5, -49 },
  { 9069, 37, 51, 42, 3, -50 },
  { 9305, 36, 49, 42, 8, -49 },
  { 9526, 34, 50, 42, 6, -49 },
  { 9739, 34, 49, 42, 9, -49 },
  { 9948, 37, 49, 42, 6, -49 },
  { 10175, 42, 49, 42, 1, -49 },
  { 10433, 38, 49, 42, 7, -49 },
  { 10666, 42, 49, 42, 0, -49 },
  { 10924, 27, 63, 42, 14, -53 },
  { 11137, 16, 63, 42, 14, -53 },
  { 11263, 27, 63, 42, 2, -53 },
  { 11476, 32, 26, 42, 6, -49 },
  { 11580, 33, 1, 42, 0, 9 },
  { 11585, 7, 11, 42, 17, -53 },
  { 11595, 31, 38, 42, 5, -37 },
  { 11743, 31, 53, 42, 6, -52 },
  { 11949, 29, 38, 42, 6, -37 },
  { 12087, 34, 53, 42, 5, -52 },
  { 12313, 29, 38, 42, 6, -37 },
  { 12451, 44, 67, 42, -1, -52 },
  { 12820, 33, 52, 42, 3, -37 },
  { 13035, 29, 52, 42, 6, -52 },
  { 13224, 29, 53, 42, 6, -52 },
  { 13417, 28, 67, 42, 8, -52 },
  { 13652, 34, 53, 42, 6, -52 },
  { 13878, 26, 53, 42, 9, -52 },
  { 14051, 37, 37, 42, 3, -37 },
  { 14223, 29, 37, 42, 6, -37 },
  { 14358, 30, 38, 42, 6, -37 },
  { 14501, 34, 51, 42, 3, -37 },
  { 14718, 31, 51, 42, 5, -37 },
  { 14916, 34, 36, 42, 8, -36 },
  { 15069, 33, 38, 42, 4, -37 },
  { 15226, 35, 50, 42, 5, -49 },
  { 15445, 29, 37, 42, 7, -36 },
  { 15580, 31, 36, 42, 6, -36 },
  { 15720, 35, 37, 42, 5, -36 },
  { 15882, 39, 38, 42, 2, -37 },
  { 16068, 33, 51, 42, 3, -36 },
  { 16279, 34, 38, 42, 4, -37 },
  { 16441, 31, 63, 42, 9, -53 },
  { 16686, 12, 63, 42, 16, -53 },
  { 16781, 32, 63, 42, 3, -53 },
  { 17033, 35, 12, 42, 4, -27 },
};

const GFXfont IBMPlexMono_ThinItalic70pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic70pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic70pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _IBMPLEXMONO_THINITALIC70PT7B_H_
