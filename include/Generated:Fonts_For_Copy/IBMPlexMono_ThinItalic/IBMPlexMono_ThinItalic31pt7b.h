#ifndef _IBMPLEXMONO_THINITALIC31PT7B_H_
#define _IBMPLEXMONO_THINITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x21, 0x08, 0x42, 0x11, 0x08, 0x42, 0x11, 0x08, 0x00,
  0x00, 0x0C, 0x60, 0x45, 0x14, 0x51, 0x8A, 0x28, 0xA2, 0x00, 0x43, 0x00,
  0x10, 0x80, 0x08, 0x20, 0x02, 0x10, 0x00, 0x84, 0x00, 0x41, 0x00, 0x10,
  0x80, 0xFC, 0x3F, 0x02, 0x08, 0x00, 0x84, 0x00, 0x21, 0x00, 0x10, 0x40,
  0x04, 0x20, 0x01, 0x08, 0x0F, 0x83, 0xF0, 0x21, 0x00, 0x08, 0x40, 0x04,
  0x10, 0x01, 0x08, 0x00, 0x42, 0x00, 0x20, 0x80, 0x08, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x3F, 0x00, 0x62, 0x60, 0x42, 0x08,
  0x41, 0x06, 0x20, 0x80, 0x20, 0x40, 0x10, 0x20, 0x04, 0x10, 0x02, 0x10,
  0x00, 0xC8, 0x00, 0x1E, 0x00, 0x02, 0xE0, 0x01, 0x18, 0x00, 0x84, 0x00,
  0x81, 0x00, 0x40, 0x80, 0x20, 0x40, 0x10, 0x44, 0x08, 0x21, 0x08, 0x20,
  0x64, 0x30, 0x0F, 0xE0, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x07,
  0x80, 0x10, 0x86, 0x02, 0x10, 0x20, 0x41, 0x02, 0x08, 0x20, 0x20, 0x82,
  0x02, 0x10, 0x20, 0x22, 0x02, 0x04, 0x40, 0x10, 0xC4, 0x00, 0xF0, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x22, 0x10, 0x04, 0x40,
  0x80, 0x84, 0x08, 0x10, 0x80, 0x81, 0x08, 0x08, 0x20, 0x80, 0x84, 0x08,
  0x10, 0x80, 0x43, 0x08, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x82, 0x00, 0x40,
  0x40, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x40, 0x10, 0x10,
  0x04, 0x08, 0x00, 0x82, 0x00, 0xF3, 0x00, 0xC7, 0x00, 0x40, 0x80, 0x10,
  0x10, 0x08, 0x04, 0x02, 0x00, 0x80, 0x80, 0x10, 0x20, 0x04, 0x18, 0x02,
  0x8D, 0x01, 0x12, 0x20, 0xC5, 0x07, 0xC0, 0xC0, 0x55, 0xAA, 0x00, 0xC0,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x03, 0x00, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x01, 0xE1, 0x0E, 0x1D, 0x70,
  0x03, 0x80, 0x02, 0x80, 0x04, 0x80, 0x08, 0x40, 0x10, 0x40, 0x20, 0x20,
  0x40, 0x30, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x7F, 0xFF, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x12, 0x24, 0x48, 0x80, 0xFF,
  0x80, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x00, 0x01, 0xF0, 0x0C, 0x10, 0x20, 0x10, 0x80, 0x12, 0x00, 0x24,
  0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x06, 0x06, 0x0C, 0x08,
  0x18, 0x00, 0x30, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x09, 0x00, 0x11,
  0x00, 0x42, 0x01, 0x03, 0x04, 0x03, 0xF0, 0x00, 0x00, 0x60, 0x07, 0x00,
  0x34, 0x01, 0x90, 0x08, 0x40, 0xC1, 0x02, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x03, 0xFF, 0xF0, 0x01,
  0xF8, 0x04, 0x08, 0x10, 0x08, 0x40, 0x11, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xF0, 0x0C, 0x18, 0x20, 0x08, 0x80,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x1F, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x0A, 0x00, 0x22, 0x00, 0x43, 0x03, 0x01, 0xF8, 0x00, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x14, 0x00, 0x14, 0x00, 0x24, 0x00, 0x44, 0x00,
  0x84, 0x01, 0x08, 0x02, 0x08, 0x04, 0x08, 0x04, 0x08, 0x08, 0x08, 0x10,
  0x08, 0x20, 0x10, 0x40, 0x10, 0x80, 0x10, 0xFF, 0xFF, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x0F, 0xFE, 0x10, 0x00, 0x20,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x27, 0xE0,
  0x70, 0x60, 0x80, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x12, 0x00, 0x44, 0x00, 0x86, 0x06, 0x03, 0xF0,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x00, 0x9F, 0x85, 0x81, 0x18, 0x02, 0x40, 0x05,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x24, 0x00, 0x90, 0x04,
  0x30, 0x60, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x18, 0x00, 0xA0, 0x04, 0x80,
  0x12, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x00, 0x03, 0xF0, 0x08, 0x18, 0x20,
  0x08, 0x80, 0x12, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x01, 0x10, 0x04,
  0x10, 0x30, 0x1F, 0x80, 0xC0, 0x82, 0x00, 0x88, 0x00, 0xA0, 0x01, 0x40,
  0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x22, 0x00, 0xC6, 0x06, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x60, 0xC2, 0x00, 0x90, 0x02, 0x40, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0A, 0x00, 0x28, 0x01, 0x90, 0x04, 0x30, 0x70,
  0x7E, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x01, 0xC0, 0x00, 0x11, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x18, 0x04, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x10, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x0F, 0x83, 0x06, 0x40, 0x28, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x01, 0x81, 0xE0, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x07, 0x00,
  0x03, 0xE0, 0x30, 0x61, 0x80, 0x84, 0x02, 0x20, 0x04, 0x80, 0x14, 0x00,
  0x50, 0x7A, 0x42, 0x1A, 0x10, 0x68, 0x40, 0xA2, 0x02, 0x88, 0x0A, 0x20,
  0x48, 0x81, 0x22, 0x04, 0x88, 0x12, 0x21, 0xC8, 0x7D, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x18, 0x00, 0x1F, 0xC0, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x48, 0x00, 0x48, 0x00, 0x88, 0x00, 0x88, 0x01, 0x08,
  0x01, 0x08, 0x02, 0x04, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x04,
  0x0F, 0xFC, 0x10, 0x02, 0x10, 0x02, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x80, 0x01, 0x1F, 0xF0, 0x20, 0x18, 0x40, 0x10, 0x80, 0x22,
  0x00, 0x24, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x08, 0x40, 0x20, 0xFF,
  0x82, 0x00, 0xC4, 0x00, 0x88, 0x00, 0x90, 0x01, 0x20, 0x02, 0x80, 0x05,
  0x00, 0x0A, 0x00, 0x24, 0x00, 0x48, 0x03, 0x1F, 0xF8, 0x00, 0x03, 0xE0,
  0x10, 0x61, 0x80, 0x84, 0x01, 0x20, 0x05, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x48, 0x02, 0x10, 0x08, 0x20, 0xC0, 0x7C,
  0x00, 0x0F, 0xE0, 0x20, 0x30, 0x40, 0x10, 0x80, 0x21, 0x00, 0x24, 0x00,
  0x48, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x0A, 0x00, 0x14,
  0x00, 0x28, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x09, 0x00, 0x12, 0x00,
  0x44, 0x01, 0x88, 0x06, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x3F, 0xFC, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x3F,
  0xFC, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x03,
  0xE0, 0x30, 0x61, 0x80, 0x84, 0x01, 0x20, 0x05, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x81, 0xFA, 0x00, 0x28,
  0x00, 0xA0, 0x02, 0x80, 0x12, 0x00, 0x48, 0x01, 0x10, 0x0C, 0x60, 0xD0,
  0x7C, 0x40, 0x10, 0x01, 0x10, 0x01, 0x10, 0x02, 0x20, 0x02, 0x20, 0x02,
  0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x04, 0x40, 0x04, 0x3F, 0xFC,
  0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x08, 0x80, 0x08, 0x80, 0x08,
  0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x10, 0x80, 0x10, 0x1F, 0xFF,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x11, 0x00, 0x22, 0x00, 0x82, 0x03, 0x06, 0x0C, 0x03, 0xE0, 0x00,
  0x10, 0x00, 0x88, 0x00, 0x84, 0x00, 0x82, 0x01, 0x81, 0x01, 0x01, 0x01,
  0x00, 0x81, 0x00, 0x41, 0x00, 0x21, 0x00, 0x11, 0x00, 0x09, 0x40, 0x09,
  0x20, 0x05, 0x08, 0x03, 0x04, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20,
  0x40, 0x10, 0x20, 0x04, 0x10, 0x02, 0x08, 0x00, 0x84, 0x00, 0x60, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFF, 0x08, 0x00, 0x8C, 0x00,
  0xC5, 0x00, 0xA2, 0x80, 0x51, 0x40, 0x48, 0xA0, 0x28, 0x88, 0x24, 0x44,
  0x22, 0x22, 0x11, 0x10, 0x90, 0x88, 0x50, 0x44, 0x28, 0x42, 0x08, 0x22,
  0x04, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x02, 0x10, 0x01,
  0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x20, 0x18, 0x01, 0x18, 0x01, 0x18,
  0x02, 0x24, 0x02, 0x24, 0x02, 0x24, 0x02, 0x22, 0x02, 0x22, 0x02, 0x22,
  0x04, 0x41, 0x04, 0x41, 0x04, 0x41, 0x04, 0x40, 0x84, 0x40, 0x84, 0x40,
  0x88, 0x80, 0x48, 0x80, 0x48, 0x80, 0x48, 0x80, 0x28, 0x80, 0x28, 0x80,
  0x30, 0x80, 0x10, 0x01, 0xF0, 0x0C, 0x10, 0x20, 0x10, 0x80, 0x12, 0x00,
  0x24, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x09, 0x00,
  0x11, 0x00, 0x42, 0x01, 0x03, 0x04, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x10,
  0x06, 0x10, 0x02, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20,
  0x02, 0x20, 0x02, 0x20, 0x06, 0x20, 0x0C, 0x3F, 0xF0, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x01, 0xF0, 0x0C, 0x10, 0x20, 0x10, 0x80,
  0x12, 0x00, 0x24, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80,
  0x09, 0x00, 0x11, 0x00, 0x42, 0x01, 0x03, 0x04, 0x03, 0xF0, 0x00, 0x80,
  0x00, 0x82, 0x00, 0x88, 0x01, 0x60, 0x01, 0x80, 0x0F, 0xF8, 0x10, 0x06,
  0x10, 0x02, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x02,
  0x20, 0x02, 0x20, 0x06, 0x20, 0x0C, 0x3F, 0xF0, 0x41, 0x00, 0x40, 0x80,
  0x40, 0x80, 0x40, 0x40, 0x40, 0x40, 0x80, 0x20, 0x80, 0x20, 0x80, 0x10,
  0x80, 0x10, 0x80, 0x08, 0x01, 0xF8, 0x03, 0x03, 0x02, 0x00, 0x42, 0x00,
  0x31, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x20, 0x01, 0x08, 0x01, 0x83, 0x01,
  0x80, 0x7F, 0x00, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x20, 0x02, 0x40, 0x04, 0x80, 0x12, 0x00, 0x24, 0x00, 0x48,
  0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00,
  0x48, 0x00, 0x90, 0x01, 0x20, 0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x22,
  0x00, 0x84, 0x01, 0x04, 0x0C, 0x07, 0xE0, 0x00, 0x80, 0x03, 0x00, 0x0A,
  0x00, 0x14, 0x00, 0x48, 0x00, 0x88, 0x02, 0x10, 0x04, 0x20, 0x08, 0x40,
  0x20, 0x80, 0x41, 0x01, 0x01, 0x02, 0x02, 0x08, 0x04, 0x10, 0x08, 0x40,
  0x10, 0x80, 0x22, 0x00, 0x44, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x80, 0x03,
  0x00, 0x00, 0x40, 0x01, 0x40, 0x01, 0x40, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x04, 0x81, 0x04, 0x83, 0x04, 0x83, 0x04, 0x85, 0x08,
  0x85, 0x08, 0x88, 0x88, 0x88, 0x88, 0x90, 0x90, 0x90, 0x90, 0xA0, 0x90,
  0xA0, 0x90, 0xC0, 0xA0, 0xC0, 0xE0, 0x80, 0x60, 0x80, 0x60, 0x08, 0x00,
  0x20, 0x80, 0x08, 0x10, 0x02, 0x01, 0x00, 0x80, 0x20, 0x20, 0x02, 0x04,
  0x00, 0x41, 0x00, 0x04, 0x40, 0x00, 0x90, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0A, 0x00, 0x02, 0x20, 0x00, 0x84, 0x00, 0x20, 0x40,
  0x04, 0x08, 0x01, 0x00, 0x80, 0x40, 0x10, 0x10, 0x01, 0x04, 0x00, 0x21,
  0x80, 0x02, 0x00, 0x80, 0x00, 0xA0, 0x00, 0x90, 0x00, 0x8C, 0x00, 0x82,
  0x00, 0x81, 0x00, 0x40, 0x40, 0x40, 0x20, 0x40, 0x08, 0x40, 0x04, 0x40,
  0x01, 0x20, 0x00, 0xA0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F,
  0xF0, 0x81, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x81, 0x01,
  0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40, 0x80, 0x81, 0x02, 0x04, 0x04,
  0x08, 0x10, 0x07, 0xF0, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x0F, 0xE0, 0x00, 0x80, 0x05, 0x00,
  0x24, 0x01, 0x10, 0x04, 0x20, 0x20, 0x81, 0x01, 0x08, 0x04, 0x40, 0x09,
  0x00, 0x28, 0x00, 0x60, 0x01, 0xFF, 0xFE, 0x84, 0x22, 0x10, 0x07, 0xC4,
  0x20, 0xD1, 0x01, 0x48, 0x02, 0x40, 0x09, 0x00, 0x28, 0x00, 0xA0, 0x02,
  0x80, 0x0A, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x31, 0x01, 0x42, 0x09,
  0x07, 0xC7, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x78, 0x16, 0x18, 0xA0, 0x13, 0x00, 0x48, 0x01, 0x20,
  0x04, 0x80, 0x12, 0x00, 0x50, 0x01, 0x40, 0x05, 0x00, 0x14, 0x00, 0x90,
  0x02, 0xA0, 0x12, 0x41, 0x88, 0xF8, 0x00, 0x07, 0xC1, 0x82, 0x20, 0x14,
  0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x28, 0x04, 0x60, 0x81, 0xF0, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x03, 0xE2, 0x08, 0x34,
  0x20, 0x28, 0x80, 0x32, 0x00, 0x44, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40,
  0x04, 0x80, 0x09, 0x00, 0x22, 0x00, 0x44, 0x01, 0x84, 0x05, 0x04, 0x12,
  0x07, 0xC4, 0x00, 0x07, 0xC0, 0xC1, 0x88, 0x04, 0x80, 0x18, 0x00, 0xC0,
  0x0A, 0x00, 0x90, 0x38, 0xFE, 0x04, 0x00, 0x20, 0x01, 0x00, 0x28, 0x02,
  0x40, 0x11, 0x83, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x7F, 0xFE,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x04,
  0x08, 0x00, 0x41, 0x00, 0x04, 0x20, 0x00, 0x64, 0x00, 0x07, 0x00, 0x00,
  0x20, 0x00, 0x07, 0xC4, 0x20, 0xD1, 0x01, 0x48, 0x03, 0x40, 0x09, 0x00,
  0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80,
  0x31, 0x01, 0x42, 0x09, 0x07, 0xC8, 0x00, 0x20, 0x00, 0x80, 0x02, 0x20,
  0x10, 0xC1, 0x80, 0xFC, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x02, 0x3C, 0x24, 0x33, 0x81, 0x20, 0x12, 0x01, 0x40,
  0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0xC2, 0x08, 0x11,
  0x81, 0x30, 0x0B, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x18, 0x10, 0x20, 0x80, 0x88,
  0x02, 0x40, 0x0E, 0x00, 0x30, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x11, 0xF0, 0x16, 0x08,
  0x28, 0x04, 0x30, 0x04, 0x30, 0x04, 0x20, 0x08, 0x20, 0x10, 0x20, 0x60,
  0x47, 0x80, 0x44, 0x00, 0x42, 0x01, 0x41, 0x02, 0x41, 0x04, 0x40, 0x88,
  0x80, 0x90, 0x80, 0x60, 0xFE, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x04, 0x83, 0x10, 0x82, 0x60, 0x50, 0x0C, 0x00,
  0x17, 0x8E, 0x14, 0x28, 0x8C, 0x18, 0x26, 0x08, 0x12, 0x04, 0x11, 0x02,
  0x08, 0x82, 0x04, 0x81, 0x02, 0x40, 0x81, 0x20, 0x40, 0x90, 0x20, 0x88,
  0x20, 0x44, 0x10, 0x24, 0x08, 0x12, 0x04, 0x09, 0x02, 0x04, 0x23, 0xC2,
  0x43, 0x38, 0x12, 0x01, 0x20, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x14,
  0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x07, 0xC0,
  0xC1, 0x08, 0x04, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x05, 0x00, 0x28, 0x02, 0x40, 0x11, 0x83, 0x03, 0xE0,
  0x08, 0xF0, 0x16, 0x18, 0x50, 0x08, 0xC0, 0x11, 0x00, 0x22, 0x00, 0x44,
  0x00, 0x88, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x22, 0x00,
  0x4A, 0x01, 0x12, 0x0C, 0x23, 0xE0, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x00, 0x07, 0xC4, 0x20, 0xD1, 0x01, 0x48,
  0x03, 0x40, 0x09, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x28,
  0x01, 0x20, 0x04, 0x80, 0x31, 0x01, 0x42, 0x09, 0x07, 0xC4, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0xFC, 0xFE, 0x0A,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x07, 0xE0, 0x60, 0x62, 0x00, 0x48, 0x00, 0x20, 0x00,
  0x80, 0x01, 0x00, 0x03, 0xF0, 0x00, 0x30, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x80, 0x0A, 0x00, 0x26, 0x03, 0x07, 0xF0, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x0C, 0x08, 0x18, 0x08, 0x60, 0x09, 0x80, 0x0A,
  0x00, 0x0C, 0x00, 0x20, 0x0A, 0x00, 0x50, 0x04, 0x80, 0x24, 0x01, 0x20,
  0x09, 0x00, 0x50, 0x02, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x48, 0x0E,
  0x40, 0x51, 0x05, 0x07, 0xC8, 0xF0, 0x08, 0x80, 0x44, 0x02, 0x20, 0x11,
  0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x20, 0x11, 0x00, 0x88, 0x08, 0x40,
  0x44, 0x04, 0x20, 0xC1, 0x1C, 0x0F, 0x80, 0x20, 0xC2, 0x20, 0x82, 0x20,
  0x82, 0x40, 0x82, 0x40, 0x81, 0x40, 0x81, 0x41, 0x01, 0x41, 0x02, 0x41,
  0x02, 0x81, 0x02, 0x81, 0x02, 0x81, 0x02, 0x83, 0x04, 0x85, 0x04, 0xC5,
  0x08, 0x78, 0xF0, 0x06, 0x0F, 0x0C, 0x88, 0xD8, 0x48, 0x30, 0x18, 0x10,
  0x0C, 0x08, 0x06, 0x04, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x20, 0x60, 0x10, 0x30, 0x08, 0x28, 0x14, 0x14, 0x32, 0x31, 0x20, 0xF0,
  0x60, 0x08, 0x02, 0x20, 0x04, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x00,
  0x84, 0x01, 0x10, 0x02, 0x20, 0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42,
  0x03, 0x84, 0x05, 0x04, 0x14, 0x07, 0xC8, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x84, 0x03, 0x06, 0x0C, 0x03, 0xE0, 0x00, 0x1F, 0x82, 0x40, 0xE5, 0x00,
  0x32, 0x00, 0x64, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x41, 0x00, 0x84, 0x00, 0x9E, 0x01, 0x27, 0xE2, 0x40,
  0x7C, 0x01, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x03,
  0xF0, 0x00, 0xE0, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x0F, 0xE0, 0x08, 0x42, 0x11, 0x08, 0x42, 0x10, 0x88, 0x42, 0x10, 0x84,
  0x42, 0x10, 0x84, 0x22, 0x10, 0x84, 0x21, 0x00, 0x07, 0xF0, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0xF0, 0x1C, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x3F, 0x80, 0x1C, 0x02, 0x44,
  0x05, 0x04, 0x0C, 0x08, 0x28, 0x08, 0x90, 0x0E, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 22, 19, 7, -22 },
  { 15, 6, 8, 19, 8, -23 },
  { 21, 18, 22, 19, 1, -22 },
  { 71, 17, 28, 19, 1, -25 },
  { 131, 20, 22, 19, 0, -22 },
  { 186, 18, 22, 19, 0, -22 },
  { 236, 2, 8, 19, 10, -23 },
  { 238, 10, 28, 19, 7, -24 },
  { 273, 10, 28, 19, 2, -24 },
  { 308, 16, 15, 19, 2, -17 },
  { 338, 15, 15, 19, 2, -17 },
  { 367, 4, 7, 19, 5, -2 },
  { 371, 9, 1, 19, 5, -10 },
  { 373, 2, 2, 19, 7, -2 },
  { 374, 17, 28, 19, 1, -24 },
  { 434, 15, 22, 19, 2, -22 },
  { 476, 14, 22, 19, 2, -22 },
  { 515, 15, 22, 19, 1, -22 },
  { 557, 15, 22, 19, 1, -22 },
  { 599, 16, 22, 19, 1, -22 },
  { 643, 15, 22, 19, 2, -22 },
  { 685, 14, 22, 19, 2, -22 },
  { 724, 14, 22, 19, 4, -22 },
  { 763, 15, 22, 19, 2, -22 },
  { 805, 14, 22, 19, 3, -22 },
  { 844, 5, 16, 19, 7, -16 },
  { 854, 7, 21, 19, 5, -16 },
  { 873, 15, 17, 19, 3, -18 },
  { 905, 15, 7, 19, 2, -13 },
  { 919, 15, 17, 19, 1, -18 },
  { 951, 12, 22, 19, 5, -22 },
  { 984, 14, 25, 19, 3, -22 },
  { 1028, 16, 22, 19, 0, -22 },
  { 1072, 15, 22, 19, 2, -22 },
  { 1114, 14, 22, 19, 3, -22 },
  { 1153, 15, 22, 19, 2, -22 },
  { 1195, 16, 22, 19, 2, -22 },
  { 1239, 16, 22, 19, 2, -22 },
  { 1283, 14, 22, 19, 3, -22 },
  { 1322, 16, 22, 19, 2, -22 },
  { 1366, 16, 22, 19, 2, -22 },
  { 1410, 15, 22, 19, 2, -22 },
  { 1452, 17, 22, 19, 2, -22 },
  { 1499, 12, 22, 19, 3, -22 },
  { 1532, 17, 22, 19, 1, -22 },
  { 1579, 16, 22, 19, 2, -22 },
  { 1623, 15, 22, 19, 2, -22 },
  { 1665, 16, 22, 19, 2, -22 },
  { 1709, 15, 27, 19, 2, -22 },
  { 1760, 16, 22, 19, 2, -22 },
  { 1804, 17, 22, 19, 1, -22 },
  { 1851, 17, 22, 19, 3, -22 },
  { 1898, 15, 22, 19, 3, -22 },
  { 1940, 15, 22, 19, 4, -22 },
  { 1982, 16, 22, 19, 3, -22 },
  { 2026, 19, 22, 19, 0, -22 },
  { 2079, 17, 22, 19, 3, -22 },
  { 2126, 19, 22, 19, 0, -22 },
  { 2179, 12, 28, 19, 6, -24 },
  { 2221, 7, 28, 19, 6, -24 },
  { 2246, 12, 28, 19, 1, -24 },
  { 2288, 14, 12, 19, 3, -22 },
  { 2309, 15, 1, 19, 0, 4 },
  { 2311, 4, 5, 19, 7, -24 },
  { 2314, 14, 16, 19, 2, -16 },
  { 2342, 14, 23, 19, 2, -23 },
  { 2383, 12, 16, 19, 3, -16 },
  { 2407, 15, 23, 19, 2, -23 },
  { 2451, 13, 16, 19, 3, -16 },
  { 2477, 19, 29, 19, 0, -23 },
  { 2546, 14, 22, 19, 2, -16 },
  { 2585, 12, 23, 19, 3, -23 },
  { 2620, 13, 23, 19, 3, -23 },
  { 2658, 13, 29, 19, 3, -23 },
  { 2706, 16, 23, 19, 2, -23 },
  { 2752, 11, 23, 19, 4, -23 },
  { 2784, 17, 16, 19, 1, -16 },
  { 2818, 12, 16, 19, 3, -16 },
  { 2842, 13, 16, 19, 3, -16 },
  { 2868, 15, 22, 19, 1, -16 },
  { 2910, 14, 22, 19, 2, -16 },
  { 2949, 15, 16, 19, 4, -16 },
  { 2979, 14, 16, 19, 2, -16 },
  { 3007, 16, 22, 19, 2, -22 },
  { 3051, 13, 16, 19, 3, -16 },
  { 3077, 13, 16, 19, 3, -16 },
  { 3103, 16, 16, 19, 2, -16 },
  { 3135, 17, 16, 19, 1, -16 },
  { 3169, 15, 22, 19, 1, -16 },
  { 3211, 15, 16, 19, 2, -16 },
  { 3241, 14, 28, 19, 4, -24 },
  { 3290, 5, 28, 19, 7, -24 },
  { 3308, 14, 28, 19, 1, -24 },
  { 3357, 15, 6, 19, 2, -12 },
};

const GFXfont IBMPlexMono_ThinItalic31pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic31pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic31pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _IBMPLEXMONO_THINITALIC31PT7B_H_
