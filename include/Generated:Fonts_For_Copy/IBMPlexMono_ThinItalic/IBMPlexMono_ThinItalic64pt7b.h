#ifndef _IBMPLEXMONO_THINITALIC64PT7B_H_
#define _IBMPLEXMONO_THINITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x00, 0x30, 0x13,
  0x01, 0x30, 0x32, 0x03, 0x20, 0x32, 0x02, 0x60, 0x26, 0x02, 0x60, 0x64,
  0x06, 0x40, 0x64, 0x04, 0xC0, 0x4C, 0x04, 0xC0, 0xC8, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x00, 0x80, 0x10,
  0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x08, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x08, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x04,
  0x00, 0xC0, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x60, 0x00, 0x00, 0x08, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x04, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x02, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x20, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x01, 0x00, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x04, 0x00, 0x80, 0x00, 0x00, 0x30, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x02, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x00, 0x80,
  0x10, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x38, 0x10, 0xE0, 0x00, 0x18, 0x04, 0x06, 0x00, 0x18,
  0x03, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x20, 0x03, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x40, 0x02, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x60, 0x00, 0x02, 0x00, 0x18, 0x00, 0x00, 0x80, 0x04, 0x00,
  0x00, 0x20, 0x01, 0x00, 0x00, 0x08, 0x00, 0x40, 0x00, 0x02, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x03,
  0x82, 0x00, 0x00, 0x00, 0x3D, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x13, 0xC0, 0x00, 0x00, 0x04, 0x1C, 0x00, 0x00, 0x01, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x20,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x40, 0x00, 0x06, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x04, 0x00, 0x00, 0x40, 0x01, 0x00, 0x00, 0x10, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x30, 0x40, 0x01, 0x00, 0x08, 0x30, 0x00, 0xC0, 0x06, 0x06,
  0x00, 0x30, 0x01, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x02, 0x00, 0x40,
  0x01, 0x80, 0x80, 0x60, 0x00, 0x3C, 0x20, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xC0, 0x07, 0x06, 0x00,
  0x00, 0x20, 0x03, 0x00, 0x40, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x04, 0x00, 0x60, 0x01, 0x00, 0x01,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x40, 0x08, 0x00, 0x30, 0x00, 0x30, 0x04,
  0x00, 0x08, 0x00, 0x0C, 0x03, 0x00, 0x02, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x40, 0x00, 0x20, 0x00, 0x20, 0x20, 0x00, 0x0C, 0x00,
  0x10, 0x10, 0x00, 0x01, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x40, 0x02, 0x06,
  0x00, 0x00, 0x08, 0x01, 0x01, 0x00, 0x00, 0x01, 0x81, 0x80, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x30, 0x30, 0x04,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x80, 0x00, 0x04, 0x04, 0x00, 0x30, 0x00,
  0x02, 0x02, 0x00, 0x04, 0x00, 0x01, 0x80, 0x80, 0x01, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x40, 0x00, 0x20, 0x10, 0x00, 0x10, 0x00, 0x10, 0x04, 0x00,
  0x04, 0x00, 0x08, 0x03, 0x00, 0x01, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x40,
  0x01, 0x00, 0x30, 0x00, 0x30, 0x00, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x40,
  0x03, 0x00, 0x02, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x80, 0x18, 0x00, 0x10,
  0x00, 0x40, 0x04, 0x00, 0x04, 0x00, 0x10, 0x02, 0x00, 0x01, 0x80, 0x08,
  0x01, 0x80, 0x00, 0x30, 0x04, 0x00, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x30,
  0x1C, 0x00, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x03, 0x00, 0x00, 0x06, 0x00, 0x10, 0x00, 0x00, 0x10, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x1F, 0x03, 0x00, 0x00, 0x06,
  0x08, 0x70, 0x00, 0x00, 0xC0, 0x7C, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x04, 0x00, 0x00, 0x08, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x20, 0x00, 0x01, 0x80, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x00, 0x50, 0x01, 0xC0, 0x00, 0x02, 0xC0,
  0x1B, 0x00, 0x00, 0x22, 0x00, 0x98, 0x00, 0x01, 0x18, 0x08, 0x40, 0x00,
  0x10, 0x60, 0xC3, 0x00, 0x00, 0x81, 0x04, 0x0C, 0x00, 0x08, 0x0C, 0x60,
  0x30, 0x01, 0x80, 0x26, 0x00, 0xE0, 0x38, 0x00, 0xA0, 0x00, 0xFE, 0x00,
  0x07, 0x00, 0x13, 0x33, 0x22, 0x66, 0x66, 0x44, 0xCC, 0xCC, 0x00, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x2F, 0x00, 0x08, 0x00, 0xF8, 0xF0, 0x0C, 0x03, 0xC0, 0x0F, 0x06,
  0x0F, 0x00, 0x00, 0xF2, 0x7C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00,
  0x80, 0x20, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x30, 0x30, 0x18, 0x08,
  0x0C, 0x04, 0x06, 0x02, 0x01, 0x01, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x08, 0x00, 0x80,
  0x00, 0x30, 0x04, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x02, 0x04, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x13,
  0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x05, 0x80,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x01, 0x40, 0x00,
  0x00, 0x05, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0xC0, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x00,
  0xA0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x22, 0x00,
  0x00, 0x00, 0x88, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x10, 0xC0, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x10, 0x01, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x01, 0x88, 0x00, 0x00, 0x38, 0x40, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30,
  0x10, 0x00, 0x07, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0x60,
  0x00, 0xE0, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0xC0,
  0x04, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x80, 0x60, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x00, 0x80, 0x08, 0x00, 0x00, 0x80, 0x30,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x20, 0x40, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x78, 0x03, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x06, 0x08, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00,
  0xC0, 0x10, 0x00, 0x00, 0x80, 0x10, 0x00, 0x01, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x40, 0x01, 0x80, 0x00, 0x40, 0x03, 0x00,
  0x00, 0x40, 0x06, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0xC0, 0x08, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x80, 0x60, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x20, 0x7F, 0x80, 0x00, 0x47, 0x00, 0xE0, 0x00,
  0x90, 0x00, 0x60, 0x03, 0x40, 0x00, 0x20, 0x07, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x07, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0C, 0x0F, 0xF0, 0x00, 0x87, 0x00, 0xC0, 0x11,
  0x80, 0x03, 0x01, 0x30, 0x00, 0x18, 0x34, 0x00, 0x00, 0xC2, 0x80, 0x00,
  0x04, 0x30, 0x00, 0x00, 0x65, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x04, 0x40, 0x00, 0x00, 0x84, 0x00, 0x00, 0x18, 0x20, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x20, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x00, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x64, 0x00, 0x00, 0x02,
  0x20, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x00, 0x81, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0x10, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x02, 0x60, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x01, 0x10, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1C, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x08, 0x30, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x11, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x28, 0x00, 0x00, 0x05, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x64, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x06, 0x88, 0x00, 0x01, 0xA1, 0x80, 0x00, 0x64, 0x08, 0x00,
  0x39, 0x80, 0xE0, 0x1C, 0x20, 0x07, 0xFC, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x03, 0xC3,
  0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0xF0, 0x70, 0x00,
  0x00, 0x38, 0x00, 0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x02, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0xE0, 0x18, 0x01, 0x80, 0x03, 0x01, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x21, 0x00, 0x00, 0x09, 0x80, 0x00, 0x04, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF8, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x40, 0x06, 0x00, 0x01,
  0x00, 0x60, 0x00, 0x08, 0x02, 0x00, 0x00, 0x20, 0x20, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x40, 0x80, 0x00, 0x02, 0x08, 0x00,
  0x00, 0x10, 0x40, 0x00, 0x00, 0x86, 0x00, 0x3F, 0x04, 0x20, 0x06, 0x06,
  0x21, 0x00, 0x60, 0x0B, 0x08, 0x06, 0x00, 0x38, 0xC0, 0x60, 0x01, 0xC4,
  0x02, 0x00, 0x0C, 0x20, 0x30, 0x00, 0x21, 0x01, 0x00, 0x03, 0x18, 0x08,
  0x00, 0x18, 0x80, 0xC0, 0x00, 0xC4, 0x06, 0x00, 0x04, 0x20, 0x20, 0x00,
  0x21, 0x01, 0x00, 0x01, 0x18, 0x08, 0x00, 0x08, 0xC0, 0x40, 0x00, 0xC6,
  0x06, 0x00, 0x06, 0x20, 0x30, 0x00, 0x21, 0x01, 0x80, 0x01, 0x08, 0x0C,
  0x00, 0x08, 0x40, 0x60, 0x00, 0xC6, 0x01, 0x00, 0x06, 0x30, 0x08, 0x00,
  0x71, 0x80, 0x60, 0x05, 0x0C, 0x01, 0x00, 0x48, 0x60, 0x0C, 0x04, 0x43,
  0x00, 0x1F, 0xC2, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x40,
  0x10, 0x00, 0x01, 0x80, 0x20, 0x00, 0x02, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x80, 0x00, 0x60, 0x01, 0x00, 0x00, 0x80, 0x02,
  0x00, 0x03, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x20, 0x01, 0x00, 0x00, 0x40,
  0x06, 0x00, 0x00, 0x80, 0x08, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x40, 0x00, 0x02, 0x01, 0x80, 0x00, 0x04, 0x02, 0x00, 0x00, 0x08, 0x0C,
  0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x00, 0x84, 0x00, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x02, 0x20, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x01, 0xFF,
  0xFF, 0x00, 0x04, 0x00, 0x03, 0x00, 0x10, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x04, 0x03, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x01, 0x02, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x10,
  0x60, 0x00, 0x00, 0x41, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x10,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x18, 0x08, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x0C, 0x01, 0xFF, 0xFF, 0xC0,
  0x06, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x06, 0x20, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x00, 0x46, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x04, 0x60, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x02,
  0x10, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x00, 0x40, 0x30, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x02, 0x04, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x10,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x08, 0x00, 0x01, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x20, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x02, 0x03,
  0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x08, 0x10,
  0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x00, 0x82, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x02, 0x08, 0x00,
  0x00, 0x04, 0x10, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x10, 0xC0, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x00, 0x42, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x20, 0x80, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x20, 0x30,
  0x00, 0x00, 0xC0, 0x40, 0x00, 0x03, 0x00, 0x80, 0x00, 0x08, 0x01, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x80, 0x00, 0x30, 0x04, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x02, 0x04, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x07, 0xFF,
  0x88, 0x00, 0x20, 0x02, 0x20, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x10, 0x80,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00, 0x0C, 0x20, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x18, 0x10, 0x00, 0x00, 0xA0, 0x60, 0x00, 0x05, 0x80, 0xC0, 0x00, 0x16,
  0x01, 0x00, 0x01, 0x98, 0x03, 0x00, 0x0C, 0x40, 0x07, 0x00, 0xC1, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00,
  0x10, 0x10, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00,
  0x06, 0x02, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x00, 0x30, 0x10, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x08, 0x0C, 0x00,
  0x00, 0x04, 0x06, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x40, 0x7F,
  0xFF, 0xFF, 0xE0, 0x30, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x18, 0x08,
  0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x02, 0x03,
  0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00, 0x80, 0x80, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x10,
  0x18, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x06,
  0x02, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00,
  0x30, 0x10, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x10, 0x10, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x18, 0x02, 0x00, 0x00, 0x80, 0x18, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x01, 0xC0, 0x30, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x18, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x01, 0x80, 0x10,
  0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x06, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x04, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x00, 0x0C, 0x0F, 0x00, 0x00, 0x00, 0x81, 0x98, 0x00, 0x00,
  0x08, 0x31, 0x80, 0x00, 0x00, 0x86, 0x0C, 0x00, 0x00, 0x08, 0xC0, 0xC0,
  0x00, 0x01, 0x90, 0x06, 0x00, 0x00, 0x1A, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00, 0x08, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x04, 0x00, 0x00, 0x04, 0x00, 0x40, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x05,
  0x00, 0xA0, 0x00, 0x01, 0xA0, 0x34, 0x00, 0x00, 0x24, 0x06, 0xC0, 0x00,
  0x0D, 0x80, 0x88, 0x00, 0x03, 0x30, 0x11, 0x00, 0x00, 0x44, 0x02, 0x30,
  0x00, 0x18, 0x80, 0x46, 0x00, 0x02, 0x10, 0x18, 0x40, 0x00, 0xC2, 0x03,
  0x08, 0x00, 0x30, 0xC0, 0x41, 0x80, 0x04, 0x18, 0x08, 0x10, 0x01, 0x82,
  0x01, 0x02, 0x00, 0x20, 0x40, 0x20, 0x40, 0x08, 0x08, 0x0C, 0x0C, 0x03,
  0x01, 0x01, 0x80, 0x80, 0x40, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x03,
  0x06, 0x01, 0x00, 0x80, 0x20, 0x80, 0x20, 0x10, 0x04, 0x30, 0x04, 0x06,
  0x00, 0x84, 0x00, 0x80, 0xC0, 0x19, 0x00, 0x30, 0x10, 0x01, 0x60, 0x06,
  0x02, 0x00, 0x28, 0x00, 0x80, 0x40, 0x07, 0x00, 0x10, 0x08, 0x00, 0x40,
  0x02, 0x03, 0x00, 0x10, 0x00, 0x40, 0x60, 0x00, 0x00, 0x18, 0x08, 0x00,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x08, 0x04,
  0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00,
  0x04, 0x02, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x10, 0x18, 0x00,
  0x00, 0x06, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x10, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00,
  0xC0, 0x50, 0x00, 0x00, 0x40, 0x68, 0x00, 0x00, 0x20, 0x36, 0x00, 0x00,
  0x10, 0x11, 0x00, 0x00, 0x08, 0x08, 0x80, 0x00, 0x0C, 0x04, 0x60, 0x00,
  0x06, 0x02, 0x10, 0x00, 0x02, 0x03, 0x08, 0x00, 0x01, 0x01, 0x86, 0x00,
  0x00, 0x80, 0x81, 0x00, 0x00, 0x40, 0x40, 0x80, 0x00, 0x60, 0x20, 0x60,
  0x00, 0x30, 0x10, 0x10, 0x00, 0x10, 0x18, 0x08, 0x00, 0x08, 0x0C, 0x06,
  0x00, 0x04, 0x04, 0x01, 0x00, 0x02, 0x02, 0x00, 0x80, 0x03, 0x01, 0x00,
  0x60, 0x01, 0x80, 0x80, 0x10, 0x00, 0x80, 0xC0, 0x0C, 0x00, 0x40, 0x60,
  0x06, 0x00, 0x20, 0x20, 0x01, 0x00, 0x10, 0x10, 0x00, 0xC0, 0x18, 0x08,
  0x00, 0x60, 0x0C, 0x04, 0x00, 0x10, 0x04, 0x06, 0x00, 0x0C, 0x02, 0x03,
  0x00, 0x02, 0x01, 0x01, 0x00, 0x01, 0x00, 0x80, 0x80, 0x00, 0xC0, 0xC0,
  0x40, 0x00, 0x20, 0x60, 0x20, 0x00, 0x10, 0x20, 0x30, 0x00, 0x0C, 0x10,
  0x18, 0x00, 0x02, 0x08, 0x08, 0x00, 0x01, 0x04, 0x04, 0x00, 0x00, 0xC6,
  0x02, 0x00, 0x00, 0x23, 0x01, 0x00, 0x00, 0x11, 0x01, 0x80, 0x00, 0x0C,
  0x80, 0xC0, 0x00, 0x02, 0x40, 0x40, 0x00, 0x01, 0x20, 0x20, 0x00, 0x00,
  0xF0, 0x10, 0x00, 0x00, 0x38, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x80, 0x00, 0x30, 0x04, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00,
  0x80, 0x80, 0x00, 0x02, 0x04, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x00, 0x46, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x04, 0x40,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x01, 0x20, 0x00,
  0x00, 0x05, 0x80, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00,
  0x01, 0x40, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x1A, 0x00,
  0x00, 0x00, 0x48, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x0C, 0x80, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x18,
  0x10, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x10, 0x01,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x20,
  0x08, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x02,
  0x03, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00,
  0x08, 0x18, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x02, 0x02, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x40, 0x00, 0x01, 0x80, 0x20, 0x00,
  0x07, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x80, 0x00, 0x30, 0x04, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x80,
  0x80, 0x00, 0x02, 0x04, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x04, 0x40, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00,
  0x05, 0x80, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x01,
  0x40, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x10, 0x10,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x10, 0x01, 0x00,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x20, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x20,
  0x08, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x02,
  0x03, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00,
  0x08, 0x18, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x02, 0x02, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x40, 0x00, 0x01, 0x80, 0x20, 0x00,
  0x07, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x10, 0x00, 0x02, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x01, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x10, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x04, 0x00, 0x00, 0x80, 0x02, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x10, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x20,
  0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0x30, 0x10,
  0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x08,
  0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x06, 0x08, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x10, 0x60, 0x00,
  0x00, 0x20, 0xC0, 0x00, 0x00, 0x41, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0x10, 0x60, 0x00, 0x00, 0x20, 0x80, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x01,
  0x82, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x08,
  0x30, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x04, 0x18,
  0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x00, 0x81, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x0C, 0x08, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x00, 0x80, 0x40, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x80, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x06, 0x40, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x0C, 0x40, 0x00,
  0x00, 0x08, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x10, 0x60, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x00, 0x40, 0x20, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x80, 0x30, 0x00,
  0x01, 0x80, 0x10, 0x00, 0x01, 0x00, 0x10, 0x00, 0x03, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x10, 0x00, 0x06, 0x00, 0x18, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x04, 0x00, 0x40, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x01, 0x30,
  0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x02, 0x10,
  0x00, 0x00, 0x00, 0x84, 0x00, 0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x00, 0x83, 0x00, 0x1C, 0x00, 0x60, 0xC0, 0x07,
  0x00, 0x10, 0x30, 0x01, 0xC0, 0x04, 0x08, 0x00, 0x90, 0x03, 0x02, 0x00,
  0x24, 0x00, 0xC0, 0x80, 0x19, 0x00, 0x20, 0x20, 0x04, 0x40, 0x08, 0x08,
  0x03, 0x10, 0x06, 0x02, 0x00, 0x86, 0x01, 0x00, 0x80, 0x61, 0x80, 0x40,
  0x20, 0x10, 0x60, 0x10, 0x08, 0x0C, 0x08, 0x0C, 0x02, 0x02, 0x02, 0x02,
  0x01, 0x81, 0x80, 0x80, 0x80, 0x60, 0x40, 0x20, 0x20, 0x18, 0x30, 0x08,
  0x18, 0x06, 0x08, 0x03, 0x04, 0x01, 0x82, 0x00, 0xC1, 0x00, 0x41, 0x80,
  0x10, 0xC0, 0x10, 0x40, 0x04, 0x30, 0x04, 0x30, 0x01, 0x08, 0x01, 0x08,
  0x00, 0x42, 0x00, 0x46, 0x00, 0x11, 0x80, 0x11, 0x00, 0x06, 0x60, 0x04,
  0xC0, 0x01, 0x90, 0x01, 0x20, 0x00, 0x64, 0x00, 0x58, 0x00, 0x0B, 0x00,
  0x14, 0x00, 0x02, 0xC0, 0x0F, 0x00, 0x00, 0xA0, 0x03, 0x80, 0x00, 0x28,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x20, 0x00,
  0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x02, 0x00, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x03, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x01, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x08, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x03, 0x01, 0x80, 0x00, 0x08, 0x02, 0x00, 0x00, 0x40, 0x0C,
  0x00, 0x03, 0x00, 0x10, 0x00, 0x18, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x03, 0x00, 0x18, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x10, 0x02,
  0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x04, 0x30, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x41, 0x81, 0x81,
  0x03, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0x01, 0xC1, 0x01, 0x80, 0x06, 0x10, 0x30, 0x00, 0x13, 0x06, 0x00, 0x01,
  0xB0, 0xC0, 0x00, 0x0A, 0x08, 0x00, 0x00, 0x61, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x04, 0x40, 0x00, 0x00, 0x44, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x08, 0x80, 0x00,
  0x00, 0x88, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x88, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x70, 0x40, 0x00, 0x0B,
  0x04, 0x00, 0x00, 0xB0, 0x20, 0x00, 0x12, 0x03, 0x00, 0x02, 0x20, 0x18,
  0x00, 0xC2, 0x00, 0x60, 0x38, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x01, 0xFC,
  0x00, 0x08, 0x30, 0x1C, 0x00, 0xC6, 0x00, 0x30, 0x06, 0x60, 0x00, 0xC0,
  0x26, 0x00, 0x03, 0x01, 0x20, 0x00, 0x08, 0x0A, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x01, 0x07, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x42, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x0C, 0x40,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x11, 0x80, 0x00,
  0x00, 0x8C, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x42, 0x00, 0x00, 0x02,
  0x10, 0x00, 0x00, 0x30, 0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x82, 0x80, 0x00, 0x0C, 0x14, 0x00, 0x00, 0xC0, 0x90, 0x00,
  0x04, 0x04, 0xC0, 0x00, 0xC0, 0x63, 0x00, 0x0C, 0x03, 0x06, 0x01, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x20, 0x00, 0x0C, 0x08, 0x00, 0x00,
  0x83, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x19, 0x00, 0x00, 0x02, 0x30,
  0x00, 0x00, 0x82, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x04, 0x00, 0x03,
  0x00, 0x40, 0x00, 0xC0, 0x04, 0x00, 0x30, 0x00, 0x70, 0x38, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x03, 0xFC, 0x02, 0x00, 0x1C, 0x07,
  0x04, 0x00, 0xC0, 0x03, 0x08, 0x03, 0x00, 0x01, 0x30, 0x0C, 0x00, 0x03,
  0x60, 0x30, 0x00, 0x02, 0xC0, 0x40, 0x00, 0x03, 0x01, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x81, 0x00, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x18, 0x20,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x01, 0x02, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x0C, 0x08, 0x00,
  0x00, 0x10, 0x10, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x07, 0x00, 0x80, 0x00, 0x1E, 0x01, 0x00, 0x00,
  0x28, 0x01, 0x00, 0x00, 0x90, 0x03, 0x00, 0x02, 0x20, 0x03, 0x00, 0x18,
  0x40, 0x01, 0x80, 0xE1, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x30,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x08, 0x40, 0x00, 0x01,
  0x18, 0x00, 0x00, 0x22, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x01, 0x90, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x10, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0xE0, 0x40, 0x00, 0xE0, 0x18, 0x07, 0xE0, 0x03, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x88, 0x00, 0x00,
  0x09, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x10, 0x60,
  0x00, 0x04, 0x04, 0x00, 0x01, 0x80, 0x40, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x00, 0x70, 0x1C, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x80,
  0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0x00, 0x19,
  0x00, 0x00, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x70, 0x1C, 0x10, 0x06, 0x00, 0x18,
  0x40, 0x30, 0x00, 0x13, 0x01, 0x80, 0x00, 0x6C, 0x0C, 0x00, 0x00, 0xA0,
  0x20, 0x00, 0x01, 0x81, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x20,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06, 0x10, 0x00,
  0x00, 0x10, 0x40, 0x00, 0x00, 0x43, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x0C, 0x20, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x20, 0x80, 0x00, 0x01, 0x82,
  0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x70, 0x10, 0x00,
  0x02, 0xC0, 0x40, 0x00, 0x0B, 0x00, 0x80, 0x00, 0x48, 0x03, 0x00, 0x02,
  0x20, 0x06, 0x00, 0x30, 0x80, 0x06, 0x03, 0x82, 0x00, 0x07, 0xF0, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x10, 0x00, 0x02, 0x00, 0xE0, 0x00,
  0x10, 0x00, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x81, 0xFC, 0x00, 0x41,
  0xC0, 0xE0, 0x10, 0x80, 0x0C, 0x04, 0x40, 0x01, 0x01, 0x20, 0x00, 0x20,
  0xD0, 0x00, 0x08, 0x38, 0x00, 0x03, 0x0A, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x0C, 0x20, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x31, 0x00, 0x00, 0x08, 0x40, 0x00, 0x02, 0x10, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x20, 0x00, 0x01,
  0x08, 0x00, 0x00, 0x42, 0x00, 0x00, 0x10, 0x80, 0x00, 0x04, 0x60, 0x00,
  0x03, 0x18, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x21, 0x00, 0x00, 0x08, 0x40,
  0x00, 0x02, 0x10, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x04, 0x20, 0x00, 0x01, 0x08, 0x00, 0x00, 0x40, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x01, 0x00, 0x40, 0x00, 0xC0, 0x10,
  0x00, 0x40, 0x04, 0x00, 0x60, 0x03, 0x00, 0x20, 0x00, 0xC0, 0x30, 0x00,
  0x20, 0x10, 0x00, 0x08, 0x18, 0x00, 0x02, 0x08, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x80, 0x10, 0x00, 0x20, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x0C,
  0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x30, 0x10, 0x00, 0x06, 0x04, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x30, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x01, 0xFC,
  0x00, 0x06, 0x0E, 0x03, 0x00, 0x06, 0x30, 0x00, 0xC0, 0x04, 0x60, 0x00,
  0x40, 0x04, 0xC0, 0x00, 0x60, 0x05, 0x80, 0x00, 0x20, 0x05, 0x00, 0x00,
  0x20, 0x0E, 0x00, 0x00, 0x20, 0x0E, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00,
  0x20, 0x0C, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x10, 0x00, 0xE0, 0x00, 0x10, 0x07, 0x00,
  0x00, 0x30, 0x38, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x20, 0x18, 0x00,
  0x00, 0x20, 0x08, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x02, 0x20, 0x04, 0x00,
  0x03, 0x60, 0x06, 0x00, 0x04, 0x60, 0x02, 0x00, 0x08, 0x40, 0x03, 0x00,
  0x10, 0x40, 0x01, 0x00, 0x20, 0x40, 0x01, 0x80, 0xC0, 0x40, 0x00, 0x81,
  0x80, 0xC0, 0x00, 0x43, 0x00, 0xC0, 0x00, 0x66, 0x00, 0x80, 0x00, 0x2C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x02, 0x03, 0x00, 0x03, 0x03, 0x00, 0x0C, 0x03,
  0x00, 0x10, 0x02, 0x00, 0x60, 0x02, 0x00, 0x80, 0x06, 0x03, 0x00, 0x06,
  0x04, 0x00, 0x06, 0x18, 0x00, 0x04, 0x20, 0x00, 0x04, 0xC0, 0x00, 0x05,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x03, 0x30, 0x60,
  0xC1, 0x01, 0x20, 0x10, 0x80, 0x40, 0xA0, 0x04, 0x80, 0x30, 0x50, 0x02,
  0x80, 0x08, 0x70, 0x01, 0x40, 0x04, 0x30, 0x00, 0xC0, 0x02, 0x18, 0x00,
  0x60, 0x01, 0x08, 0x00, 0x20, 0x00, 0x84, 0x00, 0x10, 0x00, 0xC2, 0x00,
  0x18, 0x00, 0x63, 0x00, 0x0C, 0x00, 0x31, 0x80, 0x04, 0x00, 0x10, 0x80,
  0x02, 0x00, 0x08, 0x40, 0x01, 0x00, 0x04, 0x20, 0x00, 0x80, 0x06, 0x10,
  0x00, 0xC0, 0x03, 0x18, 0x00, 0x60, 0x01, 0x8C, 0x00, 0x20, 0x00, 0x84,
  0x00, 0x10, 0x00, 0x42, 0x00, 0x08, 0x00, 0x21, 0x00, 0x04, 0x00, 0x10,
  0x80, 0x06, 0x00, 0x18, 0xC0, 0x03, 0x00, 0x0C, 0x60, 0x01, 0x80, 0x04,
  0x20, 0x00, 0x80, 0x02, 0x10, 0x00, 0x40, 0x01, 0x08, 0x00, 0x20, 0x00,
  0x84, 0x00, 0x30, 0x00, 0xC6, 0x00, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x00,
  0x21, 0x00, 0x04, 0x00, 0x10, 0x80, 0x02, 0x00, 0x08, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0xF0, 0x01, 0x07, 0x03, 0x80, 0x42, 0x00, 0x30,
  0x11, 0x00, 0x04, 0x04, 0x80, 0x00, 0x83, 0x40, 0x00, 0x20, 0xE0, 0x00,
  0x0C, 0x28, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x43, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x08, 0x40, 0x00, 0x02, 0x10, 0x00, 0x00, 0x8C, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x18, 0x80, 0x00, 0x04, 0x20, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x11, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x10,
  0x00, 0x00, 0x84, 0x00, 0x00, 0x21, 0x00, 0x00, 0x08, 0x40, 0x00, 0x02,
  0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x62, 0x00, 0x00, 0x10, 0x80, 0x00,
  0x04, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0xC0, 0x03, 0x00, 0x10, 0x00, 0x18, 0x02, 0x00, 0x00, 0xC0, 0x40,
  0x00, 0x04, 0x0C, 0x00, 0x00, 0x20, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00,
  0x31, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x12, 0x00, 0x00, 0x01, 0x20,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x01, 0x40, 0x00, 0x00, 0x14, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x44, 0x00, 0x00, 0x0C,
  0x40, 0x00, 0x00, 0x84, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x02, 0x00,
  0x00, 0x20, 0x10, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x30,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0x06, 0x03, 0x80, 0x06, 0x30, 0x01, 0x80, 0x0C, 0xC0, 0x01, 0x80,
  0x13, 0x00, 0x01, 0x80, 0x24, 0x00, 0x01, 0x00, 0x50, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x02, 0x03, 0x80, 0x00, 0x04, 0x06, 0x00, 0x00, 0x08, 0x0C,
  0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x06, 0x08, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x10, 0x20, 0x00,
  0x00, 0x20, 0xC0, 0x00, 0x00, 0x41, 0x80, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x02, 0x04, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x01, 0x40, 0x00, 0x06,
  0x02, 0x80, 0x00, 0x18, 0x04, 0x80, 0x00, 0x20, 0x09, 0x80, 0x01, 0x80,
  0x31, 0x80, 0x06, 0x00, 0x60, 0xC0, 0x30, 0x00, 0x80, 0x7F, 0x80, 0x01,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0x01, 0xC1, 0x01, 0x80, 0x06, 0x10, 0x30, 0x00,
  0x13, 0x06, 0x00, 0x01, 0xB0, 0xC0, 0x00, 0x0A, 0x08, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x62, 0x00, 0x00, 0x06, 0x20, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x44, 0x00, 0x00, 0x04,
  0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0xC8, 0x00,
  0x00, 0x0C, 0x80, 0x00, 0x00, 0x88, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00,
  0x88, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x01, 0x08, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x70, 0x40, 0x00, 0x0B, 0x04, 0x00, 0x00, 0xB0, 0x20, 0x00, 0x12, 0x03,
  0x00, 0x02, 0x20, 0x18, 0x00, 0xC2, 0x00, 0x60, 0x38, 0x60, 0x01, 0xFC,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xF8, 0x1F, 0xFC,
  0x00, 0x43, 0x80, 0x00, 0x01, 0x10, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x40, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x21, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x08, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x01, 0x02, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x04,
  0x40, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x31, 0x00, 0x00, 0x08, 0x40, 0x00, 0x02,
  0x10, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x23, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x06, 0x20, 0x00, 0x01, 0x08, 0x00, 0x00, 0x42, 0x00, 0x00, 0x11, 0x80,
  0x00, 0x04, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x08, 0x40, 0x00, 0x02, 0x30, 0x00, 0x00, 0x8C, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x18, 0x80, 0x00, 0x04, 0x20, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x30, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x07, 0x08,
  0x00, 0x01, 0x82, 0x00, 0x00, 0xA0, 0x80, 0x00, 0x68, 0x30, 0x00, 0x32,
  0x04, 0x00, 0x19, 0x80, 0x80, 0x0C, 0x60, 0x18, 0x0C, 0x10, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x00, 0x80, 0x30, 0x00,
  0x04, 0x01, 0x00, 0x00, 0x30, 0x08, 0x00, 0x01, 0x80, 0x40, 0x00, 0x04,
  0x02, 0x00, 0x00, 0x20, 0x10, 0x00, 0x01, 0x01, 0x80, 0x00, 0x08, 0x0C,
  0x00, 0x00, 0x40, 0x40, 0x00, 0x06, 0x02, 0x00, 0x00, 0x30, 0x10, 0x00,
  0x01, 0x00, 0x80, 0x00, 0x08, 0x04, 0x00, 0x00, 0x40, 0x60, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x20, 0x10, 0x00, 0x01, 0x00, 0x80, 0x00, 0x18, 0x04,
  0x00, 0x00, 0x80, 0x20, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x40, 0x18, 0x00,
  0x04, 0x00, 0xC0, 0x00, 0x60, 0x04, 0x00, 0x06, 0x00, 0x20, 0x00, 0x20,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x60, 0x00, 0x40, 0x06, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x01, 0x07, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x08, 0x00, 0x60, 0x08, 0x10, 0x00, 0xC0, 0x18, 0x20, 0x01,
  0x00, 0x10, 0xC0, 0x02, 0x00, 0x21, 0x80, 0x04, 0x00, 0x62, 0x00, 0x08,
  0x00, 0xC4, 0x00, 0x30, 0x01, 0x88, 0x00, 0x60, 0x01, 0x10, 0x00, 0x80,
  0x02, 0x60, 0x01, 0x00, 0x04, 0xC0, 0x02, 0x00, 0x09, 0x00, 0x04, 0x00,
  0x12, 0x00, 0x18, 0x00, 0x24, 0x00, 0x30, 0x00, 0x48, 0x00, 0x40, 0x00,
  0xB0, 0x00, 0x80, 0x01, 0x60, 0x01, 0x00, 0x02, 0x80, 0x02, 0x00, 0x05,
  0x00, 0x0C, 0x00, 0x1A, 0x00, 0x18, 0x00, 0x34, 0x00, 0x30, 0x00, 0x58,
  0x00, 0x40, 0x00, 0xB0, 0x00, 0x80, 0x01, 0x40, 0x01, 0x00, 0x06, 0x80,
  0x06, 0x00, 0x09, 0x00, 0x0C, 0x00, 0x12, 0x00, 0x28, 0x00, 0x64, 0x00,
  0x50, 0x00, 0x88, 0x00, 0xA0, 0x03, 0x10, 0x02, 0x40, 0x0C, 0x20, 0x08,
  0x80, 0x10, 0x60, 0x30, 0x80, 0x40, 0x60, 0xC1, 0x83, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x0E, 0x40, 0x0C, 0x30, 0x07,
  0x0C, 0x02, 0x01, 0x03, 0x00, 0x80, 0x80, 0x33, 0x80, 0x08, 0x20, 0x02,
  0xC0, 0x01, 0x08, 0x00, 0x40, 0x00, 0x31, 0x00, 0x08, 0x00, 0x06, 0x40,
  0x01, 0x00, 0x00, 0x48, 0x00, 0x20, 0x00, 0x0A, 0x00, 0x04, 0x00, 0x01,
  0x40, 0x00, 0x80, 0x00, 0x28, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x04, 0x00, 0x0A, 0x00, 0x00, 0x80,
  0x01, 0x40, 0x00, 0x10, 0x00, 0x48, 0x00, 0x02, 0x00, 0x09, 0x00, 0x00,
  0x40, 0x03, 0x20, 0x00, 0x08, 0x00, 0x46, 0x00, 0x09, 0x00, 0x18, 0x40,
  0x03, 0xA0, 0x02, 0x08, 0x01, 0x86, 0x00, 0x81, 0x80, 0xC0, 0x40, 0x20,
  0x10, 0x60, 0x0E, 0x18, 0x01, 0x30, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x80,
  0x40, 0x00, 0x02, 0x01, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x01, 0x80, 0x80, 0x00, 0x06, 0x02, 0x00, 0x00, 0x10, 0x08, 0x00,
  0x00, 0x40, 0x20, 0x00, 0x01, 0x01, 0x80, 0x00, 0x04, 0x06, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x02, 0x01, 0x00, 0x00, 0x08,
  0x04, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x40, 0x20, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x04, 0x02, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0xC0, 0x20, 0x00,
  0x07, 0x00, 0x80, 0x00, 0x18, 0x02, 0x00, 0x00, 0xA0, 0x08, 0x00, 0x06,
  0x80, 0x30, 0x00, 0x32, 0x00, 0x40, 0x01, 0x98, 0x00, 0x80, 0x0C, 0x60,
  0x01, 0x80, 0xC1, 0x00, 0x01, 0xFC, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x30, 0x08, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xC0, 0xF0, 0x03, 0x03, 0x00, 0x0C, 0x02, 0x02, 0x00, 0x03,
  0x82, 0x04, 0x00, 0x00, 0x62, 0x04, 0x00, 0x00, 0x1C, 0x04, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00,
  0xC0, 0x08, 0x00, 0x01, 0x80, 0x08, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00,
  0x20, 0x30, 0x00, 0x00, 0x20, 0x78, 0x00, 0x00, 0x20, 0x4F, 0x80, 0x00,
  0x30, 0x40, 0x7C, 0x00, 0x30, 0x40, 0x03, 0xE0, 0x10, 0xC0, 0x00, 0x1F,
  0x10, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x02, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x04, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x81,
  0x86, 0x00, 0x00, 0xC1, 0x01, 0x80, 0x00, 0x41, 0x00, 0x60, 0x00, 0x61,
  0x80, 0x18, 0x00, 0x20, 0x80, 0x04, 0x00, 0x30, 0x80, 0x01, 0x00, 0x10,
  0x40, 0x00, 0xC0, 0x18, 0x60, 0x00, 0x30, 0x18, 0x20, 0x00, 0x0C, 0x18,
  0x30, 0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 10, 45, 38, 15, -45 },
  { 58, 12, 16, 38, 17, -47 },
  { 82, 38, 45, 38, 1, -45 },
  { 296, 34, 58, 38, 2, -51 },
  { 543, 42, 46, 38, -1, -45 },
  { 785, 37, 46, 38, 1, -45 },
  { 998, 4, 16, 38, 21, -47 },
  { 1006, 20, 58, 38, 15, -49 },
  { 1151, 20, 58, 38, 5, -49 },
  { 1296, 33, 32, 38, 4, -35 },
  { 1428, 31, 31, 38, 4, -35 },
  { 1549, 9, 16, 38, 10, -5 },
  { 1567, 17, 1, 38, 11, -20 },
  { 1570, 4, 4, 38, 15, -4 },
  { 1572, 34, 58, 38, 2, -49 },
  { 1819, 30, 46, 38, 5, -45 },
  { 1992, 29, 45, 38, 3, -45 },
  { 2156, 31, 45, 38, 3, -45 },
  { 2331, 31, 46, 38, 3, -45 },
  { 2510, 32, 45, 38, 2, -45 },
  { 2690, 31, 46, 38, 4, -45 },
  { 2869, 28, 46, 38, 5, -45 },
  { 3030, 29, 45, 38, 8, -45 },
  { 3194, 31, 46, 38, 4, -45 },
  { 3373, 27, 45, 38, 7, -45 },
  { 3525, 9, 34, 38, 15, -34 },
  { 3564, 14, 45, 38, 10, -34 },
  { 3643, 30, 34, 38, 6, -37 },
  { 3771, 33, 13, 38, 3, -26 },
  { 3825, 31, 34, 38, 3, -37 },
  { 3957, 25, 45, 38, 10, -45 },
  { 4098, 29, 52, 38, 5, -45 },
  { 4287, 31, 45, 38, 1, -45 },
  { 4462, 30, 45, 38, 4, -45 },
  { 4631, 30, 46, 38, 6, -45 },
  { 4804, 31, 45, 38, 4, -45 },
  { 4979, 34, 45, 38, 4, -45 },
  { 5171, 34, 45, 38, 4, -45 },
  { 5363, 30, 46, 38, 6, -45 },
  { 5536, 33, 45, 38, 4, -45 },
  { 5722, 34, 45, 38, 3, -45 },
  { 5914, 29, 46, 38, 5, -45 },
  { 6081, 36, 45, 38, 4, -45 },
  { 6284, 24, 45, 38, 7, -45 },
  { 6419, 35, 45, 38, 3, -45 },
  { 6616, 33, 45, 38, 4, -45 },
  { 6802, 30, 46, 38, 5, -45 },
  { 6975, 33, 45, 38, 4, -45 },
  { 7161, 30, 56, 38, 5, -45 },
  { 7371, 33, 45, 38, 4, -45 },
  { 7557, 34, 46, 38, 2, -45 },
  { 7753, 33, 45, 38, 7, -45 },
  { 7939, 31, 46, 38, 6, -45 },
  { 8118, 32, 45, 38, 8, -45 },
  { 8298, 34, 45, 38, 5, -45 },
  { 8490, 38, 45, 38, 1, -45 },
  { 8704, 35, 45, 38, 6, -45 },
  { 8901, 39, 45, 38, 0, -45 },
  { 9121, 25, 58, 38, 13, -49 },
  { 9303, 14, 58, 38, 13, -49 },
  { 9405, 25, 58, 38, 2, -49 },
  { 9587, 30, 24, 38, 5, -45 },
  { 9677, 31, 1, 38, 0, 8 },
  { 9681, 7, 11, 38, 15, -49 },
  { 9691, 28, 35, 38, 5, -34 },
  { 9814, 29, 48, 38, 5, -47 },
  { 9988, 27, 35, 38, 5, -34 },
  { 10107, 31, 48, 38, 5, -47 },
  { 10293, 27, 35, 38, 5, -34 },
  { 10412, 40, 61, 38, -1, -47 },
  { 10717, 30, 48, 38, 3, -34 },
  { 10897, 26, 47, 38, 6, -47 },
  { 11050, 26, 48, 38, 6, -47 },
  { 11206, 26, 61, 38, 7, -47 },
  { 11405, 32, 48, 38, 5, -47 },
  { 11597, 24, 48, 38, 8, -47 },
  { 11741, 33, 34, 38, 3, -34 },
  { 11882, 26, 34, 38, 6, -34 },
  { 11993, 28, 35, 38, 5, -34 },
  { 12116, 31, 47, 38, 3, -34 },
  { 12299, 28, 47, 38, 5, -34 },
  { 12464, 30, 33, 38, 8, -33 },
  { 12588, 30, 35, 38, 4, -34 },
  { 12720, 31, 46, 38, 5, -45 },
  { 12899, 26, 34, 38, 7, -33 },
  { 13010, 29, 33, 38, 5, -33 },
  { 13130, 31, 34, 38, 5, -33 },
  { 13262, 35, 35, 38, 2, -34 },
  { 13416, 30, 47, 38, 3, -33 },
  { 13593, 32, 35, 38, 3, -34 },
  { 13733, 28, 58, 38, 8, -49 },
  { 13936, 11, 58, 38, 14, -49 },
  { 14016, 29, 58, 38, 3, -49 },
  { 14227, 33, 11, 38, 3, -25 },
};

const GFXfont IBMPlexMono_ThinItalic64pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic64pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic64pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _IBMPLEXMONO_THINITALIC64PT7B_H_
