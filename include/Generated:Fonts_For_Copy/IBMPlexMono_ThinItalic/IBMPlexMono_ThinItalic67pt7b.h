#ifndef _IBMPLEXMONO_THINITALIC67PT7B_H_
#define _IBMPLEXMONO_THINITALIC67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x0F, 0x81, 0xF0, 0x1C, 0x00, 0x30, 0x19, 0x80, 0xCC, 0x04, 0x40,
  0x22, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x22, 0x01, 0x10, 0x19,
  0x80, 0xCC, 0x06, 0x60, 0x33, 0x01, 0x10, 0x08, 0x80, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x01, 0x80, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x00, 0x30, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x04, 0x00, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x00, 0x40, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x01, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x01, 0x80, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x10, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x06, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x01, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0x02, 0x1E, 0x00, 0x01, 0xC0,
  0x20, 0x30, 0x00, 0x30, 0x02, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x08, 0x00, 0x40, 0x03, 0x01, 0x80, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x01, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x03, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x01, 0x80, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x08, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x00,
  0x38, 0x10, 0x00, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x21, 0xC0, 0x00, 0x00, 0x02,
  0x07, 0x00, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x04, 0x00, 0x20, 0x00, 0x00, 0x40, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x30, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x03, 0x00, 0x00, 0x08, 0x00, 0x30, 0x00, 0x00, 0x80, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x60, 0x40, 0x01, 0x80, 0x06, 0x0E, 0x00, 0x18,
  0x00, 0xC0, 0x30, 0x01, 0x00, 0x08, 0x01, 0x80, 0x10, 0x01, 0x80, 0x0C,
  0x01, 0x00, 0x30, 0x00, 0x70, 0x10, 0x0C, 0x00, 0x01, 0xE3, 0x07, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03,
  0x00, 0x10, 0x06, 0x00, 0x00, 0x20, 0x02, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x40, 0x01, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x00, 0x18, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x08, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x80,
  0x18, 0x00, 0x10, 0x00, 0x18, 0x01, 0x00, 0x03, 0x00, 0x01, 0x80, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x10, 0x08, 0x00, 0x01, 0x00, 0x03, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x20, 0x30, 0x00, 0x01, 0x00, 0x06, 0x06, 0x00, 0x00, 0x08, 0x00,
  0xC0, 0x40, 0x00, 0x00, 0xC0, 0x18, 0x08, 0x00, 0x00, 0x07, 0x07, 0x01,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x30, 0x00, 0x00, 0x30, 0x30, 0x01, 0x80, 0x00, 0x06,
  0x02, 0x00, 0x08, 0x00, 0x00, 0x40, 0x40, 0x00, 0x80, 0x00, 0x08, 0x04,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x00, 0x30, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0x00, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x10, 0x00, 0x08, 0x00, 0x20, 0x02, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x01, 0x80, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x01, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x3E, 0xC1, 0x80,
  0x00, 0x03, 0x01, 0x18, 0x00, 0x00, 0x10, 0x07, 0x80, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x00, 0x38, 0x00,
  0x60, 0x00, 0x00, 0xB0, 0x03, 0xC0, 0x00, 0x02, 0x40, 0x0B, 0x00, 0x00,
  0x11, 0x80, 0x44, 0x00, 0x00, 0x42, 0x03, 0x18, 0x00, 0x02, 0x0C, 0x08,
  0x20, 0x00, 0x18, 0x18, 0x60, 0xC0, 0x00, 0xC0, 0x21, 0x01, 0x80, 0x06,
  0x00, 0xC8, 0x01, 0xC0, 0x60, 0x01, 0x60, 0x01, 0xFE, 0x00, 0x03, 0x00,
  0x13, 0x33, 0x32, 0x26, 0x66, 0x64, 0x4C, 0xCC, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x40, 0x00, 0xEF, 0x00, 0x30, 0x03,
  0xE0, 0x78, 0x0C, 0x07, 0xC0, 0x03, 0xC3, 0x0F, 0x00, 0x00, 0x1E, 0xBE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00,
  0x10, 0x03, 0x00, 0x00, 0x08, 0x00, 0x40, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x83,
  0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x04, 0x06,
  0x02, 0x01, 0x01, 0x80, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x77, 0xFE, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x40, 0x00, 0x08, 0x00, 0x80, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x04, 0x03, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x03, 0x10,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x03, 0x60, 0x01, 0x80, 0x03, 0x40, 0x03, 0xC0, 0x02, 0x40,
  0x03, 0xC0, 0x02, 0x40, 0x03, 0x80, 0x02, 0xC0, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x04, 0xC0,
  0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0xC0, 0x20,
  0x00, 0x01, 0x80, 0x20, 0x00, 0x01, 0x00, 0x10, 0x00, 0x02, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x01, 0x80, 0x80, 0x00, 0x06, 0x01, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x06,
  0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x01, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x03, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00,
  0x02, 0x18, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x20,
  0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x02, 0x00, 0x00, 0x20, 0x01, 0x80, 0x00, 0x08, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x04, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60,
  0x7F, 0xC0, 0x00, 0x31, 0xC0, 0x38, 0x00, 0x13, 0x00, 0x03, 0x00, 0x0A,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x10, 0x03, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x08, 0x0F, 0xF0, 0x00, 0x83, 0x80, 0x70, 0x04, 0x60,
  0x00, 0xC0, 0x4C, 0x00, 0x03, 0x02, 0xC0, 0x00, 0x0C, 0x3C, 0x00, 0x00,
  0x31, 0x40, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x09,
  0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x02, 0x08, 0x00, 0x00, 0x20, 0x20, 0x00, 0x02, 0x01, 0x80, 0x00,
  0x60, 0x02, 0x00, 0x06, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x40, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x02, 0x10,
  0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x20,
  0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x01, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0x80, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x10,
  0x60, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x19, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x02, 0x84, 0x00, 0x00, 0x34, 0x30, 0x00, 0x03, 0x60, 0xC0, 0x00, 0x32,
  0x03, 0x00, 0x07, 0x30, 0x07, 0x00, 0xE1, 0x00, 0x0F, 0xF8, 0x18, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x7C,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0xF8, 0x3E, 0x07, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x40, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x78, 0x06, 0x00, 0x30, 0x00, 0x60, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x01, 0x84, 0x00, 0x00, 0x22, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x01, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x80, 0x30,
  0x00, 0x01, 0x00, 0x40, 0x00, 0x02, 0x01, 0x80, 0x00, 0x06, 0x02, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x10, 0x60, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x00, 0xC1, 0x00, 0x0F, 0xC1, 0x86, 0x00, 0x70,
  0x63, 0x0C, 0x01, 0x80, 0x24, 0x10, 0x06, 0x00, 0x28, 0x20, 0x18, 0x00,
  0x50, 0xC0, 0x20, 0x00, 0x61, 0x80, 0xC0, 0x00, 0xC2, 0x01, 0x00, 0x01,
  0x84, 0x02, 0x00, 0x02, 0x08, 0x0C, 0x00, 0x04, 0x30, 0x10, 0x00, 0x08,
  0x60, 0x20, 0x00, 0x30, 0x80, 0x40, 0x00, 0x61, 0x00, 0x80, 0x00, 0xC2,
  0x03, 0x00, 0x01, 0x0C, 0x06, 0x00, 0x02, 0x18, 0x0C, 0x00, 0x04, 0x30,
  0x10, 0x00, 0x08, 0x60, 0x20, 0x00, 0x30, 0x80, 0x40, 0x00, 0x61, 0x00,
  0x80, 0x00, 0x82, 0x01, 0x80, 0x03, 0x04, 0x03, 0x00, 0x06, 0x08, 0x02,
  0x00, 0x14, 0x10, 0x06, 0x00, 0x58, 0x60, 0x04, 0x01, 0x30, 0xC0, 0x06,
  0x0C, 0x41, 0x80, 0x07, 0xF0, 0x81, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00,
  0x21, 0x00, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x04, 0x02, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x02, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x01, 0x00, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x80, 0x04, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x40, 0x01, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x18, 0x00, 0x04, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x60, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x08, 0x01, 0x00, 0x00,
  0x04, 0x01, 0x80, 0x00, 0x03, 0x00, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x10, 0x20, 0x00,
  0x00, 0x08, 0x30, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x01, 0x88, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x70, 0x01, 0x80, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x04, 0x04,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x08,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x0C, 0x10,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x04, 0x30,
  0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x08, 0x60,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x07, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x60, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x80, 0x06,
  0x00, 0x00, 0x80, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x08, 0x10, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x20, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x08, 0x01, 0x00, 0x00,
  0x30, 0x01, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x40, 0x00,
  0xE0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x10, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x08, 0x02, 0x00,
  0x00, 0x04, 0x01, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x00, 0x82, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00,
  0x08, 0x20, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x00, 0x80, 0x80, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x00, 0x40, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x60, 0x08, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0xC0, 0x02, 0x00,
  0x03, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x70, 0x00, 0x20, 0x00, 0x18, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x80, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x06, 0x02, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x05, 0x0C, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xF8, 0xC0, 0x01, 0x00,
  0x18, 0x80, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01, 0x40, 0x20, 0x00, 0x01,
  0x40, 0x10, 0x00, 0x02, 0x40, 0x18, 0x00, 0x0C, 0xC0, 0x04, 0x00, 0x18,
  0xC0, 0x03, 0x80, 0x60, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x40, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x02, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x04, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x04, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00,
  0x02, 0x01, 0x00, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x01, 0x80, 0x80, 0x00, 0x02, 0x01, 0x80, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x40, 0x02, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x01, 0x80, 0x20,
  0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x00, 0x40, 0x38,
  0x00, 0x00, 0x02, 0x03, 0xC0, 0x00, 0x00, 0x30, 0x33, 0x00, 0x00, 0x01,
  0x86, 0x18, 0x00, 0x00, 0x0C, 0x60, 0x60, 0x00, 0x00, 0x46, 0x03, 0x00,
  0x00, 0x02, 0x60, 0x0C, 0x00, 0x00, 0x16, 0x00, 0x60, 0x00, 0x01, 0xE0,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x40, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x00, 0x50, 0x16, 0x00, 0x00, 0x0F, 0x01, 0x20, 0x00, 0x01, 0xB0, 0x12,
  0x00, 0x00, 0x13, 0x03, 0x20, 0x00, 0x03, 0x20, 0x33, 0x00, 0x00, 0x22,
  0x03, 0x10, 0x00, 0x04, 0x20, 0x21, 0x00, 0x00, 0xC6, 0x02, 0x18, 0x00,
  0x08, 0x60, 0x20, 0x80, 0x01, 0x86, 0x02, 0x08, 0x00, 0x30, 0x40, 0x60,
  0x80, 0x02, 0x04, 0x06, 0x0C, 0x00, 0x60, 0x40, 0x40, 0x40, 0x04, 0x0C,
  0x04, 0x04, 0x00, 0x80, 0xC0, 0x40, 0x60, 0x18, 0x0C, 0x04, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x20, 0x30, 0x08, 0x0C, 0x02, 0x06, 0x00, 0x80, 0x80,
  0x30, 0x40, 0x18, 0x08, 0x01, 0x0C, 0x01, 0x80, 0x80, 0x10, 0x80, 0x18,
  0x08, 0x01, 0x98, 0x01, 0x01, 0x80, 0x0B, 0x00, 0x10, 0x18, 0x00, 0xA0,
  0x01, 0x01, 0x00, 0x0E, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x03, 0x01, 0x00,
  0x08, 0x00, 0x30, 0x10, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x30, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00,
  0x06, 0x02, 0x00, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x04, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00,
  0x08, 0x0C, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x08, 0x08, 0x00,
  0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x00, 0x08, 0x05, 0x80, 0x00, 0x01, 0x00, 0xB0, 0x00,
  0x00, 0x20, 0x12, 0x00, 0x00, 0x0C, 0x02, 0x60, 0x00, 0x01, 0x80, 0xCC,
  0x00, 0x00, 0x20, 0x18, 0x80, 0x00, 0x04, 0x02, 0x18, 0x00, 0x00, 0x80,
  0x43, 0x00, 0x00, 0x10, 0x08, 0x20, 0x00, 0x06, 0x01, 0x06, 0x00, 0x00,
  0xC0, 0x60, 0x40, 0x00, 0x10, 0x0C, 0x08, 0x00, 0x02, 0x01, 0x01, 0x80,
  0x00, 0x40, 0x20, 0x10, 0x00, 0x08, 0x04, 0x02, 0x00, 0x03, 0x00, 0x80,
  0x60, 0x00, 0x60, 0x30, 0x04, 0x00, 0x08, 0x06, 0x00, 0x80, 0x01, 0x00,
  0xC0, 0x18, 0x00, 0x20, 0x10, 0x01, 0x00, 0x04, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x40, 0x06, 0x00, 0x30, 0x18, 0x00, 0x40, 0x04, 0x03, 0x00, 0x0C,
  0x00, 0x80, 0x60, 0x01, 0x80, 0x10, 0x08, 0x00, 0x10, 0x02, 0x01, 0x00,
  0x03, 0x00, 0xC0, 0x20, 0x00, 0x60, 0x18, 0x0C, 0x00, 0x04, 0x03, 0x01,
  0x80, 0x00, 0xC0, 0x40, 0x30, 0x00, 0x18, 0x08, 0x04, 0x00, 0x01, 0x01,
  0x00, 0x80, 0x00, 0x30, 0x60, 0x10, 0x00, 0x02, 0x0C, 0x06, 0x00, 0x00,
  0x41, 0x80, 0xC0, 0x00, 0x0C, 0x20, 0x18, 0x00, 0x00, 0x84, 0x02, 0x00,
  0x00, 0x10, 0x80, 0x40, 0x00, 0x03, 0x30, 0x08, 0x00, 0x00, 0x26, 0x03,
  0x00, 0x00, 0x04, 0xC0, 0x60, 0x00, 0x00, 0xD0, 0x0C, 0x00, 0x00, 0x0A,
  0x01, 0x00, 0x00, 0x01, 0xC0, 0x20, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x08, 0x00, 0x80, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x04, 0x03, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x03, 0x08, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x03, 0x10, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x20, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x02, 0x40, 0x00,
  0x00, 0x02, 0x40, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x04, 0xC0, 0x00,
  0x00, 0x04, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x08, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0xC0, 0x20, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x01, 0x00, 0x10, 0x00, 0x02, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x07, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x10, 0x10,
  0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x08, 0x00, 0x80, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x04, 0x03, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x03, 0x08, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x03, 0x10, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x20, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x02, 0x40, 0x00,
  0x00, 0x02, 0x40, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x04, 0xC0, 0x00,
  0x00, 0x04, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x08, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0xC0, 0x20, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x01, 0x00, 0x10, 0x00, 0x02, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x18, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x10, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x20,
  0x00, 0x07, 0x00, 0x08, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0x01, 0x01, 0x00, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00,
  0x10, 0x30, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x80, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x0C, 0x08, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x02, 0x01,
  0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x02, 0x00, 0x10, 0x00, 0x00, 0x80, 0x04, 0x00,
  0x00, 0x20, 0x01, 0x80, 0x00, 0x18, 0x00, 0x20, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x01, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x02, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x08, 0x18, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x10, 0x20,
  0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x04,
  0x08, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00,
  0x08, 0x08, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00,
  0x02, 0x01, 0x00, 0x00, 0x01, 0x00, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x80, 0x10, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x04, 0xC0,
  0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0xC0, 0x20,
  0x00, 0x00, 0x80, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x10, 0x00, 0x02, 0x00, 0x10, 0x00, 0x06, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x10, 0x00, 0x08, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x80, 0x00, 0x04, 0x01, 0x80, 0x00, 0x04,
  0x01, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x01,
  0x40, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x22, 0x00, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x04, 0x30, 0x00,
  0x00, 0x00, 0x84, 0x00, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x04, 0x10,
  0x00, 0x00, 0x00, 0x82, 0x00, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x06,
  0x08, 0x00, 0x00, 0x00, 0x81, 0x00, 0x0E, 0x00, 0x10, 0x20, 0x01, 0xC0,
  0x06, 0x04, 0x00, 0x78, 0x00, 0xC1, 0x80, 0x09, 0x00, 0x10, 0x30, 0x03,
  0x20, 0x02, 0x06, 0x00, 0x44, 0x00, 0xC0, 0xC0, 0x18, 0x80, 0x18, 0x18,
  0x02, 0x18, 0x02, 0x03, 0x00, 0xC3, 0x00, 0x40, 0x40, 0x18, 0x60, 0x18,
  0x08, 0x02, 0x04, 0x03, 0x01, 0x00, 0xC0, 0x80, 0x40, 0x20, 0x10, 0x10,
  0x08, 0x04, 0x06, 0x02, 0x03, 0x00, 0x80, 0x80, 0x40, 0x40, 0x10, 0x30,
  0x0C, 0x08, 0x02, 0x04, 0x01, 0x81, 0x00, 0x41, 0x80, 0x30, 0x60, 0x18,
  0x20, 0x02, 0x08, 0x03, 0x0C, 0x00, 0x41, 0x00, 0x61, 0x00, 0x08, 0x60,
  0x0C, 0x60, 0x01, 0x0C, 0x01, 0x8C, 0x00, 0x21, 0x00, 0x31, 0x00, 0x06,
  0x20, 0x04, 0x60, 0x00, 0xCC, 0x00, 0x88, 0x00, 0x19, 0x80, 0x13, 0x00,
  0x01, 0x20, 0x02, 0x40, 0x00, 0x24, 0x00, 0x58, 0x00, 0x05, 0x80, 0x0A,
  0x00, 0x00, 0xB0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x10, 0x00, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x02, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x00, 0x08, 0x20, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x30, 0x10,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x08,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x80, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x40, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0x04, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x02, 0x01,
  0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x80, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x20, 0x01, 0x80, 0x00, 0x30, 0x01, 0x00, 0x00,
  0x10, 0x03, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x08, 0x08, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x41, 0x81, 0x81, 0x03, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x00,
  0x0F, 0xF0, 0x0C, 0x00, 0xC0, 0x38, 0x30, 0x0C, 0x00, 0x30, 0x80, 0x60,
  0x00, 0x22, 0x02, 0x00, 0x00, 0x48, 0x10, 0x00, 0x01, 0xA0, 0xC0, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x0E, 0x10, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x31,
  0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x06, 0x20, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x00, 0x42, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00,
  0x04, 0x20, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0x40, 0x00, 0x02, 0x81,
  0x00, 0x00, 0x1A, 0x06, 0x00, 0x00, 0x58, 0x0C, 0x00, 0x02, 0x60, 0x10,
  0x00, 0x11, 0x00, 0x30, 0x01, 0x84, 0x00, 0x70, 0x1C, 0x1F, 0xC0, 0x3F,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x7F, 0x80, 0x02, 0x06, 0x03, 0x80, 0x08, 0x60, 0x03, 0x00, 0x22, 0x00,
  0x02, 0x01, 0x90, 0x00, 0x04, 0x06, 0xC0, 0x00, 0x18, 0x1A, 0x00, 0x00,
  0x20, 0x50, 0x00, 0x00, 0x81, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x04,
  0x30, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x43, 0x00, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x01, 0x18, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x02, 0x1C, 0x00, 0x00, 0x18, 0x70,
  0x00, 0x00, 0xC1, 0xA0, 0x00, 0x02, 0x04, 0x80, 0x00, 0x10, 0x11, 0x00,
  0x00, 0x80, 0x43, 0x00, 0x0C, 0x03, 0x07, 0x00, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x06, 0x01, 0xC0, 0x03, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x01, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x44, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06, 0x08, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x60, 0x18, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x07, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x0F, 0xF0, 0x0C, 0x00, 0x30, 0x0E, 0x0C,
  0x00, 0xC0, 0x03, 0x08, 0x01, 0x80, 0x00, 0x88, 0x02, 0x00, 0x00, 0x48,
  0x04, 0x00, 0x00, 0x68, 0x0C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x38,
  0x10, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x40, 0x00, 0x02, 0x80,
  0x40, 0x00, 0x06, 0x80, 0x60, 0x00, 0x05, 0x80, 0x30, 0x00, 0x09, 0x80,
  0x10, 0x00, 0x11, 0x00, 0x0C, 0x00, 0x61, 0x00, 0x07, 0x01, 0xC1, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x60, 0x01, 0x80, 0x18, 0x00, 0x04, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x26, 0x00, 0x00, 0x02, 0x60, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x70,
  0x80, 0x00, 0x1C, 0x08, 0x00, 0x0E, 0x00, 0x80, 0x3F, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x80,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x10, 0x20, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x00,
  0xC0, 0x03, 0x80, 0x03, 0x00, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x58, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x03, 0x00, 0x0C, 0x03, 0x83, 0x00, 0x30, 0x00, 0xC2, 0x00, 0x60,
  0x00, 0x22, 0x00, 0x80, 0x00, 0x12, 0x01, 0x00, 0x00, 0x1A, 0x03, 0x00,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0x0E, 0x04, 0x00, 0x00, 0x04, 0x0C, 0x00,
  0x00, 0x04, 0x08, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x04, 0x18, 0x00,
  0x00, 0x0C, 0x10, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x08, 0x30, 0x00,
  0x00, 0x08, 0x30, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x08, 0x30, 0x00,
  0x00, 0x18, 0x20, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x10, 0x20, 0x00,
  0x00, 0x10, 0x20, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x60, 0x10, 0x00, 0x00, 0xA0, 0x10, 0x00, 0x01, 0xA0, 0x18, 0x00,
  0x01, 0x60, 0x0C, 0x00, 0x02, 0x60, 0x04, 0x00, 0x04, 0x40, 0x03, 0x00,
  0x18, 0x40, 0x01, 0xC0, 0x70, 0x40, 0x00, 0x3F, 0x80, 0x40, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x40, 0x00, 0x04, 0x00, 0xE0, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x1F, 0xE0, 0x06, 0x0E, 0x07, 0x00,
  0xC2, 0x00, 0x30, 0x18, 0x80, 0x03, 0x03, 0x20, 0x00, 0x20, 0x48, 0x00,
  0x06, 0x0A, 0x00, 0x00, 0x43, 0x80, 0x00, 0x08, 0x70, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x04, 0x20, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x02, 0x10, 0x00, 0x00, 0x42, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x01,
  0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x06, 0x20, 0x00, 0x00, 0x84, 0x00, 0x00, 0x10, 0x80, 0x00,
  0x02, 0x30, 0x00, 0x00, 0x46, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x20, 0x00, 0x40, 0x06, 0x00, 0x18, 0x00, 0x60, 0x02, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x40, 0x10, 0x00, 0x04, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x40, 0x02, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x04, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x58,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x01, 0xFE, 0x00, 0x02,
  0x07, 0x01, 0xC0, 0x01, 0x0C, 0x00, 0x30, 0x01, 0x8C, 0x00, 0x0C, 0x00,
  0xC8, 0x00, 0x02, 0x00, 0x68, 0x00, 0x01, 0x80, 0x28, 0x00, 0x00, 0xC0,
  0x14, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x40, 0x00, 0x06, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x70,
  0x00, 0x04, 0x01, 0x80, 0x00, 0x02, 0x07, 0x00, 0x00, 0x01, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x40, 0x0C,
  0x00, 0x01, 0x20, 0x02, 0x00, 0x01, 0x10, 0x01, 0x80, 0x01, 0x08, 0x00,
  0x40, 0x01, 0x0C, 0x00, 0x30, 0x01, 0x06, 0x00, 0x08, 0x01, 0x02, 0x00,
  0x02, 0x01, 0x01, 0x00, 0x01, 0x81, 0x00, 0x80, 0x00, 0x41, 0x00, 0x40,
  0x00, 0x33, 0x00, 0x60, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x06, 0x03, 0x00, 0x06, 0x01, 0x00, 0x04, 0x00, 0x80, 0x0C, 0x00,
  0xC0, 0x08, 0x00, 0x60, 0x18, 0x00, 0x30, 0x10, 0x00, 0x10, 0x30, 0x00,
  0x08, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00, 0x03, 0x40, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x06, 0x0F, 0x80, 0x3F, 0x00, 0xC6, 0x0C, 0x18,
  0x30, 0x19, 0x00, 0x86, 0x03, 0x02, 0x40, 0x09, 0x00, 0x20, 0x50, 0x01,
  0x20, 0x06, 0x0E, 0x00, 0x28, 0x00, 0xC3, 0x80, 0x06, 0x00, 0x18, 0x60,
  0x00, 0xC0, 0x03, 0x0C, 0x00, 0x10, 0x00, 0x61, 0x80, 0x02, 0x00, 0x0C,
  0x20, 0x00, 0xC0, 0x01, 0x04, 0x00, 0x18, 0x00, 0x21, 0x80, 0x03, 0x00,
  0x04, 0x30, 0x00, 0x40, 0x01, 0x86, 0x00, 0x08, 0x00, 0x30, 0x80, 0x01,
  0x00, 0x06, 0x10, 0x00, 0x60, 0x00, 0x82, 0x00, 0x0C, 0x00, 0x10, 0x40,
  0x01, 0x80, 0x02, 0x18, 0x00, 0x20, 0x00, 0xC3, 0x00, 0x04, 0x00, 0x18,
  0x40, 0x00, 0x80, 0x03, 0x08, 0x00, 0x30, 0x00, 0x41, 0x00, 0x06, 0x00,
  0x08, 0x20, 0x00, 0xC0, 0x01, 0x0C, 0x00, 0x10, 0x00, 0x61, 0x80, 0x02,
  0x00, 0x0C, 0x20, 0x00, 0x40, 0x01, 0x84, 0x00, 0x18, 0x00, 0x20, 0x80,
  0x03, 0x00, 0x04, 0x10, 0x00, 0x60, 0x00, 0x86, 0x00, 0x08, 0x00, 0x30,
  0xC0, 0x01, 0x00, 0x06, 0x10, 0x00, 0x20, 0x00, 0xC2, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x02, 0x03, 0xFC, 0x00, 0xC1, 0xC0, 0xE0, 0x18, 0x40, 0x06,
  0x03, 0x10, 0x00, 0x60, 0x44, 0x00, 0x04, 0x09, 0x00, 0x00, 0xC1, 0x40,
  0x00, 0x08, 0x70, 0x00, 0x01, 0x0E, 0x00, 0x00, 0x21, 0x80, 0x00, 0x04,
  0x30, 0x00, 0x00, 0x84, 0x00, 0x00, 0x10, 0x80, 0x00, 0x02, 0x30, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x10, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x08, 0x40, 0x00, 0x01, 0x18, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x01, 0x88, 0x00, 0x00, 0x21, 0x00, 0x00, 0x04, 0x20,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x11, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x10, 0x80, 0x00, 0x02, 0x10, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x08, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x62, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x10, 0x03, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x01, 0x03, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x08, 0x60,
  0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x20, 0x00,
  0x00, 0x0C, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00,
  0x90, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x31, 0x00,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x40, 0x80, 0x00, 0x02, 0x03, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00,
  0xC0, 0x08, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xC0, 0x7F, 0x80, 0x00, 0x81, 0x80, 0xE0,
  0x00, 0x86, 0x00, 0x30, 0x00, 0x88, 0x00, 0x08, 0x01, 0x90, 0x00, 0x04,
  0x01, 0xB0, 0x00, 0x06, 0x01, 0xA0, 0x00, 0x02, 0x01, 0x40, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x03, 0x00, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x01,
  0x02, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x01,
  0x06, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x04,
  0x08, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x08, 0x1C, 0x00, 0x00, 0x18,
  0x1C, 0x00, 0x00, 0x30, 0x1A, 0x00, 0x00, 0x20, 0x12, 0x00, 0x00, 0x40,
  0x11, 0x00, 0x00, 0x80, 0x10, 0xC0, 0x03, 0x00, 0x30, 0x70, 0x0C, 0x00,
  0x30, 0x0F, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x0C, 0x00, 0xC0, 0x38, 0x30,
  0x0C, 0x00, 0x30, 0x80, 0x60, 0x00, 0x22, 0x02, 0x00, 0x00, 0x48, 0x10,
  0x00, 0x01, 0xA0, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x0E, 0x10, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x00, 0x42, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00,
  0x04, 0x60, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x02,
  0x30, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x01, 0x08, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x02, 0x81, 0x00, 0x00, 0x1A, 0x06, 0x00, 0x00, 0x58,
  0x0C, 0x00, 0x02, 0x60, 0x10, 0x00, 0x11, 0x00, 0x30, 0x01, 0x84, 0x00,
  0x70, 0x1C, 0x10, 0x00, 0x3F, 0x80, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x03, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x08, 0x70, 0x00,
  0x00, 0x08, 0xC0, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x78, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x02, 0x00, 0x01, 0x80, 0x06,
  0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x20, 0x18,
  0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x21, 0x00, 0x00, 0x04, 0x60, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x20, 0x00, 0x00, 0x84, 0x00,
  0x00, 0x10, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x03, 0x10, 0x00, 0x00, 0x42, 0x00, 0x00, 0x08, 0x40, 0x00,
  0x01, 0x18, 0x00, 0x00, 0x23, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x88,
  0x00, 0x00, 0x21, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x8C, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x10, 0x80,
  0x00, 0x02, 0x10, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x18, 0x40, 0x00, 0x07,
  0x08, 0x00, 0x01, 0x61, 0x80, 0x00, 0x28, 0x30, 0x00, 0x09, 0x02, 0x00,
  0x02, 0x20, 0x60, 0x00, 0xC4, 0x06, 0x00, 0x31, 0x80, 0x70, 0x18, 0x30,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x10, 0x02, 0x00, 0x00, 0x60,
  0x08, 0x00, 0x00, 0x80, 0x20, 0x00, 0x02, 0x00, 0x80, 0x00, 0x08, 0x06,
  0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x80, 0x60, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x0C, 0x04, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x80, 0x40, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x20, 0x30, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x06, 0x02, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0xC0,
  0x20, 0x00, 0x03, 0x00, 0x80, 0x00, 0x08, 0x06, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x01, 0x00, 0x40, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x20, 0x04, 0x00,
  0x01, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x60, 0x03, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x80, 0x06, 0x00,
  0x02, 0x00, 0x60, 0x00, 0x08, 0x07, 0x00, 0x00, 0x20, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x06, 0x06, 0x00, 0x18, 0x01,
  0x02, 0x00, 0x0C, 0x00, 0xC1, 0x00, 0x04, 0x00, 0x60, 0x80, 0x02, 0x00,
  0x10, 0x40, 0x01, 0x00, 0x08, 0x60, 0x00, 0x80, 0x04, 0x30, 0x00, 0xC0,
  0x03, 0x10, 0x00, 0x60, 0x01, 0x88, 0x00, 0x20, 0x00, 0xC4, 0x00, 0x10,
  0x00, 0x62, 0x00, 0x08, 0x00, 0x33, 0x00, 0x04, 0x00, 0x09, 0x80, 0x06,
  0x00, 0x0C, 0xC0, 0x03, 0x00, 0x06, 0x40, 0x01, 0x00, 0x03, 0x20, 0x00,
  0x80, 0x01, 0x90, 0x00, 0x40, 0x00, 0xD8, 0x00, 0x20, 0x00, 0x6C, 0x00,
  0x30, 0x00, 0x26, 0x00, 0x18, 0x00, 0x12, 0x00, 0x0C, 0x00, 0x09, 0x00,
  0x04, 0x00, 0x04, 0x80, 0x02, 0x00, 0x06, 0xC0, 0x01, 0x00, 0x03, 0x60,
  0x01, 0x80, 0x01, 0x30, 0x00, 0xC0, 0x01, 0x90, 0x00, 0x60, 0x00, 0x88,
  0x00, 0x70, 0x00, 0x44, 0x00, 0x38, 0x00, 0x62, 0x00, 0x24, 0x00, 0x61,
  0x00, 0x12, 0x00, 0x20, 0xC0, 0x11, 0x00, 0x30, 0x20, 0x10, 0x40, 0x30,
  0x0C, 0x30, 0x30, 0x60, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x0F, 0x80, 0x01, 0xD8, 0x01, 0x83, 0x00, 0x70, 0x60, 0x10, 0x0C, 0x0E,
  0x01, 0x01, 0x00, 0x21, 0xC0, 0x0C, 0x10, 0x01, 0xB8, 0x00, 0x21, 0x80,
  0x0C, 0x00, 0x01, 0x08, 0x00, 0x20, 0x00, 0x0C, 0x80, 0x01, 0x00, 0x00,
  0x24, 0x00, 0x08, 0x00, 0x01, 0x60, 0x00, 0x40, 0x00, 0x0A, 0x00, 0x06,
  0x00, 0x00, 0x50, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x80, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x0D, 0x00, 0x00, 0x20, 0x00, 0x48,
  0x00, 0x01, 0x00, 0x02, 0x40, 0x00, 0x08, 0x00, 0x22, 0x00, 0x00, 0x40,
  0x01, 0x18, 0x00, 0x12, 0x00, 0x10, 0x40, 0x03, 0x10, 0x01, 0x82, 0x00,
  0x60, 0xC0, 0x18, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x41, 0xC0, 0x0C, 0x18,
  0x01, 0x38, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x01, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x80, 0x40, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x02, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x80, 0x40,
  0x00, 0x01, 0x01, 0x80, 0x00, 0x02, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x18, 0x08, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x40, 0x20, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x01, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x0C, 0x04, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x01, 0x80, 0x40, 0x00, 0x07, 0x00, 0x80, 0x00, 0x16,
  0x01, 0x80, 0x00, 0x28, 0x03, 0x00, 0x00, 0x90, 0x02, 0x00, 0x02, 0x20,
  0x06, 0x00, 0x0C, 0x40, 0x06, 0x00, 0x31, 0x80, 0x07, 0x01, 0x83, 0x00,
  0x01, 0xFC, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x08, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x80, 0x60,
  0x3F, 0x00, 0xC0, 0x40, 0x01, 0xF0, 0x60, 0x40, 0x00, 0x1E, 0x30, 0x20,
  0x00, 0x03, 0xF0, 0x20, 0x00, 0x00, 0x38, 0x10, 0x00, 0x00, 0x18, 0x08,
  0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x20, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0xC0, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x04, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0xC1, 0xE0, 0x00,
  0x00, 0x20, 0xC7, 0xC0, 0x00, 0x10, 0x40, 0x3E, 0x00, 0x08, 0x20, 0x00,
  0xF8, 0x04, 0x10, 0x00, 0x03, 0xE3, 0x10, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xC1, 0x83, 0x00, 0x00,
  0x20, 0xC0, 0x60, 0x00, 0x08, 0x60, 0x0C, 0x00, 0x04, 0x10, 0x01, 0x80,
  0x01, 0x08, 0x00, 0x20, 0x00, 0x86, 0x00, 0x04, 0x00, 0x61, 0x00, 0x01,
  0x80, 0x10, 0xC0, 0x00, 0x30, 0x08, 0x20, 0x00, 0x07, 0x0C, 0x08, 0x00,
  0x00, 0x7C, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 11, 47, 40, 15, -47 },
  { 66, 13, 17, 40, 18, -50 },
  { 94, 40, 47, 40, 1, -47 },
  { 329, 36, 63, 40, 2, -55 },
  { 613, 44, 49, 40, -1, -48 },
  { 883, 38, 49, 40, 1, -48 },
  { 1116, 4, 17, 40, 22, -50 },
  { 1125, 21, 60, 40, 16, -51 },
  { 1283, 21, 60, 40, 5, -51 },
  { 1441, 34, 33, 40, 4, -37 },
  { 1582, 32, 33, 40, 5, -37 },
  { 1714, 9, 17, 40, 11, -5 },
  { 1734, 18, 1, 40, 12, -21 },
  { 1737, 5, 4, 40, 15, -4 },
  { 1740, 35, 60, 40, 3, -51 },
  { 2003, 32, 49, 40, 5, -48 },
  { 2199, 31, 47, 40, 3, -47 },
  { 2382, 33, 48, 40, 3, -48 },
  { 2580, 32, 49, 40, 3, -48 },
  { 2776, 34, 47, 40, 2, -47 },
  { 2976, 33, 48, 40, 4, -47 },
  { 3174, 29, 48, 40, 5, -47 },
  { 3348, 31, 47, 40, 8, -47 },
  { 3531, 33, 49, 40, 4, -48 },
  { 3734, 29, 48, 40, 7, -48 },
  { 3908, 10, 35, 40, 15, -35 },
  { 3952, 14, 47, 40, 11, -35 },
  { 4035, 32, 36, 40, 6, -38 },
  { 4179, 34, 13, 40, 4, -27 },
  { 4235, 32, 36, 40, 3, -38 },
  { 4379, 26, 48, 40, 10, -48 },
  { 4535, 31, 55, 40, 5, -48 },
  { 4749, 33, 47, 40, 1, -47 },
  { 4943, 32, 47, 40, 4, -47 },
  { 5131, 31, 49, 40, 6, -48 },
  { 5321, 33, 47, 40, 4, -47 },
  { 5515, 35, 47, 40, 4, -47 },
  { 5721, 36, 47, 40, 4, -47 },
  { 5933, 32, 49, 40, 6, -48 },
  { 6129, 35, 47, 40, 4, -47 },
  { 6335, 36, 47, 40, 3, -47 },
  { 6547, 31, 48, 40, 5, -47 },
  { 6733, 37, 47, 40, 4, -47 },
  { 6951, 26, 47, 40, 7, -47 },
  { 7104, 36, 47, 40, 3, -47 },
  { 7316, 35, 47, 40, 4, -47 },
  { 7522, 32, 49, 40, 5, -48 },
  { 7718, 34, 47, 40, 4, -47 },
  { 7918, 32, 59, 40, 5, -48 },
  { 8154, 34, 47, 40, 4, -47 },
  { 8354, 36, 49, 40, 2, -48 },
  { 8575, 35, 47, 40, 7, -47 },
  { 8781, 33, 48, 40, 6, -47 },
  { 8979, 32, 47, 40, 9, -47 },
  { 9167, 35, 47, 40, 6, -47 },
  { 9373, 40, 47, 40, 1, -47 },
  { 9608, 36, 47, 40, 7, -47 },
  { 9820, 40, 47, 40, 0, -47 },
  { 10055, 26, 60, 40, 13, -51 },
  { 10250, 16, 60, 40, 13, -51 },
  { 10370, 26, 60, 40, 2, -51 },
  { 10565, 32, 25, 40, 5, -47 },
  { 10665, 32, 1, 40, 0, 8 },
  { 10669, 7, 11, 40, 16, -51 },
  { 10679, 30, 36, 40, 5, -35 },
  { 10814, 30, 51, 40, 5, -50 },
  { 11006, 27, 36, 40, 6, -35 },
  { 11128, 32, 51, 40, 5, -50 },
  { 11332, 28, 36, 40, 6, -35 },
  { 11458, 42, 64, 40, -1, -50 },
  { 11794, 32, 49, 40, 3, -35 },
  { 11990, 27, 50, 40, 6, -50 },
  { 12159, 28, 52, 40, 6, -51 },
  { 12341, 28, 65, 40, 7, -51 },
  { 12569, 33, 51, 40, 5, -50 },
  { 12780, 25, 51, 40, 8, -50 },
  { 12940, 35, 35, 40, 3, -35 },
  { 13094, 27, 35, 40, 6, -35 },
  { 13213, 30, 36, 40, 5, -35 },
  { 13348, 32, 48, 40, 3, -35 },
  { 13540, 30, 48, 40, 5, -35 },
  { 13720, 32, 35, 40, 8, -35 },
  { 13860, 31, 36, 40, 4, -35 },
  { 14000, 33, 48, 40, 5, -47 },
  { 14198, 27, 36, 40, 7, -35 },
  { 14320, 30, 35, 40, 6, -35 },
  { 14452, 33, 36, 40, 5, -35 },
  { 14601, 37, 36, 40, 2, -35 },
  { 14768, 31, 49, 40, 3, -35 },
  { 14958, 33, 36, 40, 3, -35 },
  { 15107, 30, 60, 40, 8, -51 },
  { 15332, 11, 60, 40, 15, -51 },
  { 15415, 30, 60, 40, 3, -51 },
  { 15640, 34, 11, 40, 4, -26 },
};

const GFXfont IBMPlexMono_ThinItalic67pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic67pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic67pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _IBMPLEXMONO_THINITALIC67PT7B_H_
