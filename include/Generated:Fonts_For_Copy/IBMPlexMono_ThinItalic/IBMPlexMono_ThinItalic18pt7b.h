#ifndef _IBMPLEXMONO_THINITALIC18PT7B_H_
#define _IBMPLEXMONO_THINITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x92, 0x80, 0x08, 0xB6, 0xDA, 0x04, 0xC0, 0x90, 0x12,
  0x04, 0x83, 0x8E, 0x12, 0x04, 0x80, 0x90, 0xF3, 0xC4, 0x40, 0x90, 0x12,
  0x04, 0x80, 0x04, 0x02, 0x07, 0x84, 0xB4, 0x8A, 0x41, 0x20, 0x50, 0x1E,
  0x04, 0x84, 0x42, 0x29, 0x14, 0x91, 0xF0, 0x20, 0x20, 0x00, 0x1C, 0x32,
  0x44, 0x44, 0x44, 0x48, 0x45, 0x03, 0x80, 0x00, 0x00, 0x38, 0x14, 0x42,
  0x84, 0x48, 0x48, 0x48, 0x83, 0x80, 0x0E, 0x02, 0x20, 0x84, 0x10, 0x82,
  0x10, 0x22, 0x1F, 0x84, 0x40, 0x84, 0x10, 0x4A, 0x19, 0xC2, 0xA7, 0x88,
  0xF8, 0x0C, 0x42, 0x10, 0x42, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x04,
  0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x41, 0x04, 0x10, 0x82, 0x10, 0x82,
  0x30, 0x08, 0x04, 0x02, 0x11, 0x17, 0xF0, 0xC0, 0x90, 0x88, 0x82, 0x00,
  0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x40, 0x20, 0x10, 0x00, 0x5A,
  0xF8, 0x80, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10,
  0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x00, 0x0E, 0x18, 0x90, 0x28,
  0x18, 0x0C, 0x06, 0x23, 0x01, 0x81, 0x40, 0xA0, 0x48, 0x43, 0xC0, 0x04,
  0x0C, 0x14, 0x64, 0x44, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0xFF,
  0x0E, 0x18, 0x90, 0x28, 0x10, 0x10, 0x08, 0x08, 0x08, 0x08, 0x08, 0x18,
  0x10, 0x0F, 0xF0, 0x1E, 0x21, 0x41, 0x01, 0x01, 0x01, 0x1E, 0x02, 0x01,
  0x01, 0x81, 0x82, 0x7C, 0x01, 0x01, 0x81, 0x41, 0x21, 0x21, 0x11, 0x09,
  0x04, 0x82, 0x7F, 0xC1, 0x00, 0x80, 0x40, 0x1F, 0x90, 0x08, 0x08, 0x04,
  0x02, 0xF1, 0x84, 0x02, 0x01, 0x00, 0xA0, 0x48, 0x43, 0xC0, 0x03, 0x0C,
  0x10, 0x20, 0x20, 0x5E, 0xA1, 0xC1, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x7F,
  0xC0, 0xA0, 0x90, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08,
  0x08, 0x00, 0x1F, 0x10, 0x50, 0x28, 0x14, 0x09, 0x08, 0x78, 0xC2, 0x81,
  0x40, 0xA0, 0x50, 0x67, 0xC0, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x82, 0x86,
  0x7A, 0x04, 0x08, 0x10, 0x20, 0x40, 0x28, 0x00, 0x00, 0x80, 0x12, 0x00,
  0x00, 0x00, 0x44, 0x88, 0x01, 0x06, 0x08, 0x30, 0xC0, 0x80, 0x40, 0x30,
  0x08, 0x06, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x40, 0x30, 0x08, 0x06,
  0x01, 0x01, 0x06, 0x18, 0x20, 0xC0, 0x3C, 0x8A, 0x08, 0x10, 0x20, 0x82,
  0x38, 0x40, 0x80, 0x00, 0x04, 0x00, 0x0F, 0x08, 0x88, 0x28, 0x14, 0x6A,
  0x4A, 0x45, 0x22, 0xA1, 0x48, 0xA7, 0xD0, 0x08, 0x02, 0x00, 0xF0, 0x02,
  0x03, 0x01, 0x81, 0x20, 0x90, 0x88, 0x44, 0x42, 0x3F, 0x20, 0x50, 0x30,
  0x18, 0x08, 0x3F, 0x20, 0x90, 0x28, 0x14, 0x12, 0x09, 0xF9, 0x02, 0x81,
  0x40, 0xA0, 0x50, 0x2F, 0xE0, 0x1C, 0x22, 0x41, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x82, 0x84, 0x84, 0x78, 0x3E, 0x10, 0x90, 0x28, 0x14, 0x0A,
  0x05, 0x03, 0x01, 0x81, 0x40, 0xA0, 0x50, 0x4F, 0xC0, 0x3F, 0xC8, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x07, 0xF2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0xFF, 0x00, 0x3F, 0xC8, 0x04, 0x01, 0x00, 0x40, 0x10, 0x07, 0xF1, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x1C, 0x22, 0x41, 0x80, 0x80,
  0x80, 0x80, 0x8E, 0x82, 0x82, 0x82, 0x86, 0x7A, 0x40, 0xA0, 0x50, 0x28,
  0x14, 0x0A, 0x09, 0xFD, 0x02, 0x81, 0x40, 0xA0, 0x50, 0x28, 0x20, 0x3F,
  0x82, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02,
  0x0F, 0xE0, 0x1F, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02,
  0x01, 0x20, 0x90, 0x87, 0x80, 0x20, 0x50, 0x24, 0x11, 0x08, 0x4C, 0x14,
  0x06, 0x83, 0x20, 0x84, 0x21, 0x08, 0x22, 0x08, 0x81, 0x00, 0x40, 0x81,
  0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0x20, 0xC8,
  0x26, 0x19, 0x86, 0x92, 0xA5, 0x29, 0x4A, 0x64, 0x91, 0x20, 0x48, 0x12,
  0x04, 0x81, 0x00, 0x20, 0xB0, 0x54, 0x2A, 0x15, 0x0A, 0x4A, 0x25, 0x12,
  0x85, 0x42, 0xA1, 0x50, 0x68, 0x20, 0x0E, 0x18, 0x90, 0x28, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x81, 0x40, 0xA0, 0x48, 0x43, 0xC0, 0x3F, 0x10, 0x50,
  0x28, 0x14, 0x0A, 0x05, 0x04, 0xFE, 0x80, 0x40, 0x20, 0x10, 0x08, 0x00,
  0x0E, 0x18, 0x90, 0x28, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x40, 0xA0,
  0x48, 0x43, 0xC0, 0x88, 0x2C, 0x0C, 0x3F, 0x10, 0x50, 0x28, 0x14, 0x0A,
  0x05, 0x04, 0xFE, 0x88, 0x42, 0x21, 0x10, 0x48, 0x30, 0x1E, 0x10, 0x90,
  0x28, 0x04, 0x01, 0x00, 0x78, 0x02, 0x01, 0x00, 0xA0, 0x50, 0x47, 0xC0,
  0xFF, 0x84, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08,
  0x04, 0x02, 0x00, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x82,
  0x82, 0x84, 0x84, 0x78, 0x80, 0xC0, 0xA0, 0x50, 0x48, 0x22, 0x21, 0x10,
  0x88, 0x48, 0x24, 0x14, 0x0A, 0x02, 0x00, 0x40, 0x50, 0x14, 0x0A, 0x02,
  0x88, 0xA2, 0x29, 0x52, 0x54, 0xA5, 0x29, 0x4C, 0x61, 0x18, 0x82, 0x00,
  0x20, 0x22, 0x08, 0x42, 0x04, 0x80, 0xA0, 0x14, 0x01, 0x00, 0x50, 0x12,
  0x04, 0x40, 0x84, 0x20, 0x88, 0x08, 0x80, 0xE0, 0x48, 0x11, 0x08, 0x44,
  0x0A, 0x03, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x1F,
  0xE0, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x0F, 0xF8, 0x3E, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x78, 0x88, 0x88, 0x88, 0x84, 0x44,
  0x42, 0x22, 0x21, 0x3E, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10,
  0x20, 0x41, 0x02, 0x04, 0x78, 0x04, 0x05, 0x04, 0x84, 0x42, 0x12, 0x0A,
  0x02, 0xFF, 0x80, 0x94, 0x1D, 0x23, 0x41, 0x81, 0x81, 0x82, 0x82, 0x46,
  0x3B, 0x20, 0x10, 0x08, 0x08, 0x04, 0xE3, 0x89, 0x04, 0x83, 0x41, 0x40,
  0xA0, 0x48, 0x4B, 0xC0, 0x1C, 0x22, 0x41, 0x80, 0x80, 0x82, 0x83, 0x44,
  0x38, 0x00, 0x80, 0x40, 0x20, 0x21, 0xD1, 0x19, 0x05, 0x02, 0x81, 0x41,
  0x21, 0x88, 0xC3, 0xA0, 0x1E, 0x21, 0x41, 0x82, 0x7C, 0x80, 0x81, 0x42,
  0x3C, 0x01, 0xE0, 0x40, 0x08, 0x02, 0x03, 0xFC, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x81, 0x10, 0x12, 0x01, 0x80, 0x10,
  0x00, 0x1D, 0x23, 0x41, 0x81, 0x81, 0x82, 0x82, 0x46, 0x3A, 0x02, 0x04,
  0x84, 0x78, 0x40, 0x81, 0x02, 0x05, 0xD4, 0x50, 0xC1, 0x83, 0x06, 0x14,
  0x28, 0x40, 0x08, 0x00, 0x00, 0x0F, 0x04, 0x08, 0x10, 0x20, 0x45, 0x12,
  0xC2, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x20,
  0x40, 0x91, 0x12, 0x14, 0x10, 0x20, 0x10, 0x08, 0x08, 0x04, 0xE2, 0x89,
  0x84, 0x82, 0x4E, 0x48, 0x62, 0x31, 0x28, 0x60, 0xF0, 0x20, 0x40, 0x82,
  0x04, 0x08, 0x10, 0x20, 0x85, 0x32, 0x82, 0x00, 0x7B, 0xA6, 0x52, 0x31,
  0x18, 0x8C, 0x46, 0x25, 0x22, 0x91, 0x00, 0xDD, 0x45, 0x0C, 0x18, 0x30,
  0x61, 0x42, 0x84, 0x1E, 0x21, 0x41, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C,
  0x4E, 0x38, 0x90, 0x48, 0x34, 0x14, 0x0A, 0x04, 0x84, 0xBC, 0x40, 0x20,
  0x10, 0x08, 0x00, 0x1D, 0x23, 0x41, 0x81, 0x81, 0x82, 0x82, 0x46, 0x3A,
  0x02, 0x02, 0x04, 0x04, 0xF7, 0x8C, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x40, 0x00, 0x1E, 0x61, 0x40, 0x40, 0x3E, 0x01, 0x01, 0x81, 0x7C,
  0x08, 0x04, 0x02, 0x02, 0x0F, 0xF8, 0x80, 0x40, 0x20, 0x10, 0x10, 0x88,
  0xC5, 0x81, 0x00, 0x83, 0x06, 0x0C, 0x18, 0x50, 0xA3, 0x46, 0x74, 0xC2,
  0x41, 0x41, 0x42, 0x82, 0x82, 0x84, 0x98, 0x60, 0x44, 0xA4, 0x62, 0x31,
  0x18, 0x8C, 0x46, 0x23, 0x32, 0x66, 0x00, 0x09, 0xC7, 0x49, 0x11, 0x02,
  0x30, 0x41, 0x08, 0x23, 0x14, 0xA4, 0x73, 0x00, 0x41, 0x41, 0x41, 0x41,
  0x82, 0x82, 0x86, 0x46, 0x3A, 0x02, 0x04, 0x84, 0x78, 0x3C, 0xA1, 0xE0,
  0x40, 0xC0, 0x81, 0x81, 0x09, 0xE2, 0x8F, 0x00, 0x0F, 0x10, 0x10, 0x10,
  0x08, 0x08, 0x08, 0xF0, 0x10, 0x18, 0x10, 0x20, 0x40, 0x40, 0x40, 0x3C,
  0x24, 0x94, 0x92, 0x52, 0x49, 0x24, 0x1C, 0x04, 0x04, 0x04, 0x08, 0x10,
  0x10, 0x0F, 0x18, 0x20, 0x20, 0x10, 0x10, 0x10, 0x10, 0xF0, 0x30, 0xA4,
  0x62, 0x50, 0xE0,
};

const GFXglyph IBMPlexMono_ThinItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 3, 5, 11, 5, -13 },
  { 8, 11, 13, 11, 0, -13 },
  { 26, 9, 17, 11, 1, -15 },
  { 46, 12, 13, 11, 0, -13 },
  { 66, 11, 13, 11, 0, -13 },
  { 84, 1, 5, 11, 6, -13 },
  { 85, 6, 16, 11, 4, -14 },
  { 97, 6, 16, 11, 1, -14 },
  { 109, 9, 9, 11, 1, -10 },
  { 120, 9, 9, 11, 1, -10 },
  { 131, 2, 4, 11, 3, -1 },
  { 132, 5, 1, 11, 3, -6 },
  { 133, 1, 1, 11, 4, -1 },
  { 134, 9, 16, 11, 1, -14 },
  { 152, 9, 13, 11, 1, -13 },
  { 167, 8, 13, 11, 1, -13 },
  { 180, 9, 13, 11, 1, -13 },
  { 195, 8, 13, 11, 1, -13 },
  { 208, 9, 13, 11, 1, -13 },
  { 223, 9, 13, 11, 1, -13 },
  { 238, 8, 13, 11, 1, -13 },
  { 251, 9, 13, 11, 2, -13 },
  { 266, 9, 13, 11, 1, -13 },
  { 281, 8, 13, 11, 2, -13 },
  { 294, 3, 9, 11, 4, -9 },
  { 298, 4, 12, 11, 3, -9 },
  { 304, 8, 10, 11, 2, -10 },
  { 314, 9, 5, 11, 1, -8 },
  { 320, 8, 10, 11, 1, -10 },
  { 330, 7, 13, 11, 3, -13 },
  { 342, 9, 15, 11, 1, -13 },
  { 359, 9, 13, 11, 0, -13 },
  { 374, 9, 13, 11, 1, -13 },
  { 389, 8, 13, 11, 2, -13 },
  { 402, 9, 13, 11, 1, -13 },
  { 417, 10, 13, 11, 1, -13 },
  { 434, 10, 13, 11, 1, -13 },
  { 451, 8, 13, 11, 2, -13 },
  { 464, 9, 13, 11, 1, -13 },
  { 479, 9, 13, 11, 1, -13 },
  { 494, 9, 13, 11, 1, -13 },
  { 509, 10, 13, 11, 1, -13 },
  { 526, 7, 13, 11, 2, -13 },
  { 538, 10, 13, 11, 1, -13 },
  { 555, 9, 13, 11, 1, -13 },
  { 570, 9, 13, 11, 1, -13 },
  { 585, 9, 13, 11, 1, -13 },
  { 600, 9, 16, 11, 1, -13 },
  { 618, 9, 13, 11, 1, -13 },
  { 633, 9, 13, 11, 1, -13 },
  { 648, 9, 13, 11, 2, -13 },
  { 663, 8, 13, 11, 2, -13 },
  { 676, 9, 13, 11, 2, -13 },
  { 691, 10, 13, 11, 1, -13 },
  { 708, 11, 13, 11, 0, -13 },
  { 726, 10, 13, 11, 2, -13 },
  { 743, 11, 13, 11, 0, -13 },
  { 761, 7, 16, 11, 4, -14 },
  { 775, 4, 16, 11, 4, -14 },
  { 783, 7, 16, 11, 1, -14 },
  { 797, 9, 7, 11, 1, -13 },
  { 805, 9, 1, 11, 0, 2 },
  { 807, 2, 3, 11, 4, -14 },
  { 808, 8, 9, 11, 1, -9 },
  { 817, 9, 13, 11, 1, -13 },
  { 832, 8, 9, 11, 1, -9 },
  { 841, 9, 13, 11, 1, -13 },
  { 856, 8, 9, 11, 1, -9 },
  { 865, 11, 17, 11, 0, -13 },
  { 889, 8, 13, 11, 1, -9 },
  { 902, 7, 13, 11, 2, -13 },
  { 914, 7, 13, 11, 2, -13 },
  { 926, 7, 17, 11, 2, -13 },
  { 941, 9, 13, 11, 1, -13 },
  { 956, 7, 13, 11, 2, -13 },
  { 968, 9, 9, 11, 1, -9 },
  { 979, 7, 9, 11, 2, -9 },
  { 987, 8, 9, 11, 1, -9 },
  { 996, 9, 13, 11, 1, -9 },
  { 1011, 8, 13, 11, 1, -9 },
  { 1024, 9, 9, 11, 2, -9 },
  { 1035, 8, 9, 11, 1, -9 },
  { 1044, 9, 13, 11, 1, -13 },
  { 1059, 7, 9, 11, 2, -9 },
  { 1067, 8, 9, 11, 2, -9 },
  { 1076, 9, 9, 11, 1, -9 },
  { 1087, 11, 9, 11, 0, -9 },
  { 1100, 8, 13, 11, 1, -9 },
  { 1113, 9, 9, 11, 1, -9 },
  { 1124, 8, 16, 11, 2, -14 },
  { 1140, 3, 16, 11, 4, -14 },
  { 1146, 8, 16, 11, 1, -14 },
  { 1162, 9, 4, 11, 1, -7 },
};

const GFXfont IBMPlexMono_ThinItalic18pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic18pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic18pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _IBMPLEXMONO_THINITALIC18PT7B_H_
