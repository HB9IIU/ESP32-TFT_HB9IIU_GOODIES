#ifndef _IBMPLEXMONO_THINITALIC20PT7B_H_
#define _IBMPLEXMONO_THINITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x29, 0x24, 0x94, 0x90, 0x01, 0x00, 0xD9, 0x99, 0xA0, 0x02, 0x60,
  0x24, 0x04, 0x40, 0x48, 0x3C, 0x70, 0x88, 0x09, 0x00, 0x90, 0x11, 0x0F,
  0x1E, 0x12, 0x02, 0x20, 0x24, 0x02, 0x40, 0x02, 0x00, 0x81, 0xF0, 0x93,
  0x44, 0x51, 0x04, 0x40, 0x90, 0x1C, 0x02, 0xC0, 0x88, 0x22, 0x08, 0xA2,
  0x25, 0x10, 0xF8, 0x10, 0x04, 0x00, 0x1C, 0x09, 0x10, 0x90, 0x88, 0x84,
  0x84, 0x28, 0x21, 0x40, 0xF0, 0x00, 0x38, 0x1A, 0x20, 0xA1, 0x09, 0x08,
  0x88, 0x48, 0x44, 0x41, 0xC0, 0x0F, 0x01, 0x08, 0x10, 0x81, 0x08, 0x10,
  0x81, 0x08, 0x1B, 0x06, 0x40, 0x84, 0x08, 0x20, 0x81, 0x18, 0x31, 0x42,
  0xA3, 0xC4, 0xF8, 0x0C, 0x42, 0x10, 0x42, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x40, 0x80, 0x10, 0x10, 0x10, 0x20, 0x40, 0x80, 0x81,
  0x02, 0x08, 0x10, 0x20, 0x41, 0x04, 0x08, 0x21, 0x80, 0x04, 0x01, 0x00,
  0x40, 0x10, 0xE9, 0xC7, 0x81, 0x40, 0x88, 0x42, 0x10, 0x40, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x08, 0x3F, 0xF0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x29, 0x48, 0xFC, 0x80, 0x00, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x00, 0x1E, 0x10, 0x90, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x11,
  0x80, 0xC0, 0xA0, 0x50, 0x48, 0x63, 0xC0, 0x02, 0x03, 0x06, 0x86, 0x44,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x0F,
  0x04, 0x22, 0x05, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x06, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x3F, 0xE0, 0x0F, 0x04, 0x22, 0x08, 0x03, 0x00, 0x80,
  0x21, 0xF0, 0x0C, 0x00, 0x80, 0x20, 0x0A, 0x04, 0x41, 0x0F, 0x80, 0x00,
  0x80, 0x60, 0x28, 0x12, 0x09, 0x04, 0x42, 0x11, 0x04, 0x81, 0x20, 0x8F,
  0xFC, 0x08, 0x02, 0x00, 0x80, 0x1F, 0xC8, 0x02, 0x00, 0x80, 0x20, 0x17,
  0x82, 0x11, 0x02, 0x00, 0x80, 0x20, 0x0A, 0x04, 0x41, 0x0F, 0x80, 0x02,
  0x0C, 0x10, 0x20, 0x40, 0x40, 0xBE, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x82,
  0x7C, 0x7F, 0xE0, 0x28, 0x12, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08,
  0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x00, 0x0F, 0x84, 0x12, 0x05, 0x01,
  0x40, 0x48, 0x21, 0xF0, 0xC4, 0xC0, 0xA0, 0x28, 0x0A, 0x02, 0x41, 0x0F,
  0x80, 0x1E, 0x30, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x04, 0x86, 0x3E, 0x01,
  0x01, 0x01, 0x01, 0x03, 0x00, 0x40, 0x00, 0x20, 0x10, 0x00, 0x00, 0x00,
  0x24, 0x48, 0x80, 0x00, 0x81, 0x81, 0x03, 0x06, 0x04, 0x01, 0x00, 0x40,
  0x18, 0x02, 0x00, 0xC0, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x40, 0x18, 0x02,
  0x00, 0xC0, 0x10, 0x04, 0x04, 0x0C, 0x18, 0x10, 0x30, 0x00, 0x3C, 0x42,
  0x81, 0x81, 0x01, 0x02, 0x02, 0x0C, 0x30, 0x20, 0x20, 0x00, 0x00, 0x40,
  0x1F, 0x10, 0x90, 0x28, 0x18, 0xEC, 0x8A, 0x45, 0x42, 0xA1, 0x50, 0xA8,
  0x53, 0xC8, 0x04, 0x02, 0x00, 0xF8, 0x01, 0x00, 0xC0, 0x50, 0x14, 0x08,
  0x82, 0x21, 0x08, 0x42, 0x20, 0x8F, 0xE2, 0x05, 0x01, 0x40, 0x60, 0x10,
  0x3F, 0x88, 0x22, 0x05, 0x01, 0x40, 0x90, 0x27, 0xF1, 0x06, 0x80, 0xA0,
  0x28, 0x0A, 0x02, 0x81, 0x3F, 0x80, 0x0E, 0x18, 0x90, 0x28, 0x18, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x50, 0x44, 0x41, 0xC0, 0x1F, 0x08,
  0x22, 0x04, 0x81, 0x40, 0x50, 0x14, 0x05, 0x01, 0x40, 0x60, 0x28, 0x0A,
  0x04, 0x83, 0x3F, 0x00, 0x1F, 0xE4, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x0F, 0xE2, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0xFE, 0x00,
  0x1F, 0xE4, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x0F, 0xE2, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x00, 0x1E, 0x10, 0x90, 0x28,
  0x18, 0x04, 0x02, 0x01, 0x1E, 0x81, 0x40, 0xA0, 0x50, 0x2C, 0x33, 0xF0,
  0x20, 0x64, 0x09, 0x01, 0x20, 0x24, 0x04, 0x80, 0x9F, 0xE2, 0x04, 0x80,
  0x90, 0x12, 0x02, 0x40, 0x48, 0x11, 0x02, 0x00, 0x3F, 0xE0, 0x40, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x81, 0xFE, 0x00, 0x0F, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x40, 0x12, 0x04, 0x42, 0x0F, 0x00, 0x20, 0x24,
  0x08, 0x82, 0x20, 0x84, 0x20, 0x88, 0x16, 0x03, 0x20, 0x44, 0x10, 0x42,
  0x08, 0x40, 0x88, 0x11, 0x01, 0x00, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x20, 0x2C, 0x0D, 0x83,
  0x28, 0x65, 0x14, 0xA4, 0x92, 0x94, 0x62, 0x84, 0x90, 0x12, 0x02, 0x40,
  0x48, 0x09, 0x01, 0x00, 0x20, 0x66, 0x09, 0x41, 0x28, 0x24, 0x84, 0x90,
  0x92, 0x22, 0x24, 0x84, 0x90, 0x92, 0x0A, 0x41, 0x48, 0x31, 0x02, 0x00,
  0x1E, 0x10, 0x90, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xA0,
  0x50, 0x48, 0x63, 0xC0, 0x1F, 0x88, 0x12, 0x04, 0x81, 0x40, 0x50, 0x14,
  0x05, 0xFE, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x1E, 0x10,
  0x90, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xA0, 0x50, 0x48,
  0x63, 0xC0, 0x40, 0x12, 0x0A, 0x02, 0x00, 0x1F, 0x88, 0x12, 0x04, 0x81,
  0x40, 0x50, 0x14, 0x05, 0xFE, 0x44, 0x11, 0x08, 0x22, 0x08, 0x81, 0x20,
  0x60, 0x1F, 0x08, 0x24, 0x05, 0x00, 0x40, 0x08, 0x01, 0xC0, 0x0C, 0x00,
  0x80, 0x20, 0x0A, 0x02, 0x41, 0x0F, 0x80, 0xFF, 0xE0, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x40, 0x00, 0x40, 0xD0, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x12,
  0x04, 0x81, 0x20, 0x48, 0x12, 0x08, 0x82, 0x1F, 0x00, 0x80, 0xC0, 0x60,
  0x50, 0x28, 0x24, 0x12, 0x11, 0x08, 0x88, 0x24, 0x14, 0x0A, 0x06, 0x01,
  0x00, 0x80, 0x60, 0x18, 0x06, 0x02, 0x88, 0xA6, 0x29, 0x8A, 0xA4, 0xA5,
  0x29, 0x4C, 0x53, 0x18, 0x86, 0x20, 0x80, 0x20, 0x11, 0x02, 0x10, 0x40,
  0x88, 0x08, 0x80, 0x50, 0x02, 0x00, 0x20, 0x0E, 0x01, 0x10, 0x11, 0x02,
  0x08, 0x40, 0x88, 0x04, 0x80, 0x30, 0x09, 0x02, 0x20, 0x82, 0x20, 0x44,
  0x09, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x00,
  0x1F, 0xF0, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x0F, 0xFC, 0x1F, 0x20, 0x20,
  0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xF8, 0x84, 0x21, 0x08, 0x21, 0x08, 0x41, 0x08, 0x42, 0x10,
  0x42, 0x10, 0xC0, 0x1E, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x40, 0x81, 0x02, 0x04, 0x09, 0xE0, 0x04, 0x06, 0x04, 0x84, 0x44,
  0x12, 0x0A, 0x03, 0x01, 0xFF, 0xC0, 0xA4, 0x1E, 0x90, 0xD0, 0x30, 0x18,
  0x0C, 0x0A, 0x05, 0x06, 0x43, 0x1E, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0xF1, 0x85, 0x82, 0x80, 0xC0, 0x60, 0x50, 0x28, 0x16, 0x12, 0xF0,
  0x3C, 0x42, 0x81, 0x80, 0x80, 0x80, 0x81, 0x82, 0x84, 0x78, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x87, 0xA2, 0x19, 0x02, 0x80, 0xA0, 0x28, 0x12,
  0x04, 0x83, 0x10, 0xC3, 0xD0, 0x1E, 0x61, 0x81, 0x82, 0xFC, 0x80, 0x82,
  0x83, 0x86, 0x78, 0x01, 0xF0, 0x10, 0x02, 0x00, 0x20, 0x02, 0x01, 0xFF,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x08, 0x08, 0x80, 0x48, 0x03, 0x80, 0x18, 0x00, 0x1E, 0x90, 0xD0, 0x30,
  0x18, 0x0C, 0x0A, 0x05, 0x06, 0x43, 0x1E, 0x80, 0x40, 0x48, 0x63, 0xE0,
  0x20, 0x40, 0x40, 0x40, 0x40, 0x5E, 0x61, 0x41, 0x41, 0x81, 0x81, 0x82,
  0x82, 0x82, 0x82, 0x04, 0x08, 0x00, 0x00, 0xF0, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x21, 0x26, 0x38, 0x20, 0x01, 0x00, 0x00, 0x00, 0x7E, 0x02, 0x02,
  0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x84, 0x68, 0x18, 0x08, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0xF1, 0x85, 0x82, 0x81, 0x43, 0x26, 0x12,
  0x19, 0x0C, 0x5A, 0x10, 0x78, 0x88, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x20, 0x20, 0x20, 0x23, 0x24, 0x58, 0x20, 0x5D, 0xD9, 0x94, 0x46, 0x11,
  0x84, 0x62, 0x18, 0x86, 0x22, 0x88, 0xA2, 0x20, 0x5E, 0x61, 0x41, 0x41,
  0x81, 0x81, 0x82, 0x82, 0x82, 0x82, 0x3E, 0x41, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x82, 0x7C, 0x2F, 0x0C, 0x26, 0x09, 0x01, 0x40, 0x50, 0x24,
  0x09, 0x02, 0xA1, 0x27, 0x88, 0x02, 0x00, 0x80, 0x20, 0x00, 0x1E, 0x90,
  0xD0, 0x30, 0x18, 0x0C, 0x0A, 0x05, 0x06, 0x43, 0x1E, 0x80, 0x40, 0x40,
  0x20, 0x10, 0xF3, 0xC7, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x00, 0x1F, 0x08, 0x24, 0x05, 0x00, 0x3E, 0x00, 0x60, 0x08,
  0x02, 0xC1, 0x0F, 0x80, 0x08, 0x08, 0x04, 0x02, 0x0F, 0xF8, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x08, 0x44, 0xC5, 0x81, 0x00, 0x41, 0x81, 0x81, 0x81,
  0x82, 0x82, 0x82, 0x82, 0x86, 0x7A, 0xE1, 0x20, 0x50, 0x28, 0x24, 0x12,
  0x09, 0x09, 0x04, 0x8C, 0x38, 0x00, 0x44, 0x51, 0x14, 0x45, 0x11, 0x84,
  0x62, 0x18, 0x86, 0x21, 0x98, 0x99, 0xC0, 0x08, 0xE3, 0x52, 0xC6, 0x10,
  0x21, 0x04, 0x00, 0x40, 0x84, 0x08, 0xC2, 0x8A, 0xC7, 0x10, 0x20, 0xA0,
  0x50, 0x28, 0x14, 0x12, 0x0A, 0x04, 0x82, 0x43, 0x1E, 0x80, 0x80, 0x48,
  0x63, 0xC0, 0x3E, 0x50, 0x74, 0x08, 0x04, 0x06, 0x02, 0x03, 0x11, 0x04,
  0xF8, 0xA1, 0xE0, 0x07, 0x84, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08,
  0xF8, 0x0C, 0x02, 0x01, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x1E, 0x00,
  0x11, 0x22, 0x22, 0x22, 0x44, 0x44, 0x44, 0x88, 0x88, 0x1E, 0x01, 0x00,
  0x80, 0x40, 0x40, 0x40, 0x40, 0x10, 0x07, 0x86, 0x04, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x10, 0x08, 0x78, 0x00, 0x30, 0x52, 0x18, 0x4A, 0x0C,
};

const GFXglyph IBMPlexMono_ThinItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 14, 12, 5, -14 },
  { 7, 4, 5, 12, 5, -15 },
  { 10, 12, 14, 12, 0, -14 },
  { 31, 10, 18, 12, 1, -16 },
  { 54, 13, 14, 12, 0, -14 },
  { 77, 12, 14, 12, 0, -14 },
  { 98, 1, 5, 12, 7, -15 },
  { 99, 6, 18, 12, 5, -15 },
  { 113, 7, 18, 12, 1, -15 },
  { 129, 10, 10, 12, 1, -11 },
  { 142, 10, 11, 12, 1, -12 },
  { 156, 3, 5, 12, 3, -2 },
  { 158, 6, 1, 12, 3, -7 },
  { 159, 1, 1, 12, 5, -1 },
  { 160, 10, 18, 12, 1, -15 },
  { 183, 9, 14, 12, 2, -14 },
  { 199, 9, 14, 12, 1, -14 },
  { 215, 10, 14, 12, 1, -14 },
  { 233, 10, 14, 12, 1, -14 },
  { 251, 10, 14, 12, 1, -14 },
  { 269, 10, 14, 12, 1, -14 },
  { 287, 8, 14, 12, 2, -14 },
  { 301, 10, 14, 12, 2, -14 },
  { 319, 10, 14, 12, 1, -14 },
  { 337, 9, 14, 12, 2, -14 },
  { 353, 2, 10, 12, 5, -10 },
  { 356, 4, 13, 12, 3, -10 },
  { 363, 9, 11, 12, 2, -12 },
  { 376, 10, 4, 12, 1, -8 },
  { 381, 9, 11, 12, 1, -12 },
  { 394, 8, 14, 12, 3, -14 },
  { 408, 9, 16, 12, 2, -14 },
  { 426, 10, 14, 12, 0, -14 },
  { 444, 10, 14, 12, 1, -14 },
  { 462, 9, 14, 12, 2, -14 },
  { 478, 10, 14, 12, 1, -14 },
  { 496, 11, 14, 12, 1, -14 },
  { 516, 11, 14, 12, 1, -14 },
  { 536, 9, 14, 12, 2, -14 },
  { 552, 11, 14, 12, 1, -14 },
  { 572, 11, 14, 12, 1, -14 },
  { 592, 10, 14, 12, 1, -14 },
  { 610, 11, 14, 12, 1, -14 },
  { 630, 8, 14, 12, 2, -14 },
  { 644, 11, 14, 12, 1, -14 },
  { 664, 11, 14, 12, 1, -14 },
  { 684, 9, 14, 12, 2, -14 },
  { 700, 10, 14, 12, 1, -14 },
  { 718, 9, 18, 12, 2, -14 },
  { 739, 10, 14, 12, 1, -14 },
  { 757, 10, 14, 12, 1, -14 },
  { 775, 11, 14, 12, 2, -14 },
  { 795, 10, 14, 12, 2, -14 },
  { 813, 9, 14, 12, 3, -14 },
  { 829, 10, 14, 12, 2, -14 },
  { 847, 12, 14, 12, 0, -14 },
  { 868, 11, 14, 12, 2, -14 },
  { 888, 12, 14, 12, 0, -14 },
  { 909, 8, 18, 12, 4, -15 },
  { 927, 5, 18, 12, 4, -15 },
  { 939, 7, 18, 12, 1, -15 },
  { 955, 9, 8, 12, 2, -14 },
  { 964, 10, 1, 12, 0, 2 },
  { 966, 2, 3, 12, 5, -15 },
  { 967, 9, 10, 12, 1, -10 },
  { 979, 9, 15, 12, 2, -15 },
  { 996, 8, 10, 12, 2, -10 },
  { 1006, 10, 15, 12, 1, -15 },
  { 1025, 8, 10, 12, 2, -10 },
  { 1035, 12, 19, 12, 0, -15 },
  { 1064, 9, 14, 12, 1, -10 },
  { 1080, 8, 15, 12, 2, -15 },
  { 1095, 8, 14, 12, 2, -14 },
  { 1109, 8, 18, 12, 2, -14 },
  { 1127, 9, 15, 12, 2, -15 },
  { 1144, 8, 15, 12, 2, -15 },
  { 1159, 10, 10, 12, 1, -10 },
  { 1172, 8, 10, 12, 2, -10 },
  { 1182, 8, 10, 12, 2, -10 },
  { 1192, 10, 14, 12, 1, -10 },
  { 1210, 9, 14, 12, 1, -10 },
  { 1226, 10, 10, 12, 2, -10 },
  { 1239, 10, 10, 12, 1, -10 },
  { 1252, 9, 14, 12, 2, -14 },
  { 1268, 8, 10, 12, 2, -10 },
  { 1278, 9, 10, 12, 2, -10 },
  { 1290, 10, 10, 12, 1, -10 },
  { 1303, 12, 10, 12, 0, -10 },
  { 1318, 9, 14, 12, 1, -10 },
  { 1334, 10, 10, 12, 1, -10 },
  { 1347, 9, 18, 12, 2, -15 },
  { 1368, 4, 18, 12, 4, -15 },
  { 1377, 9, 18, 12, 1, -15 },
  { 1398, 10, 4, 12, 1, -8 },
};

const GFXfont IBMPlexMono_ThinItalic20pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic20pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _IBMPLEXMONO_THINITALIC20PT7B_H_
