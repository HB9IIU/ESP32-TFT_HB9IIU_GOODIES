#ifndef _IBMPLEXMONO_THINITALIC45PT7B_H_
#define _IBMPLEXMONO_THINITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x30, 0x40,
  0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x1C, 0x38, 0x00, 0x21, 0xB0, 0x90, 0x48, 0x24, 0x12, 0x09,
  0x0D, 0x84, 0x82, 0x41, 0x20, 0x80, 0x00, 0x02, 0x02, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x10, 0x10, 0x00, 0x02, 0x02, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x10, 0x10, 0x00, 0x02, 0x02, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x10, 0x10,
  0x00, 0x02, 0x04, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x10, 0x10, 0x00, 0x02,
  0x02, 0x00, 0x00, 0x80, 0x80, 0x00, 0x10, 0x10, 0x00, 0x02, 0x02, 0x00,
  0x00, 0x80, 0x80, 0x00, 0x10, 0x10, 0x00, 0x02, 0x02, 0x00, 0x00, 0x80,
  0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x02, 0x02, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x10, 0x10, 0x00, 0x02, 0x06, 0x00, 0x00, 0x80, 0x80, 0x00, 0x10, 0x10,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x80, 0x80, 0x00, 0x10, 0x10, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x07, 0xF8, 0x00, 0x70, 0x8E, 0x01,
  0x81, 0x06, 0x04, 0x02, 0x06, 0x18, 0x08, 0x04, 0x20, 0x10, 0x00, 0x40,
  0x20, 0x00, 0x80, 0x40, 0x02, 0x00, 0x80, 0x02, 0x01, 0x00, 0x04, 0x04,
  0x00, 0x08, 0x08, 0x00, 0x18, 0x10, 0x00, 0x18, 0x20, 0x00, 0x18, 0x40,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x04, 0x70, 0x00, 0x08, 0x30,
  0x00, 0x10, 0x30, 0x00, 0x20, 0x20, 0x00, 0x40, 0x60, 0x01, 0x00, 0x40,
  0x02, 0x00, 0x80, 0x04, 0x01, 0x00, 0x08, 0x02, 0x00, 0x10, 0x08, 0x80,
  0x20, 0x11, 0x00, 0x80, 0x61, 0x01, 0x00, 0x81, 0x82, 0x06, 0x01, 0xC4,
  0x38, 0x00, 0x7F, 0x80, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x02,
  0x0C, 0x00, 0x10, 0x10, 0x10, 0x00, 0x80, 0x80, 0x20, 0x04, 0x04, 0x00,
  0x80, 0x20, 0x10, 0x02, 0x00, 0x80, 0x40, 0x08, 0x04, 0x01, 0x00, 0x20,
  0x20, 0x04, 0x00, 0x81, 0x00, 0x20, 0x02, 0x04, 0x00, 0x40, 0x10, 0x20,
  0x01, 0x00, 0x41, 0x00, 0x04, 0x02, 0x08, 0x00, 0x0C, 0x30, 0x60, 0x00,
  0x1F, 0x81, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x03, 0xE0, 0x00, 0x08, 0x30, 0x40, 0x00, 0x41,
  0x00, 0x80, 0x02, 0x04, 0x02, 0x00, 0x08, 0x20, 0x04, 0x00, 0x40, 0x80,
  0x10, 0x02, 0x04, 0x00, 0x40, 0x10, 0x10, 0x01, 0x00, 0x40, 0x40, 0x08,
  0x02, 0x01, 0x00, 0x20, 0x10, 0x04, 0x00, 0x80, 0x80, 0x10, 0x04, 0x04,
  0x00, 0x20, 0x30, 0x10, 0x00, 0x41, 0x80, 0x80, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x30, 0x30, 0x00, 0x18, 0x06, 0x00, 0x04, 0x00, 0x80,
  0x02, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x04,
  0x00, 0x80, 0x01, 0x00, 0x20, 0x00, 0x20, 0x10, 0x00, 0x08, 0x08, 0x00,
  0x0F, 0x0C, 0x00, 0x0C, 0x2C, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x01, 0x00,
  0x01, 0x00, 0x40, 0x00, 0x80, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x80, 0x01, 0x00, 0x20, 0x00, 0x40, 0x28,
  0x00, 0x28, 0x0E, 0x00, 0x0B, 0x04, 0x80, 0x04, 0x41, 0x10, 0x01, 0x08,
  0x86, 0x00, 0x82, 0x60, 0xC0, 0xC0, 0x50, 0x0F, 0xC0, 0x18, 0x00, 0x29,
  0x24, 0x94, 0x92, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0xC0,
  0x10, 0x06, 0x70, 0x20, 0xF0, 0x1C, 0x8E, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x0A, 0x00, 0x00, 0x22, 0x00, 0x00, 0x84, 0x00, 0x02, 0x04,
  0x00, 0x08, 0x08, 0x00, 0x20, 0x08, 0x00, 0xC0, 0x08, 0x03, 0x00, 0x10,
  0x0C, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x31, 0x86, 0x10,
  0xC2, 0x08, 0x61, 0x04, 0x20, 0xFF, 0xF0, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0x03, 0x80, 0x10, 0x03, 0x00, 0x80, 0x04, 0x04, 0x00, 0x08, 0x20,
  0x00, 0x20, 0x80, 0x00, 0x84, 0x00, 0x01, 0x10, 0x00, 0x04, 0x80, 0x00,
  0x12, 0x00, 0x00, 0x48, 0x00, 0x01, 0x20, 0x00, 0x05, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x50, 0x00, 0x02, 0x40, 0x30, 0x09, 0x00, 0xC0, 0x24, 0x00,
  0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x48, 0x00, 0x01,
  0x20, 0x00, 0x04, 0x80, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x04, 0x10,
  0x00, 0x10, 0x40, 0x00, 0x80, 0x80, 0x04, 0x01, 0x00, 0x20, 0x03, 0x03,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x28, 0x00, 0x06, 0x40,
  0x00, 0x62, 0x00, 0x04, 0x10, 0x00, 0xC1, 0x00, 0x0C, 0x08, 0x00, 0x80,
  0x40, 0x08, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0x81, 0x80, 0x18, 0x01, 0x00, 0x80,
  0x02, 0x06, 0x00, 0x0C, 0x10, 0x00, 0x10, 0x80, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0x01, 0x80,
  0x30, 0x01, 0x01, 0x80, 0x02, 0x04, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x80,
  0x00, 0x41, 0x00, 0x03, 0x02, 0x00, 0x18, 0x07, 0x01, 0x80, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x28, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x40, 0x00, 0x04, 0x80, 0x00, 0x11, 0x00, 0x00, 0x42, 0x00, 0x01, 0x04,
  0x00, 0x04, 0x10, 0x00, 0x10, 0x20, 0x00, 0x60, 0x40, 0x00, 0x80, 0x80,
  0x02, 0x01, 0x00, 0x08, 0x02, 0x00, 0x20, 0x08, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x20, 0x08, 0x00, 0x40, 0x30, 0x00, 0x80, 0x40, 0x01, 0x01, 0x00,
  0x04, 0x04, 0x00, 0x08, 0x10, 0x00, 0x10, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x03, 0xFF, 0xFC, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x43, 0xF8, 0x01, 0x30, 0x38,
  0x07, 0x00, 0x30, 0x10, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x20, 0x00, 0x10,
  0xC0, 0x00, 0x81, 0x80, 0x04, 0x01, 0x80, 0xE0, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x43, 0xF8, 0x09, 0x80, 0xC2, 0xC0,
  0x04, 0x50, 0x00, 0x5C, 0x00, 0x0B, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x50, 0x00,
  0x0A, 0x00, 0x01, 0x40, 0x00, 0x44, 0x00, 0x10, 0xC0, 0x04, 0x06, 0x07,
  0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFA, 0x00, 0x00, 0x50, 0x00, 0x04, 0x80,
  0x00, 0x24, 0x00, 0x02, 0x20, 0x00, 0x21, 0x00, 0x01, 0x10, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0x01, 0x80, 0x30, 0x01, 0x01, 0x00, 0x02,
  0x0C, 0x00, 0x0C, 0x20, 0x00, 0x10, 0x80, 0x00, 0x46, 0x00, 0x01, 0x10,
  0x00, 0x04, 0x40, 0x00, 0x31, 0x00, 0x00, 0x82, 0x00, 0x02, 0x08, 0x00,
  0x10, 0x10, 0x00, 0x80, 0x30, 0x1C, 0x00, 0x3F, 0x80, 0x07, 0x01, 0x80,
  0x60, 0x01, 0x03, 0x00, 0x02, 0x18, 0x00, 0x0C, 0x40, 0x00, 0x12, 0x00,
  0x00, 0x48, 0x00, 0x01, 0x20, 0x00, 0x04, 0x80, 0x00, 0x12, 0x00, 0x00,
  0x48, 0x00, 0x01, 0x20, 0x00, 0x08, 0x80, 0x00, 0x61, 0x00, 0x03, 0x02,
  0x00, 0x18, 0x06, 0x01, 0x80, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xC0,
  0x60, 0x20, 0x02, 0x08, 0x00, 0x22, 0x00, 0x04, 0x80, 0x00, 0x50, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x32, 0x00, 0x0A, 0x20, 0x02,
  0x43, 0x03, 0x90, 0x1F, 0xC2, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x38, 0x70, 0x01, 0xC0, 0x70,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03,
  0x01, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x02,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x03, 0xF8, 0x06, 0x03, 0x04, 0x00, 0x44, 0x00, 0x34,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x70, 0x03, 0xC0, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00,
  0x3F, 0x00, 0x0C, 0x0C, 0x01, 0x00, 0x60, 0x20, 0x02, 0x04, 0x00, 0x10,
  0x80, 0x01, 0x08, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x11, 0x00, 0x01,
  0x20, 0x1F, 0x12, 0x06, 0x09, 0x20, 0x40, 0x54, 0x08, 0x02, 0x40, 0x80,
  0x24, 0x10, 0x02, 0x41, 0x00, 0x24, 0x10, 0x02, 0x42, 0x00, 0x28, 0x20,
  0x04, 0x82, 0x00, 0x48, 0x20, 0x04, 0x82, 0x00, 0x48, 0x20, 0x0C, 0x82,
  0x01, 0x48, 0x10, 0x18, 0x81, 0x86, 0x88, 0x07, 0xC8, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x80, 0x00, 0x05, 0x00, 0x00, 0x12, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x88, 0x00, 0x01, 0x08, 0x00, 0x04, 0x10, 0x00, 0x08, 0x20, 0x00, 0x20,
  0x40, 0x00, 0x40, 0x80, 0x01, 0x01, 0x00, 0x02, 0x01, 0x00, 0x08, 0x02,
  0x00, 0x10, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x20, 0x10, 0x00, 0x40, 0x3F, 0xFF, 0x80, 0x80, 0x01, 0x01,
  0x00, 0x02, 0x04, 0x00, 0x04, 0x08, 0x00, 0x04, 0x20, 0x00, 0x08, 0x40,
  0x00, 0x11, 0x00, 0x00, 0x22, 0x00, 0x00, 0x48, 0x00, 0x00, 0xB0, 0x00,
  0x00, 0x80, 0x07, 0xFF, 0x80, 0x20, 0x03, 0x03, 0x00, 0x04, 0x10, 0x00,
  0x20, 0x80, 0x00, 0x84, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x01, 0x10,
  0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x02,
  0x08, 0x00, 0x30, 0x80, 0x02, 0x07, 0xFF, 0xE0, 0x20, 0x01, 0xC1, 0x00,
  0x03, 0x08, 0x00, 0x08, 0x40, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x09,
  0x00, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x01, 0x20, 0x00,
  0x09, 0x00, 0x00, 0x88, 0x00, 0x0C, 0x40, 0x01, 0xC3, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x06, 0x06, 0x00, 0x40, 0x08, 0x04, 0x00, 0x20, 0x40,
  0x01, 0x04, 0x00, 0x04, 0x20, 0x00, 0x22, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x10, 0x80,
  0x01, 0x84, 0x00, 0x08, 0x10, 0x00, 0x80, 0xC0, 0x08, 0x01, 0x81, 0x80,
  0x03, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x10, 0x03, 0x00, 0x40, 0x02, 0x01,
  0x00, 0x04, 0x08, 0x00, 0x18, 0x20, 0x00, 0x20, 0x80, 0x00, 0x82, 0x00,
  0x01, 0x08, 0x00, 0x04, 0x20, 0x00, 0x11, 0x00, 0x00, 0x44, 0x00, 0x01,
  0x10, 0x00, 0x04, 0x40, 0x00, 0x11, 0x00, 0x00, 0x44, 0x00, 0x03, 0x20,
  0x00, 0x08, 0x80, 0x00, 0x22, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00,
  0x19, 0x80, 0x00, 0x44, 0x00, 0x01, 0x10, 0x00, 0x08, 0x40, 0x00, 0x21,
  0x00, 0x01, 0x04, 0x00, 0x0C, 0x20, 0x00, 0x60, 0x80, 0x03, 0x02, 0x00,
  0x30, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x06,
  0x06, 0x00, 0xC0, 0x08, 0x0C, 0x00, 0x20, 0x40, 0x01, 0x04, 0x00, 0x04,
  0x40, 0x00, 0x22, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x0F, 0xFD, 0x00, 0x00,
  0x48, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80,
  0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x10, 0x80, 0x01, 0x84, 0x00, 0x14,
  0x30, 0x00, 0xA0, 0xC0, 0x0A, 0x03, 0x81, 0x90, 0x07, 0xF0, 0x00, 0x02,
  0x00, 0x01, 0x04, 0x00, 0x01, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04,
  0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08,
  0x00, 0x04, 0x08, 0x00, 0x04, 0x08, 0x00, 0x04, 0x08, 0x00, 0x04, 0x08,
  0x00, 0x04, 0x10, 0x00, 0x04, 0x10, 0x00, 0x08, 0x1F, 0xFF, 0xF8, 0x10,
  0x00, 0x08, 0x10, 0x00, 0x08, 0x10, 0x00, 0x08, 0x20, 0x00, 0x08, 0x20,
  0x00, 0x10, 0x20, 0x00, 0x10, 0x20, 0x00, 0x10, 0x20, 0x00, 0x10, 0x20,
  0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x20, 0x40, 0x00, 0x20, 0x40,
  0x00, 0x20, 0x40, 0x00, 0x20, 0xC0, 0x00, 0x20, 0x07, 0xFF, 0xFF, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x20, 0x00, 0x40, 0x80, 0x06, 0x04, 0x00, 0x20, 0x10, 0x02, 0x00,
  0x60, 0x60, 0x01, 0xFC, 0x00, 0x04, 0x00, 0x01, 0x82, 0x00, 0x01, 0x01,
  0x00, 0x01, 0x00, 0x80, 0x01, 0x00, 0x80, 0x01, 0x00, 0x40, 0x01, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x03, 0x00, 0x08, 0x03, 0x00, 0x04, 0x03, 0x00,
  0x04, 0x02, 0x00, 0x02, 0x02, 0x00, 0x01, 0x02, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x42, 0x80, 0x00, 0x22, 0x20, 0x00, 0x22, 0x10, 0x00, 0x12, 0x04,
  0x00, 0x0E, 0x02, 0x00, 0x06, 0x00, 0x80, 0x02, 0x00, 0x40, 0x03, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x02, 0x00, 0x40, 0x01, 0x00, 0x20,
  0x00, 0x40, 0x10, 0x00, 0x20, 0x18, 0x00, 0x08, 0x08, 0x00, 0x04, 0x04,
  0x00, 0x01, 0x02, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xFE,
  0x06, 0x00, 0x01, 0x06, 0x00, 0x03, 0x06, 0x00, 0x05, 0x09, 0x00, 0x05,
  0x09, 0x00, 0x09, 0x09, 0x00, 0x11, 0x09, 0x00, 0x12, 0x08, 0x80, 0x22,
  0x08, 0x80, 0x22, 0x10, 0x80, 0x42, 0x10, 0x40, 0x82, 0x10, 0x40, 0x82,
  0x10, 0x41, 0x04, 0x10, 0x42, 0x04, 0x10, 0x22, 0x04, 0x20, 0x24, 0x04,
  0x20, 0x24, 0x04, 0x20, 0x18, 0x04, 0x20, 0x10, 0x08, 0x20, 0x10, 0x08,
  0x20, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x08,
  0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0x80, 0x00, 0x10,
  0x80, 0x00, 0x10, 0x80, 0x00, 0x10, 0x80, 0x00, 0x20, 0x02, 0x00, 0x01,
  0x05, 0x00, 0x01, 0x05, 0x00, 0x02, 0x05, 0x00, 0x02, 0x04, 0x80, 0x02,
  0x04, 0x80, 0x02, 0x04, 0x80, 0x02, 0x08, 0x40, 0x02, 0x08, 0x40, 0x04,
  0x08, 0x20, 0x04, 0x08, 0x20, 0x04, 0x08, 0x20, 0x04, 0x08, 0x10, 0x04,
  0x10, 0x10, 0x04, 0x10, 0x10, 0x08, 0x10, 0x08, 0x08, 0x10, 0x08, 0x08,
  0x10, 0x08, 0x08, 0x10, 0x04, 0x08, 0x20, 0x04, 0x08, 0x20, 0x04, 0x10,
  0x20, 0x02, 0x10, 0x20, 0x02, 0x10, 0x20, 0x01, 0x10, 0x20, 0x01, 0x10,
  0x40, 0x01, 0x10, 0x40, 0x00, 0xA0, 0x40, 0x00, 0xA0, 0x40, 0x00, 0xA0,
  0x40, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x00, 0x3F, 0x80, 0x03, 0x03, 0x80,
  0x10, 0x03, 0x00, 0x80, 0x04, 0x04, 0x00, 0x08, 0x20, 0x00, 0x20, 0x80,
  0x00, 0x84, 0x00, 0x01, 0x10, 0x00, 0x04, 0x80, 0x00, 0x12, 0x00, 0x00,
  0x48, 0x00, 0x01, 0x20, 0x00, 0x05, 0x00, 0x00, 0x14, 0x00, 0x00, 0x50,
  0x00, 0x02, 0x40, 0x00, 0x09, 0x00, 0x00, 0x24, 0x00, 0x00, 0xA0, 0x00,
  0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x48, 0x00, 0x01, 0x20, 0x00, 0x04,
  0x80, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40,
  0x00, 0x80, 0x80, 0x04, 0x01, 0x00, 0x20, 0x03, 0x03, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x08, 0x00, 0x60, 0x10, 0x00, 0x20, 0x20, 0x00,
  0x20, 0x80, 0x00, 0x41, 0x00, 0x00, 0x42, 0x00, 0x00, 0x84, 0x00, 0x01,
  0x08, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x10, 0x80, 0x00, 0x21,
  0x00, 0x00, 0xC2, 0x00, 0x01, 0x04, 0x00, 0x04, 0x08, 0x00, 0x30, 0x3F,
  0xFF, 0x80, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x03,
  0x80, 0x10, 0x03, 0x00, 0x80, 0x04, 0x04, 0x00, 0x08, 0x20, 0x00, 0x20,
  0x80, 0x00, 0x84, 0x00, 0x01, 0x10, 0x00, 0x04, 0x80, 0x00, 0x12, 0x00,
  0x00, 0x48, 0x00, 0x01, 0x20, 0x00, 0x05, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x50, 0x00, 0x02, 0x40, 0x00, 0x09, 0x00, 0x00, 0x24, 0x00, 0x00, 0xA0,
  0x00, 0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x48, 0x00, 0x01, 0x20, 0x00,
  0x04, 0x80, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x04, 0x10, 0x00, 0x10,
  0x40, 0x00, 0x80, 0x80, 0x04, 0x01, 0x00, 0x20, 0x03, 0x03, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x01, 0x00, 0x08, 0x0C, 0x00, 0x10,
  0x40, 0x00, 0x22, 0x00, 0x00, 0xD0, 0x00, 0x01, 0x80, 0x07, 0xFF, 0xE0,
  0x08, 0x00, 0x60, 0x10, 0x00, 0x20, 0x20, 0x00, 0x20, 0x80, 0x00, 0x41,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x84, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10,
  0x00, 0x08, 0x40, 0x00, 0x10, 0x80, 0x00, 0x21, 0x00, 0x00, 0xC2, 0x00,
  0x01, 0x04, 0x00, 0x04, 0x08, 0x00, 0x30, 0x3F, 0xFF, 0x80, 0x40, 0x20,
  0x00, 0x80, 0x40, 0x01, 0x00, 0x40, 0x02, 0x00, 0x80, 0x0C, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x20, 0x01, 0x00, 0x40, 0x02, 0x00, 0x80, 0x02, 0x01,
  0x00, 0x04, 0x06, 0x00, 0x04, 0x08, 0x00, 0x08, 0x10, 0x00, 0x08, 0x20,
  0x00, 0x18, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0x80, 0x60, 0x0C, 0x00, 0x30,
  0x20, 0x00, 0x10, 0xC0, 0x00, 0x21, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x44, 0x00, 0x00, 0x88,
  0x00, 0x03, 0x08, 0x00, 0x04, 0x0C, 0x00, 0x30, 0x06, 0x01, 0xC0, 0x03,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x04, 0x40,
  0x00, 0x11, 0x00, 0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00,
  0x21, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x10, 0x80, 0x00, 0x42,
  0x00, 0x01, 0x08, 0x00, 0x04, 0x20, 0x00, 0x11, 0x00, 0x00, 0x44, 0x00,
  0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x02,
  0x20, 0x00, 0x08, 0x80, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20,
  0x00, 0x10, 0x80, 0x00, 0x82, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00,
  0x40, 0xC0, 0x03, 0x01, 0x00, 0x18, 0x03, 0x01, 0xC0, 0x03, 0xFC, 0x00,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x28, 0x00, 0x01, 0xA0, 0x00, 0x04, 0x40,
  0x00, 0x31, 0x00, 0x00, 0x84, 0x00, 0x06, 0x10, 0x00, 0x10, 0x40, 0x00,
  0xC1, 0x00, 0x02, 0x06, 0x00, 0x18, 0x08, 0x00, 0x40, 0x20, 0x03, 0x00,
  0x80, 0x08, 0x02, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x00, 0x40,
  0x20, 0x01, 0x01, 0x80, 0x04, 0x04, 0x00, 0x10, 0x30, 0x00, 0x40, 0x80,
  0x01, 0x06, 0x00, 0x02, 0x10, 0x00, 0x08, 0xC0, 0x00, 0x22, 0x00, 0x00,
  0x98, 0x00, 0x02, 0x40, 0x00, 0x0B, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x20, 0x00, 0x02, 0x20, 0x00, 0x02, 0x20,
  0x00, 0x02, 0x20, 0x00, 0x04, 0x40, 0x00, 0x04, 0x40, 0x00, 0x04, 0x40,
  0x00, 0x04, 0x40, 0x00, 0x08, 0x40, 0x30, 0x08, 0x40, 0x30, 0x08, 0x40,
  0x50, 0x08, 0x40, 0x50, 0x10, 0x40, 0x50, 0x10, 0x40, 0x90, 0x10, 0x40,
  0x88, 0x10, 0x41, 0x08, 0x20, 0x41, 0x08, 0x20, 0x42, 0x08, 0x20, 0x82,
  0x08, 0x40, 0x84, 0x08, 0x40, 0x84, 0x08, 0x40, 0x88, 0x04, 0x40, 0x88,
  0x04, 0x80, 0x90, 0x04, 0x80, 0x90, 0x04, 0x80, 0x90, 0x04, 0x80, 0xA0,
  0x05, 0x00, 0xA0, 0x05, 0x00, 0xC0, 0x05, 0x00, 0xC0, 0x03, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x10, 0x00, 0x06, 0x01, 0x00, 0x00, 0xC0, 0x08, 0x00,
  0x08, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x40, 0x04, 0x00,
  0x02, 0x00, 0x80, 0x00, 0x20, 0x18, 0x00, 0x01, 0x01, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x00, 0x84, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x50, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00,
  0x90, 0x00, 0x00, 0x10, 0x80, 0x00, 0x02, 0x08, 0x00, 0x00, 0x40, 0x40,
  0x00, 0x0C, 0x04, 0x00, 0x00, 0x80, 0x20, 0x00, 0x10, 0x02, 0x00, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x08, 0x01, 0x80, 0x00,
  0x80, 0x30, 0x00, 0x04, 0x02, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x02, 0x00,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x40, 0x00, 0x04, 0x40, 0x00, 0x08,
  0x20, 0x00, 0x10, 0x20, 0x00, 0x30, 0x10, 0x00, 0x20, 0x10, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x04, 0x02, 0x00, 0x04, 0x06, 0x00,
  0x02, 0x04, 0x00, 0x02, 0x08, 0x00, 0x01, 0x10, 0x00, 0x01, 0x20, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x81, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xC0, 0x80, 0x20, 0x08, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x20, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x01, 0xFF, 0xC0,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02,
  0x03, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xA0, 0x00, 0x0D, 0x00, 0x00,
  0x44, 0x00, 0x04, 0x20, 0x00, 0x40, 0x80, 0x04, 0x04, 0x00, 0x20, 0x10,
  0x02, 0x00, 0x80, 0x20, 0x04, 0x02, 0x00, 0x10, 0x30, 0x00, 0x81, 0x00,
  0x02, 0x10, 0x00, 0x11, 0x00, 0x00, 0x58, 0x00, 0x02, 0x80, 0x00, 0x08,
  0xFF, 0xFF, 0xF8, 0x82, 0x10, 0x42, 0x08, 0x20, 0x00, 0xFC, 0x00, 0x30,
  0x31, 0x04, 0x00, 0x90, 0x80, 0x05, 0x10, 0x00, 0x51, 0x00, 0x03, 0x20,
  0x00, 0x22, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x24,
  0x00, 0x02, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x04,
  0x80, 0x00, 0x48, 0x00, 0x0C, 0x80, 0x00, 0x84, 0x00, 0x18, 0x40, 0x02,
  0x82, 0x00, 0x28, 0x30, 0x04, 0x81, 0x81, 0x8F, 0x07, 0xE0, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x87, 0xE0,
  0x11, 0x81, 0x81, 0x20, 0x0C, 0x14, 0x00, 0x41, 0x80, 0x02, 0x18, 0x00,
  0x21, 0x00, 0x01, 0x30, 0x00, 0x12, 0x00, 0x01, 0x20, 0x00, 0x12, 0x00,
  0x01, 0x20, 0x00, 0x12, 0x00, 0x01, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40,
  0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x4C, 0x00, 0x04, 0xC0, 0x00, 0x8C,
  0x00, 0x08, 0xA0, 0x01, 0x09, 0x00, 0x20, 0x8C, 0x0C, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0xC0, 0xC0, 0xC0, 0x08, 0x60, 0x02, 0x30, 0x00, 0x48,
  0x00, 0x14, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x0E, 0x00, 0x02, 0x40, 0x01, 0x10,
  0x00, 0x82, 0x00, 0x40, 0x60, 0x60, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x03, 0xF0,
  0x40, 0x30, 0x31, 0x01, 0x00, 0x24, 0x08, 0x00, 0x50, 0x40, 0x01, 0x41,
  0x00, 0x03, 0x08, 0x00, 0x08, 0x20, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00,
  0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x22, 0x00, 0x01, 0x08, 0x00, 0x04,
  0x20, 0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x0C, 0x20,
  0x00, 0x20, 0x40, 0x01, 0x81, 0x00, 0x0A, 0x02, 0x00, 0x28, 0x0C, 0x01,
  0x20, 0x18, 0x18, 0x80, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x60, 0x30,
  0x10, 0x03, 0x04, 0x00, 0x21, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x0A,
  0x00, 0x02, 0x40, 0x00, 0x50, 0x00, 0x12, 0x00, 0x04, 0x40, 0x07, 0x08,
  0x0F, 0x01, 0xFC, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x01, 0x40, 0x00, 0x44, 0x00, 0x10, 0x80, 0x06, 0x08,
  0x01, 0x80, 0xC0, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x80, 0x10, 0x00, 0x04, 0x01, 0x00,
  0x00, 0x20, 0x20, 0x00, 0x01, 0x02, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x0C, 0x0C, 0x40, 0x80, 0x12, 0x08, 0x00,
  0x50, 0x80, 0x02, 0x84, 0x00, 0x0C, 0x40, 0x00, 0x42, 0x00, 0x02, 0x20,
  0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x24, 0x00, 0x02,
  0x20, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00,
  0x03, 0x10, 0x00, 0x10, 0x40, 0x01, 0x82, 0x00, 0x14, 0x08, 0x00, 0xA0,
  0x60, 0x09, 0x01, 0x81, 0x88, 0x03, 0xF0, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x82, 0x00, 0x08, 0x08,
  0x00, 0x80, 0x30, 0x18, 0x00, 0x7F, 0x00, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x1F, 0x80, 0x98, 0x18, 0x28, 0x02, 0x14,
  0x00, 0x45, 0x00, 0x11, 0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00,
  0x12, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12, 0x00, 0x08,
  0x80, 0x02, 0x40, 0x00, 0x90, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0x40,
  0x01, 0x10, 0x00, 0x48, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x0C, 0x08, 0x02, 0x01, 0x01, 0x80, 0x20, 0x60, 0x04, 0x10, 0x00, 0x8C,
  0x00, 0x22, 0x00, 0x05, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04,
  0x08, 0x01, 0x01, 0x00, 0x40, 0x30, 0x10, 0x06, 0x04, 0x00, 0xC2, 0x00,
  0x18, 0x80, 0x03, 0x20, 0x00, 0x28, 0x00, 0x06, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0xFC,
  0x01, 0x1C, 0x18, 0x04, 0x80, 0x10, 0x14, 0x00, 0x40, 0x60, 0x00, 0x81,
  0x80, 0x02, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x40, 0x80, 0x01, 0x02, 0x00,
  0x08, 0x08, 0x00, 0x40, 0x20, 0x06, 0x01, 0x00, 0x60, 0x04, 0x1E, 0x00,
  0x10, 0xC0, 0x00, 0x41, 0x00, 0x01, 0x02, 0x00, 0x04, 0x0C, 0x00, 0xE0,
  0x10, 0x04, 0x80, 0x20, 0x22, 0x00, 0x81, 0x08, 0x01, 0x08, 0x20, 0x04,
  0x40, 0x80, 0x0A, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xC0, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x01, 0x08,
  0x02, 0x08, 0x0C, 0x08, 0x10, 0x10, 0x60, 0x10, 0x80, 0x13, 0x00, 0x14,
  0x00, 0x18, 0x00, 0x00, 0xF0, 0x7C, 0x16, 0x11, 0x0C, 0x50, 0x24, 0x08,
  0xC0, 0x30, 0x11, 0x80, 0x40, 0x22, 0x00, 0x80, 0x44, 0x01, 0x00, 0x88,
  0x04, 0x01, 0x20, 0x08, 0x02, 0x40, 0x10, 0x04, 0x80, 0x20, 0x09, 0x00,
  0x40, 0x22, 0x00, 0x80, 0x44, 0x02, 0x00, 0x90, 0x04, 0x01, 0x20, 0x08,
  0x02, 0x40, 0x10, 0x04, 0x80, 0x20, 0x11, 0x00, 0x40, 0x22, 0x01, 0x00,
  0x48, 0x02, 0x00, 0x90, 0x04, 0x01, 0x20, 0x08, 0x02, 0x40, 0x10, 0x08,
  0x00, 0x7E, 0x02, 0x60, 0x60, 0xA0, 0x08, 0x50, 0x01, 0x14, 0x00, 0x46,
  0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0x48, 0x00, 0x12, 0x00,
  0x04, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x22, 0x00, 0x09, 0x00, 0x02,
  0x40, 0x00, 0x90, 0x00, 0x24, 0x00, 0x09, 0x00, 0x04, 0x40, 0x01, 0x20,
  0x00, 0x48, 0x00, 0x12, 0x00, 0x04, 0x00, 0xFC, 0x00, 0x60, 0x60, 0x30,
  0x02, 0x0C, 0x00, 0x21, 0x00, 0x04, 0x40, 0x00, 0x58, 0x00, 0x0A, 0x00,
  0x01, 0x40, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x50, 0x00,
  0x0A, 0x00, 0x03, 0x40, 0x00, 0x44, 0x00, 0x10, 0x80, 0x06, 0x08, 0x01,
  0x80, 0xC0, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x11, 0x81, 0x80,
  0x48, 0x03, 0x01, 0x40, 0x04, 0x06, 0x00, 0x08, 0x18, 0x00, 0x20, 0x40,
  0x00, 0x43, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20, 0x00, 0x10, 0x80, 0x00,
  0x42, 0x00, 0x01, 0x08, 0x00, 0x04, 0x40, 0x00, 0x21, 0x00, 0x00, 0x84,
  0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x41, 0x00, 0x01, 0x0C, 0x00,
  0x08, 0x30, 0x00, 0x20, 0xA0, 0x01, 0x02, 0x40, 0x08, 0x08, 0xC0, 0xC0,
  0x40, 0xFC, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x30, 0x31, 0x04, 0x00, 0x90, 0x80, 0x05, 0x10,
  0x00, 0x51, 0x00, 0x03, 0x20, 0x00, 0x22, 0x00, 0x02, 0x40, 0x00, 0x24,
  0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x80, 0x00, 0x48, 0x00, 0x04,
  0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x0C, 0x80, 0x00,
  0x84, 0x00, 0x18, 0x40, 0x02, 0x82, 0x00, 0x28, 0x30, 0x04, 0x81, 0x81,
  0x88, 0x07, 0xE1, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0xFF, 0x87, 0xFC, 0x02, 0x20, 0x00, 0x0B, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x18, 0x06, 0x01, 0x00, 0x08,
  0x10, 0x00, 0x21, 0x00, 0x00, 0x88, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x48, 0x00, 0x02, 0x20,
  0x00, 0x20, 0x80, 0x02, 0x03, 0x80, 0x60, 0x03, 0xFC, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x04, 0x01, 0x00, 0x60, 0x04, 0x02, 0x00, 0x20, 0x30,
  0x00, 0x81, 0x00, 0x02, 0x18, 0x00, 0x09, 0x80, 0x00, 0x28, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x48, 0x00, 0x12, 0x00, 0x04, 0x80, 0x02, 0x20,
  0x00, 0x90, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x90, 0x00,
  0x44, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12,
  0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00, 0x62, 0x00, 0x28, 0x80,
  0x12, 0x10, 0x05, 0x06, 0x06, 0x40, 0x7E, 0x00, 0xFE, 0x00, 0x20, 0x40,
  0x02, 0x04, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x10, 0x40, 0x01, 0x04,
  0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x02, 0x08, 0x00, 0x20,
  0x80, 0x02, 0x08, 0x00, 0x40, 0x80, 0x04, 0x10, 0x00, 0x81, 0x00, 0x08,
  0x10, 0x01, 0x01, 0x00, 0x20, 0x10, 0x04, 0x01, 0x00, 0x80, 0x10, 0x30,
  0x02, 0x1C, 0x00, 0x1F, 0x00, 0x00, 0x10, 0x04, 0x08, 0x40, 0x10, 0x11,
  0x00, 0x80, 0x44, 0x02, 0x01, 0x10, 0x08, 0x04, 0x80, 0x20, 0x12, 0x00,
  0x80, 0x48, 0x02, 0x01, 0x20, 0x10, 0x04, 0x80, 0x40, 0x12, 0x01, 0x00,
  0x50, 0x04, 0x01, 0x40, 0x10, 0x05, 0x00, 0x40, 0x14, 0x02, 0x00, 0x50,
  0x08, 0x01, 0x40, 0x20, 0x0A, 0x00, 0x80, 0x28, 0x06, 0x00, 0xA0, 0x18,
  0x04, 0x80, 0xA0, 0x31, 0x02, 0x80, 0x86, 0x31, 0x0C, 0x0F, 0x83, 0xC0,
  0x00, 0xE0, 0x1E, 0x01, 0x90, 0x30, 0x83, 0x04, 0x20, 0x26, 0x02, 0x10,
  0x14, 0x00, 0x90, 0x08, 0x00, 0x50, 0x04, 0x00, 0x28, 0x02, 0x00, 0x14,
  0x01, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x40, 0x0C, 0x00, 0x20, 0x0A, 0x00, 0x10,
  0x05, 0x00, 0x08, 0x04, 0x40, 0x14, 0x02, 0x20, 0x31, 0x02, 0x10, 0x60,
  0xC6, 0x04, 0xC0, 0x3C, 0x01, 0x80, 0x00, 0x04, 0x00, 0x08, 0x20, 0x00,
  0x41, 0x00, 0x02, 0x08, 0x00, 0x20, 0x40, 0x01, 0x04, 0x00, 0x08, 0x20,
  0x00, 0x41, 0x00, 0x02, 0x08, 0x00, 0x10, 0x40, 0x01, 0x02, 0x00, 0x08,
  0x20, 0x00, 0x41, 0x00, 0x02, 0x08, 0x00, 0x10, 0x40, 0x00, 0x82, 0x00,
  0x08, 0x10, 0x00, 0x40, 0x80, 0x02, 0x04, 0x00, 0x30, 0x20, 0x02, 0x81,
  0x00, 0x24, 0x04, 0x01, 0x60, 0x30, 0x32, 0x00, 0x7E, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x40,
  0x01, 0x03, 0x00, 0x30, 0x06, 0x07, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x10, 0x38, 0x10, 0x80, 0x18, 0x42, 0x00, 0x19, 0x10, 0x00, 0x18,
  0x40, 0x00, 0x41, 0x00, 0x06, 0x04, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x08, 0x02, 0x00, 0x20, 0x10, 0x00, 0x80,
  0x80, 0x02, 0x04, 0x00, 0x08, 0x60, 0x00, 0x21, 0x70, 0x00, 0xC4, 0x3E,
  0x01, 0x20, 0x07, 0xC4, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xF0, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x01, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x80, 0x80, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x7F, 0x00, 0x3C, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x0F, 0xFC, 0x00, 0x07, 0x80, 0x02, 0x10, 0x80,
  0x04, 0x40, 0x80, 0x19, 0x00, 0x80, 0x22, 0x00, 0x80, 0x88, 0x01, 0x81,
  0x10, 0x01, 0x8C, 0x40, 0x00, 0xF0,
};

const GFXglyph IBMPlexMono_ThinItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 7, 31, 27, 10, -31 },
  { 29, 9, 11, 27, 12, -33 },
  { 42, 27, 31, 27, 1, -31 },
  { 147, 23, 43, 27, 2, -37 },
  { 271, 30, 33, 27, -1, -32 },
  { 395, 26, 33, 27, 1, -32 },
  { 503, 3, 11, 27, 15, -33 },
  { 508, 14, 40, 27, 11, -34 },
  { 578, 14, 40, 27, 3, -34 },
  { 648, 23, 22, 27, 3, -25 },
  { 712, 22, 23, 27, 3, -25 },
  { 776, 6, 12, 27, 7, -4 },
  { 785, 12, 1, 27, 8, -14 },
  { 787, 3, 3, 27, 10, -3 },
  { 789, 24, 40, 27, 2, -34 },
  { 909, 22, 33, 27, 3, -32 },
  { 1000, 21, 31, 27, 2, -31 },
  { 1082, 22, 32, 27, 2, -32 },
  { 1170, 22, 33, 27, 2, -32 },
  { 1261, 23, 31, 27, 1, -31 },
  { 1351, 22, 32, 27, 3, -31 },
  { 1439, 19, 32, 27, 4, -31 },
  { 1515, 21, 31, 27, 5, -31 },
  { 1597, 22, 33, 27, 3, -32 },
  { 1688, 19, 32, 27, 5, -32 },
  { 1764, 7, 24, 27, 10, -24 },
  { 1785, 10, 32, 27, 7, -24 },
  { 1825, 22, 24, 27, 4, -26 },
  { 1891, 23, 9, 27, 2, -18 },
  { 1917, 22, 24, 27, 2, -26 },
  { 1983, 17, 32, 27, 7, -32 },
  { 2051, 20, 37, 27, 4, -32 },
  { 2144, 23, 31, 27, 0, -31 },
  { 2234, 21, 31, 27, 3, -31 },
  { 2316, 21, 33, 27, 4, -32 },
  { 2403, 22, 31, 27, 3, -31 },
  { 2489, 23, 31, 27, 3, -31 },
  { 2579, 24, 31, 27, 3, -31 },
  { 2672, 21, 33, 27, 4, -32 },
  { 2759, 24, 31, 27, 2, -31 },
  { 2852, 24, 31, 27, 2, -31 },
  { 2945, 21, 32, 27, 3, -31 },
  { 3029, 25, 31, 27, 3, -31 },
  { 3126, 17, 31, 27, 5, -31 },
  { 3192, 24, 31, 27, 2, -31 },
  { 3285, 24, 31, 27, 2, -31 },
  { 3378, 22, 33, 27, 3, -32 },
  { 3469, 23, 31, 27, 3, -31 },
  { 3559, 22, 40, 27, 3, -32 },
  { 3669, 23, 31, 27, 3, -31 },
  { 3759, 23, 33, 27, 2, -32 },
  { 3854, 23, 31, 27, 5, -31 },
  { 3944, 22, 32, 27, 4, -31 },
  { 4032, 22, 31, 27, 6, -31 },
  { 4118, 24, 31, 27, 4, -31 },
  { 4211, 28, 31, 27, 0, -31 },
  { 4320, 24, 31, 27, 5, -31 },
  { 4413, 27, 31, 27, 0, -31 },
  { 4518, 17, 40, 27, 9, -34 },
  { 4603, 10, 40, 27, 9, -34 },
  { 4653, 18, 40, 27, 1, -34 },
  { 4743, 21, 17, 27, 4, -31 },
  { 4788, 21, 1, 27, 0, 5 },
  { 4791, 5, 7, 27, 11, -34 },
  { 4796, 20, 25, 27, 3, -24 },
  { 4859, 20, 34, 27, 4, -33 },
  { 4944, 18, 25, 27, 4, -24 },
  { 5001, 22, 34, 27, 3, -33 },
  { 5095, 19, 25, 27, 4, -24 },
  { 5155, 28, 43, 27, 0, -33 },
  { 5306, 21, 34, 27, 2, -24 },
  { 5396, 18, 33, 27, 4, -33 },
  { 5471, 19, 34, 27, 4, -33 },
  { 5552, 18, 43, 27, 5, -33 },
  { 5649, 22, 34, 27, 4, -33 },
  { 5743, 16, 34, 27, 6, -33 },
  { 5811, 23, 24, 27, 2, -24 },
  { 5880, 18, 24, 27, 4, -24 },
  { 5934, 19, 25, 27, 4, -24 },
  { 5994, 22, 33, 27, 2, -24 },
  { 6085, 20, 33, 27, 3, -24 },
  { 6168, 22, 23, 27, 5, -23 },
  { 6232, 21, 25, 27, 3, -24 },
  { 6298, 22, 32, 27, 3, -31 },
  { 6386, 18, 24, 27, 5, -23 },
  { 6440, 20, 23, 27, 4, -23 },
  { 6498, 22, 24, 27, 3, -23 },
  { 6564, 25, 25, 27, 1, -24 },
  { 6643, 21, 33, 27, 2, -23 },
  { 6730, 22, 25, 27, 2, -24 },
  { 6799, 20, 40, 27, 6, -34 },
  { 6899, 8, 40, 27, 10, -34 },
  { 6939, 20, 40, 27, 2, -34 },
  { 7039, 23, 8, 27, 2, -18 },
};

const GFXfont IBMPlexMono_ThinItalic45pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic45pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _IBMPLEXMONO_THINITALIC45PT7B_H_
