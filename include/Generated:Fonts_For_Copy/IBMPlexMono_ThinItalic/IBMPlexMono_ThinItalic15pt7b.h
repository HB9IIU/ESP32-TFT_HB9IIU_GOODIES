#ifndef _IBMPLEXMONO_THINITALIC15PT7B_H_
#define _IBMPLEXMONO_THINITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x29, 0x24, 0xA0, 0x10, 0xB7, 0x60, 0x09, 0x05, 0x04, 0x8E, 0x71,
  0x41, 0x23, 0x9C, 0x50, 0x48, 0x24, 0x00, 0x08, 0x10, 0xF2, 0x59, 0x12,
  0x1C, 0x0E, 0x13, 0x46, 0x93, 0xC2, 0x04, 0x00, 0x38, 0xD2, 0x24, 0x91,
  0x28, 0x34, 0x05, 0xC2, 0x91, 0x44, 0x89, 0x21, 0x80, 0x1C, 0x11, 0x08,
  0x84, 0x43, 0x42, 0x42, 0x21, 0x09, 0x8B, 0x38, 0x80, 0xF0, 0x16, 0x48,
  0x88, 0x88, 0x88, 0x88, 0x40, 0x20, 0x84, 0x10, 0x84, 0x22, 0x10, 0x88,
  0x88, 0x00, 0x10, 0x10, 0x10, 0xF7, 0x38, 0x48, 0xCC, 0x10, 0x20, 0x40,
  0x8F, 0xE2, 0x04, 0x10, 0x20, 0x5A, 0xF0, 0x80, 0x03, 0x02, 0x04, 0x08,
  0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x80, 0x80, 0x80, 0x1C, 0x45, 0x0C,
  0x18, 0x32, 0x60, 0xC2, 0x84, 0xF0, 0x08, 0x31, 0xA2, 0x81, 0x02, 0x04,
  0x08, 0x11, 0xFC, 0x1C, 0x45, 0x08, 0x10, 0x41, 0x84, 0x10, 0xC1, 0xF8,
  0x3C, 0x84, 0x08, 0x23, 0x81, 0x81, 0x02, 0x84, 0xF0, 0x01, 0x06, 0x0A,
  0x12, 0x22, 0x42, 0x44, 0x7F, 0x84, 0x04, 0x3E, 0x81, 0x05, 0xC4, 0x40,
  0x81, 0x02, 0x84, 0xF0, 0x0C, 0x20, 0x82, 0x0B, 0xD8, 0x60, 0xC1, 0x84,
  0xF0, 0xFF, 0x0A, 0x20, 0x41, 0x04, 0x08, 0x20, 0x81, 0x00, 0x3C, 0x86,
  0x0A, 0x13, 0xD8, 0xA0, 0xC1, 0x84, 0xF0, 0x7A, 0x18, 0x61, 0x85, 0xE0,
  0x84, 0x23, 0x00, 0x20, 0x00, 0x04, 0x10, 0x00, 0x00, 0x04, 0x48, 0x80,
  0x03, 0x0C, 0x10, 0x60, 0x80, 0x60, 0x10, 0x0C, 0xFE, 0x03, 0xF8, 0x40,
  0x40, 0x60, 0x20, 0x63, 0x18, 0x40, 0x39, 0x18, 0x41, 0x08, 0x46, 0x10,
  0x01, 0x00, 0x1C, 0x45, 0x0A, 0xFA, 0x74, 0x69, 0x52, 0x9D, 0x02, 0x03,
  0xC0, 0x0C, 0x0C, 0x14, 0x14, 0x22, 0x22, 0x3E, 0x42, 0x82, 0x83, 0x3C,
  0x85, 0x0C, 0x17, 0xD0, 0xA0, 0xC1, 0x85, 0xF0, 0x1C, 0x45, 0x0C, 0x08,
  0x10, 0x20, 0x42, 0x84, 0xF0, 0x3C, 0x85, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x85, 0xF0, 0x3F, 0x40, 0x40, 0x80, 0x7E, 0x80, 0x80, 0x80, 0x80, 0xFC,
  0x3F, 0x40, 0x40, 0x80, 0x7E, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1C, 0x45,
  0x0C, 0x08, 0x11, 0xE0, 0xC2, 0x84, 0xF8, 0x41, 0x42, 0x82, 0x82, 0x7E,
  0x82, 0x84, 0x84, 0x84, 0x84, 0x7F, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x20, 0x20, 0xFC, 0x3E, 0x04, 0x08, 0x20, 0x40, 0x81, 0x42, 0x88, 0xE0,
  0x41, 0x42, 0x4C, 0x90, 0x90, 0xF0, 0x88, 0x88, 0x84, 0x86, 0x44, 0x21,
  0x08, 0x42, 0x10, 0x87, 0xC0, 0x41, 0xC7, 0xA6, 0xAA, 0xAA, 0x92, 0x82,
  0x82, 0x84, 0x84, 0x41, 0x62, 0xA2, 0xA2, 0x92, 0x92, 0x94, 0x8C, 0x8C,
  0x84, 0x1C, 0x45, 0x0C, 0x18, 0x30, 0x60, 0xC2, 0x84, 0xF0, 0x3E, 0x42,
  0x41, 0x82, 0x82, 0x7C, 0x80, 0x80, 0x80, 0x80, 0x1C, 0x45, 0x0C, 0x18,
  0x30, 0x60, 0xC2, 0x84, 0xF0, 0x40, 0xB0, 0x80, 0x3E, 0x42, 0x41, 0x82,
  0x82, 0x7C, 0x90, 0x88, 0x88, 0x84, 0x3C, 0x86, 0x04, 0x07, 0x01, 0x80,
  0xC1, 0x84, 0xF0, 0xFE, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x80,
  0x41, 0x42, 0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0x84, 0x78, 0x83, 0x0A,
  0x14, 0x48, 0x92, 0x24, 0x30, 0x60, 0x80, 0x81, 0x81, 0x81, 0x92, 0xB2,
  0xAA, 0xCC, 0xCC, 0xCC, 0x84, 0x20, 0x90, 0x84, 0x82, 0x80, 0x80, 0xC0,
  0x50, 0x48, 0x42, 0x41, 0x80, 0x83, 0x84, 0x88, 0x50, 0x50, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x3F, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x7F, 0x80, 0x3D, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x20,
  0xF0, 0x92, 0x48, 0x92, 0x44, 0x92, 0x1C, 0x10, 0x41, 0x04, 0x20, 0x82,
  0x08, 0x21, 0x04, 0xF0, 0x18, 0x30, 0x92, 0x28, 0x30, 0x40, 0xFE, 0xC0,
  0x3A, 0x8E, 0x14, 0x28, 0x50, 0xA3, 0x3B, 0x40, 0x81, 0x02, 0xE6, 0x28,
  0x60, 0xC1, 0x85, 0x0B, 0xE0, 0x39, 0x18, 0x60, 0x82, 0x18, 0x9C, 0x02,
  0x04, 0x09, 0xD4, 0x70, 0xA1, 0x42, 0x85, 0x19, 0xD0, 0x3C, 0x86, 0x17,
  0xC8, 0x10, 0xA1, 0x3C, 0x07, 0x82, 0x02, 0x07, 0xF0, 0x80, 0x40, 0x20,
  0x10, 0x10, 0x08, 0x24, 0x12, 0x05, 0x01, 0x80, 0x3A, 0x8E, 0x14, 0x28,
  0x50, 0xA3, 0x3A, 0x09, 0x11, 0xC0, 0x41, 0x04, 0x17, 0x65, 0x18, 0x61,
  0x86, 0x18, 0x40, 0x08, 0x00, 0x07, 0x81, 0x04, 0x08, 0x10, 0x26, 0xB0,
  0x80, 0x04, 0x00, 0x3E, 0x08, 0x21, 0x04, 0x10, 0x49, 0x24, 0x60, 0x80,
  0x40, 0x40, 0x40, 0x5C, 0x62, 0x44, 0x84, 0xB8, 0xA1, 0x96, 0x88, 0xE1,
  0x08, 0x44, 0x21, 0x08, 0x4D, 0x90, 0xB6, 0x96, 0x4C, 0x99, 0x32, 0x68,
  0xD1, 0x5D, 0x94, 0x61, 0x86, 0x18, 0x61, 0x3C, 0x8A, 0x0C, 0x18, 0x30,
  0xA1, 0x3C, 0x5C, 0xC5, 0x0C, 0x18, 0x30, 0xA1, 0x7C, 0x81, 0x02, 0x00,
  0x3A, 0x8E, 0x14, 0x28, 0x50, 0xA3, 0x3A, 0x08, 0x10, 0x20, 0xEE, 0x60,
  0x82, 0x04, 0x08, 0x10, 0x20, 0x3C, 0x86, 0x03, 0xC0, 0x40, 0xA1, 0x3C,
  0x10, 0x23, 0xF9, 0x02, 0x04, 0x08, 0x13, 0x58, 0x40, 0x86, 0x28, 0xA2,
  0x8A, 0x29, 0xBC, 0xE2, 0x85, 0x0A, 0x14, 0x48, 0x92, 0x38, 0x8B, 0x26,
  0x4C, 0x99, 0x32, 0x64, 0xF6, 0x13, 0x36, 0x42, 0x21, 0x00, 0x84, 0x42,
  0x6C, 0xC8, 0x43, 0x0A, 0x14, 0x28, 0x50, 0xA3, 0x3C, 0x09, 0x11, 0xC0,
  0x7B, 0x0E, 0x10, 0xC2, 0x18, 0xB9, 0x4E, 0x1E, 0x40, 0x81, 0x01, 0x02,
  0x38, 0x10, 0x20, 0x81, 0x04, 0x07, 0x00, 0x25, 0x24, 0x92, 0x92, 0x48,
  0x38, 0x20, 0x84, 0x20, 0x81, 0xCC, 0x20, 0x82, 0x08, 0xE0, 0x63, 0x26,
  0x30,
};

const GFXglyph IBMPlexMono_ThinItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 10, 9, 3, -10 },
  { 5, 3, 4, 9, 4, -11 },
  { 7, 9, 10, 9, 0, -10 },
  { 19, 7, 14, 9, 1, -12 },
  { 32, 10, 10, 9, 0, -10 },
  { 45, 9, 10, 9, 0, -10 },
  { 57, 1, 4, 9, 5, -11 },
  { 58, 4, 13, 9, 4, -11 },
  { 65, 5, 13, 9, 1, -11 },
  { 74, 8, 7, 9, 1, -8 },
  { 81, 7, 9, 9, 1, -9 },
  { 89, 2, 4, 9, 2, -1 },
  { 90, 4, 1, 9, 3, -5 },
  { 91, 1, 1, 9, 3, -1 },
  { 92, 8, 13, 9, 1, -11 },
  { 105, 7, 10, 9, 1, -10 },
  { 114, 7, 10, 9, 1, -10 },
  { 123, 7, 10, 9, 1, -10 },
  { 132, 7, 10, 9, 1, -10 },
  { 141, 8, 10, 9, 0, -10 },
  { 151, 7, 10, 9, 1, -10 },
  { 160, 7, 10, 9, 1, -10 },
  { 169, 7, 10, 9, 2, -10 },
  { 178, 7, 10, 9, 1, -10 },
  { 187, 6, 10, 9, 2, -10 },
  { 195, 3, 8, 9, 3, -8 },
  { 198, 4, 11, 9, 2, -8 },
  { 204, 8, 8, 9, 1, -9 },
  { 212, 7, 3, 9, 1, -6 },
  { 215, 7, 8, 9, 1, -9 },
  { 222, 6, 10, 9, 2, -10 },
  { 230, 7, 12, 9, 1, -10 },
  { 241, 8, 10, 9, 0, -10 },
  { 251, 7, 10, 9, 1, -10 },
  { 260, 7, 10, 9, 1, -10 },
  { 269, 7, 10, 9, 1, -10 },
  { 278, 8, 10, 9, 1, -10 },
  { 288, 8, 10, 9, 1, -10 },
  { 298, 7, 10, 9, 1, -10 },
  { 307, 8, 10, 9, 1, -10 },
  { 317, 8, 10, 9, 1, -10 },
  { 327, 7, 10, 9, 1, -10 },
  { 336, 8, 10, 9, 1, -10 },
  { 346, 5, 10, 9, 2, -10 },
  { 353, 8, 10, 9, 1, -10 },
  { 363, 8, 10, 9, 1, -10 },
  { 373, 7, 10, 9, 1, -10 },
  { 382, 8, 10, 9, 1, -10 },
  { 392, 7, 13, 9, 1, -10 },
  { 404, 8, 10, 9, 1, -10 },
  { 414, 7, 10, 9, 1, -10 },
  { 423, 7, 10, 9, 2, -10 },
  { 432, 8, 10, 9, 1, -10 },
  { 442, 7, 10, 9, 2, -10 },
  { 451, 8, 10, 9, 1, -10 },
  { 461, 9, 10, 9, 0, -10 },
  { 473, 8, 10, 9, 2, -10 },
  { 483, 9, 10, 9, 0, -10 },
  { 495, 6, 13, 9, 3, -11 },
  { 505, 3, 13, 9, 3, -11 },
  { 510, 6, 13, 9, 0, -11 },
  { 520, 7, 6, 9, 1, -10 },
  { 526, 7, 1, 9, 0, 1 },
  { 527, 1, 2, 9, 4, -12 },
  { 528, 7, 8, 9, 1, -8 },
  { 535, 7, 11, 9, 1, -11 },
  { 545, 6, 8, 9, 1, -8 },
  { 551, 7, 11, 9, 1, -11 },
  { 561, 7, 8, 9, 1, -8 },
  { 568, 9, 14, 9, 0, -11 },
  { 584, 7, 11, 9, 1, -8 },
  { 594, 6, 11, 9, 1, -11 },
  { 603, 7, 11, 9, 1, -11 },
  { 613, 6, 14, 9, 2, -11 },
  { 624, 8, 11, 9, 1, -11 },
  { 635, 5, 11, 9, 2, -11 },
  { 642, 7, 8, 9, 1, -8 },
  { 649, 6, 8, 9, 1, -8 },
  { 655, 7, 8, 9, 1, -8 },
  { 662, 7, 11, 9, 1, -8 },
  { 672, 7, 11, 9, 1, -8 },
  { 682, 7, 8, 9, 2, -8 },
  { 689, 7, 8, 9, 1, -8 },
  { 696, 7, 10, 9, 1, -10 },
  { 705, 6, 8, 9, 2, -8 },
  { 711, 7, 8, 9, 1, -8 },
  { 718, 7, 8, 9, 1, -8 },
  { 725, 9, 8, 9, 0, -8 },
  { 734, 7, 11, 9, 1, -8 },
  { 744, 7, 8, 9, 1, -8 },
  { 751, 7, 13, 9, 2, -11 },
  { 763, 3, 13, 9, 3, -11 },
  { 768, 6, 13, 9, 1, -11 },
  { 778, 7, 3, 9, 1, -6 },
};

const GFXfont IBMPlexMono_ThinItalic15pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic15pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _IBMPLEXMONO_THINITALIC15PT7B_H_
