#ifndef _IBMPLEXMONO_THINITALIC63PT7B_H_
#define _IBMPLEXMONO_THINITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x3E, 0x0F, 0x01, 0xC0, 0x18, 0x18, 0x80, 0xC4,
  0x06, 0x20, 0x23, 0x01, 0x18, 0x18, 0xC0, 0xC4, 0x06, 0x20, 0x31, 0x01,
  0x18, 0x08, 0xC0, 0xC6, 0x06, 0x20, 0x31, 0x01, 0x18, 0x08, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x00, 0x04, 0x00, 0x80, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x02, 0x00, 0x40, 0x00, 0x00, 0x08, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x80, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x40, 0x00, 0x00, 0x18, 0x03, 0x00, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x04, 0x00, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x00, 0x08, 0x01, 0x00, 0x00, 0x00, 0x20, 0x0C,
  0x00, 0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x80, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x00, 0x80, 0x18, 0x00, 0x00, 0x02, 0x00, 0x40,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x20, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x10, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x01, 0x00, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x38, 0x31,
  0xE0, 0x00, 0x38, 0x0C, 0x0E, 0x00, 0x18, 0x02, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x18, 0x06, 0x00, 0x20, 0x02, 0x01, 0x00, 0x08, 0x00, 0xC0, 0xC0,
  0x06, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x08, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x20, 0x01, 0x00, 0x00,
  0x08, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x08, 0x00,
  0x00, 0x30, 0x02, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0x80, 0x20,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x00, 0x3D,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x13, 0xC0, 0x00, 0x00,
  0x04, 0x1C, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x20, 0x06, 0x00, 0x00, 0x08, 0x00, 0x80, 0x00, 0x02, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x30, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x80, 0x00, 0x04, 0x00, 0x20, 0x40, 0x03,
  0x00, 0x18, 0x30, 0x00, 0x80, 0x04, 0x06, 0x00, 0x20, 0x03, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x18, 0x02, 0x00, 0xC0, 0x03, 0x80, 0x80, 0x60, 0x00,
  0x3C, 0x60, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x02, 0x00, 0xC0,
  0x00, 0x18, 0x01, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x02, 0x00, 0x02,
  0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x10, 0x00, 0x30, 0x00, 0x80, 0x04,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x03, 0x00, 0x10, 0x00, 0xC0, 0x00,
  0xC0, 0x08, 0x00, 0x30, 0x00, 0x30, 0x04, 0x00, 0x08, 0x00, 0x08, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x40, 0x00,
  0x20, 0x00, 0x60, 0x20, 0x00, 0x08, 0x00, 0x10, 0x18, 0x00, 0x01, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x40, 0x06, 0x02, 0x00, 0x00, 0x08, 0x03, 0x01,
  0x00, 0x00, 0x01, 0x83, 0x80, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x30, 0x18, 0x18, 0x00, 0x00, 0x18, 0x08, 0x03,
  0x00, 0x00, 0x04, 0x04, 0x00, 0x60, 0x00, 0x02, 0x02, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x80, 0x02, 0x00, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0x00, 0x20,
  0x10, 0x00, 0x30, 0x00, 0x10, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x80, 0x08, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x02, 0x00, 0x30,
  0x00, 0x80, 0x01, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x04, 0x00, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x01, 0x00, 0x18, 0x01, 0x80, 0x00, 0x20, 0x0C,
  0x00, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x20, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x01, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x08, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x03,
  0xC0, 0x60, 0x00, 0x01, 0xC2, 0x18, 0x00, 0x00, 0x60, 0x2E, 0x00, 0x00,
  0x08, 0x01, 0x00, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x80, 0x00, 0x07, 0x00, 0x18, 0x00,
  0x00, 0x90, 0x02, 0x80, 0x00, 0x09, 0x80, 0x6C, 0x00, 0x00, 0x8C, 0x04,
  0x40, 0x00, 0x10, 0x40, 0x86, 0x00, 0x03, 0x06, 0x18, 0x30, 0x00, 0x60,
  0x21, 0x01, 0x80, 0x0C, 0x03, 0x20, 0x0E, 0x03, 0x00, 0x1E, 0x00, 0x1F,
  0xC0, 0x00, 0xC0, 0x33, 0x22, 0x66, 0x66, 0x44, 0xCC, 0xCC, 0x88, 0x00,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x78, 0x01, 0x80, 0x1F, 0x0F,
  0x01, 0x00, 0xF0, 0x01, 0xE1, 0x0F, 0x80, 0x00, 0x3D, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00,
  0x08, 0xC0, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x10, 0x00, 0x03,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x02, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x83, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x18, 0x0C,
  0x04, 0x06, 0x02, 0x03, 0x01, 0x00, 0xFF, 0xFF, 0x80, 0x77, 0xFC, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x18, 0x00, 0x80, 0x00, 0x20, 0x04, 0x00,
  0x00, 0x40, 0x20, 0x00, 0x01, 0x01, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x08, 0x30, 0x00, 0x00, 0x20, 0x80, 0x00, 0x00, 0x86, 0x00, 0x00, 0x02,
  0x10, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x09, 0x00, 0x1C,
  0x00, 0x2C, 0x00, 0x70, 0x00, 0xB0, 0x01, 0xC0, 0x02, 0xC0, 0x00, 0x00,
  0x1A, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x04,
  0x80, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x62, 0x00, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x04, 0x20, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x06, 0x04, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x80, 0x60, 0x00, 0x06,
  0x00, 0x80, 0x00, 0x30, 0x01, 0x00, 0x01, 0x80, 0x03, 0x00, 0x1C, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x19, 0x00, 0x00, 0x03, 0x88, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x60, 0x08, 0x00, 0x0C, 0x00, 0x40, 0x00, 0xC0, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x80, 0x10, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x01, 0x00, 0x80, 0x00, 0x02, 0x03, 0x00, 0x00, 0x04, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x03, 0x00, 0x06, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x80,
  0x00, 0x18, 0x04, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x00, 0x81, 0x80, 0x00, 0x04, 0x03, 0x00, 0x00, 0x60,
  0x07, 0x00, 0x03, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x01, 0x88,
  0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x04, 0x18,
  0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x30, 0x10,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x80, 0x30,
  0x00, 0x01, 0x80, 0x20, 0x00, 0x03, 0x00, 0x20, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x18, 0x00, 0x60, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x40,
  0x01, 0x80, 0x00, 0x40, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0,
  0x04, 0x00, 0x00, 0x80, 0x08, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x80,
  0x30, 0x00, 0x00, 0x80, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x3F, 0xC0, 0x00, 0x23, 0x80,
  0x70, 0x00, 0xD8, 0x00, 0x30, 0x01, 0xE0, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x20,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x7F, 0x80, 0x0C, 0x78, 0x0E, 0x01, 0x18,
  0x00, 0x20, 0x6C, 0x00, 0x03, 0x0B, 0x00, 0x00, 0x21, 0x40, 0x00, 0x06,
  0x70, 0x00, 0x00, 0x4E, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0xB0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x40, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0x10,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x18, 0x20, 0x00, 0x06, 0x02, 0x00, 0x01,
  0x80, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x32, 0x00, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x04, 0x20, 0x00, 0x00, 0x30, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x04, 0x18, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x81, 0x00, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x80, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x02, 0x00, 0x00, 0xC0,
  0x08, 0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x01, 0x01,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x00, 0x81, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x04, 0x02, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3C, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x00, 0x81, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x01,
  0x08, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0xC0, 0x40,
  0x00, 0x03, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1C,
  0x03, 0x80, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x18,
  0x30, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x11, 0x00, 0x00, 0x02, 0x60, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x50, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x1C, 0x80, 0x00, 0x05, 0x08, 0x00, 0x01,
  0xA1, 0x80, 0x00, 0x68, 0x18, 0x00, 0x31, 0x00, 0xE0, 0x3C, 0x60, 0x07,
  0xFC, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x83, 0xE1, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x03, 0x80, 0x70, 0x06, 0x00, 0x18, 0x18, 0x00, 0x04, 0x30, 0x00, 0x02,
  0x20, 0x00, 0x02, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x40, 0x04, 0x00, 0x03, 0x00, 0x40, 0x00, 0x08, 0x06, 0x00,
  0x00, 0x40, 0x20, 0x00, 0x02, 0x03, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00, 0x30, 0x40, 0x00, 0x01, 0x86,
  0x00, 0x3F, 0x0C, 0x20, 0x06, 0x04, 0x41, 0x00, 0x40, 0x12, 0x18, 0x04,
  0x00, 0x50, 0x80, 0x40, 0x02, 0x84, 0x02, 0x00, 0x0C, 0x20, 0x20, 0x00,
  0x63, 0x01, 0x00, 0x02, 0x18, 0x18, 0x00, 0x10, 0x80, 0xC0, 0x00, 0x84,
  0x04, 0x00, 0x04, 0x20, 0x20, 0x00, 0x63, 0x01, 0x00, 0x03, 0x18, 0x18,
  0x00, 0x10, 0xC0, 0xC0, 0x00, 0x84, 0x06, 0x00, 0x04, 0x20, 0x20, 0x00,
  0x21, 0x01, 0x00, 0x03, 0x08, 0x08, 0x00, 0x18, 0x40, 0x60, 0x00, 0xC6,
  0x03, 0x00, 0x0C, 0x30, 0x08, 0x00, 0xA1, 0x80, 0x40, 0x05, 0x08, 0x03,
  0x00, 0x48, 0x40, 0x0C, 0x0C, 0xC2, 0x00, 0x3F, 0xC6, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x20, 0x18, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x01, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x40, 0x00, 0x08, 0x00, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x40, 0x03, 0x00, 0x01, 0x80, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x60, 0x00, 0x30, 0x00, 0x80,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x20, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00,
  0x20, 0x40, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x04,
  0x80, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30,
  0x01, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x07, 0x00, 0x10, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x20, 0x20,
  0x00, 0x00, 0x80, 0x80, 0x00, 0x02, 0x02, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x02, 0x04, 0x00, 0x00,
  0x08, 0x10, 0x00, 0x00, 0x20, 0x40, 0x00, 0x01, 0x83, 0x00, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x80, 0x80, 0x00, 0x06, 0x02,
  0x00, 0x00, 0x60, 0x08, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0x80,
  0x00, 0x30, 0x04, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x40, 0x40, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x00, 0x42, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00, 0x04,
  0x20, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x21, 0x00, 0x00, 0x01, 0x84, 0x00,
  0x00, 0x04, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x0C, 0x08, 0x00, 0x01, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0,
  0x08, 0x00, 0x02, 0x00, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x60,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x03, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x06, 0x02, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x08, 0x08,
  0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x00, 0x41, 0x00, 0x00, 0x00, 0x82, 0x00, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x18, 0x40, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x41, 0x00, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x08,
  0x20, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x40, 0x80, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x10, 0x10,
  0x00, 0x00, 0x40, 0x20, 0x00, 0x01, 0x00, 0x40, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x30, 0x03, 0x00, 0x03, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x20, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x02, 0x00, 0x80, 0x00,
  0x18, 0x08, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x04, 0x00, 0x00, 0x08,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x1F,
  0xFF, 0x20, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x04,
  0x40, 0x00, 0x00, 0x22, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x21, 0x00, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x0E,
  0x08, 0x00, 0x00, 0x70, 0x60, 0x00, 0x05, 0x01, 0x00, 0x00, 0x48, 0x04,
  0x00, 0x04, 0x40, 0x18, 0x00, 0x46, 0x00, 0x70, 0x1C, 0x30, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x40, 0x60,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x10, 0x08,
  0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x02, 0x03,
  0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x80,
  0x40, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x10,
  0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x06,
  0x02, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x01, 0x00, 0x80, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x20, 0x00, 0x00,
  0x30, 0x10, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00,
  0x04, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x40, 0x20, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x08, 0x00,
  0x00, 0x0C, 0x04, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x02, 0x01, 0x00,
  0x00, 0x01, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x40,
  0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x10, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x40, 0x00, 0x06, 0x02, 0x00, 0x00, 0x20, 0x18, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x03, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x02, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x00, 0x81,
  0xB0, 0x00, 0x00, 0x10, 0x62, 0x00, 0x00, 0x02, 0x18, 0x60, 0x00, 0x00,
  0xC6, 0x04, 0x00, 0x00, 0x19, 0x80, 0xC0, 0x00, 0x03, 0x60, 0x08, 0x00,
  0x00, 0x58, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x30, 0x00, 0x01, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x10, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x08, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x3C, 0x0D, 0x00, 0x00, 0x0A, 0x03, 0x40, 0x00, 0x06, 0x80,
  0x90, 0x00, 0x01, 0x20, 0x26, 0x00, 0x00, 0x88, 0x08, 0x80, 0x00, 0x66,
  0x02, 0x20, 0x00, 0x11, 0x81, 0x8C, 0x00, 0x0C, 0x40, 0x61, 0x00, 0x06,
  0x10, 0x10, 0x40, 0x01, 0x04, 0x04, 0x10, 0x00, 0xC1, 0x01, 0x06, 0x00,
  0x20, 0xC0, 0x40, 0x80, 0x18, 0x30, 0x30, 0x20, 0x0C, 0x08, 0x0C, 0x0C,
  0x02, 0x02, 0x02, 0x01, 0x01, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20,
  0x10, 0x20, 0x18, 0x08, 0x06, 0x18, 0x06, 0x06, 0x00, 0x84, 0x01, 0x01,
  0x80, 0x23, 0x00, 0x40, 0x40, 0x0D, 0x80, 0x10, 0x10, 0x01, 0x40, 0x04,
  0x04, 0x00, 0x70, 0x03, 0x01, 0x00, 0x18, 0x00, 0xC0, 0xC0, 0x04, 0x00,
  0x20, 0x30, 0x01, 0x00, 0x08, 0x08, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x80, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x04, 0x06, 0x00, 0x00, 0x01, 0x01, 0x00, 0x00, 0x00, 0x40, 0x40,
  0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x08,
  0x08, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0xE0, 0x00, 0x00, 0x40, 0x78, 0x00, 0x00, 0x60, 0x34, 0x00,
  0x00, 0x30, 0x12, 0x00, 0x00, 0x10, 0x09, 0x80, 0x00, 0x08, 0x04, 0x40,
  0x00, 0x04, 0x02, 0x20, 0x00, 0x02, 0x03, 0x18, 0x00, 0x03, 0x01, 0x84,
  0x00, 0x01, 0x80, 0x83, 0x00, 0x00, 0x80, 0x41, 0x80, 0x00, 0x40, 0x20,
  0x40, 0x00, 0x20, 0x10, 0x30, 0x00, 0x10, 0x18, 0x08, 0x00, 0x18, 0x0C,
  0x04, 0x00, 0x0C, 0x04, 0x03, 0x00, 0x06, 0x02, 0x00, 0x80, 0x02, 0x01,
  0x00, 0x40, 0x01, 0x00, 0x80, 0x30, 0x00, 0x80, 0xC0, 0x08, 0x00, 0xC0,
  0x60, 0x04, 0x00, 0x60, 0x20, 0x03, 0x00, 0x30, 0x10, 0x00, 0x80, 0x10,
  0x08, 0x00, 0x40, 0x08, 0x04, 0x00, 0x30, 0x04, 0x06, 0x00, 0x08, 0x06,
  0x03, 0x00, 0x04, 0x03, 0x01, 0x00, 0x03, 0x01, 0x80, 0x80, 0x00, 0x80,
  0x80, 0x40, 0x00, 0x60, 0x40, 0x20, 0x00, 0x30, 0x20, 0x30, 0x00, 0x08,
  0x30, 0x18, 0x00, 0x06, 0x18, 0x08, 0x00, 0x01, 0x0C, 0x04, 0x00, 0x00,
  0x84, 0x02, 0x00, 0x00, 0x62, 0x01, 0x00, 0x00, 0x11, 0x01, 0x80, 0x00,
  0x09, 0x80, 0xC0, 0x00, 0x06, 0xC0, 0x40, 0x00, 0x01, 0x60, 0x20, 0x00,
  0x00, 0xA0, 0x10, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x80, 0x00, 0x20, 0x04, 0x00, 0x00, 0x40, 0x20, 0x00,
  0x01, 0x01, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x00, 0x86, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x02, 0x40, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x08, 0x80,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x04, 0x20, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x83, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x10, 0x10, 0x00, 0x00, 0x80, 0x60, 0x00, 0x06, 0x00, 0x80, 0x00, 0x30,
  0x01, 0x00, 0x01, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x70,
  0x01, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x01,
  0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x18,
  0x08, 0x00, 0x00, 0x20, 0x08, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x80, 0x00, 0x20, 0x04, 0x00, 0x00, 0x40, 0x20,
  0x00, 0x01, 0x01, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0x08, 0x30, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x00, 0x86, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x03,
  0x20, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x08,
  0x80, 0x00, 0x00, 0x62, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x04, 0x20,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x83, 0x00, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x10, 0x10, 0x00, 0x00, 0x80, 0x60, 0x00, 0x06, 0x00, 0x80, 0x00,
  0x30, 0x01, 0x00, 0x01, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x20, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x01, 0x82, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00,
  0x05, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0x80,
  0x00, 0x70, 0x01, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x04, 0x01, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x01, 0x02, 0x00,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x08, 0x0C, 0x00,
  0x00, 0x18, 0x08, 0x00, 0x00, 0x20, 0x08, 0x00, 0x01, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x00, 0x80, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x40, 0x00, 0x10, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x18, 0x00, 0x20, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x04, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x40, 0x00, 0x03, 0x00, 0x40, 0x00, 0x01, 0x00, 0x40, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x80, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x0E,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x04, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0x81, 0x00, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x20,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0x18, 0x20, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00,
  0x0C, 0x10, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x06,
  0x08, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x20,
  0x40, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x01, 0x03, 0x00, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x20, 0x10,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x00, 0x60, 0x00, 0x04, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x02, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x10, 0x60, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x00, 0x80, 0x80, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x04, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00,
  0xC0, 0x08, 0x00, 0x01, 0x00, 0x10, 0x00, 0x06, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x40, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x40, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x60, 0x00, 0x18, 0x00, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x20, 0x04, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x80, 0x20, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x03, 0x01, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x04,
  0x08, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x21,
  0x80, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x90,
  0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x02, 0x10,
  0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x00, 0x41, 0x00, 0x00, 0x00, 0x10,
  0x40, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x00,
  0x81, 0x00, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0x01, 0x03, 0x00, 0x18, 0x00, 0x40, 0x80, 0x0E,
  0x00, 0x30, 0x20, 0x02, 0x80, 0x08, 0x08, 0x01, 0xB0, 0x02, 0x02, 0x00,
  0x4C, 0x00, 0x80, 0x80, 0x11, 0x00, 0x60, 0x20, 0x0C, 0x40, 0x10, 0x08,
  0x02, 0x10, 0x04, 0x02, 0x01, 0x84, 0x03, 0x00, 0x80, 0x41, 0x00, 0xC0,
  0x20, 0x30, 0x60, 0x20, 0x18, 0x08, 0x18, 0x08, 0x06, 0x06, 0x06, 0x06,
  0x01, 0x81, 0x00, 0x81, 0x80, 0x60, 0xC0, 0x20, 0x40, 0x18, 0x20, 0x08,
  0x10, 0x04, 0x18, 0x02, 0x0C, 0x01, 0x04, 0x00, 0x82, 0x00, 0x41, 0x00,
  0x30, 0x80, 0x10, 0xC0, 0x0C, 0x20, 0x04, 0x20, 0x01, 0x18, 0x01, 0x18,
  0x00, 0x44, 0x00, 0x44, 0x00, 0x11, 0x00, 0x13, 0x00, 0x04, 0xC0, 0x04,
  0x80, 0x01, 0x30, 0x01, 0x60, 0x00, 0x48, 0x00, 0xD0, 0x00, 0x1A, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x01, 0x80, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x01, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x20,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x00,
  0x44, 0x00, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x30, 0x00, 0x00, 0x02, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00,
  0x06, 0x10, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x00, 0x08, 0x06, 0x00, 0x00, 0x02, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x08, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0x10, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x21, 0x00, 0x00,
  0x00, 0x06, 0x40, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x30, 0x80, 0x00, 0x01, 0x06, 0x00, 0x00, 0x10,
  0x10, 0x00, 0x01, 0x80, 0x80, 0x00, 0x18, 0x02, 0x00, 0x00, 0x80, 0x10,
  0x00, 0x08, 0x00, 0xC0, 0x00, 0xC0, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x40, 0x04, 0x00, 0x03, 0x00, 0x60, 0x00, 0x08, 0x06, 0x00,
  0x00, 0x40, 0x60, 0x00, 0x03, 0x02, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0xC1, 0x81, 0x81, 0x03,
  0x02, 0x06, 0x04, 0x04, 0x00, 0x0F, 0xF0, 0x18, 0x01, 0x80, 0x60, 0x80,
  0x30, 0x00, 0xC4, 0x03, 0x00, 0x03, 0x20, 0x20, 0x00, 0x09, 0x03, 0x00,
  0x00, 0x28, 0x30, 0x00, 0x01, 0xC1, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x08, 0x40, 0x00, 0x00, 0x42, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x30, 0x40, 0x00, 0x01, 0x82, 0x00,
  0x00, 0x1C, 0x10, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0A, 0x02, 0x00, 0x00,
  0x90, 0x08, 0x00, 0x0C, 0x80, 0x60, 0x00, 0xCC, 0x01, 0x80, 0x0C, 0x60,
  0x03, 0x01, 0x83, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x03, 0xF8,
  0x00, 0x61, 0xC0, 0x60, 0x04, 0x30, 0x01, 0x00, 0x44, 0x00, 0x08, 0x04,
  0x80, 0x00, 0x40, 0x50, 0x00, 0x06, 0x0D, 0x00, 0x00, 0x20, 0xE0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x08, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x01, 0x18, 0x00, 0x00, 0x11, 0x80, 0x00, 0x01, 0x10, 0x00,
  0x00, 0x11, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x11, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x22, 0x00,
  0x00, 0x02, 0x20, 0x00, 0x00, 0x62, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x86, 0x00, 0x00, 0x10, 0x50,
  0x00, 0x03, 0x05, 0x80, 0x00, 0x60, 0xCC, 0x00, 0x0C, 0x0C, 0x60, 0x01,
  0x80, 0x83, 0x80, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x1C, 0x07, 0x00, 0x0C, 0x00, 0x20, 0x0C, 0x00, 0x04, 0x06, 0x00, 0x00,
  0x81, 0x00, 0x00, 0x30, 0x80, 0x00, 0x04, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x90, 0x00, 0x00, 0x64, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x08, 0x20, 0x00, 0x06, 0x04, 0x00, 0x03, 0x01, 0x80, 0x01,
  0x80, 0x30, 0x01, 0x80, 0x03, 0x01, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x03, 0xFC, 0x06, 0x00, 0x18, 0x06,
  0x08, 0x00, 0xC0, 0x03, 0x10, 0x03, 0x00, 0x03, 0x20, 0x08, 0x00, 0x02,
  0x40, 0x30, 0x00, 0x02, 0x80, 0xC0, 0x00, 0x07, 0x01, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x20,
  0x40, 0x00, 0x00, 0x40, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x10, 0x20,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x08, 0x08, 0x00,
  0x00, 0x30, 0x10, 0x00, 0x00, 0x60, 0x20, 0x00, 0x01, 0xC0, 0x40, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x0A, 0x00, 0x80, 0x00, 0x24, 0x00, 0x80, 0x00,
  0xC8, 0x01, 0x80, 0x03, 0x30, 0x01, 0x80, 0x0C, 0x60, 0x00, 0xC0, 0x60,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x40, 0x30, 0x00, 0x04, 0x0C, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x18, 0x40, 0x00, 0x03, 0x10, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x10, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x08, 0xC0, 0x00, 0x02, 0x10, 0x00, 0x01, 0x82, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0xE0, 0x18, 0x07, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x11, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x01, 0x82, 0x00, 0x00, 0x20, 0x20, 0x00, 0x08, 0x06, 0x00,
  0x02, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x40, 0x06, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0x00, 0x11, 0x00,
  0x00, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x0C, 0x00, 0x60, 0x18, 0x20, 0x06, 0x00, 0x18, 0x80,
  0x30, 0x00, 0x32, 0x01, 0x00, 0x00, 0x48, 0x0C, 0x00, 0x00, 0xA0, 0x60,
  0x00, 0x03, 0x81, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x10, 0x20, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x01, 0x04, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x83, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x08,
  0x20, 0x00, 0x00, 0x20, 0x80, 0x00, 0x00, 0x82, 0x00, 0x00, 0x06, 0x08,
  0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x41, 0x80, 0x00, 0x01, 0x06, 0x00,
  0x00, 0x04, 0x08, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x06, 0x02, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xA0, 0x10, 0x00, 0x04,
  0x80, 0x20, 0x00, 0x32, 0x00, 0xC0, 0x01, 0x98, 0x01, 0x80, 0x0C, 0x40,
  0x01, 0x80, 0xC1, 0x00, 0x01, 0xFC, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x20, 0x04, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x1F, 0xC0, 0x08, 0x30, 0x18, 0x04, 0x60, 0x02, 0x06, 0x60,
  0x00, 0x83, 0x60, 0x00, 0x61, 0xA0, 0x00, 0x10, 0xA0, 0x00, 0x08, 0x60,
  0x00, 0x04, 0x30, 0x00, 0x02, 0x30, 0x00, 0x01, 0x18, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x44, 0x00, 0x00, 0x22, 0x00, 0x00, 0x11, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x0C, 0xC0, 0x00, 0x04, 0x40, 0x00, 0x02, 0x20, 0x00, 0x01,
  0x10, 0x00, 0x00, 0x88, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x11, 0x00, 0x00, 0x08, 0x80, 0x00, 0x04, 0x40, 0x00,
  0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x10, 0x00, 0x00, 0x88, 0x00,
  0x00, 0x44, 0x00, 0x00, 0x62, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x02, 0x00, 0x40, 0x00, 0xC0, 0x10, 0x00, 0xC0,
  0x0C, 0x00, 0x40, 0x03, 0x00, 0x60, 0x00, 0x80, 0x20, 0x00, 0x20, 0x30,
  0x00, 0x08, 0x18, 0x00, 0x06, 0x08, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x80, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x20, 0x04, 0x00, 0x04, 0x01, 0x00,
  0x00, 0x80, 0x40, 0x00, 0x18, 0x10, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0xFF, 0x00, 0x03, 0x06, 0x01,
  0x80, 0x04, 0x30, 0x00, 0x80, 0x08, 0x80, 0x01, 0x80, 0x12, 0x00, 0x01,
  0x00, 0x68, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x40,
  0x10, 0x00, 0x01, 0x80, 0x60, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x18, 0x01,
  0x00, 0x00, 0x60, 0x02, 0x00, 0x03, 0x00, 0x04, 0x00, 0x1C, 0x00, 0x08,
  0x00, 0xC0, 0x00, 0x30, 0x1E, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x80, 0x00, 0x04, 0x01,
  0x80, 0x00, 0x58, 0x01, 0x00, 0x03, 0x30, 0x03, 0x00, 0x0C, 0x40, 0x02,
  0x00, 0x30, 0x80, 0x06, 0x00, 0xC1, 0x00, 0x06, 0x03, 0x02, 0x00, 0x04,
  0x0C, 0x0C, 0x00, 0x0C, 0x30, 0x18, 0x00, 0x08, 0x80, 0x20, 0x00, 0x1A,
  0x00, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x10, 0x30, 0x00, 0x60, 0x40, 0x01, 0x00, 0x80, 0x0C, 0x01, 0x00, 0x20,
  0x06, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x30, 0x00, 0x20, 0xC0, 0x00,
  0x42, 0x00, 0x01, 0x98, 0x00, 0x03, 0x40, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x1F, 0x00, 0xFC, 0x02, 0x30, 0x60, 0x83, 0x01, 0x20, 0x11, 0x80, 0xC1,
  0xA0, 0x0C, 0x80, 0x20, 0xE0, 0x02, 0x80, 0x18, 0x70, 0x01, 0x80, 0x0C,
  0x30, 0x00, 0xC0, 0x06, 0x18, 0x00, 0x40, 0x03, 0x08, 0x00, 0x60, 0x01,
  0x0C, 0x00, 0x30, 0x00, 0x86, 0x00, 0x10, 0x00, 0x43, 0x00, 0x08, 0x00,
  0x21, 0x00, 0x04, 0x00, 0x30, 0x80, 0x02, 0x00, 0x18, 0x40, 0x03, 0x00,
  0x08, 0x60, 0x01, 0x80, 0x04, 0x30, 0x00, 0x80, 0x02, 0x18, 0x00, 0x40,
  0x01, 0x08, 0x00, 0x20, 0x01, 0x84, 0x00, 0x10, 0x00, 0xC2, 0x00, 0x18,
  0x00, 0x41, 0x00, 0x0C, 0x00, 0x21, 0x80, 0x04, 0x00, 0x10, 0xC0, 0x02,
  0x00, 0x08, 0x40, 0x01, 0x00, 0x0C, 0x20, 0x00, 0x80, 0x06, 0x10, 0x00,
  0xC0, 0x02, 0x08, 0x00, 0x60, 0x01, 0x0C, 0x00, 0x20, 0x00, 0x86, 0x00,
  0x10, 0x00, 0x42, 0x00, 0x08, 0x00, 0x61, 0x00, 0x04, 0x00, 0x30, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x04, 0x07, 0xF0, 0x02, 0x0C, 0x06, 0x01, 0x18,
  0x00, 0x81, 0x98, 0x00, 0x20, 0xD8, 0x00, 0x18, 0x48, 0x00, 0x04, 0x28,
  0x00, 0x02, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x11, 0x00, 0x00, 0x08, 0x80, 0x00, 0x04,
  0x40, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x10, 0x00, 0x00,
  0x88, 0x00, 0x00, 0x44, 0x00, 0x00, 0x22, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x08, 0x80, 0x00, 0x04, 0x40, 0x00, 0x02, 0x20, 0x00,
  0x01, 0x10, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x44, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x11, 0x00, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x10,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x80, 0x40, 0x00, 0x04, 0x08, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x02, 0x10, 0x00, 0x00, 0x23, 0x00, 0x00, 0x02, 0x20,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x48, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x84, 0x00, 0x00, 0x08, 0x40, 0x00, 0x01, 0x06, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x02, 0x03, 0x00, 0x00, 0x40, 0x18, 0x00, 0x08,
  0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0x80, 0xFE, 0x00, 0x06, 0x1C, 0x06, 0x00, 0x10, 0xC0, 0x04, 0x00, 0x44,
  0x00, 0x08, 0x01, 0x20, 0x00, 0x10, 0x05, 0x00, 0x00, 0x60, 0x34, 0x00,
  0x00, 0x80, 0xE0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00,
  0x10, 0x20, 0x00, 0x00, 0x40, 0x80, 0x00, 0x01, 0x06, 0x00, 0x00, 0x04,
  0x18, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x41, 0x00, 0x00, 0x01, 0x04,
  0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x02, 0x06, 0x00, 0x00, 0x10, 0x14, 0x00, 0x00, 0xC0,
  0x58, 0x00, 0x06, 0x03, 0x30, 0x00, 0x30, 0x0C, 0x60, 0x01, 0x80, 0x30,
  0xE0, 0x38, 0x00, 0x80, 0x7F, 0x80, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x18, 0x01, 0x80, 0x60, 0x80,
  0x30, 0x00, 0xC4, 0x03, 0x00, 0x03, 0x20, 0x20, 0x00, 0x09, 0x03, 0x00,
  0x00, 0x28, 0x30, 0x00, 0x01, 0xC1, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x08, 0x40, 0x00, 0x00, 0x42, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x30, 0x40, 0x00, 0x01, 0x82, 0x00,
  0x00, 0x1C, 0x10, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0A, 0x02, 0x00, 0x00,
  0x90, 0x08, 0x00, 0x0C, 0x80, 0x60, 0x00, 0xCC, 0x01, 0x80, 0x0C, 0x60,
  0x03, 0x01, 0x82, 0x00, 0x07, 0xF0, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x43, 0x00, 0x00, 0x01,
  0x30, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0x80, 0x3C, 0x00, 0x30, 0x00, 0x30, 0x02, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x01,
  0x80, 0x00, 0xC0, 0x03, 0x80, 0x3C, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x04, 0x20, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x08, 0x40, 0x00, 0x02, 0x10, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x01,
  0x08, 0x00, 0x00, 0x42, 0x00, 0x00, 0x10, 0x80, 0x00, 0x0C, 0x60, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x86, 0x00, 0x00, 0x21, 0x00, 0x00, 0x08, 0x40,
  0x00, 0x02, 0x10, 0x00, 0x01, 0x84, 0x00, 0x00, 0x63, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x41, 0x00, 0x00,
  0x70, 0x40, 0x00, 0x2C, 0x18, 0x00, 0x12, 0x02, 0x00, 0x08, 0x80, 0x40,
  0x04, 0x20, 0x0C, 0x06, 0x08, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x20, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x00, 0x10, 0x08, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x10, 0x08, 0x00, 0x01, 0x00, 0x80, 0x00, 0x10, 0x18, 0x00,
  0x01, 0x01, 0x80, 0x00, 0x10, 0x10, 0x00, 0x01, 0x01, 0x00, 0x00, 0x10,
  0x10, 0x00, 0x01, 0x01, 0x00, 0x00, 0x10, 0x10, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x02, 0x02, 0x00, 0x00, 0x60, 0x20, 0x00, 0x04,
  0x02, 0x00, 0x00, 0x40, 0x20, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x80, 0x60,
  0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0x40, 0x00, 0x20, 0x04, 0x00, 0x06,
  0x00, 0x40, 0x00, 0xC0, 0x04, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x08, 0x06, 0x00, 0x00, 0x83, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x60, 0x18, 0x10, 0x00, 0x80,
  0x10, 0x60, 0x01, 0x00, 0x20, 0xC0, 0x02, 0x00, 0x61, 0x00, 0x0C, 0x00,
  0x42, 0x00, 0x18, 0x00, 0x84, 0x00, 0x20, 0x01, 0x08, 0x00, 0x40, 0x02,
  0x30, 0x00, 0x80, 0x06, 0x60, 0x01, 0x00, 0x0C, 0xC0, 0x06, 0x00, 0x19,
  0x00, 0x0C, 0x00, 0x32, 0x00, 0x10, 0x00, 0x64, 0x00, 0x20, 0x00, 0xC8,
  0x00, 0x40, 0x01, 0xB0, 0x00, 0x80, 0x03, 0x60, 0x03, 0x00, 0x04, 0x80,
  0x06, 0x00, 0x09, 0x00, 0x0C, 0x00, 0x12, 0x00, 0x10, 0x00, 0x24, 0x00,
  0x20, 0x00, 0x58, 0x00, 0x40, 0x01, 0xB0, 0x00, 0x80, 0x02, 0x40, 0x03,
  0x00, 0x04, 0x80, 0x06, 0x00, 0x19, 0x00, 0x0C, 0x00, 0x32, 0x00, 0x30,
  0x00, 0x44, 0x00, 0x60, 0x01, 0x88, 0x01, 0x40, 0x02, 0x10, 0x02, 0x40,
  0x08, 0x20, 0x08, 0x80, 0x30, 0x60, 0x21, 0x80, 0xC0, 0x60, 0x81, 0x83,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x0E, 0xC0,
  0x18, 0x30, 0x06, 0x0C, 0x06, 0x03, 0x07, 0x00, 0x81, 0x00, 0x23, 0x80,
  0x18, 0x60, 0x04, 0xC0, 0x01, 0x08, 0x00, 0xC0, 0x00, 0x22, 0x00, 0x18,
  0x00, 0x04, 0x40, 0x03, 0x00, 0x00, 0xD0, 0x00, 0x60, 0x00, 0x0A, 0x00,
  0x0C, 0x00, 0x01, 0x40, 0x01, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x0E,
  0x00, 0x00, 0x80, 0x02, 0xC0, 0x00, 0x10, 0x00, 0x48, 0x00, 0x02, 0x00,
  0x19, 0x00, 0x00, 0x40, 0x02, 0x20, 0x00, 0x88, 0x00, 0xC6, 0x00, 0x39,
  0x00, 0x10, 0x40, 0x1C, 0x20, 0x04, 0x08, 0x0E, 0x02, 0x01, 0x00, 0x87,
  0x00, 0x60, 0xC0, 0x19, 0x80, 0x03, 0xE0, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x08, 0x00, 0x00, 0x40, 0x40, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x08, 0x08, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x02, 0x02, 0x00, 0x00, 0x10, 0x10, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x40, 0x60, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x10, 0x10, 0x00, 0x00, 0x80, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x02, 0x03, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x04, 0x04, 0x00, 0x00, 0x60, 0x20, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x10, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xA0,
  0x10, 0x00, 0x07, 0x00, 0x80, 0x00, 0x58, 0x06, 0x00, 0x04, 0x80, 0x10,
  0x00, 0x44, 0x00, 0x40, 0x04, 0x20, 0x01, 0x80, 0xC1, 0x00, 0x03, 0xF8,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x08, 0x04, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0xC0, 0x38, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x02, 0x03, 0x01, 0xF8, 0x0C, 0x0C, 0x00, 0x3C, 0x18, 0x30, 0x00, 0x1F,
  0x20, 0x40, 0x00, 0x07, 0xC0, 0x80, 0x00, 0x03, 0x83, 0x00, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x03, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x10, 0x00, 0xC0, 0x00, 0x20, 0x03, 0x00, 0x00, 0x40, 0x0C, 0x00,
  0x00, 0x80, 0x30, 0x00, 0x01, 0x80, 0x80, 0x00, 0x01, 0x07, 0x00, 0x00,
  0x02, 0x09, 0xF0, 0x00, 0x04, 0x10, 0x1F, 0x00, 0x08, 0x20, 0x01, 0xF0,
  0x10, 0xC0, 0x00, 0x3E, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60,
  0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0x03, 0x0C, 0x00, 0x01, 0x04, 0x06, 0x00, 0x03, 0x08, 0x03, 0x00, 0x02,
  0x10, 0x01, 0x00, 0x02, 0x10, 0x00, 0x80, 0x04, 0x20, 0x00, 0xC0, 0x0C,
  0x20, 0x00, 0x60, 0x08, 0x40, 0x00, 0x30, 0x10, 0x40, 0x00, 0x18, 0x60,
  0xC0, 0x00, 0x07, 0x80,
};

const GFXglyph IBMPlexMono_ThinItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 10, 44, 38, 14, -44 },
  { 56, 13, 16, 38, 16, -47 },
  { 82, 38, 44, 38, 1, -44 },
  { 291, 34, 58, 38, 2, -51 },
  { 538, 42, 46, 38, -1, -45 },
  { 780, 36, 46, 38, 1, -45 },
  { 987, 4, 16, 38, 21, -47 },
  { 995, 19, 57, 38, 15, -48 },
  { 1131, 19, 57, 38, 5, -48 },
  { 1267, 32, 31, 38, 4, -35 },
  { 1391, 31, 31, 38, 4, -35 },
  { 1512, 9, 16, 38, 10, -5 },
  { 1530, 17, 1, 38, 11, -20 },
  { 1533, 5, 4, 38, 14, -4 },
  { 1536, 34, 57, 38, 2, -48 },
  { 1779, 30, 46, 38, 5, -45 },
  { 1952, 29, 44, 38, 3, -44 },
  { 2112, 31, 45, 38, 3, -45 },
  { 2287, 30, 46, 38, 3, -45 },
  { 2460, 32, 44, 38, 2, -44 },
  { 2636, 31, 45, 38, 4, -44 },
  { 2811, 27, 45, 38, 5, -44 },
  { 2963, 30, 44, 38, 7, -44 },
  { 3128, 31, 46, 38, 4, -45 },
  { 3307, 27, 45, 38, 7, -45 },
  { 3459, 9, 33, 38, 14, -33 },
  { 3497, 13, 44, 38, 10, -33 },
  { 3569, 30, 34, 38, 6, -36 },
  { 3697, 32, 12, 38, 3, -25 },
  { 3745, 30, 34, 38, 3, -36 },
  { 3873, 24, 45, 38, 10, -45 },
  { 4008, 29, 52, 38, 5, -45 },
  { 4197, 31, 44, 38, 1, -44 },
  { 4368, 30, 44, 38, 4, -44 },
  { 4533, 29, 46, 38, 6, -45 },
  { 4700, 31, 44, 38, 4, -44 },
  { 4871, 33, 44, 38, 4, -44 },
  { 5053, 33, 44, 38, 4, -44 },
  { 5235, 29, 46, 38, 6, -45 },
  { 5402, 33, 44, 38, 3, -44 },
  { 5584, 34, 44, 38, 3, -44 },
  { 5771, 29, 45, 38, 5, -44 },
  { 5935, 35, 44, 38, 4, -44 },
  { 6128, 25, 44, 38, 6, -44 },
  { 6266, 34, 44, 38, 3, -44 },
  { 6453, 33, 44, 38, 3, -44 },
  { 6635, 30, 46, 38, 5, -45 },
  { 6808, 32, 44, 38, 4, -44 },
  { 6984, 30, 56, 38, 5, -45 },
  { 7194, 32, 44, 38, 4, -44 },
  { 7370, 34, 46, 38, 2, -45 },
  { 7566, 33, 44, 38, 7, -44 },
  { 7748, 31, 45, 38, 5, -44 },
  { 7923, 31, 44, 38, 8, -44 },
  { 8094, 34, 44, 38, 5, -44 },
  { 8281, 39, 44, 38, 0, -44 },
  { 8496, 35, 44, 38, 6, -44 },
  { 8689, 38, 44, 38, 0, -44 },
  { 8898, 25, 57, 38, 12, -48 },
  { 9077, 14, 57, 38, 13, -48 },
  { 9177, 24, 57, 38, 2, -48 },
  { 9348, 29, 24, 38, 5, -44 },
  { 9435, 30, 1, 38, 0, 8 },
  { 9439, 7, 10, 38, 15, -48 },
  { 9448, 29, 34, 38, 4, -33 },
  { 9572, 28, 48, 38, 5, -47 },
  { 9740, 26, 34, 38, 5, -33 },
  { 9851, 31, 48, 38, 4, -47 },
  { 10037, 27, 34, 38, 5, -33 },
  { 10152, 40, 60, 38, -1, -47 },
  { 10452, 30, 46, 38, 3, -33 },
  { 10625, 25, 47, 38, 6, -47 },
  { 10772, 26, 48, 38, 6, -47 },
  { 10928, 26, 60, 38, 7, -47 },
  { 11123, 31, 48, 38, 5, -47 },
  { 11309, 23, 48, 38, 8, -47 },
  { 11447, 33, 33, 38, 3, -33 },
  { 11584, 25, 33, 38, 6, -33 },
  { 11688, 28, 34, 38, 5, -33 },
  { 11807, 30, 46, 38, 3, -33 },
  { 11980, 29, 46, 38, 4, -33 },
  { 12147, 30, 33, 38, 8, -33 },
  { 12271, 29, 34, 38, 4, -33 },
  { 12395, 31, 45, 38, 5, -44 },
  { 12570, 26, 34, 38, 6, -33 },
  { 12681, 28, 33, 38, 5, -33 },
  { 12797, 31, 34, 38, 5, -33 },
  { 12929, 35, 34, 38, 2, -33 },
  { 13078, 29, 46, 38, 3, -33 },
  { 13245, 31, 34, 38, 3, -33 },
  { 13377, 28, 57, 38, 8, -48 },
  { 13577, 11, 57, 38, 14, -48 },
  { 13656, 28, 57, 38, 3, -48 },
  { 13856, 32, 11, 38, 3, -25 },
};

const GFXfont IBMPlexMono_ThinItalic63pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic63pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic63pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _IBMPLEXMONO_THINITALIC63PT7B_H_
