#ifndef _IBMPLEXMONO_THINITALIC14PT7B_H_
#define _IBMPLEXMONO_THINITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x68, 0x20, 0xFF, 0x0A, 0x05, 0x04, 0x8E, 0x71, 0x41, 0x23,
  0x9C, 0x50, 0x48, 0x28, 0x00, 0x18, 0x79, 0x4C, 0x89, 0x0E, 0x0B, 0x12,
  0x25, 0x49, 0xE1, 0x00, 0x38, 0xA4, 0xA2, 0x89, 0x83, 0x00, 0x30, 0xA4,
  0xA2, 0x92, 0x47, 0x00, 0x1C, 0x24, 0x44, 0x24, 0x34, 0x58, 0x88, 0x89,
  0x8D, 0x72, 0xF0, 0x19, 0x10, 0x88, 0x42, 0x10, 0x84, 0x20, 0x86, 0x00,
  0x22, 0x11, 0x11, 0x11, 0x12, 0x24, 0x80, 0x10, 0x22, 0x4B, 0x63, 0x0A,
  0x22, 0x00, 0x10, 0x20, 0x47, 0xF2, 0x04, 0x08, 0x00, 0x68, 0xF0, 0x80,
  0x02, 0x08, 0x10, 0x40, 0x82, 0x08, 0x10, 0x40, 0x82, 0x04, 0x08, 0x00,
  0x3C, 0x8A, 0x0C, 0x18, 0x32, 0x61, 0x42, 0x88, 0xE0, 0x08, 0xC7, 0x24,
  0x10, 0x41, 0x08, 0x23, 0xF0, 0x1D, 0x98, 0x41, 0x04, 0x21, 0x18, 0x83,
  0xF0, 0x3D, 0x10, 0x41, 0x38, 0x20, 0x41, 0x89, 0xC0, 0x02, 0x06, 0x0A,
  0x14, 0x24, 0x44, 0x84, 0x7F, 0x84, 0x04, 0x3E, 0x81, 0x05, 0xC4, 0x40,
  0x81, 0x02, 0x88, 0xE0, 0x0C, 0x42, 0x10, 0xBB, 0x18, 0x61, 0x85, 0xE0,
  0xFE, 0x28, 0x84, 0x10, 0x84, 0x10, 0x82, 0x00, 0x3C, 0x86, 0x0A, 0x23,
  0x98, 0xA1, 0x42, 0x84, 0xF0, 0x3C, 0x8A, 0x0C, 0x28, 0x4F, 0x82, 0x04,
  0x10, 0xC0, 0x40, 0x02, 0x20, 0x00, 0x02, 0x90, 0x02, 0x18, 0xC6, 0x04,
  0x06, 0x03, 0x00, 0xFE, 0x03, 0xF0, 0x40, 0x81, 0x81, 0x08, 0xCC, 0x00,
  0x3B, 0x28, 0x42, 0x08, 0xC4, 0x10, 0x01, 0x00, 0x1C, 0x94, 0x67, 0xA6,
  0x9C, 0x69, 0x9E, 0x07, 0x80, 0x04, 0x18, 0x50, 0xA2, 0x48, 0x8F, 0x21,
  0x83, 0x04, 0x7D, 0x18, 0x61, 0x7A, 0x18, 0x61, 0x87, 0xE0, 0x1C, 0x49,
  0x0C, 0x08, 0x10, 0x20, 0x42, 0x88, 0xE0, 0x7C, 0x89, 0x0C, 0x18, 0x30,
  0x61, 0x42, 0x89, 0xE0, 0x7E, 0x82, 0x04, 0x07, 0xD0, 0x20, 0x40, 0x81,
  0xF8, 0x7E, 0x82, 0x04, 0x07, 0xD0, 0x20, 0x40, 0x81, 0x00, 0x1C, 0x49,
  0x0C, 0x08, 0x13, 0xA1, 0x42, 0x84, 0xF8, 0x43, 0x06, 0x0C, 0x27, 0xD0,
  0xA1, 0x42, 0x85, 0x08, 0x7E, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x21,
  0xF8, 0x3C, 0x10, 0x41, 0x04, 0x10, 0xA2, 0x89, 0xC0, 0x43, 0x44, 0x88,
  0x90, 0xA0, 0xD0, 0x90, 0x88, 0x88, 0x84, 0x41, 0x04, 0x10, 0x42, 0x08,
  0x20, 0x83, 0xF0, 0xC3, 0x87, 0x1D, 0x5A, 0xB6, 0xA9, 0x42, 0x85, 0x08,
  0x43, 0x86, 0x8D, 0x2A, 0x52, 0xA5, 0x4A, 0x8D, 0x08, 0x3C, 0x8A, 0x0C,
  0x18, 0x30, 0x61, 0x42, 0x88, 0xE0, 0x7C, 0x85, 0x0C, 0x18, 0x2F, 0xA0,
  0x40, 0x81, 0x00, 0x3C, 0x8A, 0x0C, 0x18, 0x30, 0x61, 0x42, 0x88, 0xE0,
  0x80, 0xA0, 0x80, 0x7C, 0x85, 0x0C, 0x18, 0x2F, 0xA4, 0x48, 0x89, 0x18,
  0x38, 0x8A, 0x0C, 0x07, 0x01, 0x81, 0x02, 0x84, 0xF0, 0xFE, 0x40, 0x81,
  0x02, 0x04, 0x10, 0x20, 0x40, 0x80, 0x43, 0x06, 0x0C, 0x28, 0x50, 0xA1,
  0x42, 0x88, 0xF0, 0x87, 0x0A, 0x24, 0x49, 0x12, 0x24, 0x50, 0xA0, 0x80,
  0x83, 0x82, 0x82, 0x92, 0xB4, 0xB4, 0xD4, 0xD4, 0x88, 0x88, 0x41, 0x91,
  0x08, 0x82, 0x81, 0x80, 0xC0, 0xA0, 0x48, 0x44, 0x41, 0x00, 0x81, 0x42,
  0x44, 0x28, 0x30, 0x20, 0x20, 0x20, 0x20, 0x20, 0x3F, 0x01, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x80, 0xFE, 0x3A, 0x10, 0x88, 0x42, 0x10, 0x84,
  0x21, 0x0E, 0x00, 0x92, 0x49, 0x12, 0x49, 0x12, 0x1C, 0x90, 0x82, 0x08,
  0x20, 0x82, 0x10, 0x41, 0x04, 0xF0, 0x08, 0x71, 0x22, 0x28, 0x60, 0xFE,
  0x90, 0x3D, 0x18, 0x61, 0x8A, 0x27, 0x40, 0x41, 0x04, 0x1F, 0xC6, 0x18,
  0x61, 0x87, 0xE0, 0x39, 0x18, 0x20, 0x86, 0x27, 0x00, 0x02, 0x04, 0x11,
  0xE4, 0x50, 0xA1, 0x44, 0x88, 0xF0, 0x3D, 0x18, 0x7E, 0x82, 0x37, 0x00,
  0x07, 0x84, 0x02, 0x07, 0xE0, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x24,
  0x0C, 0x02, 0x00, 0x3D, 0x18, 0x61, 0x8A, 0x27, 0x82, 0x89, 0xC0, 0x41,
  0x04, 0x16, 0x65, 0x18, 0x61, 0x8A, 0x20, 0x10, 0x00, 0x3C, 0x20, 0x82,
  0x11, 0x58, 0x80, 0x08, 0x01, 0xF1, 0x08, 0x42, 0x11, 0x28, 0xC2, 0x00,
  0x40, 0x81, 0x02, 0xEE, 0x50, 0xAE, 0x51, 0x95, 0x10, 0xE1, 0x10, 0x84,
  0x21, 0x11, 0xB2, 0x00, 0xB7, 0xB6, 0x4C, 0x9A, 0x54, 0xA9, 0x00, 0x59,
  0x94, 0x61, 0x86, 0x28, 0x80, 0x39, 0x18, 0x61, 0x86, 0x17, 0x80, 0x7F,
  0x18, 0x61, 0x86, 0x1F, 0xA0, 0x82, 0x00, 0x3D, 0x18, 0x61, 0x86, 0x27,
  0x82, 0x08, 0x20, 0xFD, 0x84, 0x10, 0x41, 0x08, 0x00, 0x3F, 0x18, 0x1F,
  0x06, 0x17, 0x80, 0x10, 0x40, 0x87, 0xF2, 0x04, 0x08, 0x22, 0x58, 0x40,
  0xC6, 0x18, 0x61, 0x8A, 0x67, 0x80, 0xC5, 0x14, 0x51, 0x46, 0x27, 0x00,
  0x93, 0x26, 0x4C, 0x9A, 0x34, 0xB7, 0x00, 0x13, 0x75, 0x09, 0x10, 0x90,
  0x9B, 0x64, 0xC6, 0x18, 0x61, 0x8A, 0x67, 0x82, 0x99, 0xC0, 0x7B, 0x08,
  0x21, 0x84, 0x98, 0xAF, 0x00, 0x1C, 0x82, 0x08, 0x20, 0x4E, 0x08, 0x21,
  0x08, 0x20, 0x70, 0x69, 0x24, 0xA4, 0x92, 0x48, 0x38, 0x21, 0x04, 0x20,
  0x81, 0xC8, 0x40, 0x82, 0x08, 0xE0, 0x63, 0x2A, 0x30,
};

const GFXglyph IBMPlexMono_ThinItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 2, 4, 8, 4, -10 },
  { 5, 9, 10, 8, 0, -10 },
  { 17, 7, 12, 8, 1, -11 },
  { 28, 9, 10, 8, 0, -10 },
  { 40, 8, 10, 8, 0, -10 },
  { 50, 1, 4, 8, 5, -10 },
  { 51, 5, 13, 8, 3, -11 },
  { 60, 4, 13, 8, 1, -11 },
  { 67, 7, 7, 8, 1, -8 },
  { 74, 7, 7, 8, 1, -8 },
  { 81, 2, 3, 8, 2, -1 },
  { 82, 4, 1, 8, 2, -5 },
  { 83, 1, 1, 8, 3, -1 },
  { 84, 7, 13, 8, 1, -11 },
  { 96, 7, 10, 8, 1, -10 },
  { 105, 6, 10, 8, 1, -10 },
  { 113, 6, 10, 8, 1, -10 },
  { 121, 6, 10, 8, 1, -10 },
  { 129, 8, 10, 8, 0, -10 },
  { 139, 7, 10, 8, 1, -10 },
  { 148, 6, 10, 8, 1, -10 },
  { 156, 6, 10, 8, 2, -10 },
  { 164, 7, 10, 8, 1, -10 },
  { 173, 7, 10, 8, 1, -10 },
  { 182, 2, 8, 8, 3, -8 },
  { 184, 3, 10, 8, 2, -8 },
  { 188, 7, 7, 8, 1, -8 },
  { 195, 7, 3, 8, 1, -6 },
  { 198, 6, 7, 8, 1, -8 },
  { 204, 6, 10, 8, 2, -10 },
  { 212, 6, 11, 8, 1, -10 },
  { 221, 7, 10, 8, 0, -10 },
  { 230, 6, 10, 8, 1, -10 },
  { 238, 7, 10, 8, 1, -10 },
  { 247, 7, 10, 8, 1, -10 },
  { 256, 7, 10, 8, 1, -10 },
  { 265, 7, 10, 8, 1, -10 },
  { 274, 7, 10, 8, 1, -10 },
  { 283, 7, 10, 8, 1, -10 },
  { 292, 7, 10, 8, 1, -10 },
  { 301, 6, 10, 8, 1, -10 },
  { 309, 8, 10, 8, 1, -10 },
  { 319, 6, 10, 8, 1, -10 },
  { 327, 7, 10, 8, 1, -10 },
  { 336, 7, 10, 8, 1, -10 },
  { 345, 7, 10, 8, 1, -10 },
  { 354, 7, 10, 8, 1, -10 },
  { 363, 7, 13, 8, 1, -10 },
  { 375, 7, 10, 8, 1, -10 },
  { 384, 7, 10, 8, 1, -10 },
  { 393, 7, 10, 8, 2, -10 },
  { 402, 7, 10, 8, 1, -10 },
  { 411, 7, 10, 8, 2, -10 },
  { 420, 8, 10, 8, 1, -10 },
  { 430, 9, 10, 8, 0, -10 },
  { 442, 8, 10, 8, 1, -10 },
  { 452, 8, 10, 8, 0, -10 },
  { 462, 5, 13, 8, 3, -11 },
  { 471, 3, 13, 8, 3, -11 },
  { 476, 6, 13, 8, 0, -11 },
  { 486, 7, 5, 8, 1, -10 },
  { 491, 7, 1, 8, 0, 1 },
  { 492, 2, 2, 8, 3, -11 },
  { 493, 6, 7, 8, 1, -7 },
  { 499, 6, 10, 8, 1, -10 },
  { 507, 6, 7, 8, 1, -7 },
  { 513, 7, 10, 8, 1, -10 },
  { 522, 6, 7, 8, 1, -7 },
  { 528, 9, 13, 8, 0, -10 },
  { 543, 6, 10, 8, 1, -7 },
  { 551, 6, 10, 8, 1, -10 },
  { 559, 6, 10, 8, 1, -10 },
  { 567, 5, 13, 8, 2, -10 },
  { 576, 7, 10, 8, 1, -10 },
  { 585, 5, 10, 8, 2, -10 },
  { 592, 7, 7, 8, 1, -7 },
  { 599, 6, 7, 8, 1, -7 },
  { 605, 6, 7, 8, 1, -7 },
  { 611, 6, 10, 8, 1, -7 },
  { 619, 6, 10, 8, 1, -7 },
  { 627, 6, 7, 8, 2, -7 },
  { 633, 6, 7, 8, 1, -7 },
  { 639, 7, 10, 8, 1, -10 },
  { 648, 6, 7, 8, 1, -7 },
  { 654, 6, 7, 8, 1, -7 },
  { 660, 7, 7, 8, 1, -7 },
  { 667, 8, 7, 8, 0, -7 },
  { 674, 6, 10, 8, 1, -7 },
  { 682, 7, 7, 8, 1, -7 },
  { 689, 6, 13, 8, 2, -11 },
  { 699, 3, 13, 8, 3, -11 },
  { 704, 6, 13, 8, 1, -11 },
  { 714, 7, 3, 8, 1, -6 },
};

const GFXfont IBMPlexMono_ThinItalic14pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic14pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _IBMPLEXMONO_THINITALIC14PT7B_H_
