#ifndef _IBMPLEXMONO_THINITALIC13PT7B_H_
#define _IBMPLEXMONO_THINITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0xA0, 0x80, 0xB6, 0x80, 0x1A, 0x14, 0x73, 0x24, 0x28, 0x28,
  0xCE, 0x48, 0x50, 0x08, 0x39, 0xAA, 0x43, 0x03, 0x85, 0x09, 0xD4, 0x70,
  0x80, 0x31, 0x4A, 0x8C, 0x74, 0x00, 0x2E, 0x52, 0x92, 0x8C, 0x18, 0x24,
  0x44, 0x24, 0x78, 0x90, 0x8A, 0x8F, 0x72, 0xE0, 0x34, 0x48, 0x88, 0x88,
  0x88, 0x84, 0x22, 0x11, 0x11, 0x11, 0x22, 0x48, 0x10, 0x8A, 0x5E, 0x52,
  0x60, 0x10, 0x82, 0x3F, 0x20, 0x82, 0x00, 0x68, 0xF0, 0x80, 0x02, 0x04,
  0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x81, 0x04, 0x00, 0x39, 0x18, 0x61,
  0xA6, 0x18, 0x62, 0x70, 0x10, 0xC5, 0x24, 0x20, 0x82, 0x08, 0xFC, 0x39,
  0x18, 0x41, 0x08, 0x42, 0x30, 0xF8, 0x39, 0x10, 0x42, 0x30, 0x20, 0xA2,
  0x70, 0x06, 0x18, 0x51, 0x24, 0x50, 0x9F, 0xC4, 0x08, 0x3D, 0x08, 0x1E,
  0x88, 0x20, 0xA2, 0x70, 0x18, 0x84, 0x20, 0xBB, 0x18, 0x62, 0x70, 0xFE,
  0x29, 0x04, 0x21, 0x04, 0x20, 0x80, 0x39, 0x18, 0x61, 0x7B, 0x28, 0x61,
  0x78, 0x39, 0x18, 0x61, 0x85, 0xE1, 0x08, 0x40, 0x40, 0x08, 0x20, 0x00,
  0x14, 0x80, 0x04, 0x66, 0x20, 0x40, 0x81, 0x80, 0xFC, 0x00, 0x3F, 0x40,
  0x81, 0x81, 0x19, 0x88, 0x00, 0x74, 0x62, 0x11, 0x31, 0x00, 0x40, 0x39,
  0x18, 0x67, 0xA7, 0x2C, 0xAE, 0x81, 0xC0, 0x08, 0x30, 0x61, 0x22, 0x48,
  0x9F, 0x22, 0x86, 0x7A, 0x18, 0x61, 0x7A, 0x18, 0x62, 0xF8, 0x39, 0x18,
  0x60, 0x82, 0x08, 0xA2, 0x70, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x62, 0xF0,
  0x7F, 0x02, 0x04, 0x07, 0xD0, 0x20, 0x40, 0xF8, 0x7F, 0x02, 0x04, 0x07,
  0xD0, 0x20, 0x40, 0x80, 0x39, 0x18, 0x60, 0x9E, 0x18, 0xA2, 0x78, 0xC6,
  0x18, 0x61, 0xFE, 0x18, 0xA2, 0x88, 0x7E, 0x20, 0x41, 0x02, 0x04, 0x08,
  0x10, 0xF8, 0x3C, 0x10, 0x42, 0x08, 0x20, 0xA2, 0x70, 0x47, 0x12, 0x45,
  0x0E, 0x12, 0x24, 0x44, 0x8C, 0x42, 0x11, 0x08, 0x42, 0x10, 0xF8, 0x43,
  0x9B, 0x35, 0xAA, 0x50, 0xA1, 0x44, 0x88, 0xC7, 0x1A, 0x69, 0xA6, 0x59,
  0xA6, 0x88, 0x39, 0x18, 0x61, 0x86, 0x18, 0x62, 0x70, 0x7D, 0x18, 0x61,
  0x87, 0xE8, 0x20, 0x80, 0x39, 0x18, 0x61, 0x86, 0x18, 0x62, 0x70, 0x81,
  0x46, 0x7D, 0x18, 0x61, 0x87, 0xE9, 0x24, 0x88, 0x1C, 0xC5, 0x01, 0x01,
  0xC0, 0x80, 0xE2, 0x38, 0xFE, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x20,
  0xC6, 0x18, 0x61, 0x86, 0x18, 0xA2, 0x70, 0x86, 0x28, 0xA4, 0x92, 0x8A,
  0x30, 0x40, 0x83, 0x06, 0x14, 0xAB, 0x5A, 0xB6, 0x4C, 0x88, 0x41, 0x22,
  0x24, 0x18, 0x10, 0x28, 0x28, 0x44, 0x86, 0x83, 0x09, 0x22, 0x43, 0x04,
  0x08, 0x10, 0x20, 0x3F, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0xFE,
  0x7A, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0xC0, 0x92, 0x49, 0x22, 0x49,
  0x30, 0x38, 0x42, 0x10, 0x84, 0x42, 0x10, 0x85, 0xE0, 0x10, 0xA4, 0xA1,
  0x84, 0xFC, 0xB0, 0x37, 0x28, 0xA2, 0x8A, 0x67, 0xC0, 0x41, 0x04, 0x2E,
  0x46, 0x18, 0x61, 0x8B, 0xC0, 0x32, 0x61, 0x08, 0xC9, 0xC0, 0x04, 0x10,
  0x4D, 0xCE, 0x28, 0xA2, 0x99, 0xE0, 0x3B, 0x18, 0xBC, 0x82, 0x27, 0x00,
  0x07, 0x08, 0x08, 0x3E, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xA0, 0x60,
  0x20, 0x37, 0x38, 0xA2, 0x8A, 0x67, 0x82, 0x91, 0x80, 0x42, 0x10, 0xBE,
  0xC6, 0x31, 0x8C, 0x40, 0x10, 0x00, 0x38, 0x20, 0x84, 0x13, 0x50, 0x80,
  0x04, 0x00, 0x1E, 0x08, 0x20, 0x84, 0x10, 0x4D, 0x1C, 0x10, 0x41, 0x04,
  0x2E, 0xC6, 0x2B, 0x29, 0xA6, 0x60, 0xE4, 0x44, 0x44, 0x89, 0xA4, 0xAF,
  0x5A, 0x69, 0xA6, 0x9A, 0x40, 0xDF, 0x63, 0x18, 0xC6, 0x20, 0x39, 0x18,
  0x61, 0x8A, 0x27, 0x00, 0xB9, 0x18, 0x61, 0x86, 0x2F, 0x20, 0x82, 0x00,
  0x37, 0x38, 0xA2, 0x8A, 0x67, 0x82, 0x10, 0x40, 0xDC, 0x84, 0x10, 0x42,
  0x08, 0x00, 0x7A, 0x18, 0x1E, 0x0A, 0x27, 0x80, 0x20, 0x8F, 0xC8, 0x21,
  0x04, 0x56, 0x20, 0x86, 0x28, 0xA2, 0x8A, 0x27, 0x80, 0xC5, 0x14, 0x51,
  0x8A, 0x46, 0x00, 0x96, 0x5A, 0x69, 0xA6, 0x9D, 0x80, 0x16, 0x7A, 0x11,
  0x10, 0x90, 0xB2, 0x6C, 0x86, 0x28, 0xA2, 0x8A, 0x27, 0x84, 0x93, 0x80,
  0x7E, 0x10, 0x8C, 0x4B, 0x2B, 0x80, 0x39, 0x10, 0x42, 0x61, 0x88, 0x44,
  0x20, 0xC0, 0x55, 0xAA, 0xAA, 0x30, 0x84, 0x42, 0x0D, 0x88, 0x21, 0x09,
  0xC0, 0x66, 0x99, 0x80,
};

const GFXglyph IBMPlexMono_ThinItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 3, 3, 8, 3, -10 },
  { 6, 8, 9, 8, 0, -9 },
  { 15, 7, 11, 8, 0, -10 },
  { 25, 8, 9, 8, 0, -9 },
  { 34, 8, 9, 8, 0, -9 },
  { 43, 1, 3, 8, 4, -10 },
  { 44, 4, 12, 8, 3, -10 },
  { 50, 4, 12, 8, 1, -10 },
  { 56, 6, 6, 8, 1, -7 },
  { 61, 6, 7, 8, 1, -7 },
  { 67, 2, 3, 8, 2, -1 },
  { 68, 4, 1, 8, 2, -4 },
  { 69, 1, 1, 8, 3, -1 },
  { 70, 7, 12, 8, 0, -10 },
  { 81, 6, 9, 8, 1, -9 },
  { 88, 6, 9, 8, 1, -9 },
  { 95, 6, 9, 8, 1, -9 },
  { 102, 6, 9, 8, 1, -9 },
  { 109, 7, 9, 8, 0, -9 },
  { 117, 6, 9, 8, 1, -9 },
  { 124, 6, 9, 8, 1, -9 },
  { 131, 6, 9, 8, 2, -9 },
  { 138, 6, 9, 8, 1, -9 },
  { 145, 6, 9, 8, 1, -9 },
  { 152, 2, 7, 8, 3, -7 },
  { 154, 3, 9, 8, 2, -7 },
  { 158, 6, 7, 8, 1, -7 },
  { 164, 6, 4, 8, 1, -6 },
  { 167, 6, 7, 8, 1, -7 },
  { 173, 5, 9, 8, 2, -9 },
  { 179, 6, 10, 8, 1, -9 },
  { 187, 7, 9, 8, 0, -9 },
  { 195, 6, 9, 8, 1, -9 },
  { 202, 6, 9, 8, 1, -9 },
  { 209, 6, 9, 8, 1, -9 },
  { 216, 7, 9, 8, 1, -9 },
  { 224, 7, 9, 8, 1, -9 },
  { 232, 6, 9, 8, 1, -9 },
  { 239, 6, 9, 8, 1, -9 },
  { 246, 7, 9, 8, 1, -9 },
  { 254, 6, 9, 8, 1, -9 },
  { 261, 7, 9, 8, 1, -9 },
  { 269, 5, 9, 8, 1, -9 },
  { 275, 7, 9, 8, 1, -9 },
  { 283, 6, 9, 8, 1, -9 },
  { 290, 6, 9, 8, 1, -9 },
  { 297, 6, 9, 8, 1, -9 },
  { 304, 6, 12, 8, 1, -9 },
  { 313, 6, 9, 8, 1, -9 },
  { 320, 7, 9, 8, 0, -9 },
  { 328, 7, 9, 8, 1, -9 },
  { 336, 6, 9, 8, 1, -9 },
  { 343, 6, 9, 8, 2, -9 },
  { 350, 7, 9, 8, 1, -9 },
  { 358, 8, 9, 8, 0, -9 },
  { 367, 7, 9, 8, 1, -9 },
  { 375, 8, 9, 8, 0, -9 },
  { 384, 5, 12, 8, 3, -10 },
  { 392, 3, 12, 8, 3, -10 },
  { 397, 5, 12, 8, 0, -10 },
  { 405, 6, 5, 8, 1, -9 },
  { 409, 6, 1, 8, 0, 1 },
  { 410, 2, 2, 8, 3, -11 },
  { 411, 6, 7, 8, 1, -7 },
  { 417, 6, 10, 8, 1, -10 },
  { 425, 5, 7, 8, 1, -7 },
  { 430, 6, 10, 8, 1, -10 },
  { 438, 6, 7, 8, 1, -7 },
  { 444, 8, 13, 8, 0, -10 },
  { 457, 6, 10, 8, 1, -7 },
  { 465, 5, 10, 8, 1, -10 },
  { 472, 6, 10, 8, 1, -10 },
  { 480, 6, 13, 8, 1, -10 },
  { 490, 6, 10, 8, 1, -10 },
  { 498, 4, 10, 8, 2, -10 },
  { 503, 6, 7, 8, 1, -7 },
  { 509, 5, 7, 8, 1, -7 },
  { 514, 6, 7, 8, 1, -7 },
  { 520, 6, 10, 8, 1, -7 },
  { 528, 6, 10, 8, 1, -7 },
  { 536, 6, 7, 8, 2, -7 },
  { 542, 6, 7, 8, 1, -7 },
  { 548, 6, 9, 8, 1, -9 },
  { 555, 6, 7, 8, 1, -7 },
  { 561, 6, 7, 8, 1, -7 },
  { 567, 6, 7, 8, 1, -7 },
  { 573, 8, 7, 8, 0, -7 },
  { 580, 6, 10, 8, 1, -7 },
  { 588, 6, 7, 8, 1, -7 },
  { 594, 5, 12, 8, 2, -10 },
  { 602, 2, 12, 8, 3, -10 },
  { 605, 5, 12, 8, 1, -10 },
  { 613, 6, 3, 8, 1, -5 },
};

const GFXfont IBMPlexMono_ThinItalic13pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic13pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _IBMPLEXMONO_THINITALIC13PT7B_H_
