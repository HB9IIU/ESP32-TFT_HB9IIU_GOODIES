#ifndef _IBMPLEXMONO_THINITALIC21PT7B_H_
#define _IBMPLEXMONO_THINITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x92, 0x52, 0x00, 0x20, 0x4A, 0xA5, 0x29, 0x00, 0x03,
  0x20, 0x11, 0x00, 0x90, 0x08, 0x80, 0x44, 0x1E, 0x3C, 0x22, 0x01, 0x10,
  0x09, 0x07, 0x87, 0x04, 0x40, 0x24, 0x02, 0x20, 0x11, 0x00, 0x90, 0x00,
  0x02, 0x00, 0x40, 0x3E, 0x19, 0x24, 0x22, 0x88, 0x11, 0x02, 0x20, 0x34,
  0x01, 0xE0, 0x12, 0x04, 0x20, 0x84, 0x10, 0xA2, 0x22, 0x4C, 0x3E, 0x02,
  0x00, 0x40, 0x00, 0x1E, 0x0C, 0x88, 0x44, 0x11, 0x10, 0x48, 0x42, 0x40,
  0x8A, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x68, 0x81, 0x41, 0x09, 0x08,
  0x44, 0x22, 0x08, 0x88, 0x1C, 0x00, 0x07, 0x00, 0x88, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x08, 0x08, 0x83, 0x70, 0x44, 0x08, 0x20, 0x82, 0x08, 0x11,
  0x82, 0x94, 0x26, 0x3C, 0x60, 0xF8, 0x04, 0x21, 0x08, 0x41, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x41, 0x02, 0x00, 0x10, 0x40, 0x82,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x08, 0x21, 0x04, 0x21, 0x08, 0x00,
  0x06, 0x00, 0x80, 0x10, 0x02, 0x0E, 0x4E, 0x3E, 0x03, 0x00, 0x90, 0x22,
  0x08, 0x20, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x41, 0xFF, 0xC1, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x00, 0x25, 0x29, 0x00, 0xF8, 0x80, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00,
  0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x00, 0x1F, 0x0C, 0x24, 0x09, 0x02, 0x80, 0x60, 0x18, 0x0A, 0x22,
  0x80, 0xA0, 0x28, 0x0A, 0x04, 0x81, 0x20, 0x87, 0xC0, 0x03, 0x01, 0x80,
  0xA0, 0xC8, 0x22, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x02, 0x0F, 0xFC, 0x0F, 0x84, 0x12, 0x04, 0x81, 0x00, 0x40, 0x10,
  0x08, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x0F, 0xF8, 0x0F,
  0x04, 0x32, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x7C, 0x01, 0x00, 0x20,
  0x08, 0x02, 0x80, 0x90, 0x43, 0xE0, 0x00, 0x40, 0x60, 0x28, 0x0A, 0x04,
  0x82, 0x21, 0x08, 0x84, 0x41, 0x20, 0x48, 0x13, 0xFF, 0x01, 0x00, 0x80,
  0x20, 0x1F, 0xE2, 0x00, 0x80, 0x10, 0x02, 0x00, 0xBE, 0x08, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x48, 0x08, 0x82, 0x0F, 0x80, 0x03, 0x02,
  0x06, 0x04, 0x02, 0x02, 0x02, 0x79, 0xC2, 0x80, 0xC0, 0x60, 0x30, 0x28,
  0x14, 0x11, 0xF0, 0x7F, 0xE0, 0x18, 0x0A, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x04, 0x00, 0x0F, 0x82,
  0x08, 0x80, 0x90, 0x14, 0x04, 0x40, 0x84, 0x20, 0x78, 0x30, 0x98, 0x0A,
  0x01, 0x40, 0x28, 0x08, 0x83, 0x0F, 0x80, 0x1F, 0x10, 0xD0, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x43, 0x1E, 0x80, 0x80, 0x80, 0x80, 0x81, 0x80,
  0x60, 0x00, 0x00, 0x02, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x01, 0x08,
  0x84, 0x42, 0x00, 0x00, 0x40, 0x60, 0x60, 0x60, 0x60, 0x20, 0x04, 0x00,
  0x80, 0x18, 0x01, 0x00, 0x30, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x18, 0x08, 0x0C, 0x0C,
  0x0C, 0x00, 0x1E, 0x21, 0xC1, 0x81, 0x01, 0x01, 0x02, 0x0C, 0x30, 0x20,
  0x20, 0x00, 0x00, 0x00, 0x60, 0x0F, 0x08, 0x48, 0x28, 0x14, 0x7C, 0x4E,
  0x43, 0x41, 0xA0, 0xD0, 0xA8, 0x52, 0x69, 0xF4, 0x02, 0x01, 0x80, 0x7E,
  0x00, 0x01, 0x00, 0x60, 0x0A, 0x02, 0x40, 0x48, 0x11, 0x02, 0x20, 0x44,
  0x10, 0x42, 0x08, 0xFF, 0x10, 0x24, 0x04, 0x80, 0xA0, 0x08, 0x1F, 0x88,
  0x12, 0x04, 0x81, 0x40, 0x50, 0x14, 0x09, 0xFC, 0x40, 0x90, 0x18, 0x06,
  0x01, 0x80, 0xA0, 0x2F, 0xF0, 0x0F, 0x04, 0x22, 0x09, 0x01, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x04, 0x81, 0x10, 0x83, 0xC0,
  0x1F, 0x04, 0x18, 0x81, 0x10, 0x22, 0x02, 0x80, 0x50, 0x0A, 0x02, 0x40,
  0x48, 0x09, 0x01, 0x40, 0x48, 0x09, 0x02, 0x3F, 0x80, 0x1F, 0xE4, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x01, 0xFE, 0x40, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x3F, 0xE0, 0x1F, 0xE4, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x80, 0x10, 0x01, 0xFE, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x00, 0x0F, 0x0C, 0x22, 0x09, 0x01, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x87, 0xA0, 0x28, 0x0A, 0x04, 0x81, 0x10, 0xC3, 0xD0, 0x20, 0x24,
  0x04, 0x80, 0xA0, 0x14, 0x04, 0x80, 0x90, 0x13, 0xFE, 0x40, 0x48, 0x0A,
  0x02, 0x40, 0x48, 0x09, 0x01, 0x20, 0x20, 0x3F, 0xE0, 0x40, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x3F, 0xE0, 0x1F, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x48, 0x24, 0x21, 0xE0, 0x20, 0x32, 0x04,
  0x20, 0x82, 0x10, 0x22, 0x04, 0x40, 0x48, 0x05, 0x40, 0x64, 0x04, 0x20,
  0x42, 0x08, 0x10, 0x81, 0x08, 0x08, 0x80, 0xC0, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x20,
  0x24, 0x0D, 0x41, 0xA8, 0x55, 0x0A, 0xA2, 0x92, 0x92, 0x52, 0x8C, 0x51,
  0x0A, 0x01, 0x40, 0x48, 0x09, 0x01, 0x20, 0x20, 0x20, 0x26, 0x04, 0xC0,
  0xA8, 0x14, 0x84, 0x90, 0x91, 0x12, 0x22, 0x44, 0x50, 0x4A, 0x0A, 0x41,
  0x48, 0x19, 0x03, 0x20, 0x20, 0x1F, 0x0C, 0x24, 0x09, 0x02, 0x80, 0x60,
  0x18, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x81, 0x20, 0x87, 0xC0,
  0x1F, 0xC4, 0x08, 0x80, 0x90, 0x12, 0x02, 0x80, 0x50, 0x0A, 0x02, 0x7F,
  0x88, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x00, 0x1F, 0x0C, 0x24,
  0x09, 0x02, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04,
  0x81, 0x20, 0x87, 0xC0, 0x40, 0x08, 0x81, 0x40, 0x60, 0x1F, 0xC4, 0x08,
  0x80, 0x90, 0x12, 0x02, 0x80, 0x50, 0x0A, 0x02, 0x7F, 0x88, 0x81, 0x08,
  0x41, 0x08, 0x11, 0x02, 0x20, 0x20, 0x0F, 0x06, 0x19, 0x00, 0xA0, 0x04,
  0x00, 0x80, 0x0C, 0x00, 0x78, 0x00, 0x80, 0x08, 0x01, 0x00, 0x28, 0x08,
  0x83, 0x0F, 0x80, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x50, 0x14, 0x06, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x80, 0xA0,
  0x28, 0x12, 0x04, 0x81, 0x20, 0x87, 0xC0, 0x80, 0x60, 0x28, 0x0A, 0x04,
  0x81, 0x20, 0x88, 0x22, 0x10, 0x44, 0x12, 0x04, 0x81, 0x40, 0x50, 0x18,
  0x02, 0x00, 0x80, 0x30, 0x06, 0x01, 0x40, 0x28, 0x05, 0x10, 0xA5, 0x24,
  0xA4, 0x94, 0x94, 0xA2, 0x94, 0x62, 0x8C, 0x51, 0x0C, 0x20, 0x80, 0x10,
  0x08, 0x80, 0x82, 0x08, 0x10, 0x80, 0x48, 0x02, 0x80, 0x14, 0x00, 0x40,
  0x05, 0x00, 0x48, 0x04, 0x20, 0x21, 0x02, 0x08, 0x20, 0x22, 0x01, 0x80,
  0x80, 0x38, 0x04, 0x40, 0x44, 0x08, 0x21, 0x02, 0x20, 0x14, 0x01, 0x80,
  0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x1F,
  0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x03, 0xFF, 0x80,
  0x1F, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0xF8, 0x84, 0x21, 0x04, 0x21, 0x08,
  0x21, 0x08, 0x42, 0x08, 0x42, 0x10, 0x42, 0x1F, 0x01, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08,
  0x08, 0xF8, 0x04, 0x05, 0x04, 0x84, 0x22, 0x12, 0x0A, 0x03, 0x01, 0xFF,
  0xC0, 0x94, 0x0F, 0x4C, 0x34, 0x09, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02,
  0x81, 0x10, 0xC3, 0xCC, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x71, 0xC4,
  0x81, 0x40, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0B, 0x09, 0x78, 0x1E, 0x61,
  0x81, 0x80, 0x80, 0x80, 0x80, 0x81, 0x82, 0xC4, 0x38, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x1E, 0x8C, 0x32, 0x04, 0x40, 0x90, 0x12, 0x02,
  0x40, 0x48, 0x09, 0x02, 0x10, 0xC1, 0xE8, 0x1E, 0x10, 0xB0, 0x30, 0x28,
  0x37, 0xE2, 0x01, 0x02, 0x81, 0x21, 0x0F, 0x00, 0x00, 0xF8, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x0F, 0xF8, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x10, 0x80, 0x88, 0x03,
  0x40, 0x0E, 0x00, 0x10, 0x00, 0x0F, 0x4C, 0x34, 0x09, 0x02, 0x80, 0xA0,
  0x28, 0x0A, 0x02, 0x81, 0x10, 0xC3, 0xD0, 0x04, 0x01, 0x20, 0x87, 0xC0,
  0x20, 0x20, 0x20, 0x40, 0x40, 0x4E, 0x51, 0x61, 0x41, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x82, 0x82, 0x04, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x08, 0x44, 0x32, 0x61, 0x40, 0xC0, 0x00, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40,
  0x22, 0x10, 0x88, 0x24, 0x0A, 0x02, 0x00, 0x20, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x13, 0xC5, 0x11, 0x82, 0x41, 0x20, 0x48, 0xE2, 0x40, 0x90, 0x62,
  0x28, 0x52, 0x18, 0xF8, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41,
  0x02, 0x14, 0x69, 0x1C, 0x20, 0x5C, 0xCC, 0xA5, 0x08, 0xA2, 0x18, 0x43,
  0x08, 0xA1, 0x14, 0x42, 0x88, 0x51, 0x0A, 0x21, 0x00, 0x4E, 0x51, 0x61,
  0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x1E, 0x30, 0xA0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x02, 0x81, 0x61, 0x0F, 0x00, 0x27, 0x0E, 0x22,
  0x04, 0x81, 0x40, 0x50, 0x14, 0x05, 0x01, 0xC0, 0xA8, 0x49, 0xE2, 0x00,
  0x80, 0x20, 0x08, 0x00, 0x0F, 0x4C, 0x34, 0x09, 0x02, 0x80, 0xA0, 0x28,
  0x0A, 0x02, 0x81, 0x10, 0xC3, 0xD0, 0x04, 0x01, 0x00, 0x40, 0x20, 0xF7,
  0xC6, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04,
  0x00, 0x1F, 0x08, 0x34, 0x01, 0x00, 0x20, 0x07, 0xE0, 0x08, 0x02, 0x80,
  0x90, 0x23, 0xF0, 0x08, 0x02, 0x00, 0x80, 0x40, 0xFF, 0xC4, 0x01, 0x00,
  0x40, 0x10, 0x08, 0x02, 0x00, 0x86, 0x26, 0x0A, 0x03, 0x00, 0x40, 0xA0,
  0x60, 0x50, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x86, 0x43, 0x1E, 0x80, 0xE0,
  0x90, 0x48, 0x28, 0x14, 0x0A, 0x05, 0x04, 0x82, 0x42, 0x46, 0x1C, 0x00,
  0x84, 0xA1, 0x18, 0x86, 0x21, 0x88, 0x62, 0x18, 0x86, 0x22, 0x90, 0xAA,
  0x6E, 0x70, 0x0C, 0x61, 0x49, 0x63, 0x10, 0x21, 0x02, 0x00, 0x20, 0x04,
  0x08, 0x60, 0x86, 0x18, 0xA6, 0x71, 0x80, 0x20, 0x48, 0x24, 0x09, 0x02,
  0x40, 0x90, 0x24, 0x09, 0x04, 0x43, 0x10, 0xC3, 0xD0, 0x04, 0x02, 0x21,
  0x87, 0xC0, 0x3E, 0x50, 0x74, 0x05, 0x06, 0x02, 0x01, 0x01, 0x80, 0x82,
  0xC0, 0xBF, 0x28, 0x78, 0x0F, 0x84, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20,
  0x10, 0x08, 0x78, 0x0C, 0x01, 0x01, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x1F, 0x00, 0x24, 0x92, 0x92, 0x49, 0x49, 0x24, 0x92, 0x00, 0x1F, 0x00,
  0x80, 0x80, 0x40, 0x20, 0x20, 0x20, 0x10, 0x08, 0x03, 0xC3, 0x02, 0x01,
  0x00, 0x40, 0x20, 0x10, 0x08, 0x04, 0x3E, 0x00, 0x38, 0x29, 0x8A, 0x11,
  0x41, 0xC0,
};

const GFXglyph IBMPlexMono_ThinItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 15, 13, 5, -15 },
  { 7, 5, 5, 13, 5, -16 },
  { 11, 13, 15, 13, 0, -15 },
  { 36, 11, 19, 13, 1, -17 },
  { 63, 14, 15, 13, 0, -15 },
  { 90, 12, 15, 13, 0, -15 },
  { 113, 1, 5, 13, 7, -16 },
  { 114, 6, 19, 13, 5, -16 },
  { 129, 6, 19, 13, 2, -16 },
  { 144, 11, 10, 13, 1, -12 },
  { 158, 11, 11, 13, 1, -12 },
  { 174, 3, 6, 13, 3, -2 },
  { 177, 5, 1, 13, 4, -7 },
  { 178, 1, 1, 13, 5, -1 },
  { 179, 11, 19, 13, 1, -16 },
  { 206, 10, 15, 13, 2, -15 },
  { 225, 10, 15, 13, 1, -15 },
  { 244, 10, 15, 13, 1, -15 },
  { 263, 10, 15, 13, 1, -15 },
  { 282, 10, 15, 13, 1, -15 },
  { 301, 11, 15, 13, 1, -15 },
  { 322, 9, 15, 13, 2, -15 },
  { 339, 10, 15, 13, 2, -15 },
  { 358, 11, 15, 13, 1, -15 },
  { 379, 9, 15, 13, 2, -15 },
  { 396, 3, 11, 13, 5, -11 },
  { 401, 5, 15, 13, 3, -11 },
  { 411, 10, 11, 13, 2, -12 },
  { 425, 11, 5, 13, 1, -9 },
  { 432, 10, 11, 13, 1, -12 },
  { 446, 8, 15, 13, 3, -15 },
  { 461, 9, 17, 13, 2, -15 },
  { 481, 11, 15, 13, 0, -15 },
  { 502, 10, 15, 13, 1, -15 },
  { 521, 10, 15, 13, 2, -15 },
  { 540, 11, 15, 13, 1, -15 },
  { 561, 11, 15, 13, 1, -15 },
  { 582, 11, 15, 13, 1, -15 },
  { 603, 10, 15, 13, 2, -15 },
  { 622, 11, 15, 13, 1, -15 },
  { 643, 11, 15, 13, 1, -15 },
  { 664, 9, 15, 13, 2, -15 },
  { 681, 12, 15, 13, 1, -15 },
  { 704, 8, 15, 13, 2, -15 },
  { 719, 11, 15, 13, 1, -15 },
  { 740, 11, 15, 13, 1, -15 },
  { 761, 10, 15, 13, 2, -15 },
  { 780, 11, 15, 13, 1, -15 },
  { 801, 10, 19, 13, 2, -15 },
  { 825, 11, 15, 13, 1, -15 },
  { 846, 11, 15, 13, 1, -15 },
  { 867, 11, 15, 13, 2, -15 },
  { 888, 10, 15, 13, 2, -15 },
  { 907, 10, 15, 13, 3, -15 },
  { 926, 11, 15, 13, 2, -15 },
  { 947, 13, 15, 13, 0, -15 },
  { 972, 12, 15, 13, 2, -15 },
  { 995, 13, 15, 13, 0, -15 },
  { 1020, 8, 19, 13, 4, -16 },
  { 1039, 5, 19, 13, 4, -16 },
  { 1051, 8, 19, 13, 1, -16 },
  { 1070, 9, 8, 13, 2, -15 },
  { 1079, 10, 1, 13, 0, 2 },
  { 1081, 2, 3, 13, 5, -16 },
  { 1082, 10, 11, 13, 1, -11 },
  { 1096, 9, 16, 13, 2, -16 },
  { 1114, 8, 11, 13, 2, -11 },
  { 1125, 11, 16, 13, 1, -16 },
  { 1147, 9, 11, 13, 2, -11 },
  { 1160, 13, 20, 13, 0, -16 },
  { 1193, 10, 15, 13, 1, -11 },
  { 1212, 8, 16, 13, 2, -16 },
  { 1228, 9, 15, 13, 2, -15 },
  { 1245, 9, 19, 13, 2, -15 },
  { 1267, 10, 16, 13, 2, -16 },
  { 1287, 7, 16, 13, 3, -16 },
  { 1301, 11, 11, 13, 1, -11 },
  { 1317, 8, 11, 13, 2, -11 },
  { 1328, 9, 11, 13, 2, -11 },
  { 1341, 10, 15, 13, 1, -11 },
  { 1360, 10, 15, 13, 1, -11 },
  { 1379, 10, 11, 13, 3, -11 },
  { 1393, 10, 11, 13, 1, -11 },
  { 1407, 10, 15, 13, 2, -15 },
  { 1426, 9, 11, 13, 2, -11 },
  { 1439, 9, 11, 13, 2, -11 },
  { 1452, 10, 11, 13, 2, -11 },
  { 1466, 12, 11, 13, 0, -11 },
  { 1483, 10, 15, 13, 1, -11 },
  { 1502, 10, 11, 13, 1, -11 },
  { 1516, 9, 19, 13, 3, -16 },
  { 1538, 3, 19, 13, 5, -16 },
  { 1546, 9, 19, 13, 1, -16 },
  { 1568, 11, 4, 13, 1, -9 },
};

const GFXfont IBMPlexMono_ThinItalic21pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic21pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic21pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _IBMPLEXMONO_THINITALIC21PT7B_H_
