#ifndef _IBMPLEXMONO_THINITALIC37PT7B_H_
#define _IBMPLEXMONO_THINITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41,
  0x04, 0x20, 0x82, 0x08, 0x00, 0x00, 0x00, 0x63, 0x80, 0x42, 0x85, 0x0A,
  0x28, 0x50, 0xA1, 0x42, 0x84, 0x00, 0x10, 0x20, 0x00, 0x41, 0x00, 0x02,
  0x04, 0x00, 0x08, 0x10, 0x00, 0x20, 0x80, 0x01, 0x02, 0x00, 0x04, 0x08,
  0x00, 0x10, 0x40, 0x00, 0x81, 0x00, 0xFE, 0x07, 0xF0, 0x08, 0x20, 0x00,
  0x40, 0x80, 0x01, 0x04, 0x00, 0x04, 0x10, 0x00, 0x20, 0x40, 0x00, 0x82,
  0x00, 0xFE, 0x0F, 0xE0, 0x10, 0x20, 0x00, 0x41, 0x00, 0x01, 0x04, 0x00,
  0x08, 0x10, 0x00, 0x20, 0x80, 0x00, 0x82, 0x00, 0x04, 0x08, 0x00, 0x10,
  0x40, 0x00, 0x41, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0xFF, 0x00, 0x30, 0x8C, 0x04, 0x08, 0x20, 0x80,
  0x81, 0x08, 0x10, 0x01, 0x01, 0x00, 0x10, 0x10, 0x01, 0x01, 0x00, 0x08,
  0x10, 0x00, 0x82, 0x00, 0x04, 0x20, 0x00, 0x32, 0x00, 0x00, 0xF0, 0x00,
  0x02, 0xE0, 0x00, 0x21, 0x00, 0x04, 0x08, 0x00, 0x40, 0x80, 0x04, 0x04,
  0x00, 0x40, 0x40, 0x04, 0x04, 0x00, 0x40, 0x88, 0x08, 0x08, 0x40, 0x80,
  0x82, 0x08, 0x10, 0x18, 0x86, 0x00, 0x7F, 0x80, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0xF0, 0x01, 0x81, 0x84, 0x00,
  0x81, 0x01, 0x00, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x80, 0x40, 0x20,
  0x40, 0x20, 0x10, 0x40, 0x10, 0x08, 0x40, 0x08, 0x04, 0x40, 0x04, 0x04,
  0x20, 0x01, 0x04, 0x20, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x01, 0x8C, 0x20, 0x00, 0x88, 0x08, 0x00,
  0x84, 0x04, 0x00, 0x84, 0x02, 0x00, 0x82, 0x01, 0x00, 0x81, 0x00, 0x80,
  0x40, 0x80, 0x40, 0x40, 0x40, 0x20, 0x40, 0x20, 0x20, 0x40, 0x08, 0x20,
  0x60, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x10,
  0x00, 0x80, 0x20, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x20, 0x02, 0x00, 0x80, 0x08, 0x04, 0x00, 0x10, 0x10, 0x00, 0x20,
  0x80, 0x07, 0x8C, 0x00, 0x61, 0xC0, 0x02, 0x04, 0x00, 0x10, 0x08, 0x00,
  0x40, 0x10, 0x01, 0x00, 0x40, 0x08, 0x00, 0x80, 0x20, 0x01, 0x00, 0x80,
  0x0A, 0x06, 0x00, 0x28, 0x24, 0x00, 0x91, 0x18, 0x04, 0x64, 0x30, 0x60,
  0xA0, 0x3E, 0x01, 0x00, 0x69, 0x24, 0xA4, 0x80, 0x00, 0x20, 0x18, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x0C, 0x00, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x07, 0x82, 0x07, 0x0E,
  0x4F, 0x00, 0x3E, 0x00, 0x03, 0x00, 0x00, 0x90, 0x00, 0x22, 0x00, 0x08,
  0x20, 0x01, 0x04, 0x00, 0x40, 0x40, 0x10, 0x04, 0x0C, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x7F, 0xFF, 0xC0, 0x20, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x8C, 0x42, 0x21, 0x10, 0x80, 0xFF, 0xC0,
  0x7C, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x01, 0x83, 0x03, 0x00, 0x41, 0x00, 0x11, 0x00, 0x09, 0x00,
  0x04, 0x80, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x0C, 0x0C, 0x04, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x48, 0x00, 0x24, 0x00, 0x21, 0x00,
  0x30, 0x80, 0x30, 0x30, 0x20, 0x07, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x14,
  0x00, 0x32, 0x00, 0x32, 0x00, 0x21, 0x00, 0x60, 0x80, 0x60, 0x40, 0x20,
  0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x7F, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0xC0, 0xC0, 0x40, 0x08, 0x20,
  0x02, 0x08, 0x00, 0x44, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFC, 0x03, 0x01, 0x82, 0x00, 0x62, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0xC0, 0x3F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x14,
  0x00, 0x12, 0x00, 0x08, 0x80, 0x08, 0x30, 0x18, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x48, 0x00,
  0x11, 0x00, 0x04, 0x20, 0x01, 0x04, 0x00, 0x41, 0x00, 0x10, 0x20, 0x02,
  0x04, 0x00, 0x80, 0x80, 0x20, 0x10, 0x08, 0x02, 0x02, 0x00, 0x80, 0x80,
  0x10, 0x20, 0x02, 0x08, 0x00, 0x41, 0x00, 0x08, 0x7F, 0xFF, 0xF0, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x03, 0xFF, 0xE0, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x47, 0xE0, 0x0B, 0x02, 0x02, 0x80, 0x20, 0x20, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x11, 0x00, 0x04, 0x20, 0x00, 0x82, 0x00, 0x20, 0x30, 0x18,
  0x00, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x23,
  0xF0, 0x2C, 0x0C, 0x50, 0x06, 0x60, 0x02, 0x40, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x40,
  0x04, 0x40, 0x08, 0x30, 0x30, 0x0F, 0xC0, 0x7F, 0xFF, 0xD0, 0x00, 0x24,
  0x00, 0x11, 0x00, 0x04, 0x40, 0x02, 0x20, 0x00, 0x88, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xC0, 0x60, 0x40,
  0x0C, 0x20, 0x01, 0x08, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01,
  0x10, 0x00, 0x42, 0x00, 0x20, 0x80, 0x18, 0x18, 0x18, 0x01, 0xF8, 0x03,
  0x81, 0x81, 0x00, 0x10, 0x80, 0x02, 0x40, 0x00, 0xA0, 0x00, 0x28, 0x00,
  0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x44, 0x00, 0x11, 0x80, 0x18,
  0x38, 0x1C, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x0C, 0x0C, 0x10, 0x06, 0x20,
  0x02, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x02, 0x80, 0x02, 0x40, 0x06, 0x40, 0x0C, 0x30, 0x34, 0x0F,
  0xC4, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x70, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x8E, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x10, 0x30, 0x20, 0x20, 0x40, 0x40, 0x80,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x00, 0x07, 0xE0,
  0x60, 0xC2, 0x00, 0x90, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x0F, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x01, 0x81,
  0x01, 0x80, 0x41, 0x00, 0x20, 0x80, 0x08, 0x80, 0x04, 0x40, 0x02, 0x40,
  0x01, 0x20, 0x7C, 0x90, 0x41, 0x90, 0x40, 0xC8, 0x40, 0x24, 0x20, 0x12,
  0x10, 0x09, 0x10, 0x04, 0x88, 0x04, 0x84, 0x02, 0x42, 0x01, 0x21, 0x00,
  0x90, 0x80, 0xC8, 0x20, 0xA4, 0x18, 0xA2, 0x03, 0x91, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x04, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x09, 0x00, 0x01, 0x20,
  0x00, 0x44, 0x00, 0x08, 0x80, 0x02, 0x08, 0x00, 0x41, 0x00, 0x08, 0x20,
  0x02, 0x04, 0x00, 0x40, 0x80, 0x10, 0x10, 0x02, 0x01, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x04, 0x00, 0x80, 0xFF, 0xF0, 0x20, 0x02, 0x04, 0x00, 0x21,
  0x00, 0x04, 0x20, 0x00, 0x88, 0x00, 0x11, 0x00, 0x02, 0x40, 0x00, 0x58,
  0x00, 0x04, 0x0F, 0xFE, 0x02, 0x00, 0x40, 0x80, 0x08, 0x20, 0x02, 0x08,
  0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0x84, 0x00,
  0x21, 0x00, 0x10, 0x80, 0x18, 0x3F, 0xF8, 0x08, 0x01, 0x82, 0x00, 0x10,
  0x80, 0x04, 0x20, 0x00, 0x90, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0x40,
  0x00, 0x90, 0x00, 0x44, 0x00, 0x12, 0x00, 0x08, 0x80, 0x0C, 0x3F, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0xC0, 0x80, 0x60, 0x10, 0x20, 0x02, 0x08, 0x00,
  0x84, 0x00, 0x12, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x02,
  0x10, 0x00, 0x84, 0x00, 0x40, 0x80, 0x20, 0x18, 0x30, 0x03, 0xF0, 0x00,
  0x07, 0xFC, 0x02, 0x00, 0xC0, 0x80, 0x18, 0x20, 0x02, 0x08, 0x00, 0x42,
  0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00, 0x11, 0x00,
  0x04, 0x40, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01,
  0x20, 0x00, 0x48, 0x00, 0x24, 0x00, 0x09, 0x00, 0x04, 0x40, 0x01, 0x10,
  0x00, 0x84, 0x00, 0x21, 0x00, 0x30, 0x80, 0x38, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xFF, 0x82, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xFF,
  0x82, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0xC0, 0x80, 0x40, 0x10, 0x20, 0x02, 0x10, 0x00, 0x84, 0x00, 0x12, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x08, 0x07, 0xF2, 0x00, 0x04, 0x80, 0x01, 0x20,
  0x00, 0x48, 0x00, 0x12, 0x00, 0x08, 0x80, 0x02, 0x10, 0x00, 0x84, 0x00,
  0x60, 0x80, 0x28, 0x10, 0x32, 0x03, 0xF1, 0x00, 0x08, 0x00, 0x21, 0x00,
  0x04, 0x20, 0x00, 0x84, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x84, 0x00,
  0x10, 0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00,
  0x43, 0xFF, 0xF8, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x04, 0x40, 0x00,
  0x88, 0x00, 0x21, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x02,
  0x20, 0x00, 0x44, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x40, 0x0F, 0xFF,
  0xF0, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x84,
  0x00, 0x42, 0x00, 0x41, 0x80, 0x60, 0x60, 0xC0, 0x0F, 0xC0, 0x00, 0x0C,
  0x00, 0x18, 0x40, 0x01, 0x02, 0x00, 0x10, 0x10, 0x01, 0x00, 0x80, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x02, 0x01, 0x00, 0x10, 0x10, 0x00, 0x81,
  0x00, 0x04, 0x10, 0x00, 0x21, 0x00, 0x02, 0x14, 0x00, 0x13, 0x20, 0x00,
  0xA0, 0x80, 0x06, 0x04, 0x00, 0x20, 0x10, 0x01, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x40, 0x20, 0x02, 0x01, 0x00, 0x08, 0x08,
  0x00, 0x40, 0x80, 0x01, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x03, 0xFF, 0xF0, 0x08, 0x00, 0x31, 0x80, 0x05, 0x14,
  0x00, 0x61, 0x40, 0x0A, 0x14, 0x00, 0xA1, 0x20, 0x12, 0x12, 0x02, 0x22,
  0x20, 0x22, 0x22, 0x04, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x11, 0x04,
  0x20, 0x90, 0x44, 0x0A, 0x04, 0x40, 0xC0, 0x84, 0x04, 0x08, 0x40, 0x80,
  0x84, 0x00, 0x08, 0x40, 0x00, 0x88, 0x00, 0x08, 0x80, 0x01, 0x08, 0x00,
  0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x0C,
  0x00, 0x21, 0x80, 0x04, 0x30, 0x00, 0x85, 0x00, 0x11, 0x20, 0x02, 0x24,
  0x00, 0x84, 0x40, 0x10, 0x88, 0x02, 0x10, 0x80, 0x42, 0x10, 0x08, 0x82,
  0x01, 0x10, 0x20, 0x42, 0x04, 0x08, 0x40, 0x81, 0x08, 0x08, 0x21, 0x01,
  0x04, 0x40, 0x20, 0x88, 0x02, 0x21, 0x00, 0x44, 0x20, 0x08, 0x84, 0x00,
  0x90, 0x80, 0x12, 0x20, 0x02, 0x44, 0x00, 0x30, 0x80, 0x06, 0x10, 0x00,
  0x40, 0x00, 0xF8, 0x01, 0x83, 0x03, 0x00, 0x41, 0x00, 0x11, 0x00, 0x09,
  0x00, 0x04, 0x80, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x48, 0x00, 0x24, 0x00, 0x21,
  0x00, 0x30, 0x80, 0x30, 0x30, 0x20, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x01,
  0x00, 0x10, 0x20, 0x01, 0x04, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x44,
  0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x22, 0x00, 0x04, 0x40, 0x01, 0x08,
  0x00, 0x42, 0x00, 0x10, 0x7F, 0xFC, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00,
  0xF8, 0x01, 0x83, 0x03, 0x00, 0x41, 0x00, 0x11, 0x00, 0x09, 0x00, 0x04,
  0x80, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x40,
  0x00, 0xA0, 0x00, 0x50, 0x00, 0x48, 0x00, 0x24, 0x00, 0x21, 0x00, 0x30,
  0x80, 0x30, 0x30, 0x30, 0x07, 0xE0, 0x00, 0x40, 0x00, 0x20, 0x20, 0x08,
  0x20, 0x02, 0x20, 0x01, 0xA0, 0x00, 0x60, 0x07, 0xFF, 0x01, 0x00, 0x10,
  0x20, 0x01, 0x04, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x44, 0x00, 0x08,
  0x80, 0x01, 0x10, 0x00, 0x22, 0x00, 0x04, 0x40, 0x01, 0x08, 0x00, 0x42,
  0x00, 0x10, 0x7F, 0xFC, 0x08, 0x10, 0x01, 0x01, 0x00, 0x20, 0x20, 0x04,
  0x02, 0x01, 0x00, 0x40, 0x20, 0x04, 0x04, 0x00, 0x80, 0x80, 0x08, 0x10,
  0x01, 0x02, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x60, 0x00, 0xFE, 0x00,
  0x30, 0x1C, 0x04, 0x00, 0x20, 0x80, 0x01, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x48, 0x00, 0x08, 0x40, 0x00, 0x82, 0x00, 0x10, 0x18, 0x06, 0x00,
  0x7F, 0x80, 0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40,
  0x01, 0x20, 0x00, 0x48, 0x00, 0x22, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00,
  0x88, 0x00, 0x24, 0x00, 0x09, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0x44,
  0x00, 0x11, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00,
  0x08, 0x80, 0x02, 0x20, 0x01, 0x08, 0x00, 0x41, 0x00, 0x20, 0x20, 0x30,
  0x07, 0xF0, 0x00, 0x80, 0x00, 0x60, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x04,
  0x80, 0x01, 0x20, 0x00, 0x84, 0x00, 0x21, 0x00, 0x10, 0x40, 0x04, 0x10,
  0x02, 0x04, 0x00, 0x81, 0x00, 0x40, 0x20, 0x10, 0x08, 0x08, 0x02, 0x02,
  0x00, 0x81, 0x00, 0x20, 0x40, 0x08, 0x20, 0x01, 0x08, 0x00, 0x44, 0x00,
  0x11, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x50, 0x00, 0x14, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02,
  0x40, 0x00, 0x24, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x40,
  0x44, 0x0C, 0x08, 0x40, 0xC0, 0x84, 0x14, 0x08, 0x41, 0x20, 0x84, 0x22,
  0x10, 0x42, 0x21, 0x04, 0x42, 0x10, 0x84, 0x22, 0x08, 0x82, 0x20, 0x88,
  0x22, 0x08, 0x82, 0x20, 0x90, 0x14, 0x09, 0x01, 0x40, 0xA0, 0x14, 0x0A,
  0x01, 0x40, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0x04, 0x00, 0x06, 0x04, 0x00,
  0x08, 0x08, 0x00, 0x20, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x10, 0x08,
  0x00, 0x20, 0x20, 0x00, 0x20, 0x40, 0x00, 0x41, 0x00, 0x00, 0x44, 0x00,
  0x00, 0x90, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0x22, 0x00, 0x00, 0x84, 0x00, 0x02, 0x04, 0x00, 0x08,
  0x08, 0x00, 0x10, 0x08, 0x00, 0x40, 0x10, 0x01, 0x00, 0x10, 0x04, 0x00,
  0x20, 0x10, 0x00, 0x20, 0x20, 0x00, 0x41, 0x80, 0x00, 0x40, 0x80, 0x00,
  0x38, 0x00, 0x02, 0x40, 0x00, 0x44, 0x00, 0x08, 0x20, 0x01, 0x02, 0x00,
  0x20, 0x10, 0x02, 0x01, 0x00, 0x40, 0x08, 0x08, 0x00, 0x81, 0x00, 0x04,
  0x20, 0x00, 0x44, 0x00, 0x02, 0x40, 0x00, 0x28, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x00, 0xFF, 0x80, 0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08,
  0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x80, 0x03, 0xFE, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0xFF, 0x80, 0x00, 0x20, 0x00,
  0x28, 0x00, 0x24, 0x00, 0x11, 0x00, 0x10, 0x80, 0x10, 0x20, 0x10, 0x10,
  0x08, 0x08, 0x08, 0x02, 0x08, 0x01, 0x08, 0x00, 0x44, 0x00, 0x24, 0x00,
  0x0C, 0x00, 0x04, 0xFF, 0xFF, 0xC0, 0x84, 0x42, 0x21, 0x03, 0xF1, 0x0C,
  0x19, 0x10, 0x05, 0x20, 0x03, 0x40, 0x02, 0x40, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x04, 0x80, 0x0C, 0x80, 0x14, 0x40, 0x28, 0x20, 0x48, 0x1F, 0x8F, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x11, 0xF8, 0x09, 0x02, 0x05, 0x00, 0x85, 0x00,
  0x23, 0x00, 0x11, 0x00, 0x08, 0x80, 0x02, 0x40, 0x01, 0x20, 0x01, 0x20,
  0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x12, 0x00, 0x11, 0x00, 0x09,
  0x80, 0x08, 0xA0, 0x08, 0x4C, 0x18, 0x21, 0xF0, 0x00, 0x03, 0xF0, 0x18,
  0x10, 0x60, 0x11, 0x00, 0x12, 0x00, 0x28, 0x00, 0x10, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x01, 0x20, 0x04, 0x60, 0x10, 0x60, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x04, 0x03, 0xF1, 0x03, 0x06, 0x41, 0x00, 0x50, 0x80, 0x0C,
  0x40, 0x02, 0x10, 0x00, 0x88, 0x00, 0x22, 0x00, 0x08, 0x80, 0x02, 0x20,
  0x00, 0x88, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00,
  0xC2, 0x00, 0x50, 0x40, 0x28, 0x08, 0x12, 0x01, 0xF8, 0x80, 0x01, 0xF8,
  0x06, 0x06, 0x08, 0x02, 0x30, 0x01, 0x20, 0x01, 0x40, 0x02, 0x40, 0x02,
  0x80, 0x0C, 0x80, 0xF0, 0xFE, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x02, 0x80, 0x04, 0x40, 0x04, 0x60, 0x08, 0x30, 0x30, 0x0F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x04, 0x02, 0x00, 0x04, 0x08, 0x00, 0x06,
  0x10, 0x00, 0x06, 0x20, 0x00, 0x06, 0x40, 0x00, 0x02, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x01, 0xF8, 0x83, 0x06, 0x42, 0x00, 0xA2, 0x00, 0x32, 0x00,
  0x11, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0xA0,
  0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x11, 0x00, 0x18, 0x80, 0x14,
  0x20, 0x14, 0x08, 0x12, 0x03, 0xF1, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x21, 0x00, 0x20, 0x60, 0x60, 0x0F, 0xC0, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x10, 0xF8, 0x26, 0x08, 0x50, 0x08, 0xC0, 0x11, 0x00, 0x22, 0x00,
  0x48, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x0A, 0x00, 0x14,
  0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x02, 0x80, 0x05, 0x00, 0x12, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x03, 0x04, 0x0C, 0x04, 0x18, 0x04,
  0x60, 0x04, 0x80, 0x0B, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x06, 0x02, 0x06,
  0x04, 0x06, 0x08, 0x02, 0x10, 0x02, 0x40, 0x03, 0x80, 0x03, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0xF8, 0x04, 0xC1, 0x81, 0x40, 0x20,
  0xA0, 0x04, 0x30, 0x01, 0x08, 0x00, 0x42, 0x00, 0x20, 0x80, 0x10, 0x20,
  0x18, 0x10, 0x18, 0x04, 0x38, 0x01, 0x08, 0x00, 0x41, 0x00, 0x50, 0x40,
  0x34, 0x08, 0x1A, 0x01, 0x0C, 0x80, 0x44, 0x20, 0x0A, 0x08, 0x03, 0x00,
  0xFF, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x88, 0x18,
  0x41, 0x02, 0x30, 0x22, 0x01, 0x60, 0x0C, 0x00, 0x33, 0x83, 0xC4, 0x88,
  0x88, 0xE0, 0xE0, 0x98, 0x18, 0x12, 0x02, 0x02, 0x40, 0x40, 0x48, 0x08,
  0x0A, 0x02, 0x02, 0x40, 0x40, 0x48, 0x08, 0x09, 0x01, 0x01, 0x20, 0x20,
  0x28, 0x04, 0x05, 0x01, 0x01, 0x20, 0x20, 0x24, 0x04, 0x04, 0x80, 0x80,
  0x90, 0x10, 0x12, 0x04, 0x04, 0x00, 0x10, 0xF8, 0x26, 0x08, 0x50, 0x08,
  0xC0, 0x11, 0x00, 0x26, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40,
  0x04, 0x80, 0x0A, 0x00, 0x14, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x02,
  0x80, 0x05, 0x00, 0x12, 0x00, 0x20, 0x03, 0xF0, 0x0C, 0x0C, 0x10, 0x02,
  0x20, 0x02, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06,
  0x40, 0x04, 0x40, 0x08, 0x30, 0x30, 0x0F, 0xC0, 0x08, 0xFC, 0x02, 0x40,
  0x80, 0xA0, 0x10, 0x50, 0x02, 0x18, 0x00, 0x84, 0x00, 0x21, 0x00, 0x04,
  0x40, 0x01, 0x10, 0x00, 0x88, 0x00, 0x22, 0x00, 0x08, 0x80, 0x02, 0x20,
  0x00, 0x88, 0x00, 0x42, 0x00, 0x11, 0x80, 0x08, 0x50, 0x04, 0x13, 0x06,
  0x04, 0x3E, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF1, 0x0C, 0x19, 0x10,
  0x05, 0x20, 0x03, 0x40, 0x02, 0x40, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x0C, 0x80, 0x14, 0x40, 0x28, 0x20, 0x48, 0x1F, 0x88, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0xFF,
  0x1F, 0xC0, 0x58, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFC, 0x03, 0x01, 0x82, 0x00,
  0x22, 0x00, 0x11, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x07,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x05, 0x00, 0x02, 0x60, 0x02, 0x0C, 0x06, 0x01, 0xFC, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x03, 0xFF, 0xFF, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x0C, 0x04, 0x06, 0x01, 0x06,
  0x00, 0x86, 0x00, 0x22, 0x00, 0x0B, 0x00, 0x03, 0x00, 0x00, 0x20, 0x02,
  0x40, 0x05, 0x00, 0x0A, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x01, 0x40,
  0x02, 0x80, 0x05, 0x00, 0x12, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x03,
  0x20, 0x0A, 0x40, 0x18, 0x80, 0x50, 0xC1, 0x20, 0xF8, 0x40, 0xFC, 0x01,
  0x04, 0x00, 0x82, 0x00, 0x41, 0x00, 0x10, 0x80, 0x08, 0x40, 0x04, 0x20,
  0x04, 0x10, 0x02, 0x10, 0x01, 0x08, 0x00, 0x84, 0x00, 0x82, 0x00, 0x41,
  0x00, 0x40, 0x80, 0x60, 0x40, 0x20, 0x40, 0x60, 0x20, 0x60, 0x10, 0xC0,
  0x0F, 0x80, 0x00, 0x20, 0x20, 0x88, 0x08, 0x22, 0x04, 0x05, 0x01, 0x01,
  0x40, 0x40, 0x50, 0x10, 0x14, 0x04, 0x05, 0x02, 0x01, 0x40, 0x80, 0x60,
  0x20, 0x18, 0x08, 0x06, 0x02, 0x02, 0x80, 0x80, 0xA0, 0x40, 0x28, 0x10,
  0x0A, 0x0C, 0x04, 0x82, 0x82, 0x21, 0x21, 0x87, 0x87, 0x80, 0x01, 0x81,
  0xE0, 0x34, 0x10, 0x86, 0x11, 0x04, 0xC0, 0x90, 0x10, 0x03, 0x00, 0x80,
  0x18, 0x04, 0x00, 0xC0, 0x40, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x08, 0x04, 0x00, 0x40, 0x50, 0x02, 0x02,
  0x80, 0x10, 0x24, 0x06, 0x81, 0x20, 0xC2, 0x30, 0x98, 0x0E, 0x03, 0x00,
  0x08, 0x00, 0x84, 0x00, 0x44, 0x00, 0x22, 0x00, 0x21, 0x00, 0x10, 0x80,
  0x08, 0x40, 0x04, 0x40, 0x02, 0x20, 0x02, 0x10, 0x01, 0x08, 0x00, 0x84,
  0x00, 0x42, 0x00, 0x21, 0x00, 0x30, 0x80, 0x30, 0x40, 0x18, 0x20, 0x14,
  0x0C, 0x12, 0x03, 0xE1, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x41, 0x00, 0x60, 0x40, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x46, 0x0F,
  0x11, 0x00, 0x7C, 0x80, 0x02, 0x20, 0x01, 0x08, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x02, 0x04, 0x00, 0x82, 0x00, 0x21, 0x00, 0x04, 0xFE, 0x01, 0x21, 0xFC,
  0x48, 0x03, 0xF0, 0x00, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0xFC,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x1F, 0xE0, 0x02, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x08, 0x20,
  0x40, 0x80, 0x07, 0xF8, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x3F,
  0x00, 0xE0, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0x00, 0x0E, 0x00, 0x22, 0x20,
  0x08, 0x82, 0x01, 0x20, 0x20, 0x24, 0x02, 0x09, 0x00, 0x62, 0x20, 0x07,
  0x80,
};

const GFXglyph IBMPlexMono_ThinItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 26, 22, 8, -26 },
  { 21, 7, 9, 22, 10, -27 },
  { 29, 22, 26, 22, 1, -26 },
  { 101, 20, 34, 22, 1, -30 },
  { 186, 25, 26, 22, -1, -26 },
  { 268, 22, 26, 22, 0, -26 },
  { 340, 3, 9, 22, 12, -27 },
  { 344, 11, 33, 22, 9, -28 },
  { 390, 11, 33, 22, 3, -28 },
  { 436, 19, 18, 22, 2, -20 },
  { 479, 17, 19, 22, 3, -21 },
  { 520, 5, 9, 22, 6, -3 },
  { 526, 10, 1, 22, 6, -12 },
  { 528, 3, 2, 22, 8, -2 },
  { 529, 20, 33, 22, 1, -28 },
  { 612, 17, 26, 22, 3, -26 },
  { 668, 17, 26, 22, 2, -26 },
  { 724, 18, 26, 22, 2, -26 },
  { 783, 17, 26, 22, 2, -26 },
  { 839, 19, 26, 22, 1, -26 },
  { 901, 19, 26, 22, 2, -26 },
  { 963, 16, 26, 22, 3, -26 },
  { 1015, 18, 26, 22, 4, -26 },
  { 1074, 18, 26, 22, 2, -26 },
  { 1133, 16, 26, 22, 4, -26 },
  { 1185, 6, 19, 22, 8, -19 },
  { 1200, 8, 25, 22, 6, -19 },
  { 1225, 18, 20, 22, 3, -21 },
  { 1270, 19, 7, 22, 2, -15 },
  { 1287, 17, 20, 22, 2, -21 },
  { 1330, 14, 26, 22, 6, -26 },
  { 1376, 17, 30, 22, 3, -26 },
  { 1440, 19, 26, 22, 0, -26 },
  { 1502, 18, 26, 22, 2, -26 },
  { 1561, 18, 26, 22, 3, -26 },
  { 1620, 18, 26, 22, 2, -26 },
  { 1679, 20, 26, 22, 2, -26 },
  { 1744, 20, 26, 22, 2, -26 },
  { 1809, 18, 26, 22, 3, -26 },
  { 1868, 19, 26, 22, 2, -26 },
  { 1930, 20, 26, 22, 2, -26 },
  { 1995, 17, 26, 22, 3, -26 },
  { 2051, 21, 26, 22, 2, -26 },
  { 2120, 14, 26, 22, 4, -26 },
  { 2166, 20, 26, 22, 2, -26 },
  { 2231, 19, 26, 22, 2, -26 },
  { 2293, 17, 26, 22, 3, -26 },
  { 2349, 19, 26, 22, 2, -26 },
  { 2411, 17, 32, 22, 3, -26 },
  { 2479, 19, 26, 22, 2, -26 },
  { 2541, 20, 26, 22, 1, -26 },
  { 2606, 19, 26, 22, 4, -26 },
  { 2668, 18, 26, 22, 3, -26 },
  { 2727, 18, 26, 22, 5, -26 },
  { 2786, 20, 26, 22, 3, -26 },
  { 2851, 23, 26, 22, 0, -26 },
  { 2926, 20, 26, 22, 4, -26 },
  { 2991, 22, 26, 22, 0, -26 },
  { 3063, 15, 33, 22, 7, -28 },
  { 3125, 9, 33, 22, 7, -28 },
  { 3163, 15, 33, 22, 1, -28 },
  { 3225, 17, 14, 22, 3, -26 },
  { 3255, 18, 1, 22, 0, 4 },
  { 3258, 4, 6, 22, 9, -28 },
  { 3261, 16, 19, 22, 3, -19 },
  { 3299, 17, 27, 22, 3, -27 },
  { 3357, 15, 19, 22, 3, -19 },
  { 3393, 18, 27, 22, 3, -27 },
  { 3454, 16, 19, 22, 3, -19 },
  { 3492, 23, 34, 22, 0, -27 },
  { 3590, 17, 26, 22, 2, -19 },
  { 3646, 15, 27, 22, 3, -27 },
  { 3697, 16, 27, 22, 3, -27 },
  { 3751, 15, 34, 22, 4, -27 },
  { 3815, 18, 27, 22, 3, -27 },
  { 3876, 13, 27, 22, 5, -27 },
  { 3920, 19, 19, 22, 2, -19 },
  { 3966, 15, 19, 22, 3, -19 },
  { 4002, 16, 19, 22, 3, -19 },
  { 4040, 18, 26, 22, 2, -19 },
  { 4099, 16, 26, 22, 3, -19 },
  { 4151, 18, 19, 22, 4, -19 },
  { 4194, 17, 19, 22, 2, -19 },
  { 4235, 18, 26, 22, 3, -26 },
  { 4294, 15, 19, 22, 4, -19 },
  { 4330, 17, 19, 22, 3, -19 },
  { 4371, 18, 19, 22, 3, -19 },
  { 4414, 21, 19, 22, 1, -19 },
  { 4464, 17, 26, 22, 2, -19 },
  { 4520, 18, 19, 22, 2, -19 },
  { 4563, 16, 33, 22, 5, -28 },
  { 4629, 7, 33, 22, 8, -28 },
  { 4658, 16, 33, 22, 2, -28 },
  { 4724, 19, 7, 22, 2, -15 },
};

const GFXfont IBMPlexMono_ThinItalic37pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic37pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic37pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _IBMPLEXMONO_THINITALIC37PT7B_H_
