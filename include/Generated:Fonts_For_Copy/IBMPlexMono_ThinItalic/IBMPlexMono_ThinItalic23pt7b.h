#ifndef _IBMPLEXMONO_THINITALIC23PT7B_H_
#define _IBMPLEXMONO_THINITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x22, 0x22, 0x22, 0x44, 0x44, 0x00, 0x0C, 0xDC, 0xA5, 0x29,
  0x48, 0x01, 0x10, 0x04, 0x40, 0x22, 0x00, 0x88, 0x02, 0x20, 0xF0, 0xF0,
  0x44, 0x01, 0x10, 0x08, 0x80, 0x22, 0x0F, 0x8F, 0x04, 0x40, 0x11, 0x00,
  0x44, 0x02, 0x20, 0x08, 0x80, 0x01, 0x00, 0x10, 0x0F, 0xC1, 0x12, 0x22,
  0x14, 0x20, 0x42, 0x02, 0x20, 0x32, 0x00, 0xE0, 0x05, 0x80, 0x44, 0x04,
  0x20, 0x42, 0x04, 0x28, 0x84, 0x48, 0x83, 0xF0, 0x08, 0x00, 0x80, 0x0E,
  0x06, 0x22, 0x08, 0x84, 0x22, 0x08, 0x84, 0x12, 0x04, 0x44, 0x07, 0x10,
  0x00, 0x00, 0x00, 0xF0, 0x12, 0x20, 0x48, 0x20, 0x90, 0x42, 0x20, 0x88,
  0x42, 0x20, 0x84, 0x40, 0xF0, 0x07, 0x80, 0x21, 0x01, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x41, 0x00, 0x84, 0x07, 0x60, 0x62, 0x02, 0x08, 0x08, 0x10,
  0x20, 0x40, 0x80, 0x8A, 0x05, 0x34, 0x23, 0x0F, 0x0C, 0xFC, 0x03, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x10, 0x20, 0x20, 0x40, 0x80,
  0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x10, 0x41, 0x04, 0x00,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xC2, 0x13, 0xDE, 0x06, 0x00, 0xA0,
  0x11, 0x02, 0x10, 0x40, 0x80, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x81,
  0xFF, 0xC2, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x00, 0x29, 0x49, 0x00,
  0xFC, 0xC0, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x0F, 0x82, 0x08, 0x81,
  0x20, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x84, 0x50, 0x0A, 0x01, 0x40,
  0x28, 0x09, 0x01, 0x10, 0xC1, 0xE0, 0x01, 0x00, 0x60, 0x34, 0x0C, 0x82,
  0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x07, 0xFF, 0x07, 0x81, 0x0C, 0x40, 0x90, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x30,
  0x07, 0xFE, 0x07, 0x83, 0x0C, 0x80, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10,
  0x7C, 0x01, 0x80, 0x08, 0x01, 0x00, 0x20, 0x05, 0x00, 0x90, 0x61, 0xF0,
  0x00, 0x20, 0x18, 0x05, 0x01, 0x20, 0x44, 0x10, 0x82, 0x20, 0x84, 0x20,
  0x88, 0x12, 0x02, 0x7F, 0xF0, 0x08, 0x02, 0x00, 0x40, 0x08, 0x0F, 0xF1,
  0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x2F, 0x85, 0x04, 0x20, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x48, 0x04, 0x40, 0x83, 0xF0, 0x01, 0x81,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x05, 0xF2, 0x82, 0xC0, 0xA0, 0x18, 0x06,
  0x01, 0x80, 0xA0, 0x24, 0x10, 0xF8, 0xFF, 0xE0, 0x18, 0x0A, 0x02, 0x81,
  0x00, 0x80, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x04,
  0x02, 0x00, 0x07, 0xC1, 0x82, 0x20, 0x12, 0x01, 0x20, 0x12, 0x02, 0x10,
  0x40, 0xF8, 0x30, 0x44, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x60,
  0x83, 0xF0, 0x0F, 0x0C, 0x34, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x41, 0x8F, 0xA0, 0x10, 0x04, 0x02, 0x01, 0x01, 0x81, 0x80, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x84,
  0x42, 0x10, 0x00, 0x20, 0x18, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x20, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00,
  0xC0, 0x10, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x1F, 0x08, 0x24,
  0x0A, 0x01, 0x00, 0x80, 0x20, 0x08, 0x0C, 0x1C, 0x04, 0x01, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x0F, 0x84, 0x12, 0x04, 0x81, 0x40, 0x51,
  0xF8, 0x8E, 0x41, 0x90, 0x64, 0x29, 0x0A, 0x42, 0x91, 0xA3, 0xA8, 0x02,
  0x00, 0x40, 0x0F, 0xC0, 0x00, 0x80, 0x18, 0x02, 0x80, 0x24, 0x04, 0x40,
  0x44, 0x08, 0x40, 0x84, 0x10, 0x41, 0x02, 0x1F, 0xE2, 0x02, 0x20, 0x24,
  0x02, 0x40, 0x28, 0x01, 0x1F, 0xC4, 0x04, 0x80, 0x90, 0x12, 0x02, 0x40,
  0x50, 0x11, 0xFC, 0x40, 0x48, 0x05, 0x00, 0xA0, 0x18, 0x03, 0x00, 0xA0,
  0x37, 0xF8, 0x0F, 0x83, 0x08, 0x81, 0x20, 0x14, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x09, 0x02, 0x10, 0x41, 0xF0,
  0x1F, 0x81, 0x04, 0x20, 0x22, 0x01, 0x20, 0x12, 0x01, 0x20, 0x14, 0x01,
  0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x48, 0x04, 0x81, 0x8F, 0xE0,
  0x1F, 0xF9, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x07,
  0xFC, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x1F, 0xF8, 0x1F, 0xF9, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x07, 0xFC, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x0F, 0x82, 0x08, 0x81, 0x20, 0x14, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x87, 0xD0, 0x0A, 0x01, 0x40, 0x48, 0x09, 0x03, 0x10,
  0x61, 0xF4, 0x20, 0x12, 0x01, 0x20, 0x12, 0x01, 0x20, 0x24, 0x02, 0x40,
  0x23, 0xFE, 0x40, 0x24, 0x02, 0x40, 0x44, 0x04, 0x80, 0x48, 0x04, 0x80,
  0x48, 0x04, 0x1F, 0xF0, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08,
  0x0F, 0xFC, 0x1F, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x04, 0x81, 0x20, 0x48, 0x21, 0xF0, 0x10, 0x09,
  0x00, 0x88, 0x08, 0x41, 0x82, 0x10, 0x11, 0x00, 0x90, 0x09, 0x80, 0x52,
  0x01, 0x10, 0x10, 0x40, 0x82, 0x04, 0x08, 0x40, 0x42, 0x01, 0x10, 0x0C,
  0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x08, 0x04, 0x02, 0x01, 0xFF, 0x20, 0x19, 0x80, 0x8C, 0x0C, 0x60,
  0xA4, 0x85, 0x24, 0x49, 0x24, 0x89, 0x24, 0x46, 0x22, 0x11, 0x21, 0x09,
  0x00, 0x48, 0x04, 0x40, 0x22, 0x01, 0x10, 0x08, 0x10, 0x13, 0x01, 0x28,
  0x12, 0x81, 0x28, 0x22, 0x42, 0x44, 0x24, 0x42, 0x42, 0x24, 0x22, 0x42,
  0x44, 0x14, 0x81, 0x48, 0x14, 0x80, 0xC8, 0x04, 0x0F, 0x82, 0x08, 0x81,
  0x20, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x50, 0x0A, 0x01, 0x40,
  0x28, 0x09, 0x01, 0x10, 0xC1, 0xE0, 0x1F, 0xE1, 0x03, 0x20, 0x12, 0x01,
  0x20, 0x12, 0x01, 0x20, 0x14, 0x02, 0x3F, 0xC4, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x0F, 0x82, 0x08, 0x81, 0x20, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x09,
  0x01, 0x10, 0xC1, 0xE0, 0x08, 0x00, 0x88, 0x16, 0x01, 0x00, 0x1F, 0xE1,
  0x03, 0x20, 0x12, 0x01, 0x20, 0x12, 0x01, 0x20, 0x14, 0x02, 0x3F, 0xC4,
  0x20, 0x42, 0x04, 0x10, 0x41, 0x08, 0x08, 0x80, 0x88, 0x04, 0x0F, 0x81,
  0x06, 0x20, 0x14, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xE0, 0x01, 0x80,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x28, 0x04, 0x40, 0x83, 0xF0, 0xFF, 0xF0,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x28,
  0x05, 0x00, 0xA0, 0x14, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x0A,
  0x02, 0x40, 0x48, 0x09, 0x01, 0x30, 0x43, 0xF0, 0x80, 0x30, 0x0A, 0x01,
  0x40, 0x48, 0x09, 0x02, 0x10, 0x42, 0x10, 0x42, 0x08, 0x81, 0x10, 0x24,
  0x04, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02,
  0x80, 0x28, 0x42, 0x8C, 0x48, 0xC4, 0x92, 0x49, 0x24, 0xA2, 0x8A, 0x28,
  0xC2, 0x8C, 0x28, 0x83, 0x08, 0x30, 0x10, 0x04, 0x40, 0x20, 0x81, 0x02,
  0x08, 0x04, 0x40, 0x11, 0x00, 0x28, 0x00, 0x40, 0x03, 0x00, 0x14, 0x00,
  0x88, 0x02, 0x20, 0x10, 0x40, 0x81, 0x04, 0x02, 0x20, 0x0C, 0x80, 0x1A,
  0x00, 0x90, 0x08, 0x80, 0x82, 0x08, 0x10, 0x80, 0x44, 0x02, 0x40, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x1F, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x3F, 0xFC, 0x1F, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xF8,
  0x84, 0x21, 0x08, 0x41, 0x08, 0x42, 0x08, 0x42, 0x10, 0x82, 0x10, 0x84,
  0x10, 0x1F, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x1F, 0x00,
  0x02, 0x00, 0xC0, 0x24, 0x08, 0x82, 0x08, 0x41, 0x10, 0x14, 0x02, 0x80,
  0x60, 0xFF, 0xE0, 0xA9, 0x1E, 0x48, 0x54, 0x0E, 0x02, 0x80, 0xA0, 0x28,
  0x0A, 0x02, 0x81, 0x20, 0xCC, 0x30, 0xF3, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x40, 0x13, 0xC5, 0x09, 0x81, 0x40, 0x50, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x28, 0x0B, 0x04, 0xBE, 0x00, 0x1E, 0x10, 0xD0, 0x30, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0xC0, 0x90, 0x87, 0x80, 0x00, 0x20, 0x04, 0x01, 0x00,
  0x20, 0x04, 0x3C, 0x88, 0x52, 0x06, 0x80, 0x90, 0x12, 0x02, 0x40, 0x48,
  0x09, 0x01, 0x20, 0x46, 0x18, 0x3D, 0x00, 0x0F, 0x0C, 0x24, 0x06, 0x01,
  0x80, 0xA0, 0xCF, 0xC2, 0x00, 0x80, 0xA0, 0x24, 0x10, 0xF8, 0x00, 0xFC,
  0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x7F, 0xE0, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x02, 0x10, 0x04, 0x40, 0x09, 0x00, 0x14, 0x00, 0x20,
  0x00, 0x0F, 0x22, 0x14, 0x81, 0xA0, 0x24, 0x05, 0x00, 0xA0, 0x14, 0x02,
  0x80, 0x48, 0x31, 0x86, 0x0F, 0x40, 0x08, 0x01, 0x00, 0x46, 0x18, 0x3C,
  0x00, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x79, 0x42, 0xC1, 0x40, 0xA0,
  0x50, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x02, 0x81, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x10, 0x44, 0x62, 0x20, 0xB0, 0x10, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10,
  0x08, 0x04, 0x42, 0x31, 0x0D, 0x01, 0x80, 0x40, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x9F, 0x14, 0x23, 0x02, 0x40, 0x48, 0x12, 0x0C, 0x4E,
  0x09, 0x01, 0x10, 0x61, 0x14, 0x2C, 0x83, 0x00, 0xF8, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x21, 0x43, 0x4C, 0x50,
  0x20, 0x4C, 0x67, 0x39, 0x22, 0x14, 0x21, 0x42, 0x14, 0x21, 0x84, 0x28,
  0x42, 0x84, 0x28, 0x42, 0x84, 0x28, 0x42, 0x4F, 0x28, 0x58, 0x28, 0x14,
  0x0A, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x50, 0x20, 0x1F, 0x08, 0x24,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xA0, 0x24, 0x10, 0xF8,
  0x27, 0x85, 0x08, 0xC0, 0x90, 0x12, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40,
  0x48, 0x0A, 0x82, 0x4F, 0x88, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x00,
  0x1E, 0x48, 0x54, 0x0E, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x80, 0xA0,
  0xCC, 0x30, 0xF4, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0xF3, 0xE2,
  0x80, 0x60, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x00, 0x0F, 0x82, 0x0C, 0x80, 0x10, 0x02, 0x00, 0x3E, 0x00,
  0x30, 0x02, 0x00, 0x50, 0x09, 0x83, 0x0F, 0x80, 0x04, 0x01, 0x00, 0x20,
  0x04, 0x0F, 0xFE, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x22, 0x18, 0x44, 0x0B, 0x01, 0x80, 0x40, 0x50, 0x14, 0x09, 0x02, 0x80,
  0xA0, 0x28, 0x0A, 0x02, 0x83, 0x20, 0xC4, 0x50, 0xE4, 0xE0, 0x48, 0x12,
  0x04, 0x81, 0x20, 0x48, 0x14, 0x09, 0x02, 0x41, 0x10, 0xC4, 0x41, 0xE0,
  0x46, 0x50, 0x86, 0x10, 0xC2, 0x18, 0x43, 0x08, 0x62, 0x0C, 0x41, 0x88,
  0x53, 0x0A, 0x62, 0x73, 0x80, 0x08, 0x63, 0x49, 0xC5, 0x10, 0x61, 0x02,
  0x10, 0x40, 0x04, 0x08, 0x40, 0x8C, 0x08, 0xC3, 0x92, 0x46, 0x18, 0x20,
  0x24, 0x04, 0x81, 0x10, 0x24, 0x04, 0x80, 0x90, 0x12, 0x02, 0x41, 0x88,
  0x30, 0x8A, 0x0E, 0x40, 0x08, 0x01, 0x00, 0x44, 0x10, 0x7C, 0x00, 0x1F,
  0x24, 0x3D, 0x00, 0xA0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x82, 0x20, 0x58,
  0x0B, 0xF9, 0x41, 0xE0, 0x07, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x40, 0x10, 0x04, 0x3E, 0x01, 0x80, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x10, 0x04, 0x00, 0xF8, 0x11, 0x12, 0x22, 0x22, 0x24, 0x44, 0x44,
  0x48, 0x88, 0x88, 0x0F, 0x84, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40,
  0x20, 0x04, 0x00, 0xF0, 0xE0, 0x20, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x01, 0x00, 0x83, 0xE0, 0x38, 0x14, 0x41, 0x42, 0x28, 0x22, 0x81, 0xC0,
};

const GFXglyph IBMPlexMono_ThinItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 16, 14, 5, -16 },
  { 9, 5, 6, 14, 6, -17 },
  { 13, 14, 16, 14, 0, -16 },
  { 41, 12, 20, 14, 1, -18 },
  { 71, 15, 16, 14, 0, -16 },
  { 101, 14, 16, 14, 0, -16 },
  { 129, 1, 6, 14, 8, -17 },
  { 130, 8, 20, 14, 5, -17 },
  { 150, 7, 20, 14, 2, -17 },
  { 168, 12, 11, 14, 1, -13 },
  { 185, 11, 11, 14, 2, -13 },
  { 201, 3, 6, 14, 4, -2 },
  { 204, 6, 1, 14, 4, -8 },
  { 205, 2, 1, 14, 5, -1 },
  { 206, 12, 20, 14, 1, -17 },
  { 236, 11, 16, 14, 2, -16 },
  { 258, 11, 16, 14, 1, -16 },
  { 280, 11, 16, 14, 1, -16 },
  { 302, 11, 16, 14, 1, -16 },
  { 324, 11, 16, 14, 1, -16 },
  { 346, 12, 16, 14, 1, -16 },
  { 370, 10, 16, 14, 2, -16 },
  { 390, 10, 16, 14, 3, -16 },
  { 410, 12, 16, 14, 1, -16 },
  { 434, 10, 16, 14, 2, -16 },
  { 454, 4, 12, 14, 5, -12 },
  { 460, 5, 16, 14, 4, -12 },
  { 470, 11, 12, 14, 2, -13 },
  { 487, 12, 6, 14, 1, -10 },
  { 496, 11, 12, 14, 1, -13 },
  { 513, 10, 16, 14, 3, -16 },
  { 533, 10, 18, 14, 2, -16 },
  { 556, 12, 16, 14, 0, -16 },
  { 580, 11, 16, 14, 1, -16 },
  { 602, 11, 16, 14, 2, -16 },
  { 624, 12, 16, 14, 1, -16 },
  { 648, 13, 16, 14, 1, -16 },
  { 674, 13, 16, 14, 1, -16 },
  { 700, 11, 16, 14, 2, -16 },
  { 722, 12, 16, 14, 1, -16 },
  { 746, 12, 16, 14, 1, -16 },
  { 770, 10, 16, 14, 2, -16 },
  { 790, 13, 16, 14, 1, -16 },
  { 816, 9, 16, 14, 2, -16 },
  { 834, 13, 16, 14, 1, -16 },
  { 860, 12, 16, 14, 1, -16 },
  { 884, 11, 16, 14, 2, -16 },
  { 906, 12, 16, 14, 1, -16 },
  { 930, 11, 20, 14, 2, -16 },
  { 958, 12, 16, 14, 1, -16 },
  { 982, 12, 16, 14, 1, -16 },
  { 1006, 12, 16, 14, 3, -16 },
  { 1030, 11, 16, 14, 2, -16 },
  { 1052, 11, 16, 14, 3, -16 },
  { 1074, 12, 16, 14, 2, -16 },
  { 1098, 14, 16, 14, 0, -16 },
  { 1126, 13, 16, 14, 2, -16 },
  { 1152, 14, 16, 14, 0, -16 },
  { 1180, 8, 20, 14, 5, -17 },
  { 1200, 5, 20, 14, 5, -17 },
  { 1213, 9, 20, 14, 1, -17 },
  { 1236, 11, 9, 14, 2, -16 },
  { 1249, 11, 1, 14, 0, 3 },
  { 1251, 2, 4, 14, 6, -18 },
  { 1252, 10, 12, 14, 2, -12 },
  { 1267, 10, 17, 14, 2, -17 },
  { 1289, 9, 12, 14, 2, -12 },
  { 1303, 11, 17, 14, 2, -17 },
  { 1327, 10, 12, 14, 2, -12 },
  { 1342, 14, 22, 14, 0, -17 },
  { 1381, 11, 17, 14, 1, -12 },
  { 1405, 9, 17, 14, 2, -17 },
  { 1425, 10, 17, 14, 2, -17 },
  { 1447, 9, 22, 14, 3, -17 },
  { 1472, 11, 17, 14, 2, -17 },
  { 1496, 8, 17, 14, 3, -17 },
  { 1513, 12, 12, 14, 1, -12 },
  { 1531, 9, 12, 14, 2, -12 },
  { 1545, 10, 12, 14, 2, -12 },
  { 1560, 11, 17, 14, 1, -12 },
  { 1584, 10, 17, 14, 2, -12 },
  { 1606, 11, 12, 14, 3, -12 },
  { 1623, 11, 12, 14, 1, -12 },
  { 1640, 11, 16, 14, 2, -16 },
  { 1662, 10, 12, 14, 2, -12 },
  { 1677, 10, 12, 14, 2, -12 },
  { 1692, 11, 12, 14, 2, -12 },
  { 1709, 12, 12, 14, 1, -12 },
  { 1727, 11, 17, 14, 1, -12 },
  { 1751, 11, 12, 14, 1, -12 },
  { 1768, 10, 20, 14, 3, -17 },
  { 1793, 4, 20, 14, 5, -17 },
  { 1803, 10, 20, 14, 1, -17 },
  { 1828, 12, 5, 14, 1, -9 },
};

const GFXfont IBMPlexMono_ThinItalic23pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic23pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _IBMPLEXMONO_THINITALIC23PT7B_H_
