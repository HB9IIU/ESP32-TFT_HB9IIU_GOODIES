#ifndef _IBMPLEXMONO_THINITALIC29PT7B_H_
#define _IBMPLEXMONO_THINITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x22, 0x22, 0x22, 0x44, 0x44, 0x40, 0x00, 0xC8, 0xCC,
  0x63, 0x18, 0xCA, 0x40, 0x00, 0x84, 0x00, 0x42, 0x00, 0x22, 0x00, 0x21,
  0x00, 0x10, 0x80, 0x10, 0x80, 0xF8, 0x3E, 0x04, 0x20, 0x04, 0x20, 0x02,
  0x10, 0x01, 0x08, 0x01, 0x04, 0x00, 0x84, 0x07, 0xC3, 0xF0, 0x41, 0x00,
  0x21, 0x00, 0x10, 0x80, 0x10, 0x40, 0x08, 0x40, 0x04, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x1F, 0x80, 0xC4, 0xC2, 0x08, 0x44, 0x20,
  0x90, 0x40, 0x20, 0x80, 0x41, 0x00, 0x42, 0x00, 0x44, 0x00, 0x78, 0x00,
  0x2E, 0x00, 0x42, 0x00, 0x84, 0x01, 0x04, 0x04, 0x08, 0x08, 0x14, 0x10,
  0x44, 0x20, 0x86, 0x46, 0x03, 0xF0, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x07, 0x80, 0x61, 0x08, 0x08, 0x41, 0x02, 0x10, 0x20, 0x82, 0x04, 0x20,
  0x40, 0x84, 0x08, 0x11, 0x00, 0x84, 0x40, 0x0F, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x1E, 0x00, 0x44, 0x20, 0x11, 0x02, 0x04, 0x20, 0x40,
  0x84, 0x08, 0x21, 0x01, 0x08, 0x10, 0x42, 0x02, 0x18, 0x40, 0x3C, 0x00,
  0x01, 0xE0, 0x03, 0x0C, 0x01, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40,
  0x40, 0x20, 0x20, 0x08, 0x10, 0x02, 0x10, 0x07, 0x30, 0x0C, 0x60, 0x08,
  0x20, 0x0C, 0x08, 0x04, 0x02, 0x02, 0x00, 0x81, 0x00, 0xC1, 0x80, 0x50,
  0xA0, 0x24, 0x98, 0x22, 0x83, 0xE0, 0xC0, 0x55, 0x68, 0x01, 0x81, 0x01,
  0x01, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x00, 0x0C, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80,
  0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x20, 0x60, 0x00, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x10, 0x20, 0xDC, 0x8E, 0x07, 0xE0,
  0x05, 0x00, 0x0A, 0x00, 0x22, 0x00, 0x84, 0x02, 0x04, 0x08, 0x04, 0x00,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x3F, 0xFF, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x32, 0x44, 0x88, 0x80, 0xFF, 0xE0, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x03, 0xE0, 0x30, 0x61, 0x00, 0x84, 0x01, 0x20, 0x05, 0x00, 0x14,
  0x00, 0x50, 0x01, 0x80, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x02, 0x80, 0x0A,
  0x00, 0x28, 0x00, 0xA0, 0x04, 0x80, 0x11, 0x00, 0x82, 0x0C, 0x07, 0xC0,
  0x00, 0x60, 0x02, 0x80, 0x34, 0x01, 0x90, 0x08, 0x40, 0x41, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x3F, 0xFF, 0x01,
  0xF0, 0x18, 0x20, 0x80, 0x44, 0x01, 0x10, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x3F, 0xFE, 0x03, 0xF0,
  0x10, 0x20, 0x80, 0x44, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x1F, 0x80, 0x07, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x80, 0x09, 0x00, 0x42, 0x06, 0x07, 0xE0, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xA0, 0x02, 0x40, 0x04, 0x80, 0x11, 0x00, 0x42, 0x01, 0x08,
  0x04, 0x10, 0x10, 0x20, 0x40, 0x41, 0x00, 0x84, 0x02, 0x10, 0x04, 0x3F,
  0xFF, 0x80, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x0F,
  0xFC, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x2F, 0xC1, 0x40, 0x82, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x80, 0x12, 0x00, 0x86, 0x0C, 0x07, 0xE0, 0x00, 0x30,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x27,
  0xC2, 0xC1, 0x98, 0x04, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x02,
  0x80, 0x12, 0x01, 0x08, 0x30, 0x3F, 0x00, 0x7F, 0xFD, 0x00, 0x24, 0x00,
  0xA0, 0x04, 0x80, 0x22, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x03, 0xE0, 0x30, 0x61, 0x00, 0x48,
  0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x02, 0x18, 0x30, 0x1F, 0x03,
  0x82, 0x10, 0x04, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x12,
  0x00, 0x46, 0x06, 0x07, 0xE0, 0x0F, 0xC0, 0x81, 0x08, 0x04, 0x80, 0x28,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x02, 0x80, 0x12, 0x01, 0x98, 0x38, 0x3E,
  0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00,
  0xC0, 0x00, 0x33, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x80, 0x0C, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC2, 0x10, 0x42, 0x08,
  0x20, 0x00, 0x08, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x0F, 0x81, 0x06, 0x20, 0x24, 0x01, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x0F, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x03, 0x00, 0x03, 0xE0,
  0x10, 0x60, 0x80, 0x84, 0x02, 0x10, 0x04, 0x80, 0x22, 0x1E, 0x90, 0x86,
  0x44, 0x09, 0x10, 0x24, 0x40, 0x92, 0x02, 0x88, 0x12, 0x20, 0x48, 0x81,
  0x21, 0x0C, 0x86, 0xD2, 0x04, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0xFC, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x40, 0x04, 0x80, 0x09,
  0x00, 0x22, 0x00, 0x44, 0x01, 0x04, 0x02, 0x08, 0x08, 0x10, 0x10, 0x20,
  0x40, 0x40, 0x80, 0x81, 0xFF, 0x84, 0x01, 0x08, 0x02, 0x20, 0x04, 0x80,
  0x09, 0x00, 0x14, 0x00, 0x10, 0x1F, 0xF0, 0x80, 0xC8, 0x02, 0x40, 0x12,
  0x00, 0x90, 0x04, 0x80, 0x28, 0x01, 0x40, 0x33, 0xFE, 0x10, 0x0C, 0x80,
  0x24, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x14, 0x00, 0xA0, 0x19,
  0xFF, 0x80, 0x07, 0xC0, 0x61, 0x84, 0x04, 0x40, 0x14, 0x00, 0xA0, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x04, 0x80, 0x24, 0x02, 0x18, 0x60, 0x3C, 0x00, 0x1F,
  0xE0, 0x40, 0xC1, 0x00, 0x88, 0x02, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48,
  0x01, 0x40, 0x05, 0x00, 0x14, 0x00, 0x50, 0x01, 0x40, 0x09, 0x00, 0x28,
  0x00, 0xA0, 0x04, 0x80, 0x12, 0x00, 0x88, 0x0C, 0x3F, 0xC0, 0x1F, 0xFE,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x7F, 0xF1, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x7F, 0xF1, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x00, 0x07, 0xC0, 0x41, 0x84, 0x04, 0x40, 0x14, 0x00, 0xA0, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x07, 0xE8, 0x01, 0x40,
  0x0A, 0x00, 0x50, 0x04, 0x80, 0x24, 0x03, 0x18, 0x28, 0x3E, 0x40, 0x10,
  0x02, 0x40, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x44, 0x00, 0x90, 0x01,
  0x20, 0x04, 0x40, 0x08, 0xFF, 0xF1, 0x00, 0x22, 0x00, 0x48, 0x00, 0x90,
  0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x44, 0x01,
  0x00, 0x0F, 0xFF, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x80, 0x42, 0x01,
  0x04, 0x18, 0x0F, 0x80, 0x10, 0x03, 0x10, 0x04, 0x20, 0x08, 0x20, 0x10,
  0x20, 0x20, 0x20, 0x40, 0x20, 0x80, 0x21, 0x00, 0x42, 0x00, 0x46, 0x00,
  0x49, 0x00, 0x71, 0x00, 0x40, 0x80, 0x40, 0x80, 0x80, 0x40, 0x80, 0x40,
  0x80, 0x20, 0x80, 0x20, 0x80, 0x10, 0x80, 0x18, 0x10, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7F, 0xF0,
  0x18, 0x01, 0x18, 0x03, 0x18, 0x05, 0x18, 0x06, 0x24, 0x0A, 0x24, 0x12,
  0x24, 0x12, 0x22, 0x22, 0x22, 0x22, 0x22, 0x44, 0x42, 0x84, 0x41, 0x84,
  0x41, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x08, 0x80, 0x08, 0x80, 0x08,
  0x80, 0x08, 0x80, 0x08, 0x10, 0x02, 0x60, 0x08, 0xA0, 0x11, 0x40, 0x22,
  0x40, 0x44, 0x80, 0x91, 0x01, 0x21, 0x04, 0x42, 0x08, 0x84, 0x11, 0x04,
  0x22, 0x08, 0x48, 0x10, 0x90, 0x12, 0x20, 0x24, 0x40, 0x48, 0x80, 0x51,
  0x00, 0xA2, 0x01, 0x44, 0x01, 0x00, 0x03, 0xE0, 0x30, 0x61, 0x00, 0x84,
  0x01, 0x20, 0x05, 0x00, 0x14, 0x00, 0x50, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80, 0x11,
  0x00, 0x82, 0x0C, 0x07, 0xC0, 0x1F, 0xF0, 0x20, 0x18, 0x40, 0x11, 0x00,
  0x22, 0x00, 0x24, 0x00, 0x48, 0x01, 0x10, 0x02, 0x40, 0x04, 0x80, 0x31,
  0xFF, 0x82, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x00, 0x03, 0xE0, 0x30, 0x61, 0x00,
  0x84, 0x01, 0x20, 0x05, 0x00, 0x14, 0x00, 0x50, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80,
  0x11, 0x00, 0x82, 0x0C, 0x07, 0xC0, 0x02, 0x00, 0x08, 0x20, 0x11, 0x00,
  0x28, 0x00, 0xC0, 0x1F, 0xF0, 0x20, 0x18, 0x40, 0x11, 0x00, 0x22, 0x00,
  0x24, 0x00, 0x48, 0x01, 0x10, 0x02, 0x40, 0x04, 0x80, 0x31, 0xFF, 0x82,
  0x08, 0x04, 0x10, 0x08, 0x10, 0x20, 0x20, 0x40, 0x20, 0x80, 0x41, 0x00,
  0x42, 0x00, 0x84, 0x00, 0x80, 0x03, 0xF0, 0x18, 0x18, 0x40, 0x08, 0x80,
  0x12, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x80,
  0x08, 0x80, 0x10, 0xC0, 0xC0, 0x7E, 0x00, 0xFF, 0xFE, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x20, 0x05, 0x00,
  0x24, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80,
  0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x88, 0x02, 0x20,
  0x08, 0x80, 0x42, 0x01, 0x0C, 0x18, 0x0F, 0xC0, 0x80, 0x06, 0x00, 0x28,
  0x00, 0xA0, 0x04, 0x80, 0x12, 0x00, 0x88, 0x02, 0x10, 0x10, 0x40, 0x41,
  0x02, 0x04, 0x08, 0x10, 0x40, 0x41, 0x00, 0x88, 0x02, 0x20, 0x09, 0x00,
  0x24, 0x00, 0xA0, 0x02, 0x80, 0x04, 0x00, 0x40, 0x01, 0x40, 0x02, 0x40,
  0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x04, 0x41, 0x04, 0x43, 0x04, 0x43,
  0x04, 0x44, 0x88, 0x44, 0x88, 0x48, 0x88, 0x48, 0x88, 0x88, 0x90, 0x90,
  0x90, 0x90, 0x90, 0xA0, 0x60, 0xA0, 0x60, 0xC0, 0x60, 0xC0, 0x60, 0x08,
  0x00, 0xC2, 0x00, 0x20, 0x40, 0x10, 0x10, 0x08, 0x02, 0x04, 0x00, 0x82,
  0x00, 0x11, 0x00, 0x04, 0x40, 0x00, 0xA0, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x05, 0x00, 0x02, 0x20, 0x00, 0x8C, 0x00, 0x41, 0x00, 0x20, 0x20, 0x10,
  0x08, 0x08, 0x01, 0x04, 0x00, 0x42, 0x00, 0x08, 0x80, 0x03, 0x80, 0x04,
  0x40, 0x04, 0x40, 0x08, 0x20, 0x10, 0x20, 0x20, 0x10, 0x40, 0x10, 0x40,
  0x08, 0x80, 0x09, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xE2, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x1F, 0xC0, 0x82, 0x08, 0x20, 0x81, 0x04,
  0x10, 0x40, 0x82, 0x08, 0x20, 0x81, 0x04, 0x10, 0x40, 0x82, 0x08, 0x20,
  0x41, 0x04, 0x10, 0x0F, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x02, 0x1F, 0xC0, 0x00, 0x80, 0x05, 0x00, 0x24, 0x00, 0x88, 0x04, 0x20,
  0x20, 0x41, 0x01, 0x08, 0x04, 0x20, 0x09, 0x00, 0x28, 0x00, 0x40, 0xFF,
  0xFC, 0x91, 0x22, 0x07, 0xC8, 0xC1, 0x48, 0x06, 0x80, 0x24, 0x01, 0x40,
  0x0A, 0x00, 0x50, 0x02, 0x80, 0x14, 0x01, 0x20, 0x09, 0x00, 0x44, 0x06,
  0x30, 0xD0, 0x78, 0xE0, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x8F, 0x84, 0x82, 0x38, 0x09, 0x80, 0x48, 0x02, 0x40, 0x14,
  0x00, 0xA0, 0x05, 0x00, 0x28, 0x01, 0x40, 0x12, 0x00, 0xB0, 0x09, 0x60,
  0x88, 0xF8, 0x00, 0x07, 0xC1, 0x82, 0x20, 0x12, 0x01, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x02, 0x40, 0x42, 0x08,
  0x1F, 0x00, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x7C, 0x86, 0x0A, 0x20, 0x19, 0x00, 0x24, 0x01, 0x20, 0x04, 0x80,
  0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x22, 0x00, 0x84, 0x06, 0x18,
  0x68, 0x1E, 0x20, 0x07, 0xE0, 0x40, 0x84, 0x02, 0x40, 0x14, 0x01, 0x40,
  0x0A, 0x07, 0x9F, 0xC0, 0x80, 0x04, 0x00, 0x20, 0x04, 0x80, 0x24, 0x02,
  0x10, 0x60, 0x7C, 0x00, 0x00, 0x1F, 0xC0, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x20, 0x40, 0x04, 0x20, 0x00, 0x88, 0x00, 0x12, 0x00,
  0x02, 0x80, 0x00, 0x60, 0x00, 0x03, 0xE4, 0x30, 0x51, 0x00, 0xC8, 0x02,
  0x20, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x44, 0x01,
  0x10, 0x04, 0x20, 0x30, 0xC3, 0x40, 0xF1, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x88, 0x04, 0x10, 0x30, 0x3F, 0x00, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x09, 0xF1, 0x43, 0x50, 0x2C, 0x05, 0x00, 0xA0, 0x14, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x04, 0x01,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10,
  0x11, 0x06, 0x10, 0x81, 0x30, 0x1C, 0x01, 0x80, 0x00, 0x10, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x10, 0x81, 0x04, 0x10, 0x31, 0x01, 0x90, 0x0E,
  0x00, 0x20, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x08, 0xF8, 0x12, 0x08, 0x28, 0x08, 0x60, 0x10, 0x80, 0x41, 0x00,
  0x84, 0x02, 0x08, 0x38, 0x11, 0x80, 0x22, 0x00, 0x42, 0x06, 0x84, 0x12,
  0x04, 0x44, 0x05, 0x08, 0x0C, 0x00, 0xFC, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02,
  0x00, 0x81, 0x20, 0xC8, 0xC2, 0x41, 0x60, 0x20, 0x00, 0x27, 0x1C, 0x51,
  0x44, 0xC3, 0x09, 0x04, 0x12, 0x08, 0x28, 0x10, 0x50, 0x20, 0xA0, 0x81,
  0x41, 0x02, 0x82, 0x09, 0x04, 0x14, 0x08, 0x28, 0x10, 0x50, 0x40, 0xA0,
  0x81, 0x00, 0x27, 0xC9, 0x0D, 0x40, 0xB0, 0x14, 0x02, 0x80, 0x50, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x10, 0x07,
  0xC0, 0xC1, 0x88, 0x04, 0x40, 0x14, 0x00, 0xA0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xA0, 0x05, 0x00, 0x24, 0x02, 0x10, 0x60, 0x7C, 0x00,
  0x11, 0xF0, 0x48, 0x21, 0xC0, 0x46, 0x01, 0x10, 0x04, 0x40, 0x12, 0x00,
  0x48, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x88, 0x02, 0x60, 0x11, 0x60,
  0x84, 0x7C, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x00, 0x07, 0xC8, 0xC1, 0x48, 0x06, 0x80, 0x24, 0x01, 0x40, 0x0A, 0x00,
  0x50, 0x02, 0x80, 0x14, 0x00, 0xA0, 0x09, 0x00, 0x44, 0x06, 0x30, 0xD0,
  0x78, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x7C, 0xFE, 0x14, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x00, 0x0F, 0xE0, 0xC0, 0x88, 0x02, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xFC, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x28, 0x01,
  0x30, 0x30, 0x7E, 0x00, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x03, 0xFF, 0xF0, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x82, 0x0C, 0x08, 0x40, 0x26, 0x01,
  0x60, 0x02, 0x00, 0x40, 0x14, 0x01, 0x40, 0x24, 0x02, 0x40, 0x28, 0x02,
  0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0x48, 0x0C, 0x81, 0x44, 0x34,
  0x3C, 0x80, 0xF8, 0x08, 0x40, 0x44, 0x02, 0x20, 0x11, 0x00, 0x88, 0x04,
  0x40, 0x22, 0x01, 0x10, 0x11, 0x00, 0x88, 0x08, 0x40, 0x82, 0x08, 0x11,
  0x80, 0xF0, 0x00, 0x20, 0x85, 0x02, 0x14, 0x10, 0x50, 0x41, 0x41, 0x05,
  0x04, 0x14, 0x10, 0x60, 0x41, 0x82, 0x06, 0x08, 0x18, 0x20, 0x60, 0x82,
  0x86, 0x0A, 0x24, 0x47, 0x0E, 0x00, 0x06, 0x1E, 0x1A, 0x22, 0x61, 0x41,
  0x81, 0x41, 0x01, 0x81, 0x00, 0x81, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x81, 0x00, 0x83, 0x00, 0x83, 0x02, 0x84, 0x84, 0x88, 0x98, 0x70, 0x60,
  0x10, 0x04, 0x40, 0x11, 0x00, 0x84, 0x02, 0x10, 0x08, 0x80, 0x22, 0x00,
  0x88, 0x02, 0x20, 0x10, 0x80, 0x42, 0x01, 0x08, 0x0C, 0x20, 0x50, 0x43,
  0x40, 0xF2, 0x00, 0x08, 0x00, 0x20, 0x00, 0x88, 0x04, 0x10, 0x60, 0x3F,
  0x00, 0x1F, 0x84, 0x83, 0xE4, 0x01, 0x90, 0x04, 0x40, 0x20, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x82, 0x02, 0x10, 0x04, 0xE0, 0x12,
  0xFE, 0x48, 0x1F, 0x00, 0x03, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x02, 0x00, 0x60, 0xF8, 0x00,
  0xC0, 0x04, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0xF0, 0x08, 0x42, 0x10, 0x84, 0x42,
  0x10, 0x84, 0x22, 0x10, 0x84, 0x21, 0x10, 0x84, 0x21, 0x08, 0x84, 0x00,
  0x07, 0xE0, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x0F, 0x81, 0xC0, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x07, 0xF0, 0x00, 0x3C, 0x05, 0x18, 0x18, 0x30,
  0xA0, 0x62, 0x80, 0xF0,
};

const GFXglyph IBMPlexMono_ThinItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 4, 20, 17, 7, -20 },
  { 11, 5, 7, 17, 8, -21 },
  { 16, 17, 20, 17, 1, -20 },
  { 59, 15, 26, 17, 1, -23 },
  { 108, 19, 20, 17, 0, -20 },
  { 156, 17, 20, 17, 0, -20 },
  { 199, 2, 7, 17, 9, -21 },
  { 201, 9, 26, 17, 7, -22 },
  { 231, 9, 26, 17, 2, -22 },
  { 261, 15, 14, 17, 2, -16 },
  { 288, 14, 15, 17, 2, -16 },
  { 315, 4, 7, 17, 5, -2 },
  { 319, 8, 1, 17, 5, -9 },
  { 320, 2, 2, 17, 7, -2 },
  { 321, 16, 26, 17, 1, -22 },
  { 373, 14, 20, 17, 2, -20 },
  { 408, 14, 20, 17, 1, -20 },
  { 443, 14, 20, 17, 1, -20 },
  { 478, 14, 20, 17, 1, -20 },
  { 513, 15, 20, 17, 1, -20 },
  { 551, 14, 20, 17, 2, -20 },
  { 586, 13, 20, 17, 2, -20 },
  { 619, 14, 20, 17, 3, -20 },
  { 654, 14, 20, 17, 2, -20 },
  { 689, 13, 20, 17, 3, -20 },
  { 722, 4, 15, 17, 7, -15 },
  { 730, 6, 20, 17, 5, -15 },
  { 745, 13, 15, 17, 3, -16 },
  { 770, 14, 6, 17, 2, -12 },
  { 781, 14, 15, 17, 1, -16 },
  { 808, 12, 20, 17, 4, -20 },
  { 838, 14, 23, 17, 2, -20 },
  { 879, 15, 20, 17, 0, -20 },
  { 917, 13, 20, 17, 2, -20 },
  { 950, 13, 20, 17, 3, -20 },
  { 983, 14, 20, 17, 2, -20 },
  { 1018, 15, 20, 17, 2, -20 },
  { 1056, 15, 20, 17, 2, -20 },
  { 1094, 13, 20, 17, 3, -20 },
  { 1127, 15, 20, 17, 2, -20 },
  { 1165, 16, 20, 17, 1, -20 },
  { 1205, 14, 20, 17, 2, -20 },
  { 1240, 16, 20, 17, 2, -20 },
  { 1280, 11, 20, 17, 3, -20 },
  { 1308, 16, 20, 17, 1, -20 },
  { 1348, 15, 20, 17, 2, -20 },
  { 1386, 14, 20, 17, 2, -20 },
  { 1421, 15, 20, 17, 2, -20 },
  { 1459, 14, 25, 17, 2, -20 },
  { 1503, 15, 20, 17, 2, -20 },
  { 1541, 15, 20, 17, 1, -20 },
  { 1579, 15, 20, 17, 3, -20 },
  { 1617, 14, 20, 17, 3, -20 },
  { 1652, 14, 20, 17, 4, -20 },
  { 1687, 16, 20, 17, 2, -20 },
  { 1727, 18, 20, 17, 0, -20 },
  { 1772, 16, 20, 17, 3, -20 },
  { 1812, 17, 20, 17, 0, -20 },
  { 1855, 11, 26, 17, 6, -22 },
  { 1891, 6, 26, 17, 6, -22 },
  { 1911, 11, 26, 17, 1, -22 },
  { 1947, 14, 11, 17, 2, -20 },
  { 1967, 14, 1, 17, 0, 3 },
  { 1969, 3, 5, 17, 7, -22 },
  { 1971, 13, 15, 17, 2, -15 },
  { 1996, 13, 21, 17, 2, -21 },
  { 2031, 12, 15, 17, 2, -15 },
  { 2054, 14, 21, 17, 2, -21 },
  { 2091, 13, 15, 17, 2, -15 },
  { 2116, 18, 27, 17, 0, -21 },
  { 2177, 14, 21, 17, 1, -15 },
  { 2214, 11, 21, 17, 3, -21 },
  { 2243, 12, 22, 17, 3, -22 },
  { 2276, 12, 28, 17, 3, -22 },
  { 2318, 15, 21, 17, 2, -21 },
  { 2358, 10, 21, 17, 4, -21 },
  { 2385, 15, 15, 17, 1, -15 },
  { 2414, 11, 15, 17, 3, -15 },
  { 2435, 13, 15, 17, 2, -15 },
  { 2460, 14, 21, 17, 1, -15 },
  { 2497, 13, 21, 17, 2, -15 },
  { 2532, 14, 15, 17, 3, -15 },
  { 2559, 13, 15, 17, 2, -15 },
  { 2584, 14, 20, 17, 2, -20 },
  { 2619, 12, 15, 17, 3, -15 },
  { 2642, 13, 15, 17, 2, -15 },
  { 2667, 14, 15, 17, 2, -15 },
  { 2694, 16, 15, 17, 1, -15 },
  { 2724, 14, 21, 17, 1, -15 },
  { 2761, 14, 15, 17, 2, -15 },
  { 2788, 12, 26, 17, 4, -22 },
  { 2827, 5, 26, 17, 6, -22 },
  { 2844, 13, 26, 17, 1, -22 },
  { 2887, 14, 5, 17, 2, -12 },
};

const GFXfont IBMPlexMono_ThinItalic29pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic29pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _IBMPLEXMONO_THINITALIC29PT7B_H_
