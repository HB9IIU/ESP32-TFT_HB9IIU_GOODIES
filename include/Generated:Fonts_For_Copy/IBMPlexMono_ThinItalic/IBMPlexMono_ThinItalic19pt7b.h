#ifndef _IBMPLEXMONO_THINITALIC19PT7B_H_
#define _IBMPLEXMONO_THINITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x94, 0x92, 0x40, 0x0C, 0x9A, 0xAA, 0xA0, 0x02, 0x40, 0x44,
  0x04, 0x80, 0x48, 0x38, 0xF0, 0x90, 0x09, 0x01, 0x20, 0xF1, 0xC2, 0x20,
  0x22, 0x02, 0x40, 0x44, 0x00, 0x06, 0x01, 0x01, 0xF0, 0x92, 0x44, 0x51,
  0x04, 0x80, 0xA0, 0x1E, 0x02, 0x40, 0x88, 0x22, 0x91, 0x14, 0x43, 0xE0,
  0x40, 0x10, 0x00, 0x1C, 0x12, 0x22, 0x42, 0x44, 0x24, 0x44, 0x83, 0x90,
  0x00, 0x01, 0x1C, 0x16, 0x42, 0x44, 0x48, 0x48, 0x44, 0x83, 0x80, 0x0F,
  0x02, 0x10, 0x82, 0x10, 0x41, 0x08, 0x22, 0x0F, 0x86, 0x40, 0x84, 0x10,
  0x46, 0x0C, 0xA2, 0x63, 0x8C, 0xF8, 0x04, 0x21, 0x08, 0x41, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x04, 0x10, 0x30, 0x10, 0x20, 0x81, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x42, 0x08, 0x41, 0x08, 0xC0, 0x04, 0x01, 0x00, 0x82,
  0x21, 0x7B, 0x83, 0x01, 0x40, 0x90, 0x42, 0x00, 0x04, 0x04, 0x02, 0x01,
  0x0F, 0xF8, 0x40, 0x20, 0x10, 0x10, 0x00, 0x6A, 0x40, 0xF8, 0xC0, 0x00,
  0x40, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x00, 0x0F, 0x08, 0x48,
  0x28, 0x14, 0x0C, 0x06, 0x23, 0x01, 0x80, 0xC0, 0x60, 0x48, 0x43, 0xC0,
  0x06, 0x06, 0x05, 0x04, 0x84, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x0F, 0xF8, 0x0F, 0x08, 0x48, 0x28, 0x10, 0x08, 0x08, 0x04, 0x04,
  0x0C, 0x08, 0x08, 0x18, 0x0F, 0xF0, 0x0F, 0x18, 0x50, 0x20, 0x10, 0x08,
  0x08, 0x78, 0x06, 0x01, 0x00, 0xA0, 0x50, 0x47, 0xC0, 0x00, 0x81, 0x81,
  0x41, 0x21, 0x11, 0x09, 0x08, 0x84, 0x82, 0x7F, 0xC0, 0x80, 0x40, 0x40,
  0x1F, 0xC8, 0x02, 0x00, 0x80, 0x40, 0x17, 0x82, 0x11, 0x04, 0x01, 0x00,
  0x48, 0x11, 0x0C, 0x3C, 0x00, 0x06, 0x08, 0x30, 0x40, 0x40, 0xBC, 0xC2,
  0x81, 0x81, 0x81, 0x82, 0x86, 0x78, 0x7F, 0xC0, 0xA0, 0x50, 0x40, 0x40,
  0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08, 0x00, 0x0F, 0x0C, 0x24,
  0x09, 0x03, 0x40, 0x88, 0x21, 0xF1, 0x84, 0x80, 0xA0, 0x28, 0x09, 0x04,
  0x3E, 0x00, 0x3E, 0x41, 0x81, 0x81, 0x81, 0x81, 0x83, 0x7E, 0x02, 0x04,
  0x08, 0x10, 0x60, 0x20, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x00, 0x06,
  0x48, 0x80, 0x00, 0x81, 0x83, 0x06, 0x0C, 0x04, 0x01, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x40, 0x18, 0x02, 0x00, 0xC0,
  0x10, 0x0C, 0x18, 0x10, 0x30, 0x60, 0x00, 0x3C, 0x86, 0x0C, 0x10, 0x20,
  0x82, 0x18, 0x20, 0x80, 0x00, 0x04, 0x00, 0x1E, 0x21, 0x41, 0x41, 0x8F,
  0x93, 0xA1, 0xA1, 0xA2, 0xA2, 0x9E, 0x80, 0x80, 0x80, 0x7C, 0x02, 0x01,
  0x40, 0x50, 0x24, 0x09, 0x04, 0x41, 0x10, 0x82, 0x3F, 0x88, 0x24, 0x0A,
  0x02, 0x80, 0x40, 0x3F, 0x10, 0x50, 0x28, 0x14, 0x0A, 0x09, 0xF8, 0x82,
  0x80, 0xC0, 0x60, 0x50, 0x2F, 0xE0, 0x1E, 0x10, 0x90, 0x50, 0x18, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x41, 0x20, 0x90, 0x87, 0x80, 0x3F, 0x10, 0x48,
  0x28, 0x14, 0x0A, 0x05, 0x02, 0x81, 0x80, 0xC0, 0x60, 0x50, 0x4F, 0xC0,
  0x3F, 0xC8, 0x02, 0x01, 0x00, 0x40, 0x10, 0x07, 0xF9, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0xFF, 0x00, 0x3F, 0xC8, 0x02, 0x01, 0x00, 0x40, 0x10,
  0x07, 0xF9, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x1E, 0x10,
  0x90, 0x50, 0x18, 0x04, 0x02, 0x01, 0x1E, 0x81, 0x40, 0xA0, 0x90, 0xC7,
  0xA0, 0x20, 0x50, 0x14, 0x09, 0x02, 0x40, 0x90, 0x27, 0xFA, 0x02, 0x81,
  0x20, 0x48, 0x12, 0x04, 0x81, 0x00, 0x3F, 0xC1, 0x00, 0x40, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0xFF, 0x00, 0x1F,
  0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xA0, 0x88,
  0xC3, 0xC0, 0x20, 0x64, 0x11, 0x04, 0x21, 0x04, 0x40, 0x90, 0x16, 0x03,
  0x20, 0x84, 0x10, 0x42, 0x08, 0x40, 0x88, 0x18, 0x60, 0x81, 0x02, 0x04,
  0x08, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0x20, 0xD8, 0x36, 0x15,
  0x49, 0x52, 0xA5, 0x28, 0xCA, 0x22, 0x80, 0xA0, 0x28, 0x12, 0x04, 0x81,
  0x00, 0x20, 0x58, 0x15, 0x09, 0x42, 0x50, 0x92, 0x24, 0x8A, 0x12, 0x85,
  0x21, 0x48, 0x32, 0x0C, 0x81, 0x00, 0x0F, 0x08, 0x48, 0x28, 0x14, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x48, 0x43, 0xC0, 0x3F, 0x88, 0x22,
  0x05, 0x01, 0x40, 0x50, 0x14, 0x09, 0xFC, 0x40, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x00, 0x0F, 0x08, 0x48, 0x28, 0x14, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x48, 0x43, 0xC0, 0x40, 0x22, 0x0A, 0x02, 0x00, 0x3F, 0x88,
  0x22, 0x05, 0x01, 0x40, 0x50, 0x14, 0x09, 0xFC, 0x48, 0x21, 0x08, 0x22,
  0x08, 0x81, 0x00, 0x1E, 0x08, 0x64, 0x05, 0x00, 0x40, 0x08, 0x01, 0xE0,
  0x04, 0x00, 0x80, 0x28, 0x11, 0x04, 0x3E, 0x00, 0xFF, 0xC2, 0x00, 0x80,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x00, 0x40, 0xC0, 0x60, 0x50, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x82, 0x41,
  0x20, 0x90, 0x87, 0x80, 0x80, 0xE0, 0x28, 0x12, 0x04, 0x42, 0x10, 0x84,
  0x41, 0x10, 0x48, 0x12, 0x03, 0x00, 0xC0, 0x20, 0x00, 0x80, 0x60, 0x28,
  0x0A, 0x02, 0x89, 0x26, 0x4A, 0x92, 0xA4, 0xCA, 0x32, 0x88, 0x62, 0x18,
  0x84, 0x00, 0x20, 0x31, 0x04, 0x10, 0x40, 0x88, 0x09, 0x00, 0x60, 0x04,
  0x00, 0xA0, 0x12, 0x01, 0x10, 0x21, 0x04, 0x08, 0x80, 0xC0, 0x80, 0x60,
  0x24, 0x11, 0x08, 0x24, 0x09, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x00, 0x1F, 0xE0, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x0F, 0xFC, 0x1E, 0x40, 0x82,
  0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xF0,
  0x88, 0x88, 0x88, 0x44, 0x44, 0x22, 0x22, 0x11, 0x10, 0x3E, 0x04, 0x08,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x02, 0x08, 0xF0,
  0x0C, 0x14, 0x24, 0x22, 0x42, 0x81, 0x81, 0xFF, 0x80, 0xAC, 0x1E, 0x90,
  0xD0, 0x50, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x46, 0x1C, 0xC0, 0x40, 0x40,
  0x40, 0x40, 0x5E, 0xA1, 0x41, 0x81, 0x81, 0x81, 0x81, 0x82, 0x86, 0xF8,
  0x3C, 0x86, 0x0C, 0x08, 0x10, 0x20, 0xC2, 0x84, 0xF0, 0x00, 0xC0, 0x20,
  0x08, 0x02, 0x1E, 0x88, 0x64, 0x12, 0x04, 0x81, 0x20, 0x48, 0x12, 0x04,
  0x46, 0x0E, 0x80, 0x3E, 0x41, 0x81, 0x86, 0xF8, 0x80, 0x82, 0x82, 0x84,
  0x78, 0x01, 0xF0, 0x20, 0x02, 0x00, 0x20, 0x1F, 0xE0, 0x20, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x88, 0x04,
  0x80, 0x28, 0x01, 0x00, 0x1E, 0x90, 0xD0, 0x50, 0x28, 0x14, 0x0A, 0x05,
  0x02, 0x46, 0x1D, 0x00, 0x80, 0x48, 0x43, 0xC0, 0x40, 0x81, 0x02, 0x05,
  0xEC, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x80, 0x08, 0x00, 0x00,
  0x00, 0xF0, 0x10, 0x10, 0x20, 0x20, 0x20, 0x23, 0x24, 0x58, 0x20, 0x01,
  0x00, 0x00, 0x00, 0x7E, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x08, 0x88, 0x48, 0x38, 0x18, 0x20, 0x08, 0x02, 0x00, 0x80, 0x2F, 0x14,
  0x42, 0x09, 0x04, 0x42, 0x17, 0x05, 0x06, 0x22, 0x85, 0x20, 0x80, 0xF8,
  0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x8A, 0x25, 0x84, 0x00,
  0x59, 0x99, 0x94, 0x46, 0x21, 0x88, 0xA2, 0x28, 0x8A, 0x22, 0x88, 0xA4,
  0x20, 0x5E, 0xC7, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x08, 0x3C, 0x42,
  0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x84, 0x78, 0x6F, 0x28, 0x48, 0x28,
  0x14, 0x0A, 0x06, 0x02, 0x82, 0xC3, 0x5E, 0x20, 0x10, 0x08, 0x04, 0x00,
  0x1E, 0x90, 0xD0, 0x50, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x46, 0x1D, 0x00,
  0x80, 0x40, 0x20, 0x10, 0xF7, 0x8C, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x00, 0x1F, 0x10, 0x50, 0x08, 0x03, 0xC0, 0x18, 0x04,
  0x02, 0xC1, 0x1F, 0x00, 0x08, 0x02, 0x00, 0x83, 0xFF, 0x08, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x22, 0x30, 0xB0, 0x10, 0x00, 0x81, 0x82, 0x82,
  0x82, 0x82, 0x82, 0x82, 0x86, 0x8C, 0x74, 0xC1, 0x41, 0x41, 0x41, 0x41,
  0x42, 0x82, 0x84, 0x88, 0x70, 0x44, 0x91, 0x14, 0x46, 0x21, 0x88, 0x62,
  0x18, 0x8A, 0x62, 0x98, 0x99, 0xC0, 0x08, 0xC6, 0xA7, 0x18, 0x82, 0x10,
  0x40, 0x08, 0x21, 0x04, 0x62, 0x8A, 0xAE, 0x60, 0x40, 0xA0, 0x90, 0x48,
  0x24, 0x14, 0x0A, 0x05, 0x04, 0x46, 0x1D, 0x00, 0x80, 0x48, 0x43, 0xC0,
  0x3E, 0xA1, 0xE0, 0x40, 0x40, 0x40, 0xC0, 0x85, 0x82, 0xF9, 0x47, 0x80,
  0x07, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x10, 0x10, 0xF0, 0x0C, 0x02,
  0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x3C, 0x00, 0x24, 0x92, 0x52, 0x49,
  0x29, 0x24, 0x80, 0x1E, 0x02, 0x04, 0x04, 0x04, 0x08, 0x10, 0x08, 0x07,
  0x18, 0x10, 0x10, 0x10, 0x08, 0x08, 0x10, 0xF0, 0x30, 0x52, 0x28, 0x4A,
  0x0C,
};

const GFXglyph IBMPlexMono_ThinItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 4, 5, 11, 5, -14 },
  { 9, 12, 13, 11, 0, -13 },
  { 29, 10, 17, 11, 1, -15 },
  { 51, 12, 13, 11, 0, -13 },
  { 71, 11, 13, 11, 0, -13 },
  { 89, 1, 5, 11, 6, -14 },
  { 90, 6, 17, 11, 4, -14 },
  { 103, 6, 17, 11, 1, -14 },
  { 116, 10, 9, 11, 1, -10 },
  { 128, 9, 9, 11, 1, -10 },
  { 139, 3, 4, 11, 3, -1 },
  { 141, 5, 1, 11, 3, -6 },
  { 142, 2, 1, 11, 4, -1 },
  { 143, 10, 17, 11, 1, -14 },
  { 165, 9, 13, 11, 1, -13 },
  { 180, 9, 13, 11, 1, -13 },
  { 195, 9, 13, 11, 1, -13 },
  { 210, 9, 13, 11, 1, -13 },
  { 225, 9, 13, 11, 1, -13 },
  { 240, 10, 13, 11, 1, -13 },
  { 257, 8, 13, 11, 2, -13 },
  { 270, 9, 13, 11, 2, -13 },
  { 285, 10, 13, 11, 1, -13 },
  { 302, 8, 13, 11, 2, -13 },
  { 315, 3, 10, 11, 4, -10 },
  { 319, 4, 13, 11, 3, -10 },
  { 326, 9, 10, 11, 2, -11 },
  { 338, 10, 4, 11, 1, -8 },
  { 343, 9, 10, 11, 1, -11 },
  { 355, 7, 13, 11, 3, -13 },
  { 367, 8, 15, 11, 2, -13 },
  { 382, 10, 13, 11, 0, -13 },
  { 399, 9, 13, 11, 1, -13 },
  { 414, 9, 13, 11, 2, -13 },
  { 429, 9, 13, 11, 1, -13 },
  { 444, 10, 13, 11, 1, -13 },
  { 461, 10, 13, 11, 1, -13 },
  { 478, 9, 13, 11, 2, -13 },
  { 493, 10, 13, 11, 1, -13 },
  { 510, 10, 13, 11, 1, -13 },
  { 527, 9, 13, 11, 1, -13 },
  { 542, 11, 13, 11, 1, -13 },
  { 560, 7, 13, 11, 2, -13 },
  { 572, 10, 13, 11, 1, -13 },
  { 589, 10, 13, 11, 1, -13 },
  { 606, 9, 13, 11, 1, -13 },
  { 621, 10, 13, 11, 1, -13 },
  { 638, 9, 17, 11, 1, -13 },
  { 658, 10, 13, 11, 1, -13 },
  { 675, 10, 13, 11, 1, -13 },
  { 692, 10, 13, 11, 2, -13 },
  { 709, 9, 13, 11, 2, -13 },
  { 724, 10, 13, 11, 2, -13 },
  { 741, 10, 13, 11, 2, -13 },
  { 758, 12, 13, 11, 0, -13 },
  { 778, 10, 13, 11, 2, -13 },
  { 795, 11, 13, 11, 0, -13 },
  { 813, 7, 17, 11, 4, -14 },
  { 828, 4, 17, 11, 4, -14 },
  { 837, 7, 17, 11, 1, -14 },
  { 852, 8, 7, 11, 2, -13 },
  { 859, 9, 1, 11, 0, 2 },
  { 861, 2, 3, 11, 5, -15 },
  { 862, 9, 10, 11, 1, -10 },
  { 874, 8, 14, 11, 2, -14 },
  { 888, 7, 10, 11, 2, -10 },
  { 897, 10, 14, 11, 1, -14 },
  { 915, 8, 10, 11, 2, -10 },
  { 925, 12, 18, 11, 0, -14 },
  { 952, 9, 14, 11, 1, -10 },
  { 968, 7, 14, 11, 2, -14 },
  { 981, 8, 14, 11, 2, -14 },
  { 995, 8, 18, 11, 2, -14 },
  { 1013, 10, 14, 11, 1, -14 },
  { 1031, 7, 14, 11, 2, -14 },
  { 1044, 10, 10, 11, 1, -10 },
  { 1057, 7, 10, 11, 2, -10 },
  { 1066, 8, 10, 11, 2, -10 },
  { 1076, 9, 14, 11, 1, -10 },
  { 1092, 9, 14, 11, 1, -10 },
  { 1108, 9, 10, 11, 2, -10 },
  { 1120, 9, 10, 11, 1, -10 },
  { 1132, 10, 13, 11, 1, -13 },
  { 1149, 8, 10, 11, 2, -10 },
  { 1159, 8, 10, 11, 2, -10 },
  { 1169, 10, 10, 11, 1, -10 },
  { 1182, 11, 10, 11, 0, -10 },
  { 1196, 9, 14, 11, 1, -10 },
  { 1212, 9, 10, 11, 1, -10 },
  { 1224, 9, 17, 11, 2, -14 },
  { 1244, 3, 17, 11, 4, -14 },
  { 1251, 8, 17, 11, 1, -14 },
  { 1268, 10, 4, 11, 1, -8 },
};

const GFXfont IBMPlexMono_ThinItalic19pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic19pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _IBMPLEXMONO_THINITALIC19PT7B_H_
