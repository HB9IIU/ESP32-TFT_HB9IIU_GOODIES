#ifndef _IBMPLEXMONO_THINITALIC25PT7B_H_
#define _IBMPLEXMONO_THINITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x12, 0x22, 0x22, 0x44, 0x44, 0x48, 0x00, 0x08, 0x80, 0x99, 0x99,
  0x99, 0x00, 0x88, 0x02, 0x10, 0x04, 0x40, 0x08, 0x80, 0x21, 0x07, 0xC3,
  0xC0, 0x88, 0x02, 0x10, 0x04, 0x40, 0x08, 0x80, 0x21, 0x03, 0xC3, 0xE8,
  0x88, 0x02, 0x10, 0x04, 0x40, 0x08, 0x80, 0x21, 0x00, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x0F, 0x81, 0x93, 0x10, 0x84, 0x84, 0x04, 0x20, 0x21, 0x01,
  0x10, 0x07, 0x80, 0x0F, 0x00, 0x26, 0x01, 0x10, 0x10, 0x40, 0x82, 0x84,
  0x24, 0x21, 0x19, 0x10, 0x3F, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x0F,
  0x01, 0x10, 0x82, 0x20, 0x84, 0x20, 0x88, 0x20, 0x88, 0x20, 0x90, 0x21,
  0x20, 0x1E, 0x40, 0x00, 0x00, 0x04, 0x78, 0x08, 0x88, 0x11, 0x04, 0x12,
  0x04, 0x22, 0x04, 0x42, 0x08, 0x81, 0x08, 0x80, 0xF0, 0x03, 0xC0, 0x18,
  0x40, 0x20, 0x80, 0x80, 0x81, 0x01, 0x01, 0x04, 0x02, 0x08, 0x02, 0x20,
  0x3B, 0x80, 0x84, 0x02, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x18, 0x60,
  0x29, 0x20, 0x94, 0x3E, 0x18, 0x5A, 0xA0, 0x03, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x40, 0x40, 0x20, 0x30, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x02,
  0x02, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x80, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x84, 0x16, 0x46,
  0x1F, 0x80, 0xC0, 0x12, 0x02, 0x10, 0x41, 0x0C, 0x08, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x25, 0x29, 0x00, 0xFE, 0xC0, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x00, 0x07, 0x81,
  0x86, 0x20, 0x24, 0x01, 0x40, 0x18, 0x01, 0x80, 0x18, 0x01, 0x86, 0x18,
  0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0x84, 0x10, 0x3E, 0x00,
  0x00, 0x80, 0x38, 0x06, 0x80, 0x88, 0x31, 0x02, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40,
  0xFF, 0xF0, 0x03, 0xC0, 0xC3, 0x10, 0x12, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20,
  0x04, 0x00, 0xFF, 0xE0, 0x07, 0xC0, 0x82, 0x20, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x20, 0x06, 0x0F, 0x80, 0x0C, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x80, 0x26, 0x0C, 0x1F, 0x00, 0x00, 0x10, 0x06, 0x00, 0xA0, 0x12,
  0x02, 0x20, 0x22, 0x04, 0x20, 0x84, 0x10, 0x42, 0x04, 0x40, 0x48, 0x04,
  0xFF, 0xF0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xF8, 0x40, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0xBE, 0x06, 0x0C, 0x20, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x12, 0x01, 0x04, 0x18, 0x1F, 0x00,
  0x00, 0xC0, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x7C, 0xB0,
  0x58, 0x0A, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xA0, 0x12, 0x0C, 0x3E, 0x00,
  0x7F, 0xF8, 0x02, 0x80, 0x48, 0x04, 0x80, 0x80, 0x10, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x00, 0x07, 0xE0, 0x40, 0x84, 0x02, 0x40, 0x12, 0x00, 0x90, 0x04,
  0x80, 0x43, 0x04, 0x07, 0xC1, 0xC3, 0x10, 0x05, 0x00, 0x28, 0x01, 0x40,
  0x09, 0x00, 0x8C, 0x08, 0x1F, 0x80, 0x1F, 0x08, 0x24, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0xD0, 0x63, 0xE8, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x60, 0x00, 0x24, 0x00, 0x00, 0x00, 0x09, 0x00, 0x08, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x11, 0x08, 0x84, 0x00, 0x00, 0x10,
  0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x1F,
  0x08, 0x2C, 0x0A, 0x01, 0x00, 0x40, 0x20, 0x08, 0x0C, 0x1C, 0x08, 0x02,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x07, 0xC1, 0x04,
  0x40, 0x90, 0x12, 0x02, 0x87, 0x51, 0x1A, 0x41, 0x88, 0x32, 0x06, 0x41,
  0x48, 0x29, 0x05, 0x11, 0xA1, 0xD4, 0x00, 0x80, 0x10, 0x01, 0x00, 0x1F,
  0x80, 0x00, 0x40, 0x06, 0x00, 0x50, 0x02, 0x80, 0x24, 0x01, 0x10, 0x10,
  0x80, 0x84, 0x08, 0x20, 0x41, 0x04, 0x04, 0x3F, 0xE2, 0x01, 0x10, 0x09,
  0x00, 0x48, 0x02, 0x80, 0x08, 0x1F, 0xE1, 0x01, 0x10, 0x12, 0x01, 0x20,
  0x12, 0x01, 0x20, 0x12, 0x02, 0x3F, 0xC4, 0x06, 0x40, 0x14, 0x01, 0x40,
  0x14, 0x01, 0x80, 0x28, 0x06, 0xFF, 0x80, 0x07, 0xC0, 0x82, 0x10, 0x22,
  0x01, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x48, 0x04, 0x40, 0x86, 0x10, 0x1E, 0x00, 0x3F, 0x82, 0x04,
  0x20, 0x22, 0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x18, 0x02,
  0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x88, 0x18, 0xFE, 0x00, 0x3F,
  0xF9, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x7F, 0xE2, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0xFF, 0xC0, 0x3F, 0xF9, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x7F, 0xE2, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x00, 0x07, 0xC0, 0x82, 0x10, 0x22,
  0x01, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x3E, 0x80, 0x28,
  0x02, 0x80, 0x28, 0x04, 0x80, 0xC6, 0x1C, 0x3E, 0x40, 0x10, 0x08, 0x80,
  0x48, 0x02, 0x40, 0x12, 0x00, 0x90, 0x08, 0x80, 0x44, 0x02, 0x3F, 0xF2,
  0x00, 0x90, 0x04, 0x80, 0x44, 0x02, 0x20, 0x12, 0x00, 0x90, 0x04, 0x80,
  0x20, 0x1F, 0xFC, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0xFF, 0xE0, 0x0F, 0xE0, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40,
  0x09, 0x01, 0x20, 0x42, 0x18, 0x3C, 0x00, 0x20, 0x09, 0x00, 0x88, 0x08,
  0x80, 0x84, 0x08, 0x21, 0x81, 0x10, 0x09, 0x80, 0x54, 0x05, 0x10, 0x10,
  0x81, 0x02, 0x08, 0x10, 0x40, 0x42, 0x02, 0x10, 0x08, 0x80, 0x60, 0x20,
  0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x80, 0x10, 0x04, 0xC0, 0x63, 0x02,
  0x8A, 0x0A, 0x28, 0x48, 0xA1, 0x24, 0x48, 0x91, 0x44, 0x45, 0x11, 0x08,
  0x44, 0x41, 0x10, 0x04, 0x80, 0x12, 0x00, 0x88, 0x02, 0x20, 0x08, 0x80,
  0x20, 0x10, 0x08, 0xC0, 0x4A, 0x02, 0x50, 0x12, 0x40, 0x92, 0x08, 0x90,
  0x44, 0x42, 0x42, 0x12, 0x08, 0x90, 0x44, 0x82, 0x44, 0x0A, 0x20, 0x52,
  0x02, 0x90, 0x0C, 0x80, 0x60, 0x07, 0x81, 0x86, 0x20, 0x24, 0x01, 0x40,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x02, 0x80,
  0x48, 0x04, 0x80, 0x84, 0x10, 0x3E, 0x00, 0x3F, 0xC2, 0x03, 0x20, 0x12,
  0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x27, 0xFC, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x07, 0x81, 0x86,
  0x20, 0x24, 0x01, 0x40, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02,
  0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0x84, 0x10, 0x3E, 0x00, 0x80,
  0x04, 0x60, 0x2C, 0x01, 0x00, 0x3F, 0xC2, 0x03, 0x20, 0x12, 0x01, 0x40,
  0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x27, 0xFC, 0x84, 0x08, 0x20, 0x81,
  0x08, 0x10, 0x80, 0x88, 0x08, 0x80, 0x40, 0x07, 0xC0, 0xC1, 0x88, 0x02,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x40, 0x12, 0x00, 0x8C, 0x08, 0x1F, 0x80, 0xFF,
  0xF8, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x20, 0x12, 0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x02,
  0x40, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48, 0x04,
  0x80, 0x84, 0x18, 0x3E, 0x00, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x40,
  0x44, 0x04, 0x40, 0x84, 0x08, 0x41, 0x04, 0x10, 0x22, 0x02, 0x20, 0x24,
  0x02, 0x40, 0x28, 0x02, 0x80, 0x10, 0x00, 0x40, 0x0A, 0x00, 0x50, 0x02,
  0x80, 0x28, 0x01, 0x41, 0x0A, 0x18, 0x51, 0x44, 0x8A, 0x24, 0x51, 0x24,
  0x49, 0x22, 0x8A, 0x14, 0x50, 0xA3, 0x06, 0x18, 0x30, 0x80, 0x80, 0x10,
  0x02, 0x10, 0x08, 0x20, 0x20, 0x20, 0x80, 0x41, 0x00, 0x44, 0x00, 0x90,
  0x00, 0xC0, 0x01, 0x00, 0x05, 0x00, 0x12, 0x00, 0x22, 0x00, 0x84, 0x02,
  0x04, 0x08, 0x08, 0x20, 0x08, 0x80, 0x18, 0x80, 0x0C, 0x00, 0xA0, 0x08,
  0x80, 0x84, 0x08, 0x10, 0x80, 0x84, 0x02, 0x40, 0x14, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x0F,
  0xFE, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x00, 0xFF, 0xF8, 0x0F, 0xC4, 0x01, 0x00, 0x40,
  0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0x00, 0x82,
  0x08, 0x20, 0x81, 0x04, 0x10, 0x40, 0x82, 0x08, 0x20, 0x41, 0x04, 0x10,
  0x20, 0x82, 0x08, 0x10, 0x1F, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x47, 0xE0, 0x01, 0x00, 0x30, 0x04, 0x80, 0x88, 0x10,
  0x42, 0x04, 0x20, 0x44, 0x02, 0x80, 0x30, 0xFF, 0xF0, 0x91, 0x10, 0x0F,
  0x26, 0x15, 0x01, 0xC0, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x50,
  0x12, 0x06, 0x21, 0x43, 0xCE, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x09, 0xE2, 0xC2, 0x60, 0x24, 0x05, 0x00, 0xA0, 0x14, 0x03, 0x00,
  0x60, 0x0C, 0x02, 0xC0, 0x54, 0x32, 0x78, 0x00, 0x0F, 0x0C, 0x24, 0x05,
  0x01, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x09, 0x04, 0x3E,
  0x00, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x0F, 0x23,
  0x0A, 0x40, 0x68, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48,
  0x08, 0x81, 0x84, 0x38, 0x3C, 0x80, 0x0F, 0x82, 0x09, 0x80, 0xA0, 0x18,
  0x05, 0x07, 0x3F, 0x04, 0x00, 0x80, 0x10, 0x0A, 0x02, 0x30, 0x83, 0xE0,
  0x00, 0x7E, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x07,
  0xFF, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x04,
  0x10, 0x04, 0x40, 0x04, 0x80, 0x07, 0x00, 0x06, 0x00, 0x07, 0x91, 0x85,
  0x20, 0x34, 0x02, 0x40, 0x24, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04,
  0x40, 0xC2, 0x14, 0x1E, 0x40, 0x04, 0x00, 0x88, 0x08, 0x41, 0x03, 0xE0,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x78, 0xA1, 0x30, 0x58,
  0x14, 0x05, 0x01, 0x40, 0x50, 0x14, 0x06, 0x01, 0x80, 0xA0, 0x28, 0x08,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x18, 0x84, 0x13, 0x02,
  0x80, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x22, 0x08, 0x44, 0x09, 0x01, 0xC0, 0x30, 0x10, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x27, 0x84, 0x84, 0x70, 0x26, 0x02,
  0x40, 0x44, 0x08, 0x47, 0x08, 0x80, 0x88, 0x18, 0x41, 0x84, 0x68, 0x2C,
  0x81, 0x00, 0xFC, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x82, 0x46, 0x24, 0x1C, 0x08, 0x00,
  0x2E, 0x71, 0x8C, 0x58, 0x42, 0x82, 0x14, 0x10, 0xA1, 0x05, 0x08, 0x28,
  0x42, 0x82, 0x14, 0x10, 0xA1, 0x05, 0x08, 0x28, 0x41, 0x00, 0x27, 0x8A,
  0x13, 0x05, 0x81, 0x40, 0x50, 0x14, 0x05, 0x01, 0x40, 0x60, 0x18, 0x0A,
  0x02, 0x80, 0x80, 0x0F, 0x86, 0x09, 0x00, 0xA0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x50, 0x0A, 0x02, 0x20, 0xC3, 0xE0, 0x13, 0xC2, 0xC2,
  0x30, 0x11, 0x01, 0x20, 0x12, 0x01, 0x20, 0x14, 0x01, 0x40, 0x14, 0x02,
  0x60, 0x25, 0x0C, 0x4F, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x0F, 0x26, 0x15, 0x01, 0xC0, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80,
  0x50, 0x12, 0x06, 0x21, 0x43, 0xC8, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x20, 0xF9, 0xF0, 0xA0, 0x0C, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x00, 0x1F, 0x84, 0x0D,
  0x00, 0xA0, 0x04, 0x00, 0x60, 0x03, 0xE0, 0x02, 0x00, 0x40, 0x0A, 0x01,
  0x20, 0x63, 0xF0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0xF0, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x61, 0x0C,
  0x13, 0x01, 0xC0, 0x10, 0x00, 0xC0, 0x60, 0x18, 0x0A, 0x02, 0x80, 0xA0,
  0x28, 0x0A, 0x02, 0x81, 0x20, 0xC8, 0x32, 0x14, 0x79, 0x00, 0xF0, 0x22,
  0x04, 0x80, 0x90, 0x12, 0x02, 0x40, 0x48, 0x09, 0x02, 0x20, 0x48, 0x11,
  0x04, 0x23, 0x03, 0x80, 0x42, 0x14, 0x21, 0x42, 0x18, 0x21, 0x82, 0x18,
  0x41, 0x84, 0x18, 0x41, 0x84, 0x18, 0x42, 0x8C, 0x28, 0xC4, 0x73, 0x80,
  0x0C, 0x30, 0xD3, 0x2C, 0x28, 0x80, 0xC1, 0x02, 0x04, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x82, 0x02, 0x18, 0x08, 0xA1, 0xA2, 0x58, 0x71, 0x80, 0x30,
  0x12, 0x01, 0x20, 0x22, 0x02, 0x20, 0x22, 0x02, 0x40, 0x24, 0x02, 0x40,
  0x44, 0x04, 0x40, 0xC2, 0x14, 0x1E, 0x40, 0x04, 0x00, 0x88, 0x08, 0x43,
  0x03, 0xE0, 0x1F, 0x19, 0x07, 0x90, 0x04, 0x80, 0x40, 0x0C, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x10, 0x41, 0x01, 0x10, 0x09, 0xFE, 0x48, 0x1E, 0x00,
  0x03, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x83, 0xE0, 0x06, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x7E, 0x00, 0x11, 0x22, 0x22, 0x22, 0x44,
  0x44, 0x44, 0x88, 0x88, 0x88, 0x88, 0x0F, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x20, 0x04, 0x00, 0x40, 0x07, 0x83, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x41, 0xF8,
  0x00, 0x1C, 0x09, 0x20, 0x50, 0x85, 0x02, 0x28, 0x0E, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 4, 17, 15, 6, -17 },
  { 10, 4, 6, 15, 7, -19 },
  { 13, 15, 17, 15, 0, -17 },
  { 45, 13, 23, 15, 1, -20 },
  { 83, 16, 17, 15, 0, -17 },
  { 117, 15, 17, 15, 0, -17 },
  { 149, 2, 6, 15, 8, -19 },
  { 151, 8, 22, 15, 6, -19 },
  { 173, 8, 22, 15, 2, -19 },
  { 195, 12, 12, 15, 2, -14 },
  { 213, 12, 13, 15, 2, -14 },
  { 233, 3, 6, 15, 4, -2 },
  { 236, 7, 1, 15, 4, -8 },
  { 237, 1, 2, 15, 6, -2 },
  { 238, 13, 22, 15, 1, -19 },
  { 274, 12, 17, 15, 2, -17 },
  { 300, 12, 17, 15, 1, -17 },
  { 326, 12, 17, 15, 1, -17 },
  { 352, 12, 17, 15, 1, -17 },
  { 378, 12, 17, 15, 1, -17 },
  { 404, 13, 17, 15, 1, -17 },
  { 432, 11, 17, 15, 2, -17 },
  { 456, 12, 17, 15, 3, -17 },
  { 482, 13, 17, 15, 1, -17 },
  { 510, 10, 17, 15, 3, -17 },
  { 532, 3, 14, 15, 6, -14 },
  { 538, 5, 18, 15, 4, -14 },
  { 550, 12, 13, 15, 2, -14 },
  { 570, 13, 5, 15, 1, -10 },
  { 579, 12, 13, 15, 1, -14 },
  { 599, 10, 17, 15, 4, -17 },
  { 621, 11, 20, 15, 2, -17 },
  { 649, 13, 17, 15, 0, -17 },
  { 677, 12, 17, 15, 1, -17 },
  { 703, 12, 17, 15, 2, -17 },
  { 729, 12, 17, 15, 2, -17 },
  { 755, 13, 17, 15, 2, -17 },
  { 783, 13, 17, 15, 2, -17 },
  { 811, 12, 17, 15, 2, -17 },
  { 837, 13, 17, 15, 1, -17 },
  { 865, 14, 17, 15, 1, -17 },
  { 895, 11, 17, 15, 2, -17 },
  { 919, 13, 17, 15, 2, -17 },
  { 947, 9, 17, 15, 3, -17 },
  { 967, 14, 17, 15, 1, -17 },
  { 997, 13, 17, 15, 1, -17 },
  { 1025, 12, 17, 15, 2, -17 },
  { 1051, 12, 17, 15, 2, -17 },
  { 1077, 12, 21, 15, 2, -17 },
  { 1109, 12, 17, 15, 2, -17 },
  { 1135, 13, 17, 15, 1, -17 },
  { 1163, 13, 17, 15, 3, -17 },
  { 1191, 12, 17, 15, 2, -17 },
  { 1217, 12, 17, 15, 3, -17 },
  { 1243, 13, 17, 15, 2, -17 },
  { 1271, 15, 17, 15, 0, -17 },
  { 1303, 13, 17, 15, 3, -17 },
  { 1331, 15, 17, 15, 0, -17 },
  { 1363, 10, 22, 15, 5, -19 },
  { 1391, 6, 22, 15, 5, -19 },
  { 1408, 9, 22, 15, 1, -19 },
  { 1433, 12, 9, 15, 2, -17 },
  { 1447, 12, 1, 15, 0, 3 },
  { 1449, 3, 4, 15, 6, -19 },
  { 1451, 11, 13, 15, 2, -13 },
  { 1469, 11, 19, 15, 2, -19 },
  { 1496, 10, 13, 15, 2, -13 },
  { 1513, 12, 19, 15, 2, -19 },
  { 1542, 11, 13, 15, 2, -13 },
  { 1560, 15, 24, 15, 0, -19 },
  { 1605, 12, 18, 15, 1, -13 },
  { 1632, 10, 19, 15, 2, -19 },
  { 1656, 11, 19, 15, 2, -19 },
  { 1683, 10, 24, 15, 3, -19 },
  { 1713, 12, 19, 15, 2, -19 },
  { 1742, 9, 19, 15, 3, -19 },
  { 1764, 13, 13, 15, 1, -13 },
  { 1786, 10, 13, 15, 2, -13 },
  { 1803, 11, 13, 15, 2, -13 },
  { 1821, 12, 18, 15, 1, -13 },
  { 1848, 11, 18, 15, 2, -13 },
  { 1873, 12, 13, 15, 3, -13 },
  { 1893, 11, 13, 15, 2, -13 },
  { 1911, 12, 17, 15, 2, -17 },
  { 1937, 10, 13, 15, 3, -13 },
  { 1954, 11, 13, 15, 2, -13 },
  { 1972, 12, 13, 15, 2, -13 },
  { 1992, 14, 13, 15, 1, -13 },
  { 2015, 12, 18, 15, 1, -13 },
  { 2042, 13, 13, 15, 1, -13 },
  { 2064, 11, 22, 15, 3, -19 },
  { 2095, 4, 22, 15, 6, -19 },
  { 2106, 11, 22, 15, 1, -19 },
  { 2137, 13, 5, 15, 1, -10 },
};

const GFXfont IBMPlexMono_ThinItalic25pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic25pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _IBMPLEXMONO_THINITALIC25PT7B_H_
