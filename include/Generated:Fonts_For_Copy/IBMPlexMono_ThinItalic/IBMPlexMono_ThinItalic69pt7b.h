#ifndef _IBMPLEXMONO_THINITALIC69PT7B_H_
#define _IBMPLEXMONO_THINITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x18, 0x0C, 0x40, 0x21, 0x00,
  0x8C, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x88, 0x04, 0x20, 0x11, 0x80,
  0xC6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x00, 0x84, 0x02, 0x30, 0x18, 0xC0,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x04, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x20, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x01, 0x00, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x00, 0x08, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x40, 0x00, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x04, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x20,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x01, 0x00, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x80, 0x08, 0x00,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x18, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x20, 0x00, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x08,
  0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x02, 0x00, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x10,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x00, 0x04, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0x02, 0x1E, 0x00,
  0x01, 0x80, 0x60, 0x30, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x80, 0x04, 0x00, 0x20, 0x18, 0x00, 0x40, 0x03, 0x03, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x80, 0x00, 0x06, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x01, 0x80, 0x00, 0x03, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x01, 0x00, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0x07,
  0xA0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x27, 0x80, 0x00,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x00, 0x18, 0x00, 0x20, 0x00, 0x01, 0x00, 0x06, 0x08,
  0x00, 0x10, 0x00, 0x40, 0xC0, 0x01, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x00,
  0x80, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x30, 0x06, 0x00, 0x0E, 0x02,
  0x00, 0xC0, 0x00, 0x3C, 0x20, 0x70, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x30, 0x01, 0x80, 0x30, 0x00, 0x01,
  0x00, 0x08, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x80, 0x00, 0x60,
  0x01, 0x00, 0x02, 0x00, 0x01, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x00, 0x40, 0x03, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x30, 0x03, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x04, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x08, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x60, 0x10, 0x00, 0x01, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x20, 0x10, 0x00, 0x00, 0x20, 0x01, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x08, 0x06, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x30,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x80, 0x70, 0x70, 0x00, 0x00, 0x04, 0x03, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x18, 0x00, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x01, 0x00, 0x00,
  0x04, 0x02, 0x00, 0x06, 0x00, 0x00, 0x20, 0x18, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x40, 0x00, 0x20, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x60, 0x02, 0x00, 0x01, 0x80, 0x03, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x00, 0xC0, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x40, 0x00, 0x30, 0x00, 0x40, 0x02, 0x00, 0x00, 0x40, 0x03,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x18, 0x00, 0xC0, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x40, 0x00, 0x00, 0x3F, 0x01, 0x80, 0x00, 0x01, 0xC1, 0x06, 0x00, 0x00,
  0x07, 0x00, 0xB8, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x01, 0x40, 0x06, 0xC0, 0x00, 0x02, 0x60,
  0x04, 0xC0, 0x00, 0x02, 0x30, 0x0C, 0x40, 0x00, 0x04, 0x10, 0x18, 0x60,
  0x00, 0x04, 0x18, 0x10, 0x20, 0x00, 0x08, 0x0C, 0x30, 0x10, 0x00, 0x10,
  0x04, 0x20, 0x0C, 0x00, 0x60, 0x06, 0x40, 0x07, 0x01, 0xC0, 0x02, 0xC0,
  0x01, 0xFE, 0x00, 0x01, 0x80, 0x33, 0x33, 0x22, 0x66, 0x66, 0x44, 0xCC,
  0xCC, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0xF0, 0x00, 0xC0,
  0x03, 0xC3, 0xC0, 0x10, 0x07, 0xC0, 0x0F, 0x02, 0x07, 0xC0, 0x00, 0x3C,
  0x47, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x08,
  0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x60,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x60, 0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x81,
  0xC1, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x02,
  0x03, 0x01, 0x01, 0x80, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x06, 0x00, 0x00, 0x40, 0x06,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x01, 0x01, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x06, 0xC0, 0x03, 0x80, 0x03, 0x60, 0x01, 0xC0, 0x01, 0x20, 0x00, 0xE0,
  0x00, 0x90, 0x00, 0x70, 0x00, 0xC8, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x09, 0x80, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x01, 0x18, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x10, 0x04,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0xC0, 0x02,
  0x00, 0x01, 0x80, 0x02, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xE0,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x18, 0x02,
  0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x30,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x08, 0x02,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x01, 0x90, 0x00,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x02, 0x18,
  0x00, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x0C,
  0x08, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x01, 0x80, 0x20, 0x00,
  0x00, 0x60, 0x04, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x30, 0x00, 0x01, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x80, 0x60, 0x00,
  0x00, 0x10, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x07, 0xFC, 0x00,
  0x00, 0x86, 0x00, 0xE0, 0x00, 0x66, 0x00, 0x0C, 0x00, 0x1A, 0x00, 0x00,
  0x80, 0x05, 0x00, 0x00, 0x10, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x20, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x1F, 0xF0,
  0x01, 0x87, 0x00, 0xE0, 0x08, 0xE0, 0x00, 0xC0, 0x4C, 0x00, 0x03, 0x04,
  0x80, 0x00, 0x0C, 0x28, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x00, 0x94, 0x00,
  0x00, 0x04, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x00, 0x26, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x30, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x02, 0x20, 0x00,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x18, 0x40, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x08, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x00, 0x0C, 0x08, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0x20, 0x1C, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x00, 0x08, 0x60, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x40, 0x80, 0x00, 0x01, 0x84, 0x00, 0x00,
  0x02, 0x30, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x06, 0x40, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x05, 0x88, 0x00, 0x00,
  0x34, 0x10, 0x00, 0x01, 0xB0, 0x60, 0x00, 0x0C, 0x80, 0x60, 0x00, 0xE6,
  0x00, 0xE0, 0x1E, 0x18, 0x00, 0x7F, 0x80, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x81, 0xF0, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x04, 0x30, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x02, 0x60, 0x00, 0x00, 0x24, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x80, 0x08, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x43, 0x00, 0x00, 0x01,
  0x84, 0x00, 0x1F, 0x83, 0x08, 0x00, 0xC0, 0xC6, 0x30, 0x02, 0x00, 0x48,
  0x40, 0x08, 0x00, 0x50, 0x80, 0x20, 0x00, 0xA3, 0x00, 0xC0, 0x00, 0xC6,
  0x01, 0x00, 0x01, 0x88, 0x06, 0x00, 0x03, 0x10, 0x08, 0x00, 0x04, 0x20,
  0x10, 0x00, 0x08, 0xC0, 0x20, 0x00, 0x11, 0x80, 0xC0, 0x00, 0x63, 0x01,
  0x80, 0x00, 0xC4, 0x02, 0x00, 0x01, 0x88, 0x04, 0x00, 0x02, 0x10, 0x08,
  0x00, 0x04, 0x60, 0x10, 0x00, 0x08, 0xC0, 0x20, 0x00, 0x31, 0x80, 0x40,
  0x00, 0x63, 0x00, 0x80, 0x00, 0xC4, 0x01, 0x00, 0x03, 0x08, 0x02, 0x00,
  0x06, 0x10, 0x04, 0x00, 0x14, 0x20, 0x0C, 0x00, 0x38, 0x40, 0x08, 0x00,
  0xB0, 0x80, 0x18, 0x06, 0x61, 0x00, 0x1C, 0x18, 0x82, 0x00, 0x0F, 0xC0,
  0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x18, 0x04, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x06, 0x00, 0x08, 0x00, 0x01, 0x80, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x06, 0x00, 0x18, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00,
  0x10, 0x30, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x02, 0x60, 0x00,
  0x00, 0x00, 0x98, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x1C, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00,
  0x0C, 0x08, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x07, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x00, 0xE0, 0x04, 0x00,
  0x00, 0x18, 0x02, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x18, 0x20,
  0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x00, 0x86, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x08,
  0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x06,
  0x08, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x1C, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x06, 0x00, 0x80, 0x00,
  0x02, 0x01, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00,
  0x01, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x20, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x20,
  0x10, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00,
  0x01, 0x02, 0x00, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0x10, 0x60, 0x00,
  0x00, 0x04, 0x18, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x08,
  0x20, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x00, 0x81, 0x00, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x80, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x10, 0x08,
  0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x10, 0x00, 0x01, 0x80, 0x04, 0x00, 0x03, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x00, 0x40, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x02, 0x00,
  0x00, 0x06, 0x02, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x0F, 0xFF, 0xC6, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00,
  0x04, 0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x00, 0x1C, 0x04, 0x00, 0x00, 0x14, 0x03, 0x00, 0x00, 0x1A, 0x00, 0xC0,
  0x00, 0x19, 0x00, 0x20, 0x00, 0x19, 0x80, 0x0C, 0x00, 0x18, 0xC0, 0x03,
  0x80, 0x70, 0x60, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x08, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x20, 0x18, 0x00,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x30, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x20, 0x00,
  0x00, 0x0C, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x08, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x40, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x00, 0x10, 0x0C, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x18, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x00, 0x60, 0x10,
  0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x04,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x00, 0xC0, 0x20, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x00, 0x80, 0x60,
  0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x18,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00,
  0x01, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x40, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x01, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x70, 0x00, 0x00, 0x01, 0x03, 0x30, 0x00, 0x00, 0x02, 0x0C,
  0x20, 0x00, 0x00, 0x0C, 0x30, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x40, 0x00,
  0x00, 0x33, 0x00, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x80, 0x00, 0x00, 0xB0,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x01, 0x00, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x00, 0x40, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0x01, 0x80, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x02, 0x80, 0x68, 0x00, 0x00,
  0x1A, 0x01, 0xA0, 0x00, 0x00, 0xD8, 0x04, 0xC0, 0x00, 0x02, 0x60, 0x13,
  0x00, 0x00, 0x19, 0x80, 0x44, 0x00, 0x00, 0x44, 0x03, 0x10, 0x00, 0x03,
  0x10, 0x0C, 0x60, 0x00, 0x18, 0x40, 0x30, 0x80, 0x00, 0x43, 0x00, 0x82,
  0x00, 0x03, 0x0C, 0x02, 0x0C, 0x00, 0x08, 0x30, 0x08, 0x30, 0x00, 0x40,
  0x80, 0x60, 0x40, 0x03, 0x02, 0x01, 0x81, 0x00, 0x08, 0x08, 0x06, 0x06,
  0x00, 0x60, 0x60, 0x10, 0x08, 0x03, 0x01, 0x80, 0x40, 0x20, 0x08, 0x06,
  0x01, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x01, 0x01, 0x00, 0x40, 0x30, 0x04,
  0x0C, 0x01, 0x00, 0xC0, 0x10, 0x60, 0x0C, 0x02, 0x00, 0x61, 0x00, 0x30,
  0x08, 0x00, 0x8C, 0x00, 0xC0, 0x20, 0x02, 0x60, 0x02, 0x01, 0x80, 0x0D,
  0x00, 0x08, 0x06, 0x00, 0x1C, 0x00, 0x20, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x40, 0x01, 0x80, 0x06, 0x01, 0x00, 0x04, 0x00, 0x18, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x30, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x00, 0x20, 0x18,
  0x00, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x04, 0x00, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x0E,
  0x00, 0x00, 0x02, 0x01, 0xE0, 0x00, 0x00, 0x20, 0x1A, 0x00, 0x00, 0x02,
  0x01, 0xB0, 0x00, 0x00, 0x60, 0x13, 0x00, 0x00, 0x06, 0x01, 0x10, 0x00,
  0x00, 0x60, 0x11, 0x80, 0x00, 0x04, 0x03, 0x08, 0x00, 0x00, 0x40, 0x30,
  0x80, 0x00, 0x04, 0x03, 0x0C, 0x00, 0x00, 0xC0, 0x20, 0x40, 0x00, 0x0C,
  0x02, 0x04, 0x00, 0x00, 0xC0, 0x20, 0x60, 0x00, 0x08, 0x06, 0x02, 0x00,
  0x00, 0x80, 0x60, 0x30, 0x00, 0x08, 0x06, 0x03, 0x00, 0x01, 0x80, 0x40,
  0x10, 0x00, 0x18, 0x04, 0x01, 0x80, 0x01, 0x80, 0x40, 0x18, 0x00, 0x10,
  0x0C, 0x00, 0x80, 0x01, 0x00, 0xC0, 0x0C, 0x00, 0x10, 0x0C, 0x00, 0xC0,
  0x03, 0x00, 0x80, 0x04, 0x00, 0x30, 0x08, 0x00, 0x60, 0x03, 0x00, 0x80,
  0x06, 0x00, 0x20, 0x18, 0x00, 0x20, 0x02, 0x01, 0x80, 0x03, 0x00, 0x20,
  0x18, 0x00, 0x10, 0x06, 0x01, 0x00, 0x01, 0x00, 0x60, 0x10, 0x00, 0x18,
  0x06, 0x01, 0x00, 0x00, 0x80, 0x40, 0x30, 0x00, 0x08, 0x04, 0x03, 0x00,
  0x00, 0xC0, 0x40, 0x30, 0x00, 0x04, 0x0C, 0x02, 0x00, 0x00, 0x60, 0xC0,
  0x20, 0x00, 0x06, 0x0C, 0x02, 0x00, 0x00, 0x20, 0x80, 0x60, 0x00, 0x03,
  0x08, 0x06, 0x00, 0x00, 0x30, 0x80, 0x60, 0x00, 0x01, 0x18, 0x04, 0x00,
  0x00, 0x19, 0x80, 0x40, 0x00, 0x01, 0x98, 0x04, 0x00, 0x00, 0x09, 0x00,
  0xC0, 0x00, 0x00, 0xD0, 0x0C, 0x00, 0x00, 0x05, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x08, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x08, 0x02,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x01, 0x00, 0x00, 0x00, 0x81,
  0x80, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03,
  0x10, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00,
  0x64, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x09, 0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x41, 0x00, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x10, 0x18,
  0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00,
  0x20, 0x20, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x00, 0x10, 0x30, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x20, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x01, 0x01, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x01, 0x20, 0x00,
  0x00, 0x00, 0x90, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x09, 0x80,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x00, 0x41, 0x00, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x20,
  0x40, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x10,
  0x04, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x10, 0x60, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00,
  0x0C, 0x01, 0x00, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x01, 0x01, 0x80, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x04, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x80, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x10, 0x08,
  0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x03, 0x00, 0x20, 0x00, 0x01, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x04, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x01, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x02, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x10, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x70, 0x03, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x02,
  0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x04, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0xE0, 0x07,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x18,
  0x10, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x20, 0x60, 0x00,
  0x00, 0x08, 0x18, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x04, 0x0C,
  0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00,
  0x06, 0x04, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x00, 0x10, 0x30, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x08, 0x08,
  0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x13,
  0x00, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x08, 0x18, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x20, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x04, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x10, 0x00, 0x00, 0x80, 0x04,
  0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x10, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x08, 0x00, 0x08, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x60, 0x10, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00, 0x00, 0x11, 0x80,
  0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x00,
  0x31, 0x00, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x00, 0x21, 0x00, 0x00,
  0x00, 0x02, 0x10, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x04, 0x30,
  0x00, 0x00, 0x00, 0x43, 0x00, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x00, 0x18, 0x20, 0x00, 0x00, 0x01, 0x82, 0x00, 0x0C, 0x00, 0x10, 0x20,
  0x01, 0xC0, 0x01, 0x02, 0x00, 0x16, 0x00, 0x30, 0x20, 0x03, 0x60, 0x03,
  0x02, 0x00, 0x36, 0x00, 0x20, 0x20, 0x02, 0x20, 0x02, 0x02, 0x00, 0x62,
  0x00, 0x60, 0x60, 0x04, 0x20, 0x06, 0x06, 0x00, 0xC2, 0x00, 0x40, 0x60,
  0x08, 0x20, 0x04, 0x06, 0x01, 0x83, 0x00, 0xC0, 0x60, 0x10, 0x30, 0x08,
  0x06, 0x03, 0x03, 0x00, 0x80, 0x40, 0x20, 0x10, 0x18, 0x04, 0x06, 0x01,
  0x01, 0x80, 0x40, 0x40, 0x10, 0x10, 0x04, 0x0C, 0x01, 0x01, 0x00, 0x40,
  0xC0, 0x18, 0x30, 0x04, 0x08, 0x01, 0x83, 0x00, 0x41, 0x80, 0x18, 0x20,
  0x04, 0x10, 0x01, 0x82, 0x00, 0x43, 0x00, 0x08, 0x60, 0x0C, 0x20, 0x00,
  0x86, 0x00, 0xC6, 0x00, 0x08, 0x40, 0x0C, 0x40, 0x00, 0x8C, 0x00, 0xCC,
  0x00, 0x0C, 0xC0, 0x0C, 0x80, 0x00, 0xC8, 0x00, 0xD8, 0x00, 0x0C, 0x80,
  0x09, 0x00, 0x00, 0x58, 0x00, 0xB0, 0x00, 0x05, 0x80, 0x0B, 0x00, 0x00,
  0x50, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x11, 0x00,
  0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x1D, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00,
  0x02, 0x08, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x40,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x40, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x00, 0x84, 0x00, 0x00, 0x01, 0x06, 0x00,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x00,
  0x00, 0x08, 0x01, 0x80, 0x00, 0x18, 0x00, 0x80, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x60,
  0x01, 0x80, 0x00, 0x20, 0x03, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x10,
  0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x0C,
  0x10, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xC1, 0x81, 0x83, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x08, 0x00,
  0x07, 0xF8, 0x06, 0x00, 0x70, 0x0C, 0x0C, 0x01, 0x80, 0x06, 0x10, 0x0C,
  0x00, 0x06, 0x20, 0x30, 0x00, 0x02, 0x40, 0xC0, 0x00, 0x04, 0x81, 0x00,
  0x00, 0x07, 0x04, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x18, 0x20, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00,
  0x08, 0x40, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x04,
  0x20, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x06, 0x04,
  0x00, 0x00, 0x1C, 0x08, 0x00, 0x00, 0x28, 0x18, 0x00, 0x00, 0xB0, 0x10,
  0x00, 0x03, 0x60, 0x30, 0x00, 0x0C, 0xC0, 0x30, 0x00, 0x31, 0x00, 0x30,
  0x00, 0xC2, 0x00, 0x18, 0x06, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x7F, 0x00, 0x06,
  0x0E, 0x03, 0x80, 0x18, 0x60, 0x03, 0x00, 0x42, 0x00, 0x06, 0x01, 0x10,
  0x00, 0x0C, 0x04, 0x80, 0x00, 0x18, 0x34, 0x00, 0x00, 0x20, 0xE0, 0x00,
  0x00, 0x83, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x00, 0x46, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x04,
  0x60, 0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00, 0x01, 0x10,
  0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x03, 0x20, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x22, 0x00, 0x00,
  0x00, 0x98, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x43,
  0x80, 0x00, 0x03, 0x0D, 0x00, 0x00, 0x18, 0x36, 0x00, 0x00, 0xC0, 0x8C,
  0x00, 0x06, 0x02, 0x18, 0x00, 0x30, 0x08, 0x1C, 0x07, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0x80, 0x60, 0x00, 0xE0, 0x01,
  0x80, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x08, 0x60,
  0x00, 0x01, 0x82, 0x00, 0x00, 0x30, 0x10, 0x00, 0x06, 0x01, 0x80, 0x00,
  0xC0, 0x0C, 0x00, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x0F, 0xF0, 0x0C, 0x00, 0x38, 0x06, 0x06, 0x00, 0x30,
  0x00, 0xC2, 0x00, 0x60, 0x00, 0x31, 0x00, 0x60, 0x00, 0x04, 0x80, 0x60,
  0x00, 0x02, 0x40, 0x20, 0x00, 0x00, 0xE0, 0x20, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x04, 0x08,
  0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x00, 0x81, 0x00, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C,
  0x10, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x01,
  0x02, 0x00, 0x00, 0x00, 0x81, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00,
  0x28, 0x04, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x16, 0x00, 0x80, 0x00,
  0x13, 0x00, 0x60, 0x00, 0x19, 0x00, 0x18, 0x00, 0x18, 0x80, 0x06, 0x00,
  0x18, 0x40, 0x00, 0xC0, 0x30, 0x60, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x01, 0x00,
  0x00, 0xC0, 0x10, 0x00, 0x03, 0x01, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x26, 0x00, 0x00, 0x03, 0x20, 0x00,
  0x00, 0x31, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E,
  0x06, 0x00, 0x07, 0x80, 0x20, 0x0F, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x44, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x20, 0x10, 0x00, 0x02, 0x00, 0xC0,
  0x00, 0x20, 0x03, 0x80, 0x06, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x08, 0x00,
  0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x00, 0x04, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x00,
  0x06, 0x20, 0x00, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x01, 0x80, 0x07, 0x00, 0xC0, 0xC0, 0x06, 0x00, 0x18, 0x40, 0x0C, 0x00,
  0x06, 0x20, 0x0C, 0x00, 0x00, 0x90, 0x0C, 0x00, 0x00, 0x48, 0x04, 0x00,
  0x00, 0x1C, 0x04, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x06, 0x02, 0x00,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x81, 0x00, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x10, 0x20,
  0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x04,
  0x06, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x07, 0x00, 0x80, 0x00, 0x02,
  0x80, 0x60, 0x00, 0x02, 0xC0, 0x10, 0x00, 0x03, 0x60, 0x0C, 0x00, 0x03,
  0x20, 0x03, 0x00, 0x03, 0x10, 0x00, 0xC0, 0x03, 0x08, 0x00, 0x18, 0x06,
  0x04, 0x00, 0x03, 0xFC, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x18, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x1F, 0xE0,
  0x02, 0x06, 0x03, 0x80, 0x21, 0x80, 0x0C, 0x06, 0x20, 0x00, 0x60, 0x64,
  0x00, 0x02, 0x06, 0x80, 0x00, 0x30, 0x68, 0x00, 0x01, 0x05, 0x00, 0x00,
  0x10, 0x60, 0x00, 0x01, 0x0E, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x08, 0x00, 0x00, 0x10, 0x80, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x21, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x42, 0x00, 0x00, 0x04,
  0x20, 0x00, 0x00, 0x42, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x08, 0x60, 0x00, 0x00, 0x84, 0x00, 0x00, 0x08, 0x40, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x40, 0x06, 0x00, 0x06, 0x00, 0x40, 0x00, 0x30,
  0x0C, 0x00, 0x01, 0x80, 0x80, 0x00, 0x08, 0x18, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x06, 0x10, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x08, 0x00, 0x04,
  0x00, 0xC0, 0x00, 0x40, 0x06, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x80, 0x0C, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x20, 0x08, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x07, 0xF8, 0x00, 0x03, 0x03, 0x00,
  0xE0, 0x00, 0x61, 0x80, 0x06, 0x00, 0x08, 0xC0, 0x00, 0x60, 0x01, 0x30,
  0x00, 0x04, 0x00, 0x24, 0x00, 0x00, 0xC0, 0x0D, 0x00, 0x00, 0x18, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x0C, 0x0F, 0x00, 0x00,
  0x01, 0x01, 0x80, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x04, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x66, 0x00,
  0x60, 0x00, 0x10, 0x80, 0x06, 0x00, 0x04, 0x10, 0x00, 0x40, 0x01, 0x02,
  0x00, 0x0C, 0x00, 0x40, 0xC0, 0x00, 0x80, 0x10, 0x18, 0x00, 0x18, 0x0C,
  0x03, 0x00, 0x01, 0x03, 0x00, 0x40, 0x00, 0x30, 0xC0, 0x08, 0x00, 0x02,
  0x30, 0x01, 0x00, 0x00, 0x2C, 0x00, 0x40, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x02, 0x02, 0x00, 0x03, 0x03, 0x00, 0x02, 0x01, 0x80, 0x06, 0x00, 0xC0,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0x20, 0x08, 0x00, 0x30, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x30, 0x00, 0x02, 0x60, 0x00, 0x01,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x07, 0xC0, 0x1F, 0x80, 0x21,
  0x06, 0x06, 0x0C, 0x06, 0x60, 0x10, 0x80, 0x60, 0x68, 0x01, 0x90, 0x02,
  0x06, 0x80, 0x0A, 0x00, 0x30, 0x70, 0x00, 0xA0, 0x01, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x60, 0x00, 0xC0, 0x01, 0x0C, 0x00, 0x18, 0x00, 0x30, 0xC0,
  0x01, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x80, 0x01, 0x00, 0x02,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x80, 0x01, 0x00, 0x02, 0x18, 0x00, 0x30,
  0x00, 0x61, 0x80, 0x03, 0x00, 0x06, 0x18, 0x00, 0x30, 0x00, 0x61, 0x00,
  0x02, 0x00, 0x04, 0x10, 0x00, 0x20, 0x00, 0x41, 0x00, 0x02, 0x00, 0x04,
  0x30, 0x00, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x60,
  0x00, 0xC2, 0x00, 0x04, 0x00, 0x08, 0x20, 0x00, 0x40, 0x00, 0x82, 0x00,
  0x04, 0x00, 0x08, 0x60, 0x00, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x00, 0x18,
  0x60, 0x00, 0xC0, 0x01, 0x84, 0x00, 0x08, 0x00, 0x10, 0x40, 0x00, 0x80,
  0x01, 0x04, 0x00, 0x08, 0x00, 0x10, 0xC0, 0x01, 0x80, 0x03, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0xC0, 0x01, 0x80, 0x03, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x02, 0x01, 0xFE, 0x00, 0x20, 0x60, 0x38, 0x02, 0x18, 0x00, 0xC0, 0x62,
  0x00, 0x06, 0x06, 0x40, 0x00, 0x20, 0x68, 0x00, 0x03, 0x06, 0x80, 0x00,
  0x10, 0x50, 0x00, 0x01, 0x06, 0x00, 0x00, 0x10, 0xE0, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x10, 0x80, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x02, 0x10, 0x00, 0x00, 0x21, 0x00, 0x00, 0x02, 0x10, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x04,
  0x20, 0x00, 0x00, 0x42, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x86, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00,
  0x84, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0x10, 0x02, 0x00, 0x00,
  0x20, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x02, 0x00, 0x00, 0x06,
  0x10, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x22, 0x00, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x04,
  0x80, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x02, 0x20,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x41, 0x00, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x08, 0x08, 0x00, 0x00, 0x40, 0x30, 0x00, 0x02, 0x00, 0x60, 0x00,
  0x10, 0x00, 0xC0, 0x01, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xC0, 0x3F, 0x80, 0x00, 0x60, 0xE0, 0x38, 0x00, 0x30, 0xC0,
  0x06, 0x00, 0x10, 0x80, 0x01, 0x80, 0x08, 0x80, 0x00, 0x60, 0x04, 0x80,
  0x00, 0x18, 0x06, 0x80, 0x00, 0x04, 0x03, 0x80, 0x00, 0x02, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x20, 0x20,
  0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x04, 0x0C,
  0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x04,
  0x08, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x40, 0x70, 0x00, 0x00, 0x60, 0x34, 0x00, 0x00,
  0x60, 0x1B, 0x00, 0x00, 0x60, 0x08, 0xC0, 0x00, 0x60, 0x04, 0x30, 0x00,
  0x60, 0x02, 0x07, 0x01, 0xC0, 0x03, 0x00, 0xFF, 0x80, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x06, 0x00, 0x70, 0x0C, 0x0C,
  0x01, 0x80, 0x06, 0x10, 0x0C, 0x00, 0x06, 0x20, 0x30, 0x00, 0x02, 0x40,
  0xC0, 0x00, 0x04, 0x81, 0x00, 0x00, 0x07, 0x04, 0x00, 0x00, 0x0E, 0x18,
  0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x21, 0x00,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x04, 0x20, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x11, 0x80, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00,
  0x02, 0x10, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x00, 0x61, 0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x01,
  0x06, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x1C, 0x08, 0x00, 0x00, 0x28,
  0x18, 0x00, 0x00, 0xB0, 0x10, 0x00, 0x03, 0x60, 0x30, 0x00, 0x0C, 0x80,
  0x30, 0x00, 0x31, 0x00, 0x30, 0x00, 0xC2, 0x00, 0x18, 0x06, 0x04, 0x00,
  0x0F, 0xF0, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x06,
  0x1C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00,
  0x90, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x02, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x01, 0x08, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00, 0x21, 0x00, 0x00, 0x02,
  0x10, 0x00, 0x00, 0x61, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x04, 0x30, 0x00, 0x00, 0x42, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x08, 0x60,
  0x00, 0x00, 0x84, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x08, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0xA0, 0xC0, 0x00, 0x0A, 0x04, 0x00, 0x01, 0x20,
  0x60, 0x00, 0x26, 0x02, 0x00, 0x04, 0x60, 0x10, 0x00, 0x86, 0x00, 0xC0,
  0x70, 0x40, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x08, 0x01, 0x80,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x20, 0x0C, 0x00,
  0x00, 0x40, 0x10, 0x00, 0x00, 0x80, 0x20, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x10, 0x0C, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00,
  0x80, 0x40, 0x00, 0x03, 0x00, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x08,
  0x06, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x80,
  0x20, 0x00, 0x03, 0x00, 0x40, 0x00, 0x04, 0x00, 0x80, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x20, 0x00, 0x18, 0x00, 0x40, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x10, 0x06, 0x00, 0x00, 0x20, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x18, 0x03, 0x03, 0x00, 0x06, 0x00, 0x40, 0xC0,
  0x01, 0x00, 0x18, 0x30, 0x00, 0x40, 0x02, 0x08, 0x00, 0x10, 0x00, 0x82,
  0x00, 0x0C, 0x00, 0x20, 0x80, 0x03, 0x00, 0x0C, 0x60, 0x00, 0xC0, 0x03,
  0x18, 0x00, 0x20, 0x00, 0xC6, 0x00, 0x08, 0x00, 0x31, 0x00, 0x02, 0x00,
  0x04, 0x40, 0x01, 0x80, 0x01, 0x10, 0x00, 0x60, 0x00, 0x4C, 0x00, 0x18,
  0x00, 0x13, 0x00, 0x04, 0x00, 0x04, 0xC0, 0x01, 0x00, 0x01, 0x20, 0x00,
  0x40, 0x00, 0xC8, 0x00, 0x30, 0x00, 0x32, 0x00, 0x0C, 0x00, 0x0C, 0x80,
  0x03, 0x00, 0x03, 0x60, 0x00, 0x80, 0x00, 0xD8, 0x00, 0x20, 0x00, 0x26,
  0x00, 0x08, 0x00, 0x09, 0x00, 0x06, 0x00, 0x06, 0x40, 0x01, 0x80, 0x01,
  0x90, 0x00, 0x60, 0x00, 0x6C, 0x00, 0x10, 0x00, 0x13, 0x00, 0x04, 0x00,
  0x0C, 0xC0, 0x03, 0x00, 0x02, 0x30, 0x00, 0xC0, 0x01, 0x8C, 0x00, 0x50,
  0x00, 0x43, 0x00, 0x14, 0x00, 0x30, 0xC0, 0x09, 0x80, 0x08, 0x10, 0x06,
  0x20, 0x04, 0x06, 0x03, 0x0C, 0x02, 0x00, 0xC1, 0x81, 0x83, 0x00, 0x1F,
  0x80, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0xE6, 0x00,
  0x60, 0xC0, 0x0E, 0x08, 0x02, 0x01, 0x80, 0xE0, 0x30, 0x10, 0x03, 0x1C,
  0x00, 0x40, 0x80, 0x0D, 0xC0, 0x01, 0x84, 0x00, 0x14, 0x00, 0x02, 0x10,
  0x00, 0x40, 0x00, 0x08, 0x80, 0x01, 0x00, 0x00, 0x22, 0x00, 0x04, 0x00,
  0x00, 0xD0, 0x00, 0x10, 0x00, 0x03, 0x40, 0x00, 0x40, 0x00, 0x0D, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x02, 0x80, 0x00, 0x08, 0x00, 0x0A, 0x00, 0x00,
  0x20, 0x00, 0x6C, 0x00, 0x00, 0x80, 0x01, 0x30, 0x00, 0x02, 0x00, 0x04,
  0x40, 0x00, 0x08, 0x00, 0x21, 0x00, 0x03, 0x20, 0x01, 0x86, 0x00, 0x38,
  0xC0, 0x04, 0x08, 0x01, 0x83, 0x00, 0x20, 0x30, 0x18, 0x06, 0x01, 0x00,
  0x41, 0x80, 0x0C, 0x18, 0x01, 0x98, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x80, 0x00, 0x01, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x02, 0x01, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x06,
  0x01, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x04,
  0x03, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x0C,
  0x02, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x08,
  0x06, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x18,
  0x04, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x10,
  0x0C, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30,
  0x08, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0xB0,
  0x0C, 0x00, 0x00, 0xA0, 0x04, 0x00, 0x01, 0x20, 0x06, 0x00, 0x02, 0x20,
  0x02, 0x00, 0x04, 0x60, 0x01, 0x00, 0x08, 0x60, 0x00, 0xC0, 0x70, 0x60,
  0x00, 0x3F, 0x80, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x80, 0xE0, 0x3E, 0x00, 0xC0, 0xC0, 0x03, 0xE0,
  0x60, 0xC0, 0x00, 0x3E, 0x30, 0x40, 0x00, 0x03, 0xD8, 0x60, 0x00, 0x00,
  0x78, 0x20, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00,
  0x18, 0x04, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x61, 0xF0, 0x00, 0x00, 0x10,
  0xC7, 0xC0, 0x00, 0x08, 0x60, 0x1F, 0x00, 0x04, 0x20, 0x00, 0x7C, 0x02,
  0x10, 0x00, 0x01, 0xF1, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x40, 0x1E, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x10,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x40, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x60, 0x61, 0x80, 0x00, 0x08, 0x10, 0x08, 0x00, 0x01, 0x04, 0x00, 0x80,
  0x00, 0x61, 0x00, 0x18, 0x00, 0x08, 0x60, 0x01, 0x80, 0x03, 0x08, 0x00,
  0x10, 0x00, 0x43, 0x00, 0x01, 0x00, 0x18, 0x40, 0x00, 0x30, 0x06, 0x18,
  0x00, 0x03, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x40, 0x00, 0x01, 0xF0,
  0x00,
};

const GFXglyph IBMPlexMono_ThinItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 11, 48, 41, 16, -48 },
  { 67, 14, 17, 41, 18, -51 },
  { 97, 41, 48, 41, 1, -48 },
  { 343, 36, 64, 41, 3, -56 },
  { 631, 46, 50, 41, -1, -49 },
  { 919, 40, 50, 41, 1, -49 },
  { 1169, 4, 17, 41, 23, -51 },
  { 1178, 22, 62, 41, 16, -52 },
  { 1349, 21, 62, 41, 5, -52 },
  { 1512, 35, 34, 41, 4, -38 },
  { 1661, 33, 33, 41, 5, -38 },
  { 1798, 9, 17, 41, 11, -5 },
  { 1818, 18, 1, 41, 12, -22 },
  { 1821, 4, 4, 41, 16, -4 },
  { 1823, 36, 62, 41, 3, -52 },
  { 2102, 33, 50, 41, 5, -49 },
  { 2309, 32, 48, 41, 3, -48 },
  { 2501, 34, 49, 41, 3, -49 },
  { 2710, 33, 50, 41, 3, -49 },
  { 2917, 35, 48, 41, 2, -48 },
  { 3127, 34, 49, 41, 4, -48 },
  { 3336, 29, 49, 41, 6, -48 },
  { 3514, 32, 48, 41, 8, -48 },
  { 3706, 34, 50, 41, 4, -49 },
  { 3919, 30, 49, 41, 7, -49 },
  { 4103, 10, 36, 41, 16, -36 },
  { 4148, 15, 48, 41, 11, -36 },
  { 4238, 33, 37, 41, 6, -40 },
  { 4391, 35, 14, 41, 4, -28 },
  { 4453, 33, 37, 41, 3, -40 },
  { 4606, 28, 49, 41, 10, -49 },
  { 4778, 31, 56, 41, 6, -49 },
  { 4995, 34, 48, 41, 1, -48 },
  { 5199, 33, 48, 41, 4, -48 },
  { 5397, 32, 50, 41, 6, -49 },
  { 5597, 34, 48, 41, 4, -48 },
  { 5801, 37, 48, 41, 4, -48 },
  { 6023, 37, 48, 41, 4, -48 },
  { 6245, 33, 50, 41, 6, -49 },
  { 6452, 36, 48, 41, 4, -48 },
  { 6668, 37, 48, 41, 3, -48 },
  { 6890, 32, 49, 41, 5, -48 },
  { 7086, 39, 48, 41, 4, -48 },
  { 7320, 27, 48, 41, 7, -48 },
  { 7482, 38, 48, 41, 3, -48 },
  { 7710, 36, 48, 41, 4, -48 },
  { 7926, 33, 50, 41, 5, -49 },
  { 8133, 35, 48, 41, 4, -48 },
  { 8343, 33, 61, 41, 5, -49 },
  { 8595, 35, 48, 41, 4, -48 },
  { 8805, 36, 50, 41, 3, -49 },
  { 9030, 36, 48, 41, 8, -48 },
  { 9246, 34, 49, 41, 6, -48 },
  { 9455, 34, 48, 41, 9, -48 },
  { 9659, 36, 48, 41, 6, -48 },
  { 9875, 42, 48, 41, 1, -48 },
  { 10127, 38, 48, 41, 7, -48 },
  { 10355, 42, 48, 41, 0, -48 },
  { 10607, 26, 62, 41, 14, -52 },
  { 10809, 15, 62, 41, 14, -52 },
  { 10926, 27, 62, 41, 2, -52 },
  { 11136, 32, 26, 41, 6, -48 },
  { 11240, 33, 1, 41, 0, 9 },
  { 11245, 7, 11, 41, 17, -52 },
  { 11255, 31, 37, 41, 5, -36 },
  { 11399, 30, 52, 41, 6, -51 },
  { 11594, 28, 37, 41, 6, -36 },
  { 11724, 33, 52, 41, 5, -51 },
  { 11939, 29, 37, 41, 6, -36 },
  { 12074, 43, 66, 41, -1, -51 },
  { 12429, 33, 51, 41, 3, -36 },
  { 12640, 28, 51, 41, 6, -51 },
  { 12819, 29, 53, 41, 6, -52 },
  { 13012, 28, 67, 41, 8, -52 },
  { 13247, 35, 52, 41, 5, -51 },
  { 13475, 25, 52, 41, 9, -51 },
  { 13638, 36, 36, 41, 3, -36 },
  { 13800, 28, 36, 41, 6, -36 },
  { 13926, 30, 37, 41, 6, -36 },
  { 14065, 33, 50, 41, 3, -36 },
  { 14272, 31, 50, 41, 5, -36 },
  { 14466, 33, 36, 41, 8, -36 },
  { 14615, 32, 37, 41, 4, -36 },
  { 14763, 34, 49, 41, 5, -48 },
  { 14972, 28, 37, 41, 7, -36 },
  { 15102, 31, 36, 41, 6, -36 },
  { 15242, 34, 37, 41, 5, -36 },
  { 15400, 38, 37, 41, 2, -36 },
  { 15576, 32, 51, 41, 3, -36 },
  { 15780, 33, 37, 41, 4, -36 },
  { 15933, 31, 62, 41, 8, -52 },
  { 16174, 12, 62, 41, 15, -52 },
  { 16267, 31, 62, 41, 3, -52 },
  { 16508, 35, 12, 41, 4, -27 },
};

const GFXfont IBMPlexMono_ThinItalic69pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic69pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic69pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _IBMPLEXMONO_THINITALIC69PT7B_H_
