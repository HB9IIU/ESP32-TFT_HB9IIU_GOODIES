#ifndef _IBMPLEXMONO_THINITALIC40PT7B_H_
#define _IBMPLEXMONO_THINITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41,
  0x04, 0x10, 0x82, 0x08, 0x20, 0x00, 0x00, 0x00, 0x0E, 0x38, 0x21, 0x21,
  0x21, 0x21, 0x41, 0x42, 0x42, 0x42, 0x42, 0xC2, 0x00, 0x08, 0x10, 0x00,
  0x10, 0x20, 0x00, 0x40, 0x80, 0x00, 0x81, 0x00, 0x01, 0x02, 0x00, 0x04,
  0x08, 0x00, 0x08, 0x10, 0x00, 0x10, 0x20, 0x00, 0x40, 0x80, 0x3F, 0x81,
  0xFC, 0x01, 0x02, 0x00, 0x04, 0x08, 0x00, 0x08, 0x10, 0x00, 0x10, 0x20,
  0x00, 0x40, 0x80, 0x00, 0x81, 0x00, 0x01, 0x02, 0x00, 0x04, 0x08, 0x03,
  0xF8, 0x1F, 0xE0, 0x10, 0x20, 0x00, 0x40, 0xC0, 0x00, 0x81, 0x00, 0x01,
  0x02, 0x00, 0x04, 0x08, 0x00, 0x08, 0x10, 0x00, 0x10, 0x20, 0x00, 0x40,
  0x80, 0x00, 0x81, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x7F, 0x80, 0x06, 0x11, 0x80, 0x20, 0x41,
  0x01, 0x01, 0x02, 0x08, 0x08, 0x0C, 0x20, 0x20, 0x00, 0x80, 0x80, 0x02,
  0x02, 0x00, 0x08, 0x08, 0x00, 0x20, 0x20, 0x00, 0x41, 0x00, 0x01, 0x84,
  0x00, 0x03, 0x90, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x70, 0x00, 0x04, 0x20,
  0x00, 0x20, 0x40, 0x00, 0x80, 0x80, 0x02, 0x02, 0x00, 0x08, 0x08, 0x00,
  0x20, 0x20, 0x00, 0x80, 0x80, 0x04, 0x02, 0x30, 0x10, 0x10, 0x60, 0x40,
  0x40, 0xC1, 0x02, 0x00, 0xC4, 0x30, 0x00, 0xFF, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xF8, 0x00, 0x60,
  0x20, 0x80, 0x08, 0x08, 0x08, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x04, 0x04, 0x02, 0x00, 0x81, 0x00, 0x40, 0x10, 0x40, 0x08,
  0x02, 0x10, 0x01, 0x00, 0x82, 0x00, 0x10, 0x10, 0x80, 0x03, 0x0C, 0x20,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x43, 0x0C, 0x00, 0x10, 0x80, 0x40, 0x02, 0x10, 0x08,
  0x00, 0x84, 0x01, 0x00, 0x20, 0x80, 0x20, 0x08, 0x10, 0x04, 0x02, 0x02,
  0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x01, 0x01, 0x01,
  0x00, 0x10, 0x60, 0x60, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x03, 0x06,
  0x00, 0x08, 0x06, 0x00, 0x10, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x04, 0x01, 0x00,
  0x08, 0x04, 0x00, 0x08, 0x08, 0x00, 0x10, 0x20, 0x01, 0xF1, 0x80, 0x0C,
  0x1C, 0x00, 0x20, 0x20, 0x00, 0x40, 0x20, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x40, 0x10, 0x00, 0x80, 0xA0, 0x02,
  0x81, 0xC0, 0x04, 0x86, 0x80, 0x11, 0x08, 0x80, 0x21, 0x20, 0x81, 0x83,
  0xC0, 0xFC, 0x03, 0x00, 0x29, 0x24, 0x94, 0x90, 0x00, 0x18, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x08, 0x04, 0x03, 0x70, 0x41, 0xC0,
  0xE4, 0xE0, 0x01, 0xF0, 0x00, 0x0C, 0x00, 0x01, 0x20, 0x00, 0x22, 0x00,
  0x04, 0x10, 0x00, 0x80, 0x80, 0x10, 0x08, 0x03, 0x00, 0x40, 0x20, 0x04,
  0x04, 0x00, 0x20, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x1F, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x21, 0x84, 0x30, 0x82, 0x10, 0x42, 0x00, 0xFF, 0xE0, 0xFC,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x30, 0x20, 0x18, 0x02, 0x06, 0x00, 0x20, 0x80, 0x04, 0x20,
  0x00, 0x48, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x28, 0x00, 0x05, 0x00,
  0x00, 0xA0, 0x00, 0x14, 0x00, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x00,
  0x02, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x48, 0x00,
  0x09, 0x00, 0x01, 0x20, 0x00, 0x42, 0x00, 0x10, 0x40, 0x06, 0x04, 0x01,
  0x80, 0x40, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x06,
  0x40, 0x03, 0x10, 0x01, 0x84, 0x01, 0x82, 0x00, 0xC0, 0x80, 0x60, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x03, 0xFF, 0xFF, 0x00, 0x7E, 0x00,
  0x30, 0x30, 0x08, 0x01, 0x02, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x44,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x70, 0x30, 0x18, 0x01, 0x06,
  0x00, 0x30, 0x80, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x07,
  0xF8, 0x00, 0x03, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x24, 0x00,
  0x0C, 0x80, 0x01, 0x0C, 0x00, 0x40, 0xE0, 0x30, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xA0, 0x00, 0x12, 0x00, 0x02, 0x20,
  0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x84, 0x00, 0x10, 0x40, 0x02, 0x04,
  0x00, 0x40, 0x40, 0x08, 0x08, 0x00, 0x80, 0x80, 0x10, 0x08, 0x02, 0x00,
  0x80, 0x40, 0x08, 0x08, 0x00, 0x81, 0x00, 0x10, 0x20, 0x01, 0x02, 0x00,
  0x10, 0x40, 0x01, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x03, 0xFF, 0xF0,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x01, 0x1F, 0xC0, 0x16, 0x03, 0x01, 0x80, 0x18, 0x10, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x88, 0x00, 0x08, 0x40, 0x01, 0x02,
  0x00, 0x20, 0x18, 0x0C, 0x00, 0x7F, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x3F, 0x02, 0x60, 0x61, 0xC0,
  0x09, 0x80, 0x02, 0xC0, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x04, 0x80, 0x02, 0x40, 0x02,
  0x10, 0x02, 0x06, 0x06, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xD0, 0x00, 0x18,
  0x00, 0x0A, 0x00, 0x02, 0x80, 0x01, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x18, 0x0C, 0x02, 0x00, 0x20, 0x40, 0x01, 0x08, 0x00, 0x10, 0x80,
  0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x02, 0x08,
  0x00, 0x20, 0x40, 0x04, 0x03, 0x01, 0x80, 0x0F, 0xE0, 0x07, 0x03, 0x01,
  0x80, 0x08, 0x20, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x24, 0x00, 0x02,
  0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00,
  0x82, 0x00, 0x30, 0x18, 0x0E, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x03, 0x03,
  0x06, 0x00, 0x46, 0x00, 0x12, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x14, 0x00, 0x1A,
  0x00, 0x18, 0x80, 0x14, 0x30, 0x32, 0x0F, 0xE2, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0xE0,
  0x03, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x01, 0x01, 0x80,
  0x80, 0xC0, 0x40, 0x20, 0x20, 0x10, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF0, 0x0C,
  0x0C, 0x30, 0x06, 0x20, 0x02, 0x40, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x07, 0xC0, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x7E, 0x00, 0x60, 0x60, 0x20, 0x08,
  0x10, 0x01, 0x04, 0x00, 0x42, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10,
  0x3E, 0x48, 0x18, 0x52, 0x08, 0x0C, 0x84, 0x01, 0x21, 0x00, 0x50, 0x40,
  0x14, 0x20, 0x09, 0x08, 0x02, 0x42, 0x00, 0x90, 0x80, 0x24, 0x20, 0x0A,
  0x08, 0x06, 0x82, 0x01, 0x20, 0x80, 0xC8, 0x10, 0x52, 0x07, 0x64, 0x80,
  0x60, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x50, 0x00, 0x05,
  0x00, 0x00, 0x50, 0x00, 0x09, 0x00, 0x00, 0x90, 0x00, 0x10, 0x80, 0x01,
  0x08, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x40, 0x80, 0x04, 0x08, 0x00,
  0x80, 0x40, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x40,
  0x20, 0x04, 0x07, 0xFF, 0xE0, 0x40, 0x02, 0x08, 0x00, 0x20, 0x80, 0x02,
  0x10, 0x00, 0x21, 0x00, 0x02, 0x20, 0x00, 0x12, 0x00, 0x01, 0x40, 0x00,
  0x1C, 0x00, 0x01, 0x07, 0xFF, 0x00, 0x80, 0x18, 0x10, 0x01, 0x84, 0x00,
  0x10, 0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x10, 0x00,
  0x22, 0x00, 0x04, 0x40, 0x01, 0x08, 0x00, 0x41, 0x00, 0x10, 0x3F, 0xFC,
  0x08, 0x00, 0xC1, 0x00, 0x04, 0x20, 0x00, 0x44, 0x00, 0x08, 0x80, 0x01,
  0x10, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02,
  0x40, 0x00, 0x88, 0x00, 0x22, 0x00, 0x18, 0x7F, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0xC0, 0xC0, 0x60, 0x08, 0x20, 0x02, 0x10, 0x00, 0x44, 0x00, 0x12,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x48,
  0x00, 0x22, 0x00, 0x08, 0x40, 0x04, 0x18, 0x02, 0x03, 0x03, 0x00, 0x3F,
  0x00, 0x0F, 0xFC, 0x01, 0x00, 0x60, 0x20, 0x02, 0x04, 0x00, 0x21, 0x00,
  0x04, 0x20, 0x00, 0x44, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x22, 0x00,
  0x04, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00,
  0x09, 0x00, 0x01, 0x40, 0x00, 0x48, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00,
  0x24, 0x00, 0x08, 0x80, 0x01, 0x20, 0x00, 0x44, 0x00, 0x08, 0x80, 0x02,
  0x10, 0x01, 0x82, 0x00, 0xE0, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x03, 0xFF, 0xFC, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xC0,
  0xC0, 0x40, 0x08, 0x20, 0x02, 0x10, 0x00, 0x4C, 0x00, 0x12, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x01, 0xFE, 0x80, 0x00, 0xA0, 0x00,
  0x28, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x32,
  0x00, 0x14, 0x40, 0x06, 0x18, 0x02, 0x83, 0x03, 0x20, 0x3F, 0x08, 0x04,
  0x00, 0x08, 0x40, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x20, 0x80, 0x01,
  0x04, 0x00, 0x08, 0x20, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80,
  0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x02, 0x0F, 0xFF, 0xF0,
  0x80, 0x00, 0x84, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x02, 0x08, 0x00,
  0x10, 0x80, 0x00, 0x84, 0x00, 0x04, 0x20, 0x00, 0x41, 0x00, 0x02, 0x08,
  0x00, 0x10, 0x40, 0x00, 0x82, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x02,
  0x00, 0x07, 0xFF, 0xF8, 0x40, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x88, 0x00, 0x42, 0x00, 0x10, 0x80, 0x08, 0x10,
  0x06, 0x03, 0x06, 0x00, 0x7F, 0x00, 0x08, 0x00, 0x0C, 0x20, 0x00, 0x40,
  0x80, 0x02, 0x02, 0x00, 0x10, 0x10, 0x00, 0x80, 0x40, 0x04, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x00, 0x10, 0x18, 0x00, 0x40, 0xC0, 0x02, 0x06, 0x00,
  0x08, 0x20, 0x00, 0x21, 0x80, 0x00, 0x89, 0x00, 0x02, 0x44, 0x00, 0x0A,
  0x08, 0x00, 0x50, 0x20, 0x01, 0x80, 0x40, 0x04, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x08, 0x00, 0x40, 0x20, 0x00, 0x80,
  0x80, 0x02, 0x02, 0x00, 0x04, 0x08, 0x00, 0x10, 0x20, 0x00, 0x20, 0x04,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x60, 0xC0, 0x02, 0x82, 0x80, 0x0A, 0x12, 0x00, 0x48, 0x48, 0x01, 0x21,
  0x20, 0x09, 0x04, 0x40, 0x44, 0x11, 0x01, 0x10, 0x44, 0x08, 0x42, 0x08,
  0x21, 0x08, 0x21, 0x04, 0x20, 0x88, 0x20, 0x82, 0x20, 0x82, 0x05, 0x02,
  0x08, 0x18, 0x08, 0x40, 0x20, 0x21, 0x01, 0x00, 0x84, 0x00, 0x04, 0x10,
  0x00, 0x10, 0x40, 0x00, 0x41, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20, 0x00,
  0x10, 0x80, 0x00, 0x82, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x20,
  0x04, 0x00, 0x08, 0x50, 0x00, 0x42, 0x80, 0x02, 0x14, 0x00, 0x20, 0x90,
  0x01, 0x04, 0x80, 0x08, 0x24, 0x00, 0x42, 0x10, 0x02, 0x10, 0x80, 0x10,
  0x84, 0x01, 0x04, 0x10, 0x08, 0x20, 0x80, 0x41, 0x02, 0x02, 0x10, 0x10,
  0x10, 0x80, 0x80, 0x84, 0x02, 0x08, 0x20, 0x10, 0x41, 0x00, 0x82, 0x08,
  0x02, 0x10, 0x80, 0x10, 0x84, 0x00, 0x84, 0x20, 0x02, 0x41, 0x00, 0x12,
  0x08, 0x00, 0x90, 0x40, 0x02, 0x84, 0x00, 0x14, 0x20, 0x00, 0xA1, 0x00,
  0x02, 0x00, 0x00, 0xFE, 0x00, 0x30, 0x20, 0x18, 0x02, 0x06, 0x00, 0x20,
  0x80, 0x04, 0x20, 0x00, 0x48, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x28,
  0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x40,
  0x00, 0x48, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x42, 0x00, 0x10, 0x40,
  0x06, 0x04, 0x01, 0x80, 0x40, 0xE0, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x80, 0x0C, 0x08, 0x00, 0x20, 0x80, 0x02, 0x10, 0x00, 0x11, 0x00, 0x01,
  0x10, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00,
  0x22, 0x00, 0x06, 0x20, 0x00, 0x42, 0x00, 0x18, 0x3F, 0xFE, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x30, 0x20,
  0x18, 0x02, 0x06, 0x00, 0x20, 0x80, 0x04, 0x20, 0x00, 0x48, 0x00, 0x09,
  0x00, 0x01, 0x20, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x14,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x02, 0x80, 0x00, 0x50,
  0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x48, 0x00, 0x09, 0x00, 0x01, 0x20,
  0x00, 0x42, 0x00, 0x10, 0x40, 0x06, 0x04, 0x01, 0x80, 0x40, 0xC0, 0x07,
  0xE0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x20, 0x02, 0x0E, 0x00,
  0x22, 0x00, 0x02, 0x80, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0x00, 0x80, 0x0C,
  0x08, 0x00, 0x20, 0x80, 0x02, 0x10, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00,
  0x11, 0x00, 0x01, 0x10, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00,
  0x06, 0x20, 0x00, 0x42, 0x00, 0x18, 0x3F, 0xFE, 0x02, 0x04, 0x00, 0x40,
  0x20, 0x04, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x08, 0x04,
  0x00, 0x80, 0x80, 0x04, 0x08, 0x00, 0x40, 0x80, 0x04, 0x08, 0x00, 0x20,
  0x80, 0x02, 0x08, 0x00, 0x10, 0x00, 0x7F, 0x80, 0x06, 0x01, 0x80, 0x20,
  0x01, 0x01, 0x00, 0x02, 0x08, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x30, 0x00, 0x18, 0x60,
  0x00, 0x40, 0xC0, 0x02, 0x00, 0xC0, 0x30, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x11, 0x00, 0x02, 0x10, 0x00,
  0x21, 0x00, 0x02, 0x10, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00,
  0x04, 0x20, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0x44, 0x00, 0x04, 0x40,
  0x00, 0x44, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x00, 0x88,
  0x00, 0x08, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x20,
  0x40, 0x02, 0x04, 0x00, 0x40, 0x30, 0x18, 0x00, 0xFE, 0x00, 0x80, 0x00,
  0x38, 0x00, 0x02, 0x80, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00,
  0x08, 0x40, 0x00, 0x84, 0x00, 0x10, 0x40, 0x01, 0x02, 0x00, 0x20, 0x20,
  0x02, 0x02, 0x00, 0x40, 0x20, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01,
  0x01, 0x00, 0x10, 0x10, 0x01, 0x02, 0x00, 0x10, 0x20, 0x01, 0x04, 0x00,
  0x10, 0x40, 0x01, 0x08, 0x00, 0x08, 0x80, 0x00, 0x90, 0x00, 0x09, 0x00,
  0x00, 0xA0, 0x00, 0x0A, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x0C, 0x80,
  0x00, 0x22, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x10, 0x80, 0x00,
  0x42, 0x00, 0x01, 0x08, 0x00, 0x04, 0x40, 0x00, 0x21, 0x00, 0x80, 0x84,
  0x06, 0x02, 0x10, 0x28, 0x08, 0x40, 0x90, 0x41, 0x02, 0x41, 0x04, 0x11,
  0x04, 0x10, 0x44, 0x10, 0x42, 0x10, 0x81, 0x08, 0x42, 0x04, 0x41, 0x08,
  0x11, 0x04, 0x40, 0x48, 0x09, 0x01, 0x20, 0x24, 0x05, 0x00, 0x90, 0x24,
  0x02, 0x80, 0xA0, 0x0A, 0x02, 0x80, 0x28, 0x0A, 0x00, 0xA0, 0x30, 0x01,
  0x00, 0x06, 0x00, 0x01, 0x81, 0x00, 0x01, 0x00, 0x40, 0x01, 0x80, 0x20,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x80, 0x01, 0x00, 0x80, 0x00,
  0x80, 0x80, 0x00, 0x20, 0x40, 0x00, 0x10, 0x40, 0x00, 0x04, 0x40, 0x00,
  0x02, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x22, 0x00, 0x00, 0x21, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x20, 0x20, 0x00, 0x10, 0x08, 0x00, 0x10, 0x04, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x00, 0x80, 0x10, 0x00, 0x20, 0x18, 0x00, 0x10, 0x08, 0x00,
  0x04, 0x18, 0x00, 0x02, 0x00, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x24, 0x00,
  0x01, 0x08, 0x00, 0x08, 0x20, 0x00, 0x40, 0x40, 0x02, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x10, 0x10, 0x00, 0x40, 0x80, 0x00,
  0x84, 0x00, 0x02, 0x30, 0x00, 0x04, 0x80, 0x00, 0x14, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFE,
  0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x07, 0xFE, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x03,
  0xFF, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0xFF, 0xC0, 0x00,
  0x18, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x22, 0x00, 0x08, 0x40, 0x02,
  0x04, 0x00, 0x80, 0x80, 0x10, 0x08, 0x04, 0x01, 0x01, 0x00, 0x10, 0x40,
  0x02, 0x08, 0x00, 0x42, 0x00, 0x04, 0x80, 0x00, 0xA0, 0x00, 0x08, 0xFF,
  0xFF, 0xE0, 0x88, 0x44, 0x22, 0x10, 0x01, 0xF8, 0x41, 0x81, 0x10, 0x80,
  0x28, 0x40, 0x06, 0x20, 0x00, 0x90, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02,
  0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x20,
  0x00, 0x48, 0x00, 0x22, 0x00, 0x08, 0x80, 0x06, 0x10, 0x02, 0x86, 0x01,
  0x20, 0xC0, 0x88, 0x0F, 0xC3, 0xC0, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x04, 0x3F, 0x01, 0x10, 0x30, 0x48, 0x06, 0x14, 0x00, 0x86,
  0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12, 0x00,
  0x04, 0x80, 0x01, 0x20, 0x00, 0x50, 0x00, 0x14, 0x00, 0x09, 0x00, 0x02,
  0x40, 0x01, 0x10, 0x00, 0x46, 0x00, 0x22, 0x40, 0x10, 0x88, 0x18, 0x21,
  0xF8, 0x00, 0x01, 0xF8, 0x03, 0x03, 0x02, 0x00, 0x42, 0x00, 0x22, 0x00,
  0x09, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x05, 0x00, 0x02,
  0x40, 0x02, 0x20, 0x02, 0x08, 0x02, 0x03, 0x06, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x3F, 0x08, 0x18,
  0x11, 0x04, 0x01, 0x41, 0x00, 0x18, 0x40, 0x01, 0x10, 0x00, 0x22, 0x00,
  0x04, 0x40, 0x00, 0x90, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00,
  0x11, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00,
  0xC1, 0x00, 0x28, 0x30, 0x09, 0x03, 0x02, 0x20, 0x1F, 0x88, 0x00, 0x00,
  0xFC, 0x01, 0x81, 0x83, 0x00, 0x63, 0x00, 0x11, 0x00, 0x09, 0x00, 0x05,
  0x00, 0x02, 0x80, 0x03, 0x40, 0x03, 0x40, 0x06, 0x20, 0x3C, 0x1F, 0xE0,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x03, 0x40, 0x01, 0x20,
  0x01, 0x08, 0x01, 0x03, 0x03, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x02, 0x01, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x20, 0x40, 0x00, 0x08, 0x20, 0x00, 0x02, 0x10, 0x00, 0x00, 0xC8, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFC, 0x20, 0x60, 0x44,
  0x10, 0x05, 0x04, 0x00, 0x61, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x11,
  0x00, 0x02, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x44,
  0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x03, 0x04,
  0x00, 0xA0, 0xC0, 0x24, 0x0C, 0x08, 0x80, 0x7E, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x83, 0x00, 0x60, 0x30,
  0x18, 0x01, 0xFC, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0xF8,
  0x13, 0x06, 0x14, 0x02, 0x28, 0x01, 0x30, 0x01, 0x30, 0x01, 0x20, 0x01,
  0x20, 0x01, 0x60, 0x01, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x04, 0x80, 0x04, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x04, 0x01, 0x04, 0x06, 0x04, 0x0C, 0x04, 0x30, 0x04, 0x60, 0x09, 0x80,
  0x0B, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x01, 0x00, 0x81, 0xC0, 0x40,
  0x30, 0x20, 0x04, 0x10, 0x01, 0x08, 0x00, 0x48, 0x00, 0x14, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01,
  0x07, 0xE0, 0x11, 0x83, 0x01, 0x20, 0x08, 0x14, 0x00, 0x81, 0x80, 0x08,
  0x10, 0x00, 0x81, 0x00, 0x08, 0x20, 0x01, 0x02, 0x00, 0x20, 0x20, 0x0C,
  0x02, 0x03, 0x00, 0x23, 0xC0, 0x04, 0x10, 0x00, 0x41, 0x00, 0x04, 0x08,
  0x01, 0x40, 0x80, 0x64, 0x04, 0x0C, 0x40, 0x21, 0x88, 0x02, 0x30, 0x80,
  0x14, 0x08, 0x00, 0x80, 0xFF, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x84,
  0x06, 0x08, 0x10, 0x20, 0xC0, 0x42, 0x00, 0x98, 0x01, 0x40, 0x03, 0x00,
  0x00, 0x11, 0xC1, 0xE0, 0xB1, 0x10, 0x86, 0x05, 0x04, 0x20, 0x30, 0x13,
  0x01, 0x00, 0x90, 0x08, 0x08, 0x80, 0x40, 0x44, 0x02, 0x02, 0x20, 0x20,
  0x12, 0x01, 0x00, 0x90, 0x08, 0x04, 0x80, 0x40, 0x44, 0x02, 0x02, 0x20,
  0x20, 0x11, 0x01, 0x00, 0x90, 0x08, 0x04, 0x80, 0x40, 0x24, 0x02, 0x02,
  0x20, 0x10, 0x11, 0x01, 0x00, 0x88, 0x08, 0x04, 0x00, 0x10, 0xF8, 0x13,
  0x06, 0x24, 0x02, 0x28, 0x01, 0x30, 0x01, 0x30, 0x01, 0x20, 0x01, 0x20,
  0x01, 0x60, 0x01, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x04, 0x80, 0x04, 0x01, 0xF8, 0x01, 0x81, 0x80, 0x80, 0x10, 0x40, 0x02,
  0x20, 0x00, 0x88, 0x00, 0x24, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x50,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00,
  0x0A, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0x82, 0x00, 0x40, 0x60, 0x60,
  0x07, 0xE0, 0x00, 0x08, 0x7E, 0x01, 0x10, 0x30, 0x24, 0x03, 0x05, 0x00,
  0x20, 0xC0, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00,
  0x22, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00,
  0x88, 0x00, 0x11, 0x00, 0x04, 0x20, 0x00, 0x86, 0x00, 0x21, 0x20, 0x08,
  0x22, 0x06, 0x04, 0x3F, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00,
  0x01, 0xF8, 0x41, 0x81, 0x10, 0x80, 0x28, 0x40, 0x06, 0x20, 0x00, 0x90,
  0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00,
  0x12, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x22, 0x00, 0x08,
  0x80, 0x06, 0x10, 0x02, 0x86, 0x01, 0x20, 0xC0, 0x88, 0x0F, 0xC4, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0xFF, 0x1F, 0xE0, 0x2C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFC, 0x03, 0x80,
  0xC1, 0x80, 0x08, 0x40, 0x01, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00,
  0x44, 0x00, 0x20, 0xC0, 0x30, 0x0F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x80, 0x20, 0x18, 0x04, 0x06, 0x00, 0x40, 0x80, 0x04, 0x30, 0x00, 0x4C,
  0x00, 0x05, 0x00, 0x00, 0x60, 0x00, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01,
  0x20, 0x01, 0x20, 0x01, 0x40, 0x01, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x0C, 0x80, 0x14, 0x80, 0x14, 0x40, 0x28, 0x60, 0xC8, 0x1F, 0x08,
  0xFC, 0x00, 0x41, 0x00, 0x10, 0x40, 0x04, 0x10, 0x01, 0x04, 0x00, 0x41,
  0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80,
  0x08, 0x20, 0x02, 0x08, 0x01, 0x04, 0x00, 0x41, 0x00, 0x20, 0x40, 0x18,
  0x10, 0x0C, 0x04, 0x06, 0x01, 0x02, 0x00, 0x47, 0x00, 0x1E, 0x00, 0x00,
  0x20, 0x10, 0x22, 0x01, 0x02, 0x20, 0x10, 0x22, 0x02, 0x02, 0x20, 0x20,
  0x22, 0x02, 0x01, 0x40, 0x20, 0x14, 0x02, 0x01, 0x40, 0x40, 0x14, 0x04,
  0x01, 0x40, 0x40, 0x24, 0x04, 0x02, 0x80, 0x40, 0x28, 0x04, 0x02, 0x80,
  0x80, 0x28, 0x08, 0x04, 0x81, 0x80, 0x48, 0x18, 0x08, 0x82, 0x40, 0x8C,
  0x64, 0x30, 0x78, 0x3E, 0x00, 0x01, 0x80, 0xF0, 0x19, 0x04, 0x21, 0x82,
  0x20, 0x58, 0x09, 0x01, 0x00, 0x24, 0x04, 0x00, 0x60, 0x10, 0x01, 0x80,
  0x40, 0x04, 0x01, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x02, 0x00, 0x80, 0x08, 0x06, 0x00, 0x20, 0x14,
  0x00, 0x80, 0x90, 0x0A, 0x02, 0x40, 0x48, 0x10, 0x86, 0x10, 0x82, 0x60,
  0x3C, 0x06, 0x00, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01,
  0x08, 0x00, 0x44, 0x00, 0x11, 0x00, 0x08, 0x40, 0x02, 0x10, 0x00, 0x84,
  0x00, 0x21, 0x00, 0x08, 0x80, 0x02, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00,
  0x10, 0x80, 0x0C, 0x20, 0x05, 0x08, 0x01, 0x41, 0x00, 0xA0, 0x60, 0xC8,
  0x07, 0xC2, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x02, 0x08, 0x01, 0x81, 0x81, 0x80, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x10,
  0x81, 0xE2, 0x10, 0x03, 0xE1, 0x00, 0x06, 0x20, 0x00, 0x42, 0x00, 0x18,
  0x20, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x10, 0x08, 0x01, 0x01, 0x00,
  0x08, 0x20, 0x00, 0x86, 0x00, 0x08, 0xFF, 0x00, 0x88, 0x3F, 0xC8, 0x80,
  0x0F, 0x80, 0x00, 0x7F, 0xC0, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x3F, 0x80, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xC0, 0x02,
  0x04, 0x10, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x00, 0x03, 0xFC, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x07, 0xF0,
  0x07, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x03, 0xFE, 0x00, 0x0F, 0x00, 0x18, 0x84, 0x00, 0x88, 0x10, 0x04,
  0x80, 0x40, 0x44, 0x03, 0x06, 0x40, 0x0C, 0x62, 0x00, 0x1C, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 6, 28, 24, 9, -28 },
  { 22, 8, 10, 24, 10, -30 },
  { 32, 23, 28, 24, 1, -28 },
  { 113, 22, 36, 24, 1, -32 },
  { 212, 27, 28, 24, -1, -28 },
  { 307, 23, 28, 24, 1, -28 },
  { 388, 3, 10, 24, 13, -30 },
  { 392, 13, 36, 24, 9, -30 },
  { 451, 12, 36, 24, 3, -30 },
  { 505, 20, 20, 24, 3, -22 },
  { 555, 19, 19, 24, 3, -22 },
  { 601, 6, 10, 24, 6, -3 },
  { 609, 11, 1, 24, 7, -13 },
  { 611, 3, 2, 24, 9, -2 },
  { 612, 21, 36, 24, 2, -30 },
  { 707, 19, 28, 24, 3, -28 },
  { 774, 18, 28, 24, 2, -28 },
  { 837, 19, 28, 24, 2, -28 },
  { 904, 19, 28, 24, 2, -28 },
  { 971, 20, 28, 24, 1, -28 },
  { 1041, 20, 28, 24, 2, -28 },
  { 1111, 17, 28, 24, 3, -28 },
  { 1171, 18, 28, 24, 5, -28 },
  { 1234, 20, 28, 24, 2, -28 },
  { 1304, 17, 28, 24, 4, -28 },
  { 1364, 6, 21, 24, 9, -21 },
  { 1380, 9, 28, 24, 6, -21 },
  { 1412, 19, 21, 24, 4, -23 },
  { 1462, 21, 8, 24, 2, -16 },
  { 1483, 19, 21, 24, 2, -23 },
  { 1533, 16, 28, 24, 6, -28 },
  { 1589, 18, 32, 24, 3, -28 },
  { 1661, 20, 28, 24, 0, -28 },
  { 1731, 19, 28, 24, 2, -28 },
  { 1798, 18, 28, 24, 4, -28 },
  { 1861, 19, 28, 24, 3, -28 },
  { 1928, 20, 28, 24, 3, -28 },
  { 1998, 21, 28, 24, 3, -28 },
  { 2072, 18, 28, 24, 4, -28 },
  { 2135, 21, 28, 24, 2, -28 },
  { 2209, 21, 28, 24, 2, -28 },
  { 2283, 18, 28, 24, 3, -28 },
  { 2346, 22, 28, 24, 3, -28 },
  { 2423, 16, 28, 24, 4, -28 },
  { 2479, 22, 28, 24, 2, -28 },
  { 2556, 21, 28, 24, 2, -28 },
  { 2630, 19, 28, 24, 3, -28 },
  { 2697, 20, 28, 24, 3, -28 },
  { 2767, 19, 35, 24, 3, -28 },
  { 2851, 20, 28, 24, 3, -28 },
  { 2921, 22, 28, 24, 1, -28 },
  { 2998, 21, 28, 24, 4, -28 },
  { 3072, 20, 28, 24, 3, -28 },
  { 3142, 20, 28, 24, 5, -28 },
  { 3212, 22, 28, 24, 3, -28 },
  { 3289, 25, 28, 24, 0, -28 },
  { 3377, 22, 28, 24, 4, -28 },
  { 3454, 24, 28, 24, 0, -28 },
  { 3538, 15, 36, 24, 8, -30 },
  { 3606, 9, 36, 24, 8, -30 },
  { 3647, 16, 36, 24, 1, -30 },
  { 3719, 19, 15, 24, 3, -28 },
  { 3755, 19, 1, 24, 0, 5 },
  { 3758, 4, 7, 24, 10, -31 },
  { 3762, 18, 21, 24, 3, -21 },
  { 3810, 18, 30, 24, 3, -30 },
  { 3878, 17, 21, 24, 3, -21 },
  { 3923, 19, 30, 24, 3, -30 },
  { 3995, 17, 21, 24, 3, -21 },
  { 4040, 25, 38, 24, 0, -30 },
  { 4159, 19, 29, 24, 2, -21 },
  { 4228, 16, 30, 24, 4, -30 },
  { 4288, 16, 30, 24, 4, -30 },
  { 4348, 17, 38, 24, 4, -30 },
  { 4429, 20, 30, 24, 3, -30 },
  { 4504, 15, 30, 24, 5, -30 },
  { 4561, 21, 21, 24, 2, -21 },
  { 4617, 16, 21, 24, 4, -21 },
  { 4659, 18, 21, 24, 3, -21 },
  { 4707, 19, 29, 24, 2, -21 },
  { 4776, 18, 29, 24, 3, -21 },
  { 4842, 19, 21, 24, 5, -21 },
  { 4892, 18, 21, 24, 3, -21 },
  { 4940, 20, 28, 24, 3, -28 },
  { 5010, 16, 21, 24, 4, -21 },
  { 5052, 18, 21, 24, 3, -21 },
  { 5100, 20, 21, 24, 3, -21 },
  { 5153, 22, 21, 24, 1, -21 },
  { 5211, 18, 29, 24, 2, -21 },
  { 5277, 20, 21, 24, 2, -21 },
  { 5330, 18, 36, 24, 5, -30 },
  { 5411, 7, 36, 24, 9, -30 },
  { 5443, 18, 36, 24, 2, -30 },
  { 5524, 21, 7, 24, 2, -16 },
};

const GFXfont IBMPlexMono_ThinItalic40pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic40pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic40pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _IBMPLEXMONO_THINITALIC40PT7B_H_
