#ifndef _IBMPLEXMONO_THINITALIC56PT7B_H_
#define _IBMPLEXMONO_THINITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x83, 0x80, 0x20, 0x64, 0x08,
  0x81, 0x30, 0x26, 0x04, 0x81, 0x90, 0x32, 0x04, 0x40, 0x98, 0x13, 0x02,
  0x40, 0xC8, 0x19, 0x02, 0x00, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x30,
  0x08, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x0C,
  0x02, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x40, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x80, 0x20, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x60, 0x10, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x00, 0x10, 0x04, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00,
  0x08, 0x02, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x80, 0x00, 0x01, 0x00, 0x40, 0x00, 0x00, 0x80, 0x60, 0x00,
  0x00, 0x80, 0x20, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x20, 0x18, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x10, 0x04, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x08, 0x02, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x06, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x80, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x60, 0x10,
  0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0E, 0x08, 0x70, 0x00, 0x40, 0x20, 0x60, 0x06, 0x00, 0x80, 0x40,
  0x10, 0x06, 0x00, 0x80, 0x80, 0x10, 0x03, 0x02, 0x00, 0x40, 0x00, 0x10,
  0x01, 0x00, 0x00, 0x40, 0x04, 0x00, 0x01, 0x00, 0x10, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x10, 0x02, 0x00, 0x00, 0x40, 0x08, 0x00, 0x01, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x80, 0x00, 0x08, 0x02, 0x00, 0x00, 0x10, 0x18, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x00, 0x71, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x47, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x08, 0x04, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x80, 0x30, 0x00, 0x02,
  0x00, 0x40, 0x00, 0x08, 0x01, 0x00, 0x00, 0x60, 0x04, 0x00, 0x01, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x40, 0x00, 0x10, 0x01, 0x00, 0x00, 0x40, 0x04,
  0x00, 0x01, 0x00, 0x30, 0x80, 0x0C, 0x00, 0x81, 0x00, 0x20, 0x06, 0x06,
  0x00, 0x80, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x1C, 0x08, 0x0C, 0x00, 0x1E,
  0x20, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x00, 0xC0, 0x10, 0x0C, 0x00, 0x04, 0x01, 0x00, 0x20, 0x00, 0x40,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x80, 0x04, 0x00, 0x60, 0x08, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x01, 0x00, 0x20, 0x02, 0x00, 0x08, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x30, 0x00, 0x80, 0x02, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x10,
  0x00, 0x60, 0x01, 0x01, 0x00, 0x01, 0x00, 0x08, 0x18, 0x00, 0x08, 0x00,
  0x80, 0x80, 0x00, 0x40, 0x04, 0x08, 0x00, 0x01, 0x00, 0x40, 0x80, 0x00,
  0x06, 0x0C, 0x0C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x81, 0xC1, 0x80, 0x00, 0x08, 0x18, 0x04,
  0x00, 0x00, 0x81, 0x80, 0x10, 0x00, 0x0C, 0x08, 0x00, 0x80, 0x00, 0x40,
  0x80, 0x02, 0x00, 0x04, 0x04, 0x00, 0x10, 0x00, 0x40, 0x20, 0x00, 0x80,
  0x06, 0x03, 0x00, 0x04, 0x00, 0x20, 0x10, 0x00, 0x60, 0x02, 0x00, 0x80,
  0x03, 0x00, 0x20, 0x04, 0x00, 0x10, 0x03, 0x00, 0x20, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x0C, 0x01, 0x00, 0x0C, 0x00, 0x40, 0x10, 0x00, 0x20, 0x04,
  0x01, 0x80, 0x01, 0x80, 0x60, 0x08, 0x00, 0x06, 0x0E, 0x00, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0x20, 0x06, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x40, 0x01, 0x00, 0x00,
  0x80, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x00,
  0x80, 0x01, 0x80, 0x00, 0x80, 0x01, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00,
  0x40, 0x01, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00,
  0x30, 0x04, 0x00, 0x00, 0x10, 0x08, 0x00, 0x01, 0xE8, 0x30, 0x00, 0x06,
  0x09, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x20,
  0x02, 0x00, 0x00, 0x40, 0x01, 0x00, 0x00, 0x40, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x80, 0x00, 0x30, 0x00, 0x80, 0x00, 0x30, 0x00, 0x80,
  0x00, 0x28, 0x01, 0x80, 0x00, 0x2C, 0x02, 0x80, 0x00, 0x24, 0x04, 0xC0,
  0x00, 0x46, 0x04, 0x40, 0x00, 0xC2, 0x08, 0x60, 0x00, 0x81, 0x18, 0x30,
  0x03, 0x01, 0x90, 0x0C, 0x0E, 0x00, 0xA0, 0x03, 0xF0, 0x00, 0x60, 0x13,
  0x32, 0x22, 0x26, 0x64, 0x44, 0x4C, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60,
  0x00, 0xC0, 0x04, 0x00, 0x37, 0x80, 0x40, 0x3C, 0x0F, 0x04, 0x1E, 0x00,
  0x1E, 0x4F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x41, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x00, 0x40, 0x00, 0x40,
  0x06, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x01, 0x00, 0x20, 0x00, 0x10,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x10, 0x30, 0x20, 0x20, 0x60, 0x40,
  0xC0, 0x80, 0xFF, 0xFE, 0xEF, 0xE0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x01,
  0x80, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x00, 0x80, 0x10, 0x00, 0x08, 0x04,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x10, 0x20, 0x00, 0x02, 0x08, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x88, 0x00, 0x00, 0x13, 0x00,
  0x00, 0x02, 0x40, 0x00, 0x00, 0x48, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x01, 0xA0, 0x07,
  0x00, 0x24, 0x00, 0xE0, 0x04, 0x80, 0x1C, 0x00, 0xB0, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x02, 0x40, 0x00, 0x00, 0x48, 0x00, 0x00, 0x19, 0x00, 0x00, 0x02, 0x30,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x10, 0x40, 0x00, 0x02, 0x08, 0x00, 0x00,
  0x81, 0x00, 0x00, 0x30, 0x30, 0x00, 0x04, 0x02, 0x00, 0x01, 0x00, 0x20,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x00, 0x30, 0x1C, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0xC2, 0x00, 0x01, 0x81, 0x00, 0x01, 0x81, 0x80, 0x01,
  0x80, 0xC0, 0x03, 0x00, 0x40, 0x03, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x30,
  0x00, 0x80, 0x04, 0x00, 0x04, 0x00, 0x80, 0x00, 0x60, 0x18, 0x00, 0x02,
  0x01, 0x00, 0x00, 0x30, 0x20, 0x00, 0x01, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0E, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x80, 0x80, 0x00, 0x10, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x22, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x18,
  0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0x38, 0x07, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x40,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x88, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x60, 0x80, 0x00, 0x04, 0x08,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x10, 0x10, 0x00, 0x02, 0x01, 0x00, 0x00,
  0x60, 0x10, 0x00, 0x0C, 0x01, 0x00, 0x01, 0x80, 0x10, 0x00, 0x10, 0x03,
  0x00, 0x02, 0x00, 0x20, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x80, 0x02, 0x00, 0x30, 0x00, 0x20, 0x06, 0x00, 0x06, 0x00, 0x40, 0x00,
  0x40, 0x08, 0x00, 0x04, 0x01, 0x00, 0x00, 0x40, 0x20, 0x00, 0x04, 0x06,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x1F, 0xE0, 0x00, 0x4E, 0x03, 0x80, 0x0D, 0x00, 0x0C,
  0x00, 0xA0, 0x00, 0x20, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x06, 0x04, 0x00, 0x00, 0xC0,
  0x20, 0x00, 0x08, 0x01, 0x80, 0x03, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x3F, 0xC0, 0x0C, 0x60, 0x18, 0x04, 0xC0,
  0x03, 0x06, 0x80, 0x00, 0xC2, 0x80, 0x00, 0x21, 0x80, 0x00, 0x19, 0xC0,
  0x00, 0x04, 0xC0, 0x00, 0x02, 0x60, 0x00, 0x01, 0xA0, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x16, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x04, 0x80, 0x00, 0x06, 0x40, 0x00, 0x02, 0x20, 0x00, 0x03,
  0x18, 0x00, 0x01, 0x04, 0x00, 0x01, 0x01, 0x00, 0x01, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x07, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xD0, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x19, 0x00, 0x00, 0x04, 0x40, 0x00, 0x03, 0x30,
  0x00, 0x01, 0x88, 0x00, 0x00, 0x42, 0x00, 0x00, 0x30, 0x80, 0x00, 0x08,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x60, 0x00,
  0x80, 0x0C, 0x00, 0x04, 0x01, 0x80, 0x00, 0x20, 0x30, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x06, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x01, 0x04, 0x00, 0x00, 0x30, 0x40, 0x00, 0x03, 0x04, 0x00, 0x00, 0x20,
  0x40, 0x00, 0x02, 0x06, 0x00, 0x00, 0x40, 0x20, 0x00, 0x0C, 0x03, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x30, 0x00, 0x60, 0x1C, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x70, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x82, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x44, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x04, 0xC0,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x08, 0x40, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0x20, 0x00, 0x02, 0x03,
  0x00, 0x00, 0xC0, 0x08, 0x00, 0x18, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0x70, 0x06, 0x00, 0x18, 0x0C,
  0x00, 0x04, 0x18, 0x00, 0x06, 0x10, 0x00, 0x02, 0x20, 0x00, 0x03, 0x60,
  0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x40, 0x00, 0x0A, 0x60,
  0x00, 0x14, 0x20, 0x00, 0x24, 0x18, 0x00, 0x4C, 0x0E, 0x03, 0x88, 0x03,
  0xFC, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0xF0, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x06, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x38, 0x0E, 0x02,
  0x00, 0x18, 0x20, 0x00, 0x62, 0x00, 0x01, 0x20, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x1F,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1C, 0x0E, 0x00, 0x10, 0x01,
  0x80, 0x10, 0x00, 0x60, 0x10, 0x00, 0x10, 0x10, 0x00, 0x08, 0x08, 0x00,
  0x02, 0x08, 0x00, 0x01, 0x04, 0x00, 0x00, 0x84, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x11, 0x00, 0x3F, 0x08, 0x80, 0x60, 0x44, 0xC0,
  0x60, 0x14, 0x40, 0x60, 0x06, 0x20, 0x20, 0x03, 0x10, 0x30, 0x00, 0x88,
  0x10, 0x00, 0x4C, 0x08, 0x00, 0x64, 0x0C, 0x00, 0x22, 0x04, 0x00, 0x11,
  0x02, 0x00, 0x08, 0x81, 0x00, 0x04, 0xC0, 0x80, 0x02, 0x60, 0x40, 0x01,
  0x20, 0x20, 0x01, 0x90, 0x10, 0x00, 0x88, 0x08, 0x00, 0x44, 0x04, 0x00,
  0x62, 0x02, 0x00, 0x51, 0x01, 0x00, 0x28, 0x80, 0x40, 0x2C, 0x40, 0x30,
  0x64, 0x20, 0x07, 0xE2, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x82, 0x00, 0x00,
  0x18, 0x20, 0x00, 0x01, 0x02, 0x00, 0x00, 0x30, 0x30, 0x00, 0x02, 0x01,
  0x00, 0x00, 0x60, 0x10, 0x00, 0x04, 0x01, 0x00, 0x00, 0xC0, 0x10, 0x00,
  0x08, 0x01, 0x00, 0x01, 0x80, 0x18, 0x00, 0x10, 0x00, 0x80, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x08, 0x00, 0x40, 0x00, 0xC0,
  0x0C, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x40, 0x1F, 0xFF, 0xFC, 0x01, 0x00,
  0x00, 0x40, 0x30, 0x00, 0x04, 0x02, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x02, 0x08, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x02, 0x10, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x10, 0x01, 0xFF, 0xFC, 0x00,
  0x20, 0x00, 0xE0, 0x0C, 0x00, 0x06, 0x01, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x04, 0x04, 0x00, 0x00, 0x80, 0x80, 0x00, 0x18, 0x10, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x04, 0x10, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x04, 0x08, 0x00, 0x00, 0x83, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x04, 0x08, 0x00, 0x01, 0x01, 0x00, 0x00, 0x40, 0x20, 0x00, 0x30,
  0x07, 0xFF, 0xF8, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x40, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x82, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x02, 0x10, 0x00, 0x00, 0x62, 0x00, 0x00, 0x08, 0x40, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x21, 0x00, 0x00, 0x04, 0x60, 0x00, 0x01, 0x88,
  0x00, 0x00, 0x21, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x03, 0x04, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x70, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x0E, 0x03, 0x00, 0x06, 0x00, 0x20, 0x02, 0x00, 0x04, 0x01, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x20, 0x60, 0x00, 0x04, 0x10, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x10, 0x00, 0x01, 0x04, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x20, 0x20, 0x00, 0x10, 0x04, 0x00, 0x08, 0x00,
  0x80, 0x0C, 0x00, 0x18, 0x0E, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x18, 0x01, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x18, 0x08, 0x00, 0x01, 0x01, 0x00, 0x00, 0x10, 0x20, 0x00,
  0x02, 0x04, 0x00, 0x00, 0x40, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x10, 0x80, 0x00, 0x02, 0x10, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x08, 0x40, 0x00, 0x01, 0x18, 0x00, 0x00, 0x22, 0x00, 0x00, 0x0C, 0x40,
  0x00, 0x01, 0x88, 0x00, 0x00, 0x21, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00,
  0x8C, 0x00, 0x00, 0x11, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0x10, 0x80, 0x00, 0x02, 0x10, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x02, 0x10, 0x00, 0x00, 0x82, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x04, 0x08, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x40, 0x00, 0x18, 0x08,
  0x00, 0x04, 0x01, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0x03,
  0x00, 0x04, 0x00, 0x20, 0x06, 0x00, 0x04, 0x01, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x20, 0x40, 0x00, 0x04, 0x30, 0x00, 0x01, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x7F, 0xF2, 0x00, 0x00, 0x04,
  0x80, 0x00, 0x01, 0x20, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x08, 0x80, 0x00, 0x02, 0x20, 0x00, 0x00, 0x88, 0x00, 0x00, 0x22, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x06, 0x10, 0x00, 0x01, 0x04, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x50, 0x20, 0x00, 0x14, 0x0C, 0x00, 0x09, 0x01, 0x80, 0x0C,
  0xC0, 0x18, 0x0C, 0x20, 0x01, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x18, 0x00, 0x00, 0x40, 0x80, 0x00, 0x02, 0x04, 0x00, 0x00, 0x30, 0x20,
  0x00, 0x01, 0x01, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x02, 0x04, 0x00, 0x00, 0x10, 0x20, 0x00, 0x01, 0x81, 0x00, 0x00, 0x08,
  0x08, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x02, 0x06, 0x00, 0x00, 0x10, 0x20,
  0x00, 0x00, 0x81, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x40, 0x40, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x10, 0x3F, 0xFF, 0xFF, 0x81, 0x00, 0x00, 0x04,
  0x08, 0x00, 0x00, 0x60, 0x40, 0x00, 0x02, 0x02, 0x00, 0x00, 0x10, 0x30,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x04, 0x08, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x81, 0x80, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0x20, 0x40, 0x00, 0x01, 0x02, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x00, 0x80, 0x80, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x20, 0x60, 0x00,
  0x01, 0x02, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x20, 0x00, 0x0C, 0x0C,
  0x00, 0x02, 0x01, 0x00, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x01, 0xC0, 0x60, 0x00, 0x1F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x0E, 0x04,
  0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x30, 0x01, 0x00, 0x00, 0xC0, 0x02, 0x00,
  0x03, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x80, 0x00, 0x40, 0x02, 0x00, 0x00, 0x80, 0x08, 0x00, 0x01, 0x00, 0x20,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x04, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x20, 0x70, 0x00, 0x00, 0x41, 0x90, 0x00, 0x00, 0x86, 0x20, 0x00,
  0x01, 0x18, 0x20, 0x00, 0x02, 0x60, 0x40, 0x00, 0x0D, 0x00, 0x40, 0x00,
  0x14, 0x00, 0x80, 0x00, 0x30, 0x00, 0x80, 0x00, 0x40, 0x01, 0x00, 0x00,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x04, 0x00, 0x20, 0x00, 0x08, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x80, 0x00, 0x10, 0x03, 0x00, 0x00, 0x10, 0x04, 0x00,
  0x00, 0x20, 0x08, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x40, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0x80,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x16, 0x00,
  0x00, 0xA0, 0x24, 0x00, 0x03, 0x40, 0x48, 0x00, 0x04, 0x80, 0x90, 0x00,
  0x19, 0x01, 0x10, 0x00, 0x66, 0x06, 0x20, 0x00, 0x8C, 0x08, 0x40, 0x03,
  0x10, 0x10, 0xC0, 0x04, 0x20, 0x20, 0x80, 0x10, 0x40, 0x41, 0x00, 0x60,
  0x80, 0x82, 0x00, 0x83, 0x03, 0x02, 0x03, 0x06, 0x04, 0x04, 0x04, 0x08,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x60, 0x20, 0x20, 0x10, 0x80, 0x40,
  0x40, 0x22, 0x01, 0x81, 0x80, 0x44, 0x03, 0x02, 0x00, 0x50, 0x04, 0x04,
  0x00, 0xE0, 0x08, 0x08, 0x01, 0x80, 0x10, 0x10, 0x02, 0x00, 0x20, 0x20,
  0x04, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x81, 0x00, 0x00, 0x02, 0x02, 0x00,
  0x00, 0x04, 0x04, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x10, 0x10, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x01, 0x01, 0x00, 0x00,
  0x02, 0x02, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x08, 0x1C, 0x00,
  0x00, 0x40, 0xA0, 0x00, 0x02, 0x05, 0x80, 0x00, 0x30, 0x24, 0x00, 0x01,
  0x01, 0x20, 0x00, 0x08, 0x19, 0x80, 0x00, 0x40, 0xC4, 0x00, 0x02, 0x04,
  0x20, 0x00, 0x10, 0x20, 0x80, 0x01, 0x81, 0x04, 0x00, 0x08, 0x08, 0x20,
  0x00, 0x40, 0xC0, 0x80, 0x02, 0x06, 0x04, 0x00, 0x10, 0x20, 0x20, 0x00,
  0x81, 0x00, 0x80, 0x0C, 0x08, 0x04, 0x00, 0x40, 0x40, 0x30, 0x02, 0x06,
  0x00, 0x80, 0x10, 0x30, 0x04, 0x00, 0x81, 0x00, 0x30, 0x04, 0x08, 0x00,
  0x80, 0x60, 0x40, 0x04, 0x02, 0x02, 0x00, 0x30, 0x10, 0x30, 0x00, 0x80,
  0x81, 0x80, 0x04, 0x04, 0x08, 0x00, 0x30, 0x20, 0x40, 0x00, 0x83, 0x02,
  0x00, 0x04, 0x10, 0x10, 0x00, 0x10, 0x81, 0x80, 0x00, 0x84, 0x0C, 0x00,
  0x04, 0x20, 0x40, 0x00, 0x11, 0x02, 0x00, 0x00, 0x98, 0x10, 0x00, 0x06,
  0x80, 0x80, 0x00, 0x14, 0x0C, 0x00, 0x00, 0xA0, 0x60, 0x00, 0x07, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x01, 0x80, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x00, 0x80, 0x10, 0x00, 0x08, 0x04, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x10, 0x20, 0x00, 0x02, 0x08, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x01, 0x88, 0x00, 0x00, 0x13, 0x00, 0x00, 0x02,
  0x40, 0x00, 0x00, 0x48, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x12, 0x00, 0x00, 0x02, 0x40,
  0x00, 0x00, 0x48, 0x00, 0x00, 0x19, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x10, 0x40, 0x00, 0x02, 0x08, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x04, 0x02, 0x00, 0x01, 0x00, 0x20, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x00, 0x30, 0x1C, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x20, 0x00, 0x38, 0x02, 0x00, 0x00, 0xC0, 0x20, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x20, 0x40, 0x00, 0x03, 0x04, 0x00, 0x00, 0x10,
  0x40, 0x00, 0x01, 0x04, 0x00, 0x00, 0x10, 0x40, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x10, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x30, 0x80, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x20, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x08, 0x10, 0x00, 0x03, 0x01, 0x00, 0x00, 0xE0, 0x1F, 0xFF, 0xF8,
  0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x01, 0x80, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x00, 0x80, 0x10, 0x00, 0x08, 0x04, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x10, 0x20, 0x00, 0x02, 0x08, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x01, 0x88, 0x00, 0x00, 0x13, 0x00, 0x00, 0x02,
  0x40, 0x00, 0x00, 0x48, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x12, 0x00, 0x00, 0x02, 0x40,
  0x00, 0x00, 0x48, 0x00, 0x00, 0x19, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x10, 0x40, 0x00, 0x02, 0x08, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x04, 0x02, 0x00, 0x01, 0x00, 0x20, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x00, 0x30, 0x1C, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x04, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x40, 0x60,
  0x00, 0x04, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x20, 0x00, 0x38, 0x02, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x06, 0x06, 0x00, 0x00, 0x20, 0x40, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x10, 0x40, 0x00, 0x01, 0x04, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x10, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x02, 0x08, 0x00, 0x00, 0x20, 0x80, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x08, 0x10, 0x00, 0x03, 0x01, 0x00, 0x00, 0xE0,
  0x1F, 0xFF, 0xF8, 0x01, 0x00, 0x40, 0x00, 0x30, 0x02, 0x00, 0x02, 0x00,
  0x20, 0x00, 0x20, 0x01, 0x00, 0x02, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x00, 0x40, 0x04, 0x00, 0x04, 0x00, 0x40,
  0x00, 0x60, 0x04, 0x00, 0x02, 0x00, 0x40, 0x00, 0x30, 0x04, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x18, 0x08, 0x00, 0x00, 0x80, 0x80, 0x00, 0x0C, 0x08,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xE0, 0x0F, 0x00, 0x04, 0x00, 0x06, 0x00, 0x20, 0x00, 0x04, 0x01, 0x00,
  0x00, 0x08, 0x08, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x01, 0x00, 0xC0, 0x00, 0x08, 0x01, 0xC0, 0x00, 0xC0, 0x01, 0xE0, 0x0C,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x21, 0x80, 0x00, 0x04, 0x20, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x30, 0x80, 0x00, 0x04, 0x10, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x02, 0x10, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x18, 0x40, 0x00, 0x02, 0x08, 0x00, 0x00, 0x41, 0x00, 0x00, 0x08, 0x60,
  0x00, 0x01, 0x08, 0x00, 0x00, 0x21, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x20, 0x80, 0x00, 0x04, 0x30, 0x00, 0x00, 0x84, 0x00,
  0x00, 0x10, 0x80, 0x00, 0x06, 0x10, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x10,
  0x40, 0x00, 0x02, 0x18, 0x00, 0x00, 0x42, 0x00, 0x00, 0x08, 0x40, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x41, 0x00, 0x00, 0x08, 0x20, 0x00, 0x01, 0x04,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x08, 0x10, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x40, 0x20, 0x00, 0x18, 0x04, 0x00, 0x06, 0x00, 0x40, 0x01, 0x80, 0x07,
  0x00, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x00, 0x44, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x01, 0x06, 0x00, 0x00, 0x10, 0x20, 0x00,
  0x02, 0x02, 0x00, 0x00, 0x20, 0x20, 0x00, 0x04, 0x02, 0x00, 0x00, 0x40,
  0x20, 0x00, 0x08, 0x03, 0x00, 0x00, 0x80, 0x10, 0x00, 0x10, 0x01, 0x00,
  0x01, 0x00, 0x10, 0x00, 0x20, 0x01, 0x00, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x80, 0x04, 0x00, 0x08, 0x00, 0x80, 0x00, 0x80, 0x08, 0x00, 0x08,
  0x01, 0x00, 0x00, 0x80, 0x10, 0x00, 0x08, 0x02, 0x00, 0x00, 0xC0, 0x20,
  0x00, 0x04, 0x04, 0x00, 0x00, 0x40, 0x40, 0x00, 0x04, 0x08, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x04, 0x10, 0x00, 0x00, 0x61, 0x00, 0x00, 0x06, 0x20,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x02, 0x80, 0x00, 0x00, 0x28, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x02, 0x40, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00,
  0x44, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x21, 0x00, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x86, 0x00, 0x60, 0x04, 0x30, 0x07,
  0x00, 0x21, 0x00, 0x28, 0x03, 0x08, 0x03, 0x40, 0x10, 0x40, 0x12, 0x00,
  0x82, 0x01, 0x90, 0x04, 0x10, 0x08, 0xC0, 0x60, 0x80, 0x46, 0x02, 0x04,
  0x04, 0x10, 0x10, 0x20, 0x20, 0x80, 0x81, 0x02, 0x04, 0x0C, 0x08, 0x10,
  0x20, 0x40, 0x41, 0x81, 0x02, 0x02, 0x08, 0x08, 0x30, 0x30, 0xC0, 0x61,
  0x01, 0x84, 0x01, 0x08, 0x0C, 0x60, 0x08, 0x40, 0x42, 0x00, 0x46, 0x02,
  0x30, 0x02, 0x20, 0x11, 0x00, 0x11, 0x00, 0x88, 0x00, 0x88, 0x04, 0x80,
  0x04, 0xC0, 0x24, 0x00, 0x34, 0x01, 0x40, 0x00, 0xA0, 0x0A, 0x00, 0x05,
  0x00, 0x60, 0x00, 0x38, 0x03, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x10, 0x01, 0x00, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x02, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x01,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x20, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x40, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x01, 0x18,
  0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x02, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x06, 0x00, 0x02, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x10, 0x04, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00,
  0x11, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x11, 0x00,
  0x00, 0x08, 0x40, 0x00, 0x04, 0x08, 0x00, 0x03, 0x02, 0x00, 0x00, 0x80,
  0x40, 0x00, 0x40, 0x10, 0x00, 0x20, 0x06, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x30, 0x02, 0x00, 0x04, 0x01, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x20,
  0x60, 0x00, 0x08, 0x10, 0x00, 0x01, 0x08, 0x00, 0x00, 0x46, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x86, 0x10, 0xC2, 0x18, 0x41, 0x08, 0x00, 0x3F, 0x80, 0x00, 0x60, 0x30,
  0x40, 0xC0, 0x06, 0x20, 0xC0, 0x01, 0xB0, 0xC0, 0x00, 0x58, 0x40, 0x00,
  0x18, 0x40, 0x00, 0x0C, 0x20, 0x00, 0x06, 0x20, 0x00, 0x03, 0x10, 0x00,
  0x01, 0x98, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x44, 0x00, 0x00, 0x22, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x09, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x06, 0x40,
  0x00, 0x02, 0x20, 0x00, 0x01, 0x10, 0x00, 0x00, 0x88, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x31, 0x80, 0x00, 0x30, 0x40, 0x00, 0x18,
  0x20, 0x00, 0x14, 0x08, 0x00, 0x12, 0x06, 0x00, 0x13, 0x01, 0x80, 0x11,
  0x80, 0x70, 0x30, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x3F, 0x80, 0x04, 0x38,
  0x18, 0x01, 0x18, 0x01, 0x00, 0x48, 0x00, 0x20, 0x14, 0x00, 0x04, 0x05,
  0x00, 0x01, 0x03, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x08, 0x30, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x82, 0x00, 0x00, 0x30, 0x80, 0x00, 0x0C, 0x60, 0x00,
  0x03, 0x10, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x21, 0x00, 0x00, 0x08, 0x40,
  0x00, 0x02, 0x10, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x62, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x04, 0x20, 0x00, 0x01, 0x08, 0x00, 0x00, 0x82, 0x00, 0x00,
  0x21, 0x80, 0x00, 0x10, 0x50, 0x00, 0x0C, 0x14, 0x00, 0x02, 0x04, 0x80,
  0x01, 0x01, 0x10, 0x01, 0x80, 0x43, 0x01, 0xC0, 0x20, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x01, 0x80, 0xC0, 0x0C, 0x00, 0x40, 0x20, 0x00, 0x40,
  0x80, 0x00, 0x42, 0x00, 0x00, 0x8C, 0x00, 0x01, 0x90, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x01, 0x40, 0x00, 0x04, 0x40, 0x00, 0x18,
  0x80, 0x00, 0x61, 0x80, 0x00, 0x81, 0x80, 0x06, 0x01, 0x80, 0x18, 0x01,
  0xC0, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x1F, 0xC0, 0x40, 0x0C,
  0x06, 0x08, 0x06, 0x00, 0x31, 0x01, 0x80, 0x03, 0x60, 0x60, 0x00, 0x2C,
  0x08, 0x00, 0x03, 0x02, 0x00, 0x00, 0x60, 0x40, 0x00, 0x0C, 0x10, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x10, 0x00, 0x00, 0x82,
  0x00, 0x00, 0x10, 0x40, 0x00, 0x02, 0x18, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x18, 0x40, 0x00, 0x03, 0x08, 0x00, 0x00, 0x41, 0x00, 0x00, 0x08, 0x20,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x20, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x60, 0x20, 0x00, 0x0C, 0x04, 0x00, 0x02, 0x80, 0x40,
  0x00, 0x90, 0x0C, 0x00, 0x32, 0x00, 0xC0, 0x0C, 0xC0, 0x0E, 0x06, 0x10,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xC0, 0x60, 0x06, 0x00,
  0x30, 0x30, 0x00, 0x20, 0xC0, 0x00, 0x61, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x98, 0x00, 0x01, 0x20, 0x00, 0x02, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x6C, 0x00, 0x01, 0x90, 0x00, 0x0C, 0x20, 0x00, 0xE0, 0x40,
  0x3E, 0x00, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x01, 0x40, 0x00,
  0x06, 0x40, 0x00, 0x08, 0x80, 0x00, 0x21, 0x80, 0x00, 0xC1, 0x80, 0x03,
  0x01, 0x80, 0x0C, 0x01, 0xC0, 0x60, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x01, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x10, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x00, 0x01, 0x90, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x18, 0x0C, 0x10, 0x18, 0x00, 0xC4,
  0x0C, 0x00, 0x1B, 0x06, 0x00, 0x02, 0xC1, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x18, 0x20, 0x00, 0x06, 0x10, 0x00, 0x01, 0x84, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x04, 0x20, 0x00, 0x01, 0x08, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x11, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x03, 0x10, 0x00, 0x00,
  0x84, 0x00, 0x00, 0x21, 0x00, 0x00, 0x08, 0x40, 0x00, 0x02, 0x10, 0x00,
  0x01, 0x84, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x20, 0x00, 0x0C, 0x08,
  0x00, 0x05, 0x01, 0x00, 0x02, 0x40, 0x60, 0x01, 0x30, 0x0C, 0x00, 0x8C,
  0x01, 0xC0, 0xC2, 0x00, 0x1F, 0xC0, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x0E, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x7E, 0x00, 0x43, 0x03, 0x00, 0x88, 0x01, 0x03,
  0x20, 0x01, 0x04, 0x80, 0x02, 0x0A, 0x00, 0x06, 0x18, 0x00, 0x04, 0x30,
  0x00, 0x08, 0x40, 0x00, 0x11, 0x80, 0x00, 0x22, 0x00, 0x00, 0x44, 0x00,
  0x01, 0x88, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x08, 0x80, 0x00,
  0x11, 0x00, 0x00, 0x22, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x08, 0x00, 0x02,
  0x30, 0x00, 0x04, 0x60, 0x00, 0x08, 0x80, 0x00, 0x11, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x84, 0x00, 0x01, 0x18, 0x00, 0x02, 0x30, 0x00, 0x04, 0x40,
  0x00, 0x08, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x02, 0x01, 0x00, 0x18, 0x02, 0x00, 0x40, 0x04, 0x03,
  0x00, 0x18, 0x08, 0x00, 0x20, 0x60, 0x00, 0x41, 0x80, 0x00, 0x84, 0x00,
  0x01, 0x30, 0x00, 0x06, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x06, 0x00, 0x10, 0x06, 0x00, 0x20, 0x06, 0x00, 0x40, 0x06, 0x00, 0x80,
  0x02, 0x03, 0x00, 0x02, 0x04, 0x00, 0x02, 0x08, 0x00, 0x02, 0x10, 0x00,
  0x03, 0x20, 0x00, 0x03, 0x40, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x7F, 0x00, 0x04, 0x18, 0x0C, 0x00, 0x46, 0x00, 0x20, 0x04, 0x80,
  0x03, 0x00, 0x50, 0x00, 0x10, 0x06, 0x00, 0x01, 0x00, 0xA0, 0x00, 0x10,
  0x0C, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x10, 0x08, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x20, 0x08, 0x00, 0x06, 0x01, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x10,
  0x01, 0x00, 0x06, 0x00, 0x10, 0x01, 0x80, 0x01, 0x00, 0xE0, 0x00, 0x10,
  0x70, 0x00, 0x02, 0x02, 0x00, 0x00, 0x20, 0x30, 0x00, 0x02, 0x01, 0x00,
  0x00, 0x20, 0x18, 0x00, 0x12, 0x00, 0x80, 0x06, 0x60, 0x0C, 0x00, 0xC6,
  0x00, 0x40, 0x18, 0x40, 0x02, 0x03, 0x04, 0x00, 0x20, 0x60, 0x40, 0x01,
  0x0C, 0x04, 0x00, 0x19, 0x80, 0xC0, 0x00, 0xB0, 0x00, 0x00, 0x0E, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x03,
  0x06, 0x00, 0x30, 0x30, 0x06, 0x01, 0x00, 0x60, 0x08, 0x04, 0x00, 0x40,
  0xC0, 0x02, 0x08, 0x00, 0x31, 0x80, 0x01, 0x10, 0x00, 0x0B, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x11, 0x04, 0x10, 0x40, 0x48,
  0x08, 0x80, 0x81, 0x40, 0x24, 0x02, 0x06, 0x00, 0xA0, 0x0C, 0x30, 0x03,
  0x00, 0x30, 0xC0, 0x0C, 0x00, 0xC2, 0x00, 0x20, 0x03, 0x08, 0x00, 0x80,
  0x08, 0x20, 0x02, 0x00, 0x20, 0x80, 0x08, 0x00, 0x86, 0x00, 0x20, 0x02,
  0x10, 0x01, 0x80, 0x18, 0x40, 0x04, 0x00, 0x61, 0x00, 0x10, 0x01, 0x04,
  0x00, 0x40, 0x04, 0x10, 0x01, 0x00, 0x10, 0xC0, 0x04, 0x00, 0x42, 0x00,
  0x30, 0x01, 0x08, 0x00, 0x80, 0x0C, 0x20, 0x02, 0x00, 0x20, 0x80, 0x08,
  0x00, 0x82, 0x00, 0x20, 0x02, 0x18, 0x00, 0x80, 0x08, 0x40, 0x06, 0x00,
  0x21, 0x00, 0x10, 0x01, 0x84, 0x00, 0x40, 0x04, 0x10, 0x01, 0x00, 0x10,
  0x40, 0x04, 0x00, 0x43, 0x00, 0x30, 0x01, 0x00, 0x00, 0x0F, 0xC0, 0x08,
  0x60, 0x60, 0x31, 0x00, 0x20, 0x64, 0x00, 0x20, 0x90, 0x00, 0x41, 0x40,
  0x00, 0xC3, 0x00, 0x00, 0x86, 0x00, 0x01, 0x18, 0x00, 0x02, 0x30, 0x00,
  0x04, 0x40, 0x00, 0x08, 0x80, 0x00, 0x31, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x8C, 0x00, 0x01, 0x10, 0x00, 0x02, 0x20, 0x00, 0x04, 0x40, 0x00, 0x18,
  0x80, 0x00, 0x21, 0x00, 0x00, 0x46, 0x00, 0x00, 0x8C, 0x00, 0x01, 0x10,
  0x00, 0x02, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x10, 0x80, 0x00, 0x23, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x88, 0x00, 0x01, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x18, 0x04, 0x00, 0x0C, 0x08,
  0x00, 0x04, 0x18, 0x00, 0x02, 0x10, 0x00, 0x02, 0x20, 0x00, 0x03, 0x20,
  0x00, 0x01, 0x60, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80,
  0x00, 0x06, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x0C, 0x80,
  0x00, 0x08, 0x40, 0x00, 0x10, 0x60, 0x00, 0x30, 0x20, 0x00, 0x60, 0x18,
  0x00, 0xC0, 0x0E, 0x03, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x43, 0x81, 0x80, 0x08, 0xC0, 0x08, 0x01, 0x20, 0x00, 0x80, 0x28, 0x00,
  0x08, 0x05, 0x00, 0x01, 0x01, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x08, 0x10, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x06, 0x10, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x02, 0x08, 0x00, 0x00, 0x41, 0x00, 0x00, 0x08, 0x60, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x61, 0x00, 0x00, 0x08, 0x20, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x40, 0x80, 0x00, 0x08, 0x30, 0x00, 0x02, 0x05, 0x00, 0x00, 0xC0,
  0xA0, 0x00, 0x10, 0x12, 0x00, 0x04, 0x02, 0x20, 0x03, 0x00, 0x43, 0x01,
  0xC0, 0x18, 0x1F, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x60, 0x30, 0x40, 0xC0, 0x06,
  0x20, 0xC0, 0x01, 0xB0, 0xC0, 0x00, 0x58, 0x40, 0x00, 0x18, 0x40, 0x00,
  0x0C, 0x20, 0x00, 0x06, 0x20, 0x00, 0x03, 0x10, 0x00, 0x01, 0x98, 0x00,
  0x00, 0xC8, 0x00, 0x00, 0x44, 0x00, 0x00, 0x22, 0x00, 0x00, 0x13, 0x00,
  0x00, 0x09, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x06, 0x40, 0x00, 0x02, 0x20,
  0x00, 0x01, 0x10, 0x00, 0x00, 0x88, 0x00, 0x00, 0x44, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x30, 0x40, 0x00, 0x18, 0x20, 0x00, 0x14,
  0x08, 0x00, 0x12, 0x06, 0x00, 0x13, 0x01, 0x80, 0x11, 0x80, 0x70, 0x30,
  0x80, 0x0F, 0xE0, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0xFF, 0xE0, 0xFF, 0xE0, 0x04, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x01, 0x80,
  0xC0, 0x00, 0x20, 0xC0, 0x00, 0x08, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x80, 0x00, 0x02, 0x40, 0x00, 0x01, 0x30,
  0x00, 0x01, 0x8C, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80, 0x70, 0x07, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x80, 0x03, 0x80, 0x08, 0x00, 0xC0, 0x00, 0x80, 0x10, 0x00, 0x08,
  0x06, 0x00, 0x00, 0x81, 0x80, 0x00, 0x18, 0x30, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x11, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x06, 0x20, 0x00, 0x08, 0x40, 0x00, 0x11, 0x80, 0x00, 0x23, 0x00,
  0x00, 0x44, 0x00, 0x00, 0x88, 0x00, 0x03, 0x10, 0x00, 0x04, 0x20, 0x00,
  0x08, 0x40, 0x00, 0x11, 0x80, 0x00, 0x22, 0x00, 0x00, 0x44, 0x00, 0x01,
  0x88, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x08, 0xC0, 0x00, 0x11,
  0x00, 0x00, 0x22, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10,
  0x00, 0x0C, 0x20, 0x00, 0x28, 0x40, 0x00, 0x50, 0x80, 0x01, 0x61, 0x00,
  0x02, 0x81, 0x00, 0x09, 0x03, 0x00, 0x22, 0x03, 0x81, 0x84, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0x00, 0x80, 0x00, 0x80, 0x40, 0x00, 0x40,
  0x60, 0x00, 0x20, 0x20, 0x00, 0x18, 0x10, 0x00, 0x04, 0x08, 0x00, 0x02,
  0x04, 0x00, 0x01, 0x02, 0x00, 0x01, 0x81, 0x00, 0x00, 0x81, 0x80, 0x00,
  0x40, 0x80, 0x00, 0x20, 0x40, 0x00, 0x10, 0x20, 0x00, 0x18, 0x10, 0x00,
  0x08, 0x08, 0x00, 0x04, 0x04, 0x00, 0x06, 0x06, 0x00, 0x02, 0x02, 0x00,
  0x03, 0x01, 0x00, 0x01, 0x00, 0x80, 0x01, 0x00, 0x40, 0x01, 0x00, 0x20,
  0x01, 0x80, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08, 0x03, 0x00, 0x04,
  0x03, 0x00, 0x02, 0x0E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x80,
  0x40, 0x80, 0x18, 0x04, 0x18, 0x01, 0x00, 0x21, 0x80, 0x10, 0x02, 0x10,
  0x01, 0x00, 0x21, 0x00, 0x10, 0x02, 0x10, 0x01, 0x00, 0x21, 0x00, 0x30,
  0x03, 0x30, 0x03, 0x00, 0x33, 0x00, 0x20, 0x03, 0x20, 0x02, 0x00, 0x32,
  0x00, 0x20, 0x03, 0x20, 0x02, 0x00, 0x32, 0x00, 0x60, 0x03, 0x60, 0x06,
  0x00, 0x36, 0x00, 0x40, 0x02, 0x40, 0x04, 0x00, 0x24, 0x00, 0x40, 0x02,
  0x40, 0x04, 0x00, 0x24, 0x00, 0x40, 0x06, 0x40, 0x0C, 0x00, 0x6C, 0x00,
  0x80, 0x04, 0x80, 0x08, 0x00, 0x48, 0x01, 0x80, 0x08, 0x80, 0x18, 0x00,
  0x88, 0x02, 0x80, 0x10, 0x80, 0x24, 0x03, 0x04, 0x04, 0x40, 0x60, 0x61,
  0x82, 0x0C, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x38, 0x00, 0xF8, 0x00, 0xE4,
  0x03, 0x0C, 0x03, 0x82, 0x04, 0x06, 0x0E, 0x02, 0x08, 0x02, 0x30, 0x03,
  0x18, 0x02, 0x00, 0x01, 0x10, 0x03, 0x00, 0x01, 0x20, 0x03, 0x00, 0x01,
  0x20, 0x03, 0x00, 0x01, 0xA0, 0x03, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0xC0, 0x05,
  0x00, 0x00, 0xC0, 0x04, 0x80, 0x00, 0xC0, 0x0C, 0x80, 0x00, 0xC0, 0x08,
  0x80, 0x04, 0xC0, 0x10, 0x80, 0x18, 0x40, 0x10, 0x40, 0x60, 0x60, 0x20,
  0x41, 0x80, 0x30, 0xC0, 0x26, 0x00, 0x1F, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x08, 0x04, 0x00, 0x01, 0x01, 0x80, 0x00, 0x20,
  0x30, 0x00, 0x04, 0x04, 0x00, 0x00, 0x80, 0x80, 0x00, 0x30, 0x10, 0x00,
  0x04, 0x02, 0x00, 0x00, 0x80, 0x40, 0x00, 0x10, 0x18, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x40, 0x40, 0x00, 0x18, 0x08, 0x00, 0x02, 0x01, 0x00, 0x00,
  0x40, 0x20, 0x00, 0x08, 0x0C, 0x00, 0x01, 0x01, 0x00, 0x00, 0x20, 0x20,
  0x00, 0x0C, 0x04, 0x00, 0x01, 0x00, 0x80, 0x00, 0x20, 0x10, 0x00, 0x0C,
  0x02, 0x00, 0x02, 0x80, 0x40, 0x00, 0x70, 0x08, 0x00, 0x16, 0x01, 0x00,
  0x02, 0x80, 0x10, 0x00, 0x90, 0x03, 0x00, 0x22, 0x00, 0x38, 0x18, 0x40,
  0x01, 0xFC, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x80, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x38,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x60, 0x70, 0x04,
  0x10, 0x01, 0xC0, 0x84, 0x00, 0x06, 0x10, 0x80, 0x00, 0x3E, 0x10, 0x00,
  0x01, 0x84, 0x00, 0x00, 0x60, 0x80, 0x00, 0x10, 0x10, 0x00, 0x04, 0x02,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x01,
  0x00, 0x18, 0x00, 0x20, 0x06, 0x00, 0x04, 0x01, 0x00, 0x00, 0x80, 0x40,
  0x00, 0x10, 0x30, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x61, 0xF0, 0x00, 0x04,
  0x61, 0xF0, 0x00, 0x88, 0x01, 0xE0, 0x11, 0x00, 0x03, 0xE2, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x0C,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x18,
  0x21, 0x80, 0x00, 0x82, 0x02, 0x00, 0x04, 0x20, 0x18, 0x00, 0x42, 0x00,
  0x60, 0x02, 0x10, 0x01, 0x00, 0x21, 0x00, 0x04, 0x03, 0x08, 0x00, 0x30,
  0x10, 0xC0, 0x00, 0xC3, 0x04, 0x00, 0x01, 0xE0, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 9, 39, 34, 13, -39 },
  { 45, 11, 14, 34, 15, -41 },
  { 65, 33, 39, 34, 1, -39 },
  { 226, 30, 53, 34, 2, -46 },
  { 425, 37, 41, 34, -1, -40 },
  { 615, 32, 41, 34, 1, -40 },
  { 779, 4, 14, 34, 18, -41 },
  { 786, 18, 51, 34, 13, -43 },
  { 901, 17, 51, 34, 4, -43 },
  { 1010, 28, 28, 34, 4, -31 },
  { 1108, 27, 27, 34, 4, -31 },
  { 1200, 8, 14, 34, 9, -4 },
  { 1214, 15, 1, 34, 10, -18 },
  { 1216, 4, 3, 34, 13, -3 },
  { 1218, 30, 51, 34, 2, -43 },
  { 1410, 27, 41, 34, 4, -40 },
  { 1549, 25, 39, 34, 3, -39 },
  { 1671, 28, 40, 34, 2, -40 },
  { 1811, 26, 41, 34, 3, -40 },
  { 1945, 28, 39, 34, 2, -39 },
  { 2082, 28, 40, 34, 3, -39 },
  { 2222, 25, 40, 34, 4, -39 },
  { 2347, 26, 39, 34, 7, -39 },
  { 2474, 28, 41, 34, 3, -40 },
  { 2618, 24, 40, 34, 6, -40 },
  { 2738, 8, 29, 34, 13, -29 },
  { 2767, 12, 39, 34, 9, -29 },
  { 2826, 27, 30, 34, 5, -32 },
  { 2928, 29, 11, 34, 3, -23 },
  { 2968, 26, 30, 34, 3, -32 },
  { 3066, 21, 40, 34, 9, -40 },
  { 3171, 25, 46, 34, 5, -40 },
  { 3315, 28, 39, 34, 0, -39 },
  { 3452, 27, 39, 34, 3, -39 },
  { 3584, 26, 41, 34, 5, -40 },
  { 3718, 27, 39, 34, 4, -39 },
  { 3850, 29, 39, 34, 4, -39 },
  { 3992, 29, 39, 34, 4, -39 },
  { 4134, 26, 41, 34, 5, -40 },
  { 4268, 29, 39, 34, 3, -39 },
  { 4410, 30, 39, 34, 3, -39 },
  { 4557, 26, 40, 34, 4, -39 },
  { 4687, 31, 39, 34, 4, -39 },
  { 4839, 21, 39, 34, 6, -39 },
  { 4942, 31, 39, 34, 2, -39 },
  { 5094, 29, 39, 34, 3, -39 },
  { 5236, 27, 41, 34, 4, -40 },
  { 5375, 28, 39, 34, 4, -39 },
  { 5512, 27, 49, 34, 4, -40 },
  { 5678, 28, 39, 34, 4, -39 },
  { 5815, 30, 41, 34, 2, -40 },
  { 5969, 29, 39, 34, 6, -39 },
  { 6111, 27, 40, 34, 5, -39 },
  { 6246, 28, 39, 34, 7, -39 },
  { 6383, 29, 39, 34, 5, -39 },
  { 6525, 35, 39, 34, 0, -39 },
  { 6696, 30, 39, 34, 6, -39 },
  { 6843, 34, 39, 34, 0, -39 },
  { 7009, 22, 51, 34, 11, -43 },
  { 7150, 13, 51, 34, 11, -43 },
  { 7233, 21, 51, 34, 2, -43 },
  { 7367, 26, 21, 34, 5, -39 },
  { 7436, 27, 1, 34, 0, 7 },
  { 7440, 5, 9, 34, 14, -42 },
  { 7446, 25, 31, 34, 4, -30 },
  { 7543, 26, 42, 34, 4, -41 },
  { 7680, 23, 31, 34, 5, -30 },
  { 7770, 27, 42, 34, 4, -41 },
  { 7912, 23, 31, 34, 5, -30 },
  { 8002, 35, 53, 34, -1, -41 },
  { 8234, 26, 42, 34, 3, -30 },
  { 8371, 23, 41, 34, 5, -41 },
  { 8489, 23, 43, 34, 5, -42 },
  { 8613, 23, 54, 34, 6, -42 },
  { 8769, 28, 42, 34, 4, -41 },
  { 8916, 21, 42, 34, 7, -41 },
  { 9027, 30, 30, 34, 2, -30 },
  { 9140, 23, 30, 34, 5, -30 },
  { 9227, 24, 31, 34, 5, -30 },
  { 9320, 27, 41, 34, 3, -30 },
  { 9459, 25, 41, 34, 4, -30 },
  { 9588, 27, 29, 34, 7, -29 },
  { 9686, 25, 31, 34, 4, -30 },
  { 9783, 28, 40, 34, 4, -39 },
  { 9923, 23, 30, 34, 6, -29 },
  { 10010, 25, 29, 34, 5, -29 },
  { 10101, 28, 30, 34, 4, -29 },
  { 10206, 32, 31, 34, 1, -30 },
  { 10330, 27, 41, 34, 2, -29 },
  { 10469, 27, 31, 34, 3, -30 },
  { 10574, 25, 51, 34, 7, -43 },
  { 10734, 9, 51, 34, 13, -43 },
  { 10792, 25, 51, 34, 3, -43 },
  { 10952, 29, 10, 34, 3, -22 },
};

const GFXfont IBMPlexMono_ThinItalic56pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic56pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic56pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _IBMPLEXMONO_THINITALIC56PT7B_H_
