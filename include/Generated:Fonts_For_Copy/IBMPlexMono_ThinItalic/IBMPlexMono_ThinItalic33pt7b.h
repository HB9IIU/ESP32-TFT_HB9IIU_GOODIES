#ifndef _IBMPLEXMONO_THINITALIC33PT7B_H_
#define _IBMPLEXMONO_THINITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x20, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x10, 0x82,
  0x08, 0x20, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x45, 0x18, 0x61, 0x8A, 0x28,
  0xA2, 0x00, 0x21, 0x80, 0x08, 0x20, 0x01, 0x04, 0x00, 0x21, 0x00, 0x08,
  0x20, 0x01, 0x08, 0x00, 0x21, 0x01, 0xF8, 0x3F, 0x01, 0x08, 0x00, 0x21,
  0x00, 0x08, 0x20, 0x01, 0x08, 0x00, 0x21, 0x00, 0x08, 0x20, 0x3F, 0x07,
  0xE0, 0x21, 0x00, 0x08, 0x20, 0x01, 0x04, 0x00, 0x41, 0x00, 0x08, 0x20,
  0x01, 0x04, 0x00, 0x41, 0x00, 0x08, 0x20, 0x00, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x07, 0xF0, 0x06, 0x23, 0x02, 0x08, 0x21, 0x02, 0x04,
  0x40, 0x80, 0x10, 0x20, 0x04, 0x10, 0x01, 0x04, 0x00, 0x41, 0x00, 0x0C,
  0x40, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x02, 0x30, 0x00, 0x82, 0x00, 0x20,
  0x80, 0x08, 0x10, 0x02, 0x04, 0x00, 0x81, 0x20, 0x40, 0x88, 0x10, 0x21,
  0x84, 0x10, 0x11, 0x18, 0x03, 0xF8, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x01, 0xE0, 0x04, 0x18, 0x40, 0x20, 0x40, 0x81, 0x02, 0x02,
  0x04, 0x08, 0x08, 0x20, 0x40, 0x21, 0x01, 0x00, 0x88, 0x04, 0x04, 0x20,
  0x08, 0x11, 0x00, 0x30, 0x88, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x06, 0x21, 0x00, 0x11, 0x02, 0x00, 0x88, 0x08, 0x04, 0x20,
  0x20, 0x20, 0x80, 0x80, 0x82, 0x02, 0x04, 0x08, 0x08, 0x20, 0x20, 0x41,
  0x00, 0x42, 0x0C, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x60, 0x80, 0x08,
  0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x10, 0x02, 0x02, 0x00, 0x40, 0x80, 0x0C, 0x20, 0x0E, 0x78, 0x02, 0x08,
  0x00, 0x80, 0x80, 0x10, 0x10, 0x04, 0x01, 0x00, 0x80, 0x10, 0x10, 0x03,
  0x06, 0x00, 0x60, 0xC0, 0x12, 0x34, 0x02, 0x24, 0x41, 0x85, 0x07, 0xC0,
  0x40, 0x56, 0xAA, 0x00, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x03,
  0x02, 0x0E, 0x71, 0x38, 0x07, 0xE0, 0x00, 0xC0, 0x00, 0x90, 0x00, 0x88,
  0x00, 0x82, 0x00, 0x81, 0x00, 0x80, 0x40, 0x80, 0x30, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x18, 0x8C, 0x42, 0x21, 0x10,
  0x80, 0xFF, 0x80, 0x7C, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x00,
  0x03, 0xF0, 0x18, 0x10, 0x60, 0x10, 0x80, 0x12, 0x00, 0x28, 0x00, 0x50,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x04, 0x0C, 0x18, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x12, 0x00, 0x24,
  0x00, 0x84, 0x02, 0x0C, 0x18, 0x07, 0xC0, 0x00, 0x00, 0x60, 0x01, 0xC0,
  0x06, 0x80, 0x11, 0x00, 0xC2, 0x03, 0x04, 0x08, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x3F, 0xFF, 0x80, 0x00, 0xFC, 0x01, 0x83, 0x01, 0x00, 0x41, 0x00,
  0x20, 0x80, 0x08, 0x80, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x03, 0xFF, 0xF8, 0x03, 0xF0, 0x08, 0x18, 0x20, 0x08, 0x80,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x1F, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x14, 0x00, 0x48, 0x01, 0x0C, 0x0C, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0x00, 0x02, 0x80, 0x02, 0x80, 0x01, 0x40, 0x01, 0x20,
  0x01, 0x10, 0x01, 0x08, 0x01, 0x08, 0x01, 0x04, 0x01, 0x02, 0x00, 0x81,
  0x00, 0x80, 0x80, 0x80, 0x40, 0x80, 0x40, 0x80, 0x20, 0x80, 0x10, 0x80,
  0x08, 0x7F, 0xFF, 0xC0, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x07, 0xFF, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x27, 0xE0, 0x2C, 0x18,
  0x30, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x80, 0x08, 0x40, 0x18, 0x30, 0x30, 0x0F, 0xC0,
  0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x01, 0x1F, 0x85, 0x83, 0x28, 0x02, 0xC0, 0x0A, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x40,
  0x11, 0x81, 0x81, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x06, 0x00, 0x14, 0x00,
  0x48, 0x00, 0x90, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x00, 0x01, 0xF8, 0x06, 0x06, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20,
  0x01, 0x20, 0x01, 0x10, 0x01, 0x10, 0x02, 0x0C, 0x0C, 0x03, 0xF0, 0x1C,
  0x18, 0x20, 0x04, 0x40, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x04, 0x40, 0x08, 0x30, 0x30, 0x0F, 0xC0, 0x03,
  0xE0, 0x18, 0x30, 0x40, 0x11, 0x00, 0x24, 0x00, 0x28, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x09, 0x00, 0x32, 0x00, 0xA3, 0x02, 0x81,
  0xF9, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0xE0, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x08, 0x30, 0x40, 0x82, 0x04,
  0x10, 0x20, 0x00, 0x00, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x08, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x00, 0x00, 0x0F, 0xC0, 0x81, 0x88, 0x04, 0x80, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x0F, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x0C, 0x10, 0x20, 0x10,
  0x80, 0x21, 0x00, 0x24, 0x00, 0x48, 0x00, 0xA0, 0x79, 0x43, 0x0C, 0x84,
  0x19, 0x10, 0x14, 0x20, 0x28, 0x40, 0x51, 0x00, 0xA2, 0x02, 0x44, 0x04,
  0x88, 0x09, 0x10, 0x32, 0x10, 0xA4, 0x1E, 0x88, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x04, 0x40, 0x02, 0x20, 0x02, 0x10,
  0x01, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0x80, 0x80, 0x40, 0x40, 0x40,
  0x20, 0x20, 0x10, 0x10, 0x08, 0x1F, 0xFC, 0x08, 0x01, 0x08, 0x00, 0x84,
  0x00, 0x44, 0x00, 0x24, 0x00, 0x12, 0x00, 0x0A, 0x00, 0x02, 0x0F, 0xF8,
  0x10, 0x04, 0x10, 0x02, 0x10, 0x02, 0x10, 0x01, 0x10, 0x01, 0x20, 0x02,
  0x20, 0x02, 0x20, 0x02, 0x20, 0x04, 0x20, 0x08, 0x3F, 0xF0, 0x40, 0x0C,
  0x40, 0x04, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x80, 0x02,
  0x80, 0x04, 0x80, 0x0C, 0x80, 0x18, 0xFF, 0xE0, 0x01, 0xF0, 0x0C, 0x10,
  0x20, 0x10, 0x80, 0x12, 0x00, 0x24, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x12, 0x00, 0x24, 0x00, 0x84, 0x02, 0x06,
  0x08, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x08, 0x0C, 0x10, 0x02, 0x10, 0x02,
  0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01,
  0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x40, 0x01, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x04, 0x40, 0x04, 0x80, 0x08, 0x80, 0x10, 0x80, 0x60,
  0xFF, 0x80, 0x0F, 0xFF, 0x84, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x07, 0xFF, 0xC2, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC2, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0xFF, 0xF8, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF0, 0x0C, 0x18, 0x20,
  0x10, 0x80, 0x12, 0x00, 0x24, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x0F, 0xD0, 0x00, 0xA0, 0x01, 0x40,
  0x02, 0x80, 0x05, 0x00, 0x12, 0x00, 0x24, 0x00, 0xC4, 0x02, 0x86, 0x09,
  0x07, 0xE2, 0x00, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x22, 0x00, 0x21,
  0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x01,
  0x0F, 0xFF, 0x88, 0x00, 0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80,
  0x08, 0x40, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x44,
  0x00, 0x42, 0x00, 0x20, 0x1F, 0xFF, 0x80, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x04, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x80, 0x10, 0x80, 0x10, 0x40, 0x20, 0x20,
  0xC0, 0x1F, 0x80, 0x08, 0x00, 0x44, 0x00, 0x21, 0x00, 0x10, 0x40, 0x08,
  0x10, 0x04, 0x04, 0x02, 0x01, 0x03, 0x00, 0x81, 0x00, 0x20, 0x80, 0x08,
  0x40, 0x02, 0x30, 0x00, 0x92, 0x00, 0x28, 0x80, 0x14, 0x10, 0x02, 0x04,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x04, 0x01, 0x02, 0x00, 0x20,
  0x80, 0x08, 0x20, 0x01, 0x08, 0x00, 0x60, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x03, 0xFF, 0xE0, 0x08, 0x00, 0x43,
  0x00, 0x30, 0xC0, 0x0C, 0x50, 0x05, 0x12, 0x02, 0x44, 0x80, 0x91, 0x20,
  0x48, 0x48, 0x22, 0x11, 0x08, 0x88, 0x44, 0x22, 0x11, 0x08, 0x84, 0x82,
  0x20, 0xC1, 0x08, 0x30, 0x42, 0x08, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10,
  0x00, 0x44, 0x00, 0x21, 0x00, 0x08, 0x40, 0x02, 0x20, 0x00, 0x88, 0x00,
  0x20, 0x08, 0x00, 0x8C, 0x00, 0x45, 0x00, 0x22, 0x80, 0x21, 0x40, 0x11,
  0x10, 0x08, 0x88, 0x04, 0x44, 0x02, 0x21, 0x01, 0x10, 0x81, 0x08, 0x40,
  0x88, 0x10, 0x44, 0x08, 0x22, 0x04, 0x11, 0x01, 0x08, 0x80, 0x88, 0x40,
  0x24, 0x40, 0x12, 0x20, 0x09, 0x10, 0x02, 0x88, 0x01, 0x44, 0x00, 0xC2,
  0x00, 0x20, 0x03, 0xF0, 0x18, 0x10, 0x60, 0x10, 0x80, 0x12, 0x00, 0x28,
  0x00, 0x50, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x12,
  0x00, 0x24, 0x00, 0x84, 0x02, 0x0C, 0x18, 0x07, 0xC0, 0x00, 0x0F, 0xFC,
  0x04, 0x01, 0x04, 0x00, 0x42, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40,
  0x02, 0x20, 0x01, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x84, 0x00, 0xC3,
  0xFF, 0x81, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x03,
  0xF0, 0x18, 0x10, 0x60, 0x10, 0x80, 0x12, 0x00, 0x28, 0x00, 0x50, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x12, 0x00, 0x24, 0x00,
  0x84, 0x02, 0x0C, 0x18, 0x07, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x02, 0x18,
  0x04, 0x60, 0x05, 0x80, 0x04, 0x00, 0x0F, 0xFC, 0x04, 0x01, 0x04, 0x00,
  0x42, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x01, 0x20,
  0x01, 0x10, 0x00, 0x88, 0x00, 0x84, 0x00, 0xC3, 0xFF, 0x81, 0x04, 0x01,
  0x02, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x04, 0x08, 0x02,
  0x08, 0x00, 0x84, 0x00, 0x42, 0x00, 0x10, 0x01, 0xFC, 0x01, 0x80, 0xC0,
  0x80, 0x08, 0x40, 0x01, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x48,
  0x00, 0x21, 0x00, 0x08, 0x60, 0x04, 0x06, 0x06, 0x00, 0x7E, 0x00, 0xFF,
  0xFF, 0x80, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x04, 0x40, 0x04, 0x80, 0x04,
  0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08,
  0x80, 0x10, 0x80, 0x10, 0x80, 0x20, 0x60, 0x60, 0x3F, 0x80, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x02, 0x40, 0x02, 0x40, 0x04, 0x40, 0x04, 0x40, 0x08,
  0x40, 0x08, 0x40, 0x10, 0x20, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40,
  0x20, 0x40, 0x20, 0x80, 0x20, 0x80, 0x11, 0x00, 0x11, 0x00, 0x12, 0x00,
  0x12, 0x00, 0x14, 0x00, 0x14, 0x00, 0x08, 0x00, 0x40, 0x00, 0xA0, 0x00,
  0x50, 0x00, 0x28, 0x00, 0x24, 0x00, 0x12, 0x00, 0x09, 0x00, 0x05, 0x03,
  0x04, 0x81, 0x82, 0x41, 0x41, 0x20, 0xA0, 0x90, 0x90, 0x88, 0x48, 0x44,
  0x44, 0x22, 0x21, 0x21, 0x20, 0x90, 0x90, 0x48, 0x48, 0x24, 0x28, 0x14,
  0x14, 0x0A, 0x0C, 0x05, 0x06, 0x02, 0x82, 0x00, 0x80, 0x08, 0x00, 0x10,
  0x40, 0x02, 0x04, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x10, 0x10,
  0x01, 0x02, 0x00, 0x08, 0x40, 0x00, 0x88, 0x00, 0x05, 0x00, 0x00, 0x50,
  0x00, 0x02, 0x00, 0x00, 0x50, 0x00, 0x09, 0x00, 0x01, 0x08, 0x00, 0x20,
  0x80, 0x02, 0x04, 0x00, 0x40, 0x40, 0x08, 0x02, 0x01, 0x00, 0x20, 0x20,
  0x01, 0x04, 0x00, 0x10, 0xC0, 0x00, 0x80, 0x80, 0x00, 0x50, 0x00, 0x24,
  0x00, 0x10, 0x80, 0x04, 0x20, 0x02, 0x04, 0x01, 0x01, 0x00, 0x80, 0x20,
  0x40, 0x08, 0x10, 0x01, 0x08, 0x00, 0x44, 0x00, 0x12, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x80,
  0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x0F, 0xE0, 0x81, 0x02, 0x04, 0x08, 0x10, 0x10,
  0x20, 0x40, 0x80, 0x81, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40, 0x40,
  0x81, 0x02, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x07, 0xF8, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x7F, 0x80, 0x00, 0x40,
  0x01, 0x80, 0x04, 0x80, 0x11, 0x00, 0x41, 0x00, 0x82, 0x02, 0x02, 0x08,
  0x04, 0x20, 0x08, 0x40, 0x09, 0x00, 0x14, 0x00, 0x10, 0xFF, 0xFF, 0x89,
  0x12, 0x03, 0xE2, 0x18, 0x34, 0x40, 0x29, 0x00, 0x32, 0x00, 0x48, 0x00,
  0x90, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x24, 0x00, 0x48,
  0x00, 0x88, 0x03, 0x10, 0x0A, 0x18, 0x28, 0x1F, 0x8E, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0xF8, 0x24,
  0x18, 0xA0, 0x23, 0x00, 0x48, 0x01, 0x40, 0x05, 0x00, 0x14, 0x00, 0x50,
  0x01, 0x40, 0x06, 0x00, 0x18, 0x00, 0x60, 0x02, 0x80, 0x0B, 0x00, 0x4B,
  0x06, 0x23, 0xE0, 0x07, 0xC0, 0xC1, 0x88, 0x02, 0x80, 0x14, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x01,
  0x40, 0x09, 0x00, 0x84, 0x18, 0x1F, 0x00, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x03, 0xE2, 0x0C,
  0x1A, 0x10, 0x0A, 0x20, 0x06, 0x20, 0x04, 0x40, 0x04, 0x40, 0x04, 0x80,
  0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x40,
  0x18, 0x40, 0x28, 0x30, 0x48, 0x1F, 0x90, 0x03, 0xE0, 0x30, 0x61, 0x00,
  0x98, 0x01, 0x40, 0x06, 0x00, 0x28, 0x01, 0x20, 0x78, 0xFC, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x0A, 0x00, 0x44, 0x02, 0x08, 0x10, 0x1F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xFE, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x80, 0x80, 0x0C, 0x08, 0x00, 0x61, 0x00, 0x01, 0x10, 0x00, 0x09,
  0x00, 0x00, 0x50, 0x00, 0x03, 0x00, 0x00, 0x03, 0xE2, 0x18, 0x34, 0x40,
  0x29, 0x00, 0x32, 0x00, 0x48, 0x00, 0x90, 0x01, 0x40, 0x02, 0x80, 0x05,
  0x00, 0x0A, 0x00, 0x24, 0x00, 0x48, 0x00, 0x88, 0x03, 0x10, 0x0A, 0x18,
  0x24, 0x1F, 0x90, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x10, 0x0C,
  0x10, 0x30, 0x1F, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x3C, 0x26, 0x19, 0x40, 0x4C, 0x02, 0x40, 0x12,
  0x00, 0xB0, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x05, 0x00,
  0x28, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x00, 0xC0, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x82, 0x03, 0x08, 0x30, 0x23, 0x00, 0x98, 0x03,
  0x80, 0x08, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF4, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x84, 0x04, 0x30, 0x40, 0xC2,
  0x03, 0x10, 0x04, 0x80, 0x14, 0x00, 0x60, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x21, 0xF0, 0x26,
  0x08, 0x28, 0x08, 0x30, 0x04, 0x20, 0x04, 0x20, 0x08, 0x40, 0x08, 0x40,
  0x30, 0x41, 0xC0, 0x46, 0x00, 0x84, 0x00, 0x82, 0x01, 0x82, 0x02, 0x81,
  0x04, 0x80, 0x98, 0x80, 0xB0, 0x80, 0x60, 0xFF, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x01, 0x10, 0x31,
  0x04, 0x11, 0x82, 0x20, 0x2C, 0x03, 0x00, 0x13, 0x87, 0x05, 0x12, 0x21,
  0x85, 0x04, 0x41, 0x81, 0x20, 0x20, 0x48, 0x10, 0x22, 0x04, 0x08, 0x81,
  0x02, 0x20, 0x40, 0x90, 0x10, 0x24, 0x08, 0x09, 0x02, 0x04, 0x40, 0x81,
  0x10, 0x20, 0x44, 0x08, 0x12, 0x02, 0x04, 0x81, 0x01, 0x00, 0x21, 0xE1,
  0x30, 0xCA, 0x02, 0x60, 0x12, 0x00, 0x90, 0x05, 0x80, 0x28, 0x01, 0x40,
  0x0A, 0x00, 0x50, 0x02, 0x80, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02,
  0x80, 0x10, 0x07, 0xE0, 0x60, 0x42, 0x00, 0x90, 0x01, 0x40, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x02, 0x80,
  0x0A, 0x00, 0x44, 0x03, 0x18, 0x10, 0x1F, 0x80, 0x11, 0xF0, 0x24, 0x18,
  0x50, 0x10, 0xC0, 0x11, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20,
  0x02, 0x40, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x48, 0x00, 0x98, 0x02,
  0x2C, 0x18, 0x87, 0xC1, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x03, 0xE2, 0x18, 0x34, 0x40, 0x29, 0x00,
  0x32, 0x00, 0x48, 0x00, 0x90, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0A,
  0x00, 0x24, 0x00, 0x48, 0x00, 0x88, 0x03, 0x10, 0x0A, 0x18, 0x24, 0x1F,
  0x90, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x10, 0xFE, 0x7F, 0x04, 0x80, 0x07, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x03, 0xF0, 0x18, 0x18, 0x40, 0x09, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x07, 0x00, 0x03, 0xF8, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x50, 0x00, 0x90, 0x01, 0x18, 0x0C, 0x0F, 0xE0, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x0C, 0x08, 0x30, 0x08, 0x40,
  0x11, 0x80, 0x16, 0x00, 0x18, 0x00, 0x20, 0x04, 0x80, 0x12, 0x00, 0x90,
  0x02, 0x40, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0x40, 0x12, 0x00, 0x48,
  0x01, 0x20, 0x04, 0x80, 0x32, 0x01, 0x44, 0x06, 0x18, 0x68, 0x1E, 0x20,
  0xF8, 0x04, 0x20, 0x11, 0x00, 0x44, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00,
  0x44, 0x01, 0x20, 0x04, 0x80, 0x22, 0x00, 0x88, 0x04, 0x20, 0x20, 0x81,
  0x82, 0x0C, 0x10, 0xC0, 0x3C, 0x00, 0x20, 0x41, 0x10, 0x20, 0x88, 0x10,
  0x44, 0x08, 0x12, 0x04, 0x0A, 0x04, 0x05, 0x02, 0x02, 0x81, 0x01, 0x40,
  0x80, 0xA0, 0x40, 0x90, 0x40, 0x50, 0x20, 0x28, 0x10, 0x14, 0x18, 0x12,
  0x0C, 0x08, 0x89, 0x18, 0x78, 0x78, 0x00, 0x03, 0x07, 0x83, 0x42, 0x33,
  0x09, 0x07, 0x02, 0x81, 0x00, 0xA0, 0x40, 0x30, 0x10, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x02, 0x06, 0x00, 0x81, 0x80,
  0x20, 0x50, 0x28, 0x24, 0x32, 0x10, 0xB0, 0x78, 0x30, 0x00, 0x08, 0x01,
  0x08, 0x01, 0x08, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02,
  0x10, 0x02, 0x10, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x0C,
  0x20, 0x14, 0x10, 0x18, 0x18, 0x68, 0x07, 0x88, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x10, 0x80, 0x20, 0x60, 0xC0, 0x1F, 0x80, 0x0F, 0xC1,
  0x10, 0x79, 0x20, 0x0E, 0x20, 0x02, 0x40, 0x0C, 0x40, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x08, 0x18, 0x08, 0x20, 0x08,
  0x40, 0x04, 0xF8, 0x04, 0x8F, 0xC4, 0x80, 0x7C, 0x01, 0xFE, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x60, 0x3F, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x03, 0xF8, 0x00, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x08,
  0x41, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41,
  0x04, 0x20, 0x82, 0x00, 0x0F, 0xF0, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x06, 0x00, 0x07, 0xC0, 0xE0, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x03, 0xF8, 0x00, 0x1C, 0x01, 0x91,
  0x80, 0x90, 0x40, 0x50, 0x10, 0x48, 0x04, 0x44, 0x01, 0xC0,
};

const GFXglyph IBMPlexMono_ThinItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 23, 20, 7, -23 },
  { 19, 6, 8, 20, 9, -24 },
  { 25, 19, 23, 20, 1, -23 },
  { 80, 18, 29, 20, 1, -26 },
  { 146, 22, 23, 20, -1, -23 },
  { 210, 19, 23, 20, 0, -23 },
  { 265, 2, 8, 20, 11, -24 },
  { 267, 10, 30, 20, 8, -25 },
  { 305, 11, 30, 20, 2, -25 },
  { 347, 17, 16, 20, 2, -18 },
  { 381, 16, 17, 20, 2, -19 },
  { 415, 5, 9, 20, 5, -3 },
  { 421, 9, 1, 20, 6, -11 },
  { 423, 3, 2, 20, 7, -2 },
  { 424, 18, 30, 20, 1, -25 },
  { 492, 15, 23, 20, 3, -23 },
  { 536, 15, 23, 20, 2, -23 },
  { 580, 17, 23, 20, 1, -23 },
  { 629, 15, 23, 20, 2, -23 },
  { 673, 17, 23, 20, 1, -23 },
  { 722, 16, 23, 20, 2, -23 },
  { 768, 14, 23, 20, 3, -23 },
  { 809, 15, 23, 20, 4, -23 },
  { 853, 16, 23, 20, 2, -23 },
  { 899, 15, 23, 20, 3, -23 },
  { 943, 5, 17, 20, 7, -17 },
  { 954, 7, 23, 20, 5, -17 },
  { 975, 16, 18, 20, 3, -19 },
  { 1011, 17, 7, 20, 2, -14 },
  { 1026, 15, 18, 20, 2, -19 },
  { 1060, 13, 23, 20, 5, -23 },
  { 1098, 15, 27, 20, 3, -23 },
  { 1149, 17, 23, 20, 0, -23 },
  { 1198, 16, 23, 20, 2, -23 },
  { 1244, 15, 23, 20, 3, -23 },
  { 1288, 16, 23, 20, 2, -23 },
  { 1334, 17, 23, 20, 2, -23 },
  { 1383, 18, 23, 20, 2, -23 },
  { 1435, 15, 23, 20, 3, -23 },
  { 1479, 17, 23, 20, 2, -23 },
  { 1528, 17, 23, 20, 2, -23 },
  { 1577, 16, 23, 20, 2, -23 },
  { 1623, 18, 23, 20, 2, -23 },
  { 1675, 13, 23, 20, 3, -23 },
  { 1713, 18, 23, 20, 1, -23 },
  { 1765, 17, 23, 20, 2, -23 },
  { 1814, 15, 23, 20, 3, -23 },
  { 1858, 17, 23, 20, 2, -23 },
  { 1907, 15, 29, 20, 3, -23 },
  { 1962, 17, 23, 20, 2, -23 },
  { 2011, 18, 23, 20, 1, -23 },
  { 2063, 17, 23, 20, 4, -23 },
  { 2112, 16, 23, 20, 3, -23 },
  { 2158, 16, 23, 20, 4, -23 },
  { 2204, 17, 23, 20, 3, -23 },
  { 2253, 20, 23, 20, 0, -23 },
  { 2311, 18, 23, 20, 3, -23 },
  { 2363, 20, 23, 20, 0, -23 },
  { 2421, 12, 30, 20, 7, -25 },
  { 2466, 7, 30, 20, 7, -25 },
  { 2493, 13, 30, 20, 1, -25 },
  { 2542, 15, 12, 20, 3, -23 },
  { 2565, 16, 1, 20, 0, 4 },
  { 2567, 3, 5, 20, 8, -25 },
  { 2569, 15, 17, 20, 2, -17 },
  { 2601, 14, 24, 20, 3, -24 },
  { 2643, 13, 17, 20, 3, -17 },
  { 2671, 16, 24, 20, 2, -24 },
  { 2719, 14, 17, 20, 3, -17 },
  { 2749, 20, 31, 20, 0, -24 },
  { 2827, 15, 24, 20, 2, -17 },
  { 2872, 13, 24, 20, 3, -24 },
  { 2911, 14, 25, 20, 3, -25 },
  { 2955, 13, 32, 20, 4, -25 },
  { 3007, 16, 24, 20, 3, -24 },
  { 3055, 12, 24, 20, 4, -24 },
  { 3091, 18, 17, 20, 1, -17 },
  { 3130, 13, 17, 20, 3, -17 },
  { 3158, 14, 17, 20, 3, -17 },
  { 3188, 15, 24, 20, 2, -17 },
  { 3233, 15, 24, 20, 2, -17 },
  { 3278, 16, 17, 20, 4, -17 },
  { 3312, 15, 17, 20, 2, -17 },
  { 3344, 16, 23, 20, 3, -23 },
  { 3390, 14, 17, 20, 3, -17 },
  { 3420, 14, 17, 20, 3, -17 },
  { 3450, 17, 17, 20, 2, -17 },
  { 3487, 18, 17, 20, 1, -17 },
  { 3526, 16, 24, 20, 1, -17 },
  { 3574, 16, 17, 20, 2, -17 },
  { 3608, 15, 30, 20, 4, -25 },
  { 3665, 6, 30, 20, 7, -25 },
  { 3688, 14, 30, 20, 2, -25 },
  { 3741, 17, 6, 20, 2, -13 },
};

const GFXfont IBMPlexMono_ThinItalic33pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic33pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic33pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _IBMPLEXMONO_THINITALIC33PT7B_H_
