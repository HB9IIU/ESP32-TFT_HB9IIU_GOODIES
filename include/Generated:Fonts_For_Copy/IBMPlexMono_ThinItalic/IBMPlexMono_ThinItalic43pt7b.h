#ifndef _IBMPLEXMONO_THINITALIC43PT7B_H_
#define _IBMPLEXMONO_THINITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x41,
  0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x0E, 0x18, 0x00, 0x20, 0x90, 0xC8, 0x4C, 0x24, 0x12, 0x09, 0x04,
  0x86, 0x42, 0x61, 0x20, 0x80, 0x00, 0x04, 0x04, 0x00, 0x02, 0x04, 0x00,
  0x01, 0x02, 0x00, 0x01, 0x01, 0x00, 0x00, 0x81, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x40, 0x40, 0x00, 0x20, 0x40, 0x00, 0x20, 0x20, 0x00, 0x10, 0x10,
  0x07, 0xF8, 0x1F, 0xE0, 0x08, 0x08, 0x00, 0x04, 0x04, 0x00, 0x02, 0x04,
  0x00, 0x02, 0x02, 0x00, 0x01, 0x01, 0x00, 0x00, 0x81, 0x00, 0x00, 0x80,
  0x80, 0x00, 0x40, 0x40, 0x1F, 0xE0, 0x7F, 0x80, 0x20, 0x20, 0x00, 0x10,
  0x10, 0x00, 0x08, 0x10, 0x00, 0x08, 0x08, 0x00, 0x04, 0x04, 0x00, 0x02,
  0x04, 0x00, 0x02, 0x02, 0x00, 0x01, 0x01, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x80, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x7F, 0x80, 0x06, 0x11, 0xC0, 0x60, 0x41, 0x81, 0x01,
  0x01, 0x08, 0x04, 0x04, 0x20, 0x20, 0x01, 0x00, 0x80, 0x04, 0x02, 0x00,
  0x10, 0x08, 0x00, 0x40, 0x20, 0x00, 0x80, 0x80, 0x02, 0x04, 0x00, 0x06,
  0x10, 0x00, 0x0E, 0x40, 0x00, 0x0F, 0x80, 0x00, 0x05, 0xC0, 0x00, 0x10,
  0xC0, 0x00, 0x81, 0x80, 0x02, 0x02, 0x00, 0x08, 0x04, 0x00, 0x20, 0x10,
  0x00, 0x80, 0x40, 0x04, 0x01, 0x00, 0x10, 0x04, 0x80, 0x40, 0x22, 0x01,
  0x00, 0x84, 0x04, 0x04, 0x08, 0x10, 0x20, 0x1C, 0x83, 0x00, 0x1F, 0xF0,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x18, 0x0C, 0x10, 0x00, 0x80, 0x80, 0x40, 0x08, 0x04,
  0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04,
  0x04, 0x01, 0x00, 0x20, 0x40, 0x08, 0x01, 0x04, 0x00, 0x40, 0x08, 0x20,
  0x01, 0x00, 0x82, 0x00, 0x08, 0x0C, 0x20, 0x00, 0x20, 0xC2, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0x0C, 0x10, 0x00, 0x10, 0xC0, 0x40, 0x01, 0x04, 0x02,
  0x00, 0x08, 0x40, 0x08, 0x00, 0x82, 0x00, 0x40, 0x08, 0x10, 0x02, 0x00,
  0x80, 0x80, 0x20, 0x04, 0x08, 0x01, 0x00, 0x40, 0x40, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x40, 0x08, 0x04, 0x04, 0x00, 0x20, 0xC0, 0x60, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xC1, 0x80, 0x01, 0x00, 0x40, 0x02, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x02, 0x00, 0x40, 0x01, 0x00,
  0x40, 0x00, 0x80, 0x80, 0x00, 0x81, 0x00, 0x0F, 0x46, 0x00, 0x10, 0x78,
  0x00, 0x60, 0x20, 0x00, 0x40, 0x10, 0x00, 0x80, 0x10, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x80, 0x04, 0x00, 0x80, 0x02, 0x00, 0x80, 0x05,
  0x01, 0x80, 0x05, 0x01, 0x80, 0x04, 0x82, 0x80, 0x08, 0x44, 0x40, 0x18,
  0x44, 0x30, 0x30, 0x28, 0x0F, 0xC0, 0x10, 0x25, 0xA4, 0x92, 0x92, 0x00,
  0x00, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0xE0, 0x20, 0x3C, 0x70, 0x87, 0x00,
  0x3A, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x40, 0x00, 0x11,
  0x00, 0x00, 0x82, 0x00, 0x04, 0x04, 0x00, 0x20, 0x10, 0x01, 0x00, 0x20,
  0x08, 0x00, 0x80, 0x60, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x61, 0x0C, 0x20, 0x84, 0x10, 0x82, 0x00, 0xFF, 0xF0,
  0xFF, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0E, 0x06,
  0x00, 0xC0, 0x18, 0x08, 0x00, 0x40, 0xC0, 0x01, 0x04, 0x00, 0x08, 0x40,
  0x00, 0x42, 0x00, 0x01, 0x20, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x02,
  0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x09, 0x01, 0xC0, 0x48, 0x0C,
  0x02, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x48,
  0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x01, 0x10, 0x00, 0x08, 0x40, 0x00,
  0x82, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0x40, 0x0C, 0x01, 0x81, 0xC0, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x32, 0x00, 0x06, 0x20,
  0x00, 0xC2, 0x00, 0x10, 0x20, 0x06, 0x04, 0x00, 0xC0, 0x40, 0x10, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x06, 0x06, 0x00, 0x40,
  0x0C, 0x04, 0x00, 0x20, 0x40, 0x00, 0x86, 0x00, 0x04, 0x20, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0x00, 0x0C, 0x06, 0x00, 0x80, 0x08, 0x08, 0x00, 0x20, 0x80,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x07, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x44, 0x00, 0x02, 0x10, 0x00, 0x20, 0x40,
  0x02, 0x01, 0x80, 0x60, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xA0, 0x00, 0x07, 0x00, 0x00, 0x14, 0x00, 0x00, 0x90, 0x00, 0x04, 0x40,
  0x00, 0x21, 0x00, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x40, 0x80, 0x01,
  0x02, 0x00, 0x08, 0x08, 0x00, 0x40, 0x20, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x40, 0x20, 0x01, 0x00, 0x80, 0x04, 0x04,
  0x00, 0x10, 0x20, 0x00, 0x81, 0x00, 0x02, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xF8, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x1F, 0xC0, 0x0B, 0x01, 0x80, 0xA0, 0x02, 0x06, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x84,
  0x00, 0x04, 0x20, 0x00, 0x40, 0xC0, 0x04, 0x03, 0x80, 0xC0, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x0F, 0xC0, 0x4E, 0x06, 0x0B, 0x00,
  0x21, 0x80, 0x02, 0x60, 0x00, 0x4C, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x02, 0x40, 0x00,
  0x48, 0x00, 0x11, 0x80, 0x04, 0x10, 0x01, 0x81, 0x80, 0xC0, 0x0F, 0xE0,
  0x00, 0x7F, 0xFF, 0xF4, 0x00, 0x01, 0x40, 0x00, 0x24, 0x00, 0x04, 0x40,
  0x00, 0x48, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0C, 0x06, 0x00, 0x80, 0x08,
  0x08, 0x00, 0x20, 0x80, 0x00, 0x84, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00,
  0x01, 0x10, 0x00, 0x18, 0x80, 0x00, 0x84, 0x00, 0x04, 0x10, 0x00, 0x40,
  0xC0, 0x04, 0x01, 0x80, 0xC0, 0x07, 0xF8, 0x01, 0xC0, 0x60, 0x10, 0x00,
  0x81, 0x00, 0x02, 0x10, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x02, 0x40,
  0x00, 0x12, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x64, 0x00, 0x02,
  0x30, 0x00, 0x20, 0xC0, 0x06, 0x03, 0x80, 0xE0, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x03, 0x81, 0x81, 0x80, 0x10, 0x80, 0x02, 0x40, 0x00, 0x50, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x64, 0x00, 0x29, 0x80, 0x1A, 0x30,
  0x19, 0x03, 0xF8, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x71, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x8C,
  0x00, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0xC0, 0x40, 0x60, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x1C, 0x0C,
  0x30, 0x02, 0x60, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0xE0, 0x07, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x00, 0x7E, 0x00, 0x30,
  0x30, 0x08, 0x01, 0x02, 0x00, 0x20, 0x80, 0x02, 0x10, 0x00, 0x44, 0x00,
  0x08, 0x80, 0x01, 0x20, 0x00, 0x24, 0x07, 0xC4, 0x81, 0x86, 0x90, 0x40,
  0x54, 0x10, 0x04, 0x82, 0x00, 0x90, 0x40, 0x12, 0x10, 0x02, 0x82, 0x00,
  0x50, 0x40, 0x0A, 0x08, 0x02, 0x41, 0x00, 0x48, 0x20, 0x09, 0x04, 0x01,
  0x20, 0x80, 0x64, 0x10, 0x14, 0x81, 0x05, 0x10, 0x1F, 0x22, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x04, 0x80, 0x00, 0x11,
  0x00, 0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x10, 0x40, 0x00, 0x41, 0x00,
  0x02, 0x04, 0x00, 0x08, 0x08, 0x00, 0x40, 0x20, 0x01, 0x00, 0x80, 0x08,
  0x02, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x20, 0x01,
  0x00, 0xFF, 0xFC, 0x04, 0x00, 0x10, 0x10, 0x00, 0x40, 0x80, 0x01, 0x02,
  0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x22, 0x00, 0x00, 0x88, 0x00,
  0x02, 0x40, 0x00, 0x0B, 0x00, 0x00, 0x10, 0x0F, 0xFF, 0x00, 0x80, 0x0C,
  0x08, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x10, 0x80, 0x01, 0x10, 0x00,
  0x11, 0x00, 0x01, 0x10, 0x00, 0x11, 0x00, 0x02, 0x10, 0x00, 0x21, 0x00,
  0x06, 0x20, 0x00, 0x42, 0x00, 0x18, 0x3F, 0xFE, 0x02, 0x00, 0x18, 0x20,
  0x00, 0xC2, 0x00, 0x04, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x24,
  0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x80, 0x00, 0x48, 0x00, 0x04,
  0x80, 0x00, 0x88, 0x00, 0x18, 0x80, 0x07, 0x0F, 0xFF, 0x80, 0x00, 0x7E,
  0x00, 0x18, 0x18, 0x03, 0x00, 0x40, 0x40, 0x02, 0x08, 0x00, 0x21, 0x00,
  0x01, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x08, 0x80, 0x00,
  0x84, 0x00, 0x10, 0x40, 0x02, 0x02, 0x00, 0x40, 0x18, 0x18, 0x00, 0x7E,
  0x00, 0x07, 0xFE, 0x00, 0x20, 0x0C, 0x02, 0x00, 0x10, 0x10, 0x00, 0x40,
  0x80, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x01, 0x10, 0x00,
  0x08, 0x80, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x00, 0x88,
  0x00, 0x04, 0x80, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x00,
  0x88, 0x00, 0x04, 0x80, 0x00, 0x24, 0x00, 0x02, 0x20, 0x00, 0x11, 0x00,
  0x01, 0x88, 0x00, 0x08, 0x40, 0x00, 0xC4, 0x00, 0x04, 0x20, 0x00, 0x41,
  0x00, 0x0C, 0x08, 0x01, 0xC0, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF,
  0xFE, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0xFE,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x18, 0x18, 0x02,
  0x00, 0x40, 0x40, 0x02, 0x08, 0x00, 0x21, 0x00, 0x01, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x3F,
  0xC8, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00,
  0x04, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x00, 0x84, 0x00, 0x18, 0x40,
  0x02, 0x82, 0x00, 0x48, 0x18, 0x19, 0x00, 0x7E, 0x10, 0x04, 0x00, 0x02,
  0x08, 0x00, 0x08, 0x10, 0x00, 0x10, 0x20, 0x00, 0x20, 0x40, 0x00, 0x41,
  0x00, 0x00, 0x82, 0x00, 0x01, 0x04, 0x00, 0x04, 0x08, 0x00, 0x08, 0x10,
  0x00, 0x10, 0x20, 0x00, 0x20, 0x80, 0x00, 0x41, 0x00, 0x00, 0x82, 0x00,
  0x02, 0x07, 0xFF, 0xFC, 0x08, 0x00, 0x08, 0x10, 0x00, 0x10, 0x40, 0x00,
  0x20, 0x80, 0x00, 0x41, 0x00, 0x01, 0x02, 0x00, 0x02, 0x04, 0x00, 0x04,
  0x08, 0x00, 0x08, 0x20, 0x00, 0x10, 0x40, 0x00, 0x20, 0x80, 0x00, 0x41,
  0x00, 0x01, 0x02, 0x00, 0x02, 0x04, 0x00, 0x04, 0x10, 0x00, 0x08, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x80, 0x03, 0x08, 0x00, 0x20, 0x40, 0x04, 0x06, 0x00,
  0xC0, 0x30, 0x30, 0x00, 0xFC, 0x00, 0x04, 0x00, 0x03, 0x04, 0x00, 0x04,
  0x08, 0x00, 0x08, 0x08, 0x00, 0x10, 0x08, 0x00, 0x20, 0x08, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x10, 0x06, 0x00, 0x10, 0x08, 0x00,
  0x10, 0x10, 0x00, 0x10, 0x20, 0x00, 0x10, 0x40, 0x00, 0x20, 0xC0, 0x00,
  0x21, 0x20, 0x00, 0x22, 0x20, 0x00, 0x24, 0x10, 0x00, 0x28, 0x10, 0x00,
  0x30, 0x08, 0x00, 0x20, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x40, 0x02, 0x00, 0x40, 0x01, 0x00, 0x40, 0x01, 0x00,
  0x80, 0x00, 0x80, 0x80, 0x00, 0x80, 0x80, 0x00, 0x40, 0x80, 0x00, 0x60,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x07, 0xFF, 0xFC, 0x04, 0x00, 0x02, 0x14, 0x00, 0x0C, 0x28, 0x00,
  0x28, 0x50, 0x00, 0x90, 0xA0, 0x01, 0x21, 0x20, 0x04, 0x82, 0x40, 0x09,
  0x08, 0x80, 0x22, 0x10, 0x80, 0x84, 0x21, 0x01, 0x08, 0x42, 0x04, 0x10,
  0x84, 0x08, 0x41, 0x04, 0x20, 0x84, 0x08, 0x81, 0x08, 0x11, 0x02, 0x10,
  0x14, 0x04, 0x20, 0x30, 0x08, 0x40, 0x60, 0x20, 0x80, 0x80, 0x42, 0x00,
  0x00, 0x84, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00,
  0x10, 0x40, 0x00, 0x21, 0x00, 0x00, 0x42, 0x00, 0x00, 0x84, 0x00, 0x01,
  0x08, 0x00, 0x02, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x02, 0x0C, 0x00,
  0x08, 0x14, 0x00, 0x10, 0x28, 0x00, 0x20, 0x50, 0x00, 0x41, 0x10, 0x00,
  0x82, 0x20, 0x01, 0x04, 0x40, 0x04, 0x08, 0x40, 0x08, 0x10, 0x80, 0x10,
  0x21, 0x00, 0x20, 0x81, 0x00, 0x41, 0x02, 0x00, 0x82, 0x04, 0x02, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x08, 0x10, 0x40, 0x10, 0x20, 0x80,
  0x20, 0x41, 0x00, 0x21, 0x02, 0x00, 0x42, 0x04, 0x00, 0x84, 0x08, 0x00,
  0x88, 0x20, 0x01, 0x10, 0x40, 0x02, 0x20, 0x80, 0x02, 0x41, 0x00, 0x05,
  0x02, 0x00, 0x0A, 0x04, 0x00, 0x0C, 0x10, 0x00, 0x18, 0x00, 0x00, 0x7F,
  0x00, 0x0E, 0x06, 0x00, 0xC0, 0x18, 0x08, 0x00, 0x40, 0xC0, 0x01, 0x04,
  0x00, 0x08, 0x40, 0x00, 0x42, 0x00, 0x01, 0x20, 0x00, 0x09, 0x00, 0x00,
  0x48, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x09, 0x00,
  0x00, 0x48, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x05,
  0x00, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x01, 0x10, 0x00,
  0x08, 0x40, 0x00, 0x82, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0x40, 0x0C, 0x01,
  0x81, 0xC0, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x10, 0x01, 0x80, 0x80,
  0x01, 0x02, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x10, 0x80, 0x00,
  0x44, 0x00, 0x01, 0x10, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x00, 0x84,
  0x00, 0x06, 0x10, 0x00, 0x10, 0x80, 0x00, 0x82, 0x00, 0x0C, 0x0F, 0xFF,
  0xC0, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0E, 0x06, 0x00, 0xC0, 0x18,
  0x08, 0x00, 0x40, 0xC0, 0x01, 0x04, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00,
  0x01, 0x20, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x02, 0x80, 0x00, 0x14,
  0x00, 0x00, 0xA0, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x02, 0x80, 0x00,
  0x14, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x48, 0x00, 0x02, 0x40,
  0x00, 0x12, 0x00, 0x01, 0x10, 0x00, 0x08, 0x40, 0x00, 0x82, 0x00, 0x0C,
  0x18, 0x00, 0xC0, 0x40, 0x0C, 0x01, 0x81, 0xC0, 0x03, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x20, 0x01, 0x06, 0x00, 0x04, 0x60,
  0x00, 0x14, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x10, 0x01, 0x80,
  0x80, 0x01, 0x02, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x10, 0x80,
  0x00, 0x44, 0x00, 0x01, 0x10, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x00,
  0x84, 0x00, 0x06, 0x10, 0x00, 0x10, 0x80, 0x00, 0x82, 0x00, 0x0C, 0x0F,
  0xFF, 0xC0, 0x20, 0x20, 0x00, 0x80, 0x40, 0x02, 0x01, 0x00, 0x08, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x04, 0x00, 0x40, 0x10, 0x01, 0x80,
  0x40, 0x02, 0x01, 0x00, 0x08, 0x08, 0x00, 0x10, 0x20, 0x00, 0x40, 0x80,
  0x00, 0x82, 0x00, 0x03, 0x00, 0x00, 0x7F, 0x80, 0x06, 0x01, 0xC0, 0x60,
  0x01, 0x81, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x22, 0x00, 0x00, 0x84, 0x00, 0x04, 0x08, 0x00, 0x20, 0x1C, 0x03,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x08, 0x80, 0x00, 0x84, 0x00, 0x04, 0x20,
  0x00, 0x21, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x04,
  0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00,
  0x02, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0x44,
  0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00,
  0x42, 0x00, 0x02, 0x10, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x18, 0x20,
  0x00, 0x80, 0x80, 0x08, 0x03, 0x01, 0x80, 0x07, 0xF0, 0x00, 0xC0, 0x00,
  0x0D, 0x00, 0x00, 0x24, 0x00, 0x01, 0x10, 0x00, 0x04, 0x40, 0x00, 0x21,
  0x00, 0x00, 0x82, 0x00, 0x04, 0x08, 0x00, 0x10, 0x20, 0x00, 0x80, 0x80,
  0x02, 0x02, 0x00, 0x10, 0x08, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x40, 0x04, 0x01, 0x00, 0x10, 0x08, 0x00, 0x40, 0x20, 0x01,
  0x01, 0x00, 0x02, 0x04, 0x00, 0x08, 0x20, 0x00, 0x20, 0x80, 0x00, 0x84,
  0x00, 0x02, 0x10, 0x00, 0x08, 0x80, 0x00, 0x12, 0x00, 0x00, 0x50, 0x00,
  0x01, 0x40, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x05,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x50, 0x00, 0x01, 0x40, 0x00, 0x09, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x90, 0x00, 0x04, 0x40, 0x00, 0x11, 0x00, 0x80,
  0x44, 0x06, 0x01, 0x10, 0x18, 0x08, 0x40, 0x90, 0x21, 0x02, 0x40, 0x84,
  0x11, 0x02, 0x20, 0x44, 0x10, 0x82, 0x10, 0x42, 0x08, 0x41, 0x08, 0x21,
  0x04, 0x21, 0x04, 0x20, 0x84, 0x08, 0x82, 0x20, 0x22, 0x08, 0x80, 0x88,
  0x24, 0x02, 0x40, 0x90, 0x09, 0x02, 0x80, 0x24, 0x0A, 0x00, 0xA0, 0x30,
  0x02, 0x80, 0xC0, 0x06, 0x02, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x10, 0x04, 0x00, 0x04, 0x00, 0xC0, 0x01, 0x80, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x08, 0x00, 0x10, 0x02, 0x00, 0x02, 0x00, 0x80, 0x00,
  0x20, 0x20, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x41, 0x00, 0x00, 0x0C, 0x40,
  0x00, 0x00, 0x90, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x84, 0x00,
  0x00, 0x20, 0x40, 0x00, 0x08, 0x08, 0x00, 0x03, 0x00, 0x80, 0x00, 0x40,
  0x10, 0x00, 0x10, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x02, 0x00,
  0x40, 0x00, 0x40, 0x18, 0x00, 0x04, 0x02, 0x00, 0x00, 0x81, 0x80, 0x00,
  0x08, 0x00, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20,
  0x00, 0x08, 0x10, 0x00, 0x10, 0x10, 0x00, 0x20, 0x08, 0x00, 0x40, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x80, 0x04, 0x01, 0x00, 0x02, 0x02, 0x00, 0x02,
  0x04, 0x00, 0x02, 0x08, 0x00, 0x01, 0x18, 0x00, 0x01, 0x10, 0x00, 0x00,
  0xA0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xFF, 0xC0, 0x80, 0x40, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x02,
  0x01, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x03, 0xFF, 0x80, 0x00,
  0x18, 0x00, 0x05, 0x00, 0x00, 0x90, 0x00, 0x22, 0x00, 0x08, 0x40, 0x02,
  0x04, 0x00, 0x40, 0x80, 0x10, 0x08, 0x04, 0x01, 0x01, 0x00, 0x10, 0x20,
  0x02, 0x08, 0x00, 0x22, 0x00, 0x04, 0x80, 0x00, 0xB0, 0x00, 0x0C, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0xC2, 0x08, 0x41, 0x08, 0x20, 0x01, 0xFC, 0x20,
  0xE0, 0x64, 0x30, 0x06, 0x8C, 0x00, 0x53, 0x00, 0x06, 0x40, 0x00, 0x90,
  0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x58, 0x00, 0x0A, 0x00, 0x01, 0x40,
  0x00, 0x48, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x0C, 0x80,
  0x01, 0x88, 0x00, 0x61, 0x00, 0x14, 0x10, 0x04, 0x81, 0x83, 0x10, 0x0F,
  0x83, 0xC0, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x7E, 0x00, 0x98, 0x18, 0x0B, 0x00, 0x41, 0xC0,
  0x02, 0x14, 0x00, 0x21, 0x80, 0x02, 0x10, 0x00, 0x11, 0x00, 0x01, 0x10,
  0x00, 0x12, 0x00, 0x01, 0x20, 0x00, 0x12, 0x00, 0x02, 0x20, 0x00, 0x22,
  0x00, 0x02, 0x20, 0x00, 0x24, 0x00, 0x04, 0x40, 0x00, 0x46, 0x00, 0x08,
  0x60, 0x01, 0x85, 0x00, 0x30, 0x4C, 0x0C, 0x08, 0x3F, 0x00, 0x01, 0xF8,
  0x03, 0x03, 0x02, 0x00, 0x42, 0x00, 0x12, 0x00, 0x0A, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x40, 0x01,
  0x10, 0x01, 0x0C, 0x01, 0x03, 0x83, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x7F, 0x08, 0x0E, 0x06, 0x40, 0xC0, 0x1A, 0x0C, 0x00, 0x50, 0xC0, 0x01,
  0x84, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x11, 0x80,
  0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x10,
  0x80, 0x00, 0x84, 0x00, 0x0C, 0x20, 0x00, 0x60, 0x80, 0x06, 0x04, 0x00,
  0x50, 0x10, 0x06, 0x80, 0x60, 0xC4, 0x00, 0xFC, 0x20, 0x00, 0xFC, 0x01,
  0xC0, 0xC0, 0xC0, 0x08, 0x40, 0x02, 0x20, 0x00, 0x50, 0x00, 0x14, 0x00,
  0x0A, 0x00, 0x02, 0x80, 0x01, 0x20, 0x03, 0x88, 0x0F, 0x03, 0xFC, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x02, 0x80, 0x01, 0x20,
  0x00, 0x44, 0x00, 0x21, 0x80, 0x10, 0x18, 0x18, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x80, 0x20, 0x00, 0x20, 0x08,
  0x00, 0x06, 0x02, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x18, 0x20, 0x00, 0x03,
  0x10, 0x00, 0x00, 0x24, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x10, 0x18, 0x11, 0x06, 0x00, 0xD0, 0xC0, 0x05, 0x08,
  0x00, 0x31, 0x00, 0x02, 0x10, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x22,
  0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x04,
  0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0xC4, 0x00, 0x18, 0x20, 0x01,
  0x82, 0x00, 0x28, 0x10, 0x04, 0x80, 0xC1, 0x88, 0x03, 0xE0, 0x80, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x08, 0x00, 0x20, 0x40,
  0x0C, 0x03, 0x03, 0x80, 0x0F, 0xE0, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x1F, 0x02, 0x30, 0x61, 0x20, 0x18, 0xA0,
  0x04, 0x60, 0x02, 0x60, 0x01, 0x30, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24,
  0x00, 0x12, 0x00, 0x0B, 0x00, 0x05, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01,
  0x20, 0x00, 0x90, 0x00, 0x50, 0x00, 0x28, 0x00, 0x24, 0x00, 0x12, 0x00,
  0x09, 0x00, 0x04, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0xC0,
  0x80, 0xC0, 0x20, 0x40, 0x10, 0x60, 0x04, 0x20, 0x01, 0x30, 0x00, 0x50,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x80,
  0x20, 0x60, 0x10, 0x18, 0x08, 0x06, 0x04, 0x00, 0x82, 0x00, 0x21, 0x00,
  0x09, 0x00, 0x02, 0x80, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x83,
  0xF0, 0x02, 0x30, 0x20, 0x0B, 0x00, 0x40, 0x70, 0x00, 0x81, 0x40, 0x02,
  0x06, 0x00, 0x08, 0x10, 0x00, 0x40, 0x40, 0x01, 0x01, 0x00, 0x08, 0x08,
  0x00, 0xC0, 0x20, 0x0C, 0x00, 0x81, 0xC0, 0x02, 0x18, 0x00, 0x08, 0x20,
  0x00, 0x20, 0x80, 0x09, 0x01, 0x00, 0x34, 0x02, 0x01, 0x10, 0x08, 0x08,
  0x40, 0x10, 0xC1, 0x00, 0x46, 0x04, 0x00, 0xB0, 0x20, 0x01, 0x00, 0xFF,
  0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x01, 0x04,
  0x03, 0x08, 0x04, 0x08, 0x18, 0x08, 0x20, 0x08, 0xC0, 0x09, 0x00, 0x16,
  0x00, 0x18, 0x00, 0x11, 0xE0, 0xF8, 0x48, 0x44, 0x31, 0x40, 0xA0, 0x46,
  0x03, 0x01, 0x10, 0x0C, 0x04, 0x40, 0x20, 0x12, 0x00, 0x80, 0x48, 0x02,
  0x01, 0x20, 0x10, 0x04, 0x80, 0x40, 0x12, 0x01, 0x00, 0x88, 0x04, 0x02,
  0x40, 0x10, 0x09, 0x00, 0x40, 0x24, 0x02, 0x00, 0x90, 0x08, 0x02, 0x40,
  0x20, 0x12, 0x00, 0x80, 0x48, 0x02, 0x01, 0x20, 0x10, 0x04, 0x80, 0x40,
  0x12, 0x01, 0x00, 0x80, 0x10, 0x7C, 0x08, 0xC1, 0x84, 0x80, 0x62, 0x80,
  0x11, 0x80, 0x08, 0x80, 0x04, 0xC0, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90,
  0x00, 0x48, 0x00, 0x24, 0x00, 0x14, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04,
  0x80, 0x02, 0x40, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x90, 0x00, 0x48, 0x00,
  0x24, 0x00, 0x10, 0x01, 0xFC, 0x01, 0x81, 0x80, 0x80, 0x10, 0x40, 0x02,
  0x20, 0x00, 0x50, 0x00, 0x14, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0A, 0x00, 0x02, 0x80, 0x01, 0x20, 0x00, 0x44, 0x00, 0x21, 0x80, 0x10,
  0x30, 0x18, 0x03, 0xF8, 0x00, 0x04, 0x3F, 0x00, 0x26, 0x06, 0x01, 0x60,
  0x08, 0x0C, 0x00, 0x20, 0xA0, 0x01, 0x06, 0x00, 0x08, 0x20, 0x00, 0x21,
  0x00, 0x01, 0x08, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00,
  0x21, 0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0x44, 0x00, 0x04, 0x20,
  0x00, 0x21, 0x80, 0x02, 0x0C, 0x00, 0x30, 0x50, 0x03, 0x02, 0x60, 0x60,
  0x20, 0xFC, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x20, 0xE0, 0x64, 0x30, 0x06, 0x8C, 0x00,
  0x53, 0x00, 0x06, 0x40, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00,
  0x58, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x48, 0x00, 0x09, 0x00, 0x01,
  0x20, 0x00, 0x24, 0x00, 0x0C, 0x80, 0x01, 0x88, 0x00, 0x61, 0x00, 0x14,
  0x10, 0x04, 0x81, 0x83, 0x10, 0x0F, 0x82, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x01, 0x00, 0xFF, 0x8F, 0xF8, 0x05, 0xC0, 0x00, 0x58,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x60, 0x18, 0x08, 0x00, 0x61, 0x00,
  0x03, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x48, 0x00, 0x04,
  0x80, 0x00, 0xC6, 0x00, 0x18, 0x18, 0x07, 0x00, 0x7F, 0x80, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xF8, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x01, 0x80, 0x40,
  0x18, 0x02, 0x03, 0x00, 0x10, 0x60, 0x00, 0x84, 0x00, 0x04, 0xC0, 0x00,
  0x58, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x44, 0x00, 0x12, 0x00, 0x04,
  0x80, 0x02, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00, 0x08, 0x80, 0x02, 0x40,
  0x00, 0x90, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00,
  0x48, 0x00, 0x32, 0x00, 0x08, 0x80, 0x06, 0x20, 0x02, 0x84, 0x00, 0xA1,
  0x00, 0x48, 0x30, 0x62, 0x03, 0xE1, 0x00, 0xFC, 0x00, 0x40, 0x80, 0x08,
  0x10, 0x00, 0x82, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08,
  0x40, 0x01, 0x08, 0x00, 0x41, 0x00, 0x08, 0x20, 0x01, 0x08, 0x00, 0x21,
  0x00, 0x08, 0x20, 0x01, 0x04, 0x00, 0x40, 0x80, 0x10, 0x10, 0x06, 0x02,
  0x01, 0x80, 0x80, 0x60, 0x10, 0x30, 0x02, 0x1C, 0x00, 0x7C, 0x00, 0x00,
  0x10, 0x08, 0x10, 0x80, 0x40, 0x44, 0x02, 0x02, 0x40, 0x20, 0x12, 0x01,
  0x00, 0x90, 0x08, 0x04, 0x80, 0x40, 0x24, 0x02, 0x01, 0x40, 0x10, 0x0A,
  0x01, 0x00, 0x50, 0x08, 0x02, 0x80, 0x40, 0x14, 0x02, 0x00, 0xA0, 0x10,
  0x06, 0x00, 0x80, 0x30, 0x08, 0x02, 0x80, 0x40, 0x14, 0x02, 0x01, 0x20,
  0x30, 0x09, 0x02, 0x40, 0x84, 0x23, 0x18, 0x1E, 0x0F, 0x80, 0x00, 0xC0,
  0x3C, 0x03, 0x20, 0xC2, 0x0C, 0x31, 0x01, 0x30, 0x11, 0x01, 0x40, 0x12,
  0x01, 0x00, 0x14, 0x01, 0x00, 0x0C, 0x01, 0x00, 0x0C, 0x01, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x80, 0x10, 0x00, 0x80, 0x30, 0x00, 0x80, 0x28,
  0x00, 0x80, 0x48, 0x02, 0x80, 0xC8, 0x0C, 0xC0, 0x84, 0x30, 0x43, 0x04,
  0xC0, 0x3C, 0x03, 0x00, 0x04, 0x00, 0x10, 0x40, 0x01, 0x08, 0x00, 0x10,
  0x80, 0x02, 0x08, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x20, 0x80, 0x02,
  0x10, 0x00, 0x21, 0x00, 0x04, 0x10, 0x00, 0x41, 0x00, 0x04, 0x10, 0x00,
  0x41, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x08, 0x20, 0x00, 0x82, 0x00,
  0x18, 0x20, 0x02, 0x81, 0x00, 0x28, 0x10, 0x04, 0x80, 0xC1, 0x90, 0x07,
  0xE1, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x08,
  0x00, 0x40, 0xC0, 0x0C, 0x06, 0x03, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x08, 0x60, 0x78, 0x42, 0x00, 0x7A, 0x20, 0x00, 0x71, 0x00, 0x03, 0x08,
  0x00, 0x20, 0x40, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x01, 0x01, 0x80, 0x08, 0x10, 0x00, 0x41, 0x00, 0x02, 0x1C, 0x00, 0x10,
  0xFF, 0x80, 0x48, 0x0F, 0xE2, 0x40, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x7F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x03, 0xFE, 0x00, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x10, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0xF0, 0x03, 0x80, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x3F, 0xE0,
  0x00, 0x07, 0x80, 0x04, 0x23, 0x00, 0x11, 0x06, 0x00, 0x88, 0x0C, 0x02,
  0x40, 0x10, 0x11, 0x00, 0x20, 0x44, 0x00, 0x46, 0x20, 0x00, 0xF0,
};

const GFXglyph IBMPlexMono_ThinItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 7, 30, 26, 10, -30 },
  { 28, 9, 11, 26, 11, -32 },
  { 41, 25, 30, 26, 1, -30 },
  { 135, 22, 38, 26, 2, -34 },
  { 240, 29, 30, 26, -1, -30 },
  { 349, 24, 30, 26, 1, -30 },
  { 439, 3, 11, 26, 14, -32 },
  { 444, 13, 39, 26, 10, -33 },
  { 508, 13, 39, 26, 3, -33 },
  { 572, 22, 21, 26, 3, -24 },
  { 630, 21, 21, 26, 3, -24 },
  { 686, 6, 10, 26, 7, -3 },
  { 694, 12, 1, 26, 7, -14 },
  { 696, 3, 3, 26, 10, -3 },
  { 698, 23, 39, 26, 2, -33 },
  { 811, 21, 30, 26, 3, -30 },
  { 890, 20, 30, 26, 2, -30 },
  { 965, 21, 30, 26, 2, -30 },
  { 1044, 21, 30, 26, 2, -30 },
  { 1123, 22, 30, 26, 1, -30 },
  { 1206, 21, 30, 26, 3, -30 },
  { 1285, 19, 30, 26, 3, -30 },
  { 1357, 20, 30, 26, 5, -30 },
  { 1432, 21, 30, 26, 3, -30 },
  { 1511, 18, 30, 26, 5, -30 },
  { 1579, 6, 23, 26, 10, -23 },
  { 1597, 9, 30, 26, 7, -23 },
  { 1631, 20, 23, 26, 4, -25 },
  { 1689, 22, 8, 26, 2, -17 },
  { 1711, 21, 23, 26, 2, -25 },
  { 1772, 16, 30, 26, 7, -30 },
  { 1832, 19, 35, 26, 4, -30 },
  { 1916, 22, 30, 26, 0, -30 },
  { 1999, 20, 30, 26, 3, -30 },
  { 2074, 20, 30, 26, 4, -30 },
  { 2149, 21, 30, 26, 3, -30 },
  { 2228, 22, 30, 26, 3, -30 },
  { 2311, 22, 30, 26, 3, -30 },
  { 2394, 20, 30, 26, 4, -30 },
  { 2469, 23, 30, 26, 2, -30 },
  { 2556, 23, 30, 26, 2, -30 },
  { 2643, 20, 30, 26, 3, -30 },
  { 2718, 24, 30, 26, 3, -30 },
  { 2808, 17, 30, 26, 4, -30 },
  { 2872, 23, 30, 26, 2, -30 },
  { 2959, 23, 30, 26, 2, -30 },
  { 3046, 21, 30, 26, 3, -30 },
  { 3125, 22, 30, 26, 3, -30 },
  { 3208, 21, 37, 26, 3, -30 },
  { 3306, 22, 30, 26, 3, -30 },
  { 3389, 22, 30, 26, 2, -30 },
  { 3472, 22, 30, 26, 5, -30 },
  { 3555, 21, 30, 26, 4, -30 },
  { 3634, 22, 30, 26, 5, -30 },
  { 3717, 22, 30, 26, 4, -30 },
  { 3800, 27, 30, 26, 0, -30 },
  { 3902, 24, 30, 26, 4, -30 },
  { 3992, 26, 30, 26, 0, -30 },
  { 4090, 16, 39, 26, 9, -33 },
  { 4168, 9, 39, 26, 9, -33 },
  { 4212, 17, 39, 26, 1, -33 },
  { 4295, 19, 16, 26, 4, -30 },
  { 4333, 21, 1, 26, 0, 5 },
  { 4336, 5, 7, 26, 10, -33 },
  { 4341, 19, 22, 26, 3, -22 },
  { 4394, 20, 32, 26, 3, -32 },
  { 4474, 17, 22, 26, 4, -22 },
  { 4521, 21, 32, 26, 3, -32 },
  { 4605, 18, 22, 26, 4, -22 },
  { 4655, 26, 41, 26, 0, -32 },
  { 4789, 20, 31, 26, 2, -22 },
  { 4867, 17, 32, 26, 4, -32 },
  { 4935, 18, 32, 26, 4, -32 },
  { 5007, 17, 41, 26, 5, -32 },
  { 5095, 22, 32, 26, 3, -32 },
  { 5183, 16, 32, 26, 5, -32 },
  { 5247, 22, 22, 26, 2, -22 },
  { 5308, 17, 22, 26, 4, -22 },
  { 5355, 18, 22, 26, 4, -22 },
  { 5405, 21, 31, 26, 2, -22 },
  { 5487, 19, 31, 26, 3, -22 },
  { 5561, 21, 22, 26, 5, -22 },
  { 5619, 20, 22, 26, 3, -22 },
  { 5674, 21, 30, 26, 3, -30 },
  { 5753, 18, 22, 26, 4, -22 },
  { 5803, 19, 22, 26, 4, -22 },
  { 5856, 21, 22, 26, 3, -22 },
  { 5914, 24, 22, 26, 1, -22 },
  { 5980, 20, 31, 26, 2, -22 },
  { 6058, 21, 22, 26, 2, -22 },
  { 6116, 19, 39, 26, 5, -33 },
  { 6209, 7, 39, 26, 10, -33 },
  { 6244, 19, 39, 26, 2, -33 },
  { 6337, 22, 8, 26, 2, -17 },
};

const GFXfont IBMPlexMono_ThinItalic43pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic43pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic43pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _IBMPLEXMONO_THINITALIC43PT7B_H_
