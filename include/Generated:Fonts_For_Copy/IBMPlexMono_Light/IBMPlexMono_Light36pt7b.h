#ifndef _IBMPLEXMONO_LIGHT36PT7B_H_
#define _IBMPLEXMONO_LIGHT36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light36pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x44, 0x40, 0x00, 0x0E,
  0xFF, 0xE0, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x00, 0xC3, 0x00, 0x08, 0x30, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01, 0x86,
  0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x30, 0x60, 0x7F, 0x07, 0xF7, 0xF0,
  0x7F, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x06,
  0x0C, 0x0F, 0xE0, 0xFE, 0xFE, 0x1F, 0xE0, 0x61, 0x80, 0x04, 0x18, 0x00,
  0xC1, 0x80, 0x0C, 0x18, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00,
  0x18, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x07, 0xF8, 0x07, 0xFF, 0x83, 0xCC, 0xF1, 0xC3, 0x0E, 0x60, 0xC1, 0x98,
  0x30, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x1C, 0x30, 0x03, 0xCC,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x0C, 0x78, 0x03, 0x06,
  0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x1D, 0x03, 0x06, 0xE0, 0xC1, 0x9C,
  0x30, 0xE3, 0xCC, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x37, 0xF8, 0x06, 0x61,
  0xC0, 0x4C, 0x0C, 0x0C, 0xC0, 0xC1, 0x8C, 0x04, 0x18, 0xC0, 0x43, 0x0C,
  0x0C, 0x30, 0xC0, 0xC6, 0x06, 0x1C, 0x60, 0x7F, 0x8C, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x03, 0x1F, 0xC0, 0x63, 0x8E, 0x04, 0x20,
  0x60, 0xC6, 0x03, 0x18, 0x60, 0x31, 0x86, 0x03, 0x30, 0x60, 0x33, 0x03,
  0x06, 0x60, 0x38, 0xE6, 0x01, 0xFC, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xFF, 0x00, 0x70, 0x70, 0x0C, 0x06, 0x01, 0x80, 0x80, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x81, 0xF1, 0xF8, 0x3E, 0x73, 0x06, 0x18, 0x30, 0xC3, 0x07, 0x18, 0xC0,
  0x73, 0x18, 0x07, 0x63, 0x00, 0x78, 0x60, 0x07, 0x0E, 0x00, 0x60, 0xC0,
  0x16, 0x1E, 0x0E, 0x61, 0xFF, 0x8E, 0x0F, 0xC0, 0xE0, 0xFF, 0xFF, 0xF0,
  0x01, 0x81, 0x81, 0x81, 0x81, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x10,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x02,
  0x01, 0x80, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0xE0, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x00,
  0x60, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x60, 0x10, 0x0C,
  0x06, 0x03, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x0C, 0x1F, 0xE3, 0x3F, 0x1F, 0xFE,
  0x00, 0xFC, 0x00, 0x1E, 0x00, 0x0D, 0x80, 0x07, 0x30, 0x01, 0x86, 0x00,
  0xC1, 0xC0, 0x70, 0x30, 0x18, 0x06, 0x0C, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x7B, 0xDC, 0xE6, 0x33, 0x98, 0xC6, 0x00, 0xFF, 0xFF, 0xF0, 0xEF, 0xFE,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00,
  0x03, 0xF0, 0x07, 0xFE, 0x07, 0x07, 0x87, 0x00, 0xC3, 0x00, 0x33, 0x00,
  0x19, 0x80, 0x0E, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x38, 0x3E, 0x1E, 0x1F, 0x0E, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0xEC, 0x00, 0x63, 0x00, 0x31, 0xC0, 0x30, 0x70,
  0x78, 0x1F, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x76,
  0x00, 0x39, 0x80, 0x1C, 0x60, 0x0E, 0x18, 0x07, 0x06, 0x03, 0x81, 0x80,
  0x40, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x01, 0xFF, 0xFF,
  0x7F, 0xFF, 0xC0, 0x0F, 0xE0, 0x1F, 0xF8, 0x78, 0x3C, 0x60, 0x0C, 0xE0,
  0x0E, 0xC0, 0x06, 0x40, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x1F, 0xF8, 0x3C, 0x1E, 0x70,
  0x0E, 0x60, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x1C, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x07, 0x60,
  0x06, 0x78, 0x1E, 0x1F, 0xFC, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1B, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x31, 0x80,
  0x0C, 0x30, 0x01, 0x86, 0x00, 0x60, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00,
  0xC0, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x81, 0x80, 0x30, 0x60, 0x06, 0x0C,
  0x00, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x3F, 0xFE, 0x7F, 0xFE, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x67, 0xE0, 0x6F, 0xF8, 0x78, 0x3C, 0x60, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0xC0,
  0x06, 0xE0, 0x0E, 0x78, 0x3C, 0x3F, 0xF8, 0x0F, 0xE0, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x63, 0xE0, 0xEF, 0xF8, 0xD8, 0x1C, 0xE0, 0x0E, 0xE0,
  0x06, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xE0, 0x06, 0x60, 0x0E, 0x38, 0x1C, 0x1F, 0xF8, 0x07, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x80, 0x06, 0x80, 0x06, 0x80, 0x0C, 0x80,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0x03, 0x86, 0x00, 0xE7, 0x00, 0x33,
  0x00, 0x1D, 0x80, 0x0E, 0xC0, 0x06, 0x70, 0x03, 0x18, 0x03, 0x87, 0x03,
  0x81, 0xFF, 0x00, 0xFF, 0x81, 0xE0, 0x71, 0xC0, 0x0C, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x36, 0x00, 0x1B, 0x80, 0x1C,
  0xF0, 0x3C, 0x3F, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x38,
  0x1C, 0x70, 0x0E, 0xE0, 0x06, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0x70, 0x0B, 0x78, 0x1E, 0x3F,
  0xF6, 0x0F, 0xC6, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0xEF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xE0, 0x73, 0xDE, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x7B, 0x9C, 0xC6, 0x73, 0x18, 0xC0, 0x00,
  0x01, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x80, 0x00,
  0x07, 0xE0, 0x3F, 0xF0, 0xE0, 0x73, 0x80, 0x76, 0x00, 0x78, 0x00, 0xD0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70, 0x0F, 0x80, 0x3C,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0xE0, 0x3F, 0xF0, 0xE0, 0xF1, 0x80, 0x66, 0x00, 0x6C, 0x00, 0xF0, 0x01,
  0xE0, 0x79, 0xC3, 0xFB, 0x86, 0x17, 0x18, 0x1E, 0x30, 0x1C, 0x60, 0x38,
  0xC0, 0x71, 0x80, 0xE3, 0x01, 0xC6, 0x03, 0x8C, 0x07, 0x18, 0x1E, 0x18,
  0x3C, 0x3F, 0xB8, 0x3E, 0x70, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xD8, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0xC6, 0x00, 0x18,
  0xE0, 0x03, 0x0C, 0x00, 0xE1, 0x80, 0x18, 0x38, 0x03, 0x03, 0x00, 0xE0,
  0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0xE0, 0x18, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0xE0, 0x06, 0x1C, 0x00, 0xC3, 0x00, 0x1C, 0x60, 0x01, 0x9C, 0x00,
  0x33, 0x00, 0x07, 0xE0, 0x00, 0x60, 0xFF, 0xF0, 0xFF, 0xF8, 0xC0, 0x1C,
  0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x0C, 0xC0, 0x1C, 0xFF, 0xF0, 0xFF, 0xF8, 0xC0, 0x0E, 0xC0, 0x06,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x06, 0xC0, 0x0E, 0xFF, 0xFC, 0xFF, 0xF0, 0x07, 0xF0, 0x1F, 0xF8,
  0x3C, 0x1C, 0x30, 0x06, 0x70, 0x07, 0x60, 0x03, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x03,
  0x70, 0x07, 0x30, 0x06, 0x3C, 0x1C, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xC1,
  0xFF, 0xE3, 0x01, 0xE6, 0x00, 0xCC, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x6C,
  0x00, 0xD8, 0x03, 0x30, 0x1E, 0x7F, 0xF8, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFE, 0xFF,
  0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x03, 0x87, 0x00, 0xE3, 0x00, 0x33,
  0x80, 0x1D, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xE0,
  0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6E, 0x00, 0x73, 0x00, 0x39, 0xC0, 0x2C,
  0x70, 0x36, 0x1F, 0xF3, 0x03, 0xE1, 0x80, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x06, 0xFF, 0xFF, 0xFF, 0xFC, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xF0, 0x03, 0xE0, 0x1D, 0x80, 0x67, 0x07, 0x8F, 0xFC, 0x0F,
  0xC0, 0xE0, 0x03, 0xF0, 0x03, 0xB8, 0x03, 0x9C, 0x01, 0x8E, 0x01, 0x87,
  0x01, 0x83, 0x81, 0xC1, 0xC1, 0xC0, 0xE1, 0xC0, 0x71, 0xC0, 0x38, 0xC0,
  0x1C, 0xF0, 0x0E, 0xD8, 0x07, 0xCE, 0x03, 0xE3, 0x81, 0xE0, 0xC0, 0xE0,
  0x70, 0x70, 0x1C, 0x38, 0x06, 0x1C, 0x03, 0x8E, 0x00, 0xC7, 0x00, 0x33,
  0x80, 0x1D, 0xC0, 0x06, 0xE0, 0x01, 0x80, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0B, 0xF0,
  0x1B, 0xD8, 0x1B, 0xD8, 0x33, 0xCC, 0x33, 0xCC, 0x23, 0xC6, 0x63, 0xC6,
  0x63, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0x83, 0xC1, 0x83, 0xC1, 0x03, 0xC1,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1E, 0xC0,
  0x3D, 0x80, 0x79, 0x80, 0xF3, 0x01, 0xE7, 0x03, 0xC6, 0x07, 0x8E, 0x0F,
  0x0C, 0x1E, 0x18, 0x3C, 0x18, 0x78, 0x30, 0xF0, 0x31, 0xE0, 0x63, 0xC0,
  0x67, 0x80, 0xCF, 0x01, 0xDE, 0x01, 0xBC, 0x03, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xC0, 0x0E, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x07, 0x87, 0x00,
  0xC3, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0E, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xEC, 0x00, 0x63, 0x00,
  0x31, 0xC0, 0x30, 0x70, 0x78, 0x1F, 0xF8, 0x03, 0xF0, 0x00, 0xFF, 0xF8,
  0xFF, 0xFC, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x0E, 0xFF, 0xFC,
  0xFF, 0xF8, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x03, 0xF0, 0x07, 0xFE, 0x07, 0x07, 0x87, 0x00, 0xC3, 0x00, 0x33, 0x00,
  0x19, 0x80, 0x0E, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0xEC, 0x00, 0x63, 0x00, 0x31, 0xC0, 0x38, 0x70,
  0x78, 0x1F, 0xF8, 0x07, 0xF0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0F, 0xE0, 0x03, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xE0, 0x0E, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x0E, 0xFF, 0xFC, 0xFF, 0xF0, 0xE0, 0xC0, 0xE0, 0xE0,
  0xE0, 0x60, 0xE0, 0x70, 0xE0, 0x30, 0xE0, 0x18, 0xE0, 0x1C, 0xE0, 0x0C,
  0xE0, 0x0E, 0xE0, 0x06, 0xE0, 0x03, 0x07, 0xF0, 0x0F, 0xFF, 0x0F, 0x03,
  0xCE, 0x00, 0x76, 0x00, 0x13, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xF8,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x68, 0x00,
  0x3E, 0x00, 0x1B, 0x80, 0x1C, 0xF0, 0x3C, 0x3F, 0xFC, 0x07, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x36, 0x00, 0x6E, 0x01, 0xCE, 0x07, 0x1F, 0xFC, 0x0F, 0xE0, 0xC0,
  0x00, 0xF0, 0x00, 0x7E, 0x00, 0x19, 0x80, 0x06, 0x60, 0x03, 0x9C, 0x00,
  0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x06, 0x0E, 0x01, 0x81, 0x80, 0x60,
  0x60, 0x30, 0x1C, 0x0C, 0x03, 0x03, 0x00, 0xC1, 0xC0, 0x38, 0x60, 0x06,
  0x18, 0x01, 0x8E, 0x00, 0x63, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xD8,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0B,
  0x07, 0x06, 0xC1, 0xC1, 0xB0, 0x78, 0x6C, 0x16, 0x19, 0x0D, 0x86, 0x63,
  0x21, 0x98, 0xCC, 0x66, 0x33, 0x19, 0x98, 0xC6, 0x66, 0x11, 0x99, 0x86,
  0x66, 0x61, 0x91, 0xB0, 0x6C, 0x6C, 0x0B, 0x1B, 0x03, 0xC2, 0xC0, 0xF0,
  0xE0, 0x3C, 0x38, 0x07, 0x00, 0x60, 0x00, 0xE6, 0x00, 0x18, 0xE0, 0x06,
  0x0C, 0x01, 0xC0, 0xC0, 0x30, 0x1C, 0x0E, 0x01, 0x81, 0x80, 0x18, 0x60,
  0x03, 0x9C, 0x00, 0x33, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x6E, 0x00, 0x1C, 0xC0, 0x03, 0x0C, 0x00, 0xC1, 0xC0,
  0x18, 0x18, 0x06, 0x03, 0x81, 0xC0, 0x30, 0x30, 0x03, 0x0C, 0x00, 0x73,
  0x80, 0x06, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0x76, 0x00, 0x06, 0x70, 0x00,
  0xC3, 0x00, 0x1C, 0x38, 0x01, 0x81, 0x80, 0x38, 0x0C, 0x03, 0x00, 0xE0,
  0x60, 0x06, 0x0E, 0x00, 0x70, 0xC0, 0x03, 0x1C, 0x00, 0x19, 0x80, 0x01,
  0xB0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xBF, 0xFF,
  0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x36, 0x00, 0x0C, 0xC0, 0x06, 0x38, 0x03, 0x86, 0x00, 0xC1,
  0xC0, 0x60, 0x30, 0x18, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x31, 0x80, 0x0E,
  0xE0, 0x01, 0xB0, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x46, 0x18,
  0xE3, 0x0C, 0x20, 0x0F, 0xC0, 0x1F, 0xF8, 0x1C, 0x0E, 0x18, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x1F, 0xFC, 0x3F, 0xFE,
  0x3C, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x71, 0x80,
  0x58, 0xE0, 0x6C, 0x3F, 0xE7, 0xC7, 0xE1, 0xE0, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC7,
  0xE1, 0x9F, 0xE3, 0x60, 0xE7, 0x00, 0xEC, 0x00, 0xD8, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0x70, 0x0E, 0xD8, 0x39, 0xBF, 0xE3, 0x1F, 0x80, 0x07,
  0xE0, 0x1F, 0xF0, 0x70, 0x71, 0x80, 0x77, 0x00, 0x6C, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x1C, 0x01, 0x98, 0x03, 0x3C, 0x1C, 0x1F, 0xF0, 0x1F, 0x80, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x07, 0xE3, 0x1F, 0xF3, 0x3C, 0x1B, 0x30, 0x07, 0x70,
  0x07, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x70, 0x07, 0x30, 0x07, 0x3C,
  0x1B, 0x1F, 0xF3, 0x07, 0xC3, 0x07, 0xE0, 0x1F, 0xF8, 0x38, 0x1C, 0x70,
  0x0C, 0x60, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x02, 0x70,
  0x06, 0x38, 0x1C, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0xFF, 0x01, 0xFF, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x80, 0x07, 0xC1, 0xFA, 0x03, 0xFF, 0x03, 0x81, 0xC1,
  0x80, 0x61, 0x80, 0x30, 0xC0, 0x1C, 0x60, 0x0E, 0x30, 0x06, 0x1C, 0x03,
  0x07, 0x03, 0x81, 0xFF, 0x80, 0x7F, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xE6, 0x00, 0x36, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xF8, 0x03, 0x9F, 0xFF, 0x83, 0xFE,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC7, 0xC3, 0x3F, 0xCD, 0x07, 0xB8, 0x06, 0xC0, 0x1F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xC0, 0x03, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xCF, 0xFE, 0x7F, 0xE0, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x0F, 0xC0, 0x1C, 0xC0, 0x38, 0xC0, 0x70, 0xC0,
  0xE0, 0xC1, 0xC0, 0xC3, 0x80, 0xC7, 0x00, 0xCF, 0x00, 0xD9, 0x80, 0xF1,
  0xC0, 0xE0, 0xE0, 0xC0, 0x70, 0xC0, 0x30, 0xC0, 0x38, 0xC0, 0x1C, 0xC0,
  0x0E, 0xC0, 0x06, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF,
  0x0F, 0x6F, 0xCF, 0xFC, 0x68, 0xFC, 0x18, 0x3C, 0x0C, 0x1E, 0x06, 0x0F,
  0x03, 0x07, 0x81, 0x83, 0xC0, 0xC1, 0xE0, 0x60, 0xF0, 0x30, 0x78, 0x18,
  0x3C, 0x0C, 0x1E, 0x06, 0x0F, 0x03, 0x07, 0x81, 0x83, 0xC0, 0xC1, 0xE0,
  0x60, 0xF0, 0x30, 0x60, 0xC7, 0xC3, 0x3F, 0xCD, 0x07, 0xB8, 0x06, 0xC0,
  0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xC0, 0x07, 0xE0, 0x1F, 0xF8, 0x38, 0x3C, 0x70, 0x0C, 0x60, 0x06,
  0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0x60, 0x06, 0x70, 0x0C, 0x38, 0x3C,
  0x1F, 0xF8, 0x07, 0xE0, 0xC7, 0xE1, 0x9F, 0xE3, 0x60, 0xE7, 0x00, 0xEC,
  0x00, 0xD8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0x70, 0x0E, 0xD8, 0x39,
  0xBF, 0xE3, 0x1F, 0x86, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0x07, 0xE3, 0x1F, 0xF3, 0x3C, 0x1B, 0x30,
  0x07, 0x70, 0x07, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x70, 0x07, 0x30,
  0x07, 0x3C, 0x1B, 0x1F, 0xF3, 0x07, 0xC3, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xFF, 0x1F, 0xFF,
  0x9F, 0xC0, 0xD8, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0x3F,
  0xFF, 0x80, 0x0F, 0xE0, 0x3F, 0xF8, 0x78, 0x1E, 0x60, 0x06, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x7E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x40, 0x03, 0xE0, 0x06, 0x78, 0x1E,
  0x3F, 0xFC, 0x0F, 0xF0, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x01, 0xF8, 0x07, 0x70, 0x6C, 0xFF, 0x31, 0xF8, 0xC0, 0xC0,
  0x03, 0xC0, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x30, 0x0C, 0x30,
  0x0C, 0x30, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x0C, 0x30, 0x0C,
  0x20, 0x04, 0x60, 0x06, 0x60, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0xC0, 0x60, 0x38, 0x1C, 0x0D, 0x03, 0xC1, 0xB0, 0x58, 0x36, 0x0B,
  0x06, 0xC3, 0x20, 0xD8, 0x64, 0x13, 0x0C, 0xC6, 0x21, 0x18, 0xC6, 0x21,
  0x18, 0xCC, 0x23, 0x19, 0x86, 0x63, 0x20, 0xC8, 0x64, 0x19, 0x05, 0x81,
  0x60, 0xB0, 0x2C, 0x1E, 0x07, 0x83, 0x80, 0xF0, 0x70, 0x1C, 0x00, 0xE0,
  0x07, 0x60, 0x0E, 0x30, 0x0C, 0x38, 0x18, 0x18, 0x38, 0x0C, 0x30, 0x0E,
  0x60, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x06, 0xE0, 0x0E,
  0x60, 0x0C, 0x30, 0x18, 0x38, 0x38, 0x18, 0x70, 0x0C, 0x60, 0x0E, 0xC0,
  0x07, 0xE0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x60,
  0xC0, 0x30, 0x60, 0x18, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x0C, 0x01, 0x86,
  0x00, 0xC3, 0x00, 0x63, 0x00, 0x19, 0x80, 0x0D, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFE, 0xFF,
  0xFC, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x1F,
  0xF0, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x38, 0x3F,
  0x80, 0xFF, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFE, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xFF, 0x03, 0xFC, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x0F, 0xF8, 0x3F, 0xC0, 0x1E, 0x00, 0xCF,
  0xC0, 0x27, 0x38, 0x19, 0x87, 0x06, 0xC0, 0xE3, 0x30, 0x1F, 0xCC, 0x01,
  0xE0,
};

const GFXglyph IBMPlexMono_Light36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 4, 25, 22, 9, -25 },
  { 14, 8, 10, 22, 7, -27 },
  { 24, 20, 25, 22, 1, -25 },
  { 87, 18, 33, 22, 2, -29 },
  { 162, 20, 25, 22, 1, -25 },
  { 225, 19, 25, 22, 1, -25 },
  { 285, 2, 10, 22, 10, -27 },
  { 288, 9, 32, 22, 8, -27 },
  { 324, 10, 32, 22, 4, -27 },
  { 364, 18, 18, 22, 2, -20 },
  { 405, 17, 18, 22, 2, -20 },
  { 444, 5, 10, 22, 8, -4 },
  { 451, 10, 2, 22, 6, -12 },
  { 454, 4, 4, 22, 9, -4 },
  { 456, 15, 32, 22, 3, -27 },
  { 516, 17, 25, 22, 2, -25 },
  { 570, 18, 25, 22, 2, -25 },
  { 627, 16, 25, 22, 3, -25 },
  { 677, 16, 25, 22, 2, -25 },
  { 727, 19, 25, 22, 1, -25 },
  { 787, 16, 25, 22, 3, -25 },
  { 837, 16, 25, 22, 3, -25 },
  { 887, 16, 25, 22, 3, -25 },
  { 937, 17, 25, 22, 2, -25 },
  { 991, 16, 25, 22, 3, -25 },
  { 1041, 4, 19, 22, 9, -19 },
  { 1051, 5, 25, 22, 8, -19 },
  { 1067, 16, 20, 22, 3, -21 },
  { 1107, 17, 8, 22, 2, -15 },
  { 1124, 16, 20, 22, 3, -21 },
  { 1164, 15, 25, 22, 3, -25 },
  { 1211, 15, 29, 22, 3, -25 },
  { 1266, 19, 25, 22, 1, -25 },
  { 1326, 16, 25, 22, 3, -25 },
  { 1376, 16, 25, 22, 3, -25 },
  { 1426, 15, 25, 22, 4, -25 },
  { 1473, 16, 25, 22, 3, -25 },
  { 1523, 16, 25, 22, 3, -25 },
  { 1573, 17, 25, 22, 2, -25 },
  { 1627, 15, 25, 22, 3, -25 },
  { 1674, 15, 25, 22, 3, -25 },
  { 1721, 14, 25, 22, 3, -25 },
  { 1765, 17, 25, 22, 3, -25 },
  { 1819, 14, 25, 22, 5, -25 },
  { 1863, 16, 25, 22, 3, -25 },
  { 1913, 15, 25, 22, 3, -25 },
  { 1960, 17, 25, 22, 2, -25 },
  { 2014, 16, 25, 22, 3, -25 },
  { 2064, 17, 30, 22, 2, -25 },
  { 2128, 16, 25, 22, 3, -25 },
  { 2178, 17, 25, 22, 2, -25 },
  { 2232, 19, 25, 22, 1, -25 },
  { 2292, 15, 25, 22, 3, -25 },
  { 2339, 18, 25, 22, 2, -25 },
  { 2396, 18, 25, 22, 2, -25 },
  { 2453, 19, 25, 22, 1, -25 },
  { 2513, 20, 25, 22, 1, -25 },
  { 2576, 18, 25, 22, 2, -25 },
  { 2633, 9, 32, 22, 9, -27 },
  { 2669, 15, 32, 22, 3, -27 },
  { 2729, 10, 32, 22, 3, -27 },
  { 2769, 18, 14, 22, 2, -25 },
  { 2801, 17, 2, 22, 2, 4 },
  { 2806, 5, 7, 22, 7, -28 },
  { 2811, 17, 19, 22, 3, -19 },
  { 2852, 15, 27, 22, 4, -27 },
  { 2903, 15, 19, 22, 3, -19 },
  { 2939, 16, 27, 22, 2, -27 },
  { 2993, 16, 19, 22, 3, -19 },
  { 3031, 16, 27, 22, 3, -27 },
  { 3085, 17, 28, 22, 3, -21 },
  { 3145, 14, 27, 22, 4, -27 },
  { 3193, 16, 26, 22, 4, -26 },
  { 3245, 13, 33, 22, 3, -26 },
  { 3299, 16, 27, 22, 4, -27 },
  { 3353, 16, 27, 22, 3, -27 },
  { 3407, 17, 19, 22, 2, -19 },
  { 3448, 14, 19, 22, 4, -19 },
  { 3482, 16, 19, 22, 3, -19 },
  { 3520, 15, 26, 22, 4, -19 },
  { 3569, 16, 26, 22, 2, -19 },
  { 3621, 17, 19, 22, 3, -19 },
  { 3662, 16, 19, 22, 3, -19 },
  { 3700, 18, 25, 22, 1, -25 },
  { 3757, 14, 19, 22, 4, -19 },
  { 3791, 16, 19, 22, 3, -19 },
  { 3829, 19, 19, 22, 1, -19 },
  { 3875, 16, 19, 22, 3, -19 },
  { 3913, 17, 26, 22, 2, -19 },
  { 3969, 15, 19, 22, 3, -19 },
  { 4005, 14, 32, 22, 4, -27 },
  { 4061, 2, 32, 22, 10, -27 },
  { 4069, 14, 32, 22, 4, -27 },
  { 4125, 18, 7, 22, 2, -15 },
};

const GFXfont IBMPlexMono_Light36pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light36pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light36pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _IBMPLEXMONO_LIGHT36PT7B_H_
