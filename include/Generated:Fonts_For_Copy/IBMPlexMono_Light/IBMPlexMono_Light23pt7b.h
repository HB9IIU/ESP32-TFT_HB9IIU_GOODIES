#ifndef _IBMPLEXMONO_LIGHT23PT7B_H_
#define _IBMPLEXMONO_LIGHT23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xA8, 0x0F, 0xCE, 0x73, 0x9C, 0xE4, 0x02, 0x20, 0x31,
  0x01, 0x18, 0x08, 0x80, 0x44, 0x3E, 0x3C, 0x31, 0x01, 0x98, 0x08, 0xC0,
  0x44, 0x3E, 0x3E, 0x11, 0x01, 0x88, 0x08, 0xC0, 0x44, 0x02, 0x20, 0x02,
  0x00, 0x40, 0x7E, 0x19, 0x34, 0x22, 0x84, 0x10, 0x82, 0x10, 0x22, 0x03,
  0xE0, 0x0F, 0x01, 0x30, 0x22, 0x04, 0x40, 0x8E, 0x11, 0x62, 0x43, 0xF0,
  0x08, 0x01, 0x00, 0x3C, 0x0B, 0x30, 0x90, 0x84, 0x84, 0x44, 0x22, 0x21,
  0x21, 0x9B, 0x07, 0x80, 0x00, 0xF0, 0x68, 0xC2, 0x42, 0x22, 0x13, 0x10,
  0x90, 0x85, 0x84, 0x78, 0x1E, 0x1E, 0x02, 0x10, 0x61, 0x86, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x03, 0x80, 0x68, 0x7C, 0x44, 0x82, 0x48, 0x34, 0x81,
  0x88, 0x0C, 0x43, 0x63, 0xC3, 0xFF, 0xF0, 0x0C, 0x43, 0x08, 0x41, 0x0C,
  0x20, 0x82, 0x08, 0x20, 0x83, 0x04, 0x10, 0x20, 0xC1, 0x03, 0xC1, 0x82,
  0x04, 0x18, 0x20, 0x83, 0x04, 0x10, 0x41, 0x0C, 0x20, 0x86, 0x10, 0x86,
  0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xE6, 0x73, 0xFC, 0x06, 0x00,
  0xF0, 0x19, 0x01, 0x08, 0x20, 0xC0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x61, 0xFF, 0xC1, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x6D, 0xAD,
  0xA0, 0xFC, 0xF0, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x18, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x03, 0x00, 0x1F, 0x06, 0x19, 0x81, 0x20, 0x34, 0x02, 0x80,
  0x70, 0x0E, 0x31, 0xC6, 0x38, 0x05, 0x00, 0xA0, 0x14, 0x06, 0xC0, 0x8C,
  0x30, 0xF8, 0x0C, 0x06, 0x81, 0x90, 0x62, 0x08, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x07, 0xFF,
  0x3E, 0x18, 0x6C, 0x0A, 0x02, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x03, 0xFF, 0x1F, 0x04, 0x19, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0xF8, 0x01, 0x80, 0x08, 0x01, 0x80,
  0x30, 0x07, 0x80, 0x98, 0x30, 0xF8, 0x01, 0x80, 0x38, 0x02, 0x80, 0x48,
  0x04, 0x80, 0x88, 0x18, 0x81, 0x08, 0x20, 0x86, 0x08, 0x40, 0x88, 0x08,
  0xFF, 0xF0, 0x08, 0x00, 0x80, 0x08, 0x7F, 0x90, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x0D, 0xF3, 0x86, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0xE0, 0x26,
  0x18, 0xF8, 0x06, 0x02, 0x01, 0x00, 0x80, 0x60, 0x10, 0x0D, 0xF2, 0x86,
  0xC0, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x70, 0x26, 0x18, 0xF8, 0xFF, 0xE0,
  0x38, 0x0A, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0,
  0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x1F, 0x86, 0x19, 0x81, 0xA0, 0x34,
  0x06, 0xC0, 0xCC, 0x30, 0x78, 0x30, 0xC8, 0x0D, 0x00, 0xE0, 0x14, 0x02,
  0x80, 0xCC, 0x30, 0xFC, 0x3E, 0x18, 0x6C, 0x0A, 0x01, 0x80, 0x60, 0x18,
  0x07, 0x03, 0x61, 0x4F, 0xB0, 0x08, 0x06, 0x01, 0x00, 0x80, 0xC0, 0xE0,
  0xF0, 0x00, 0x0F, 0x6C, 0x00, 0x00, 0x0D, 0xB5, 0xB4, 0x00, 0x40, 0x70,
  0x30, 0x30, 0x38, 0x18, 0x08, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x40, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x04, 0x06, 0x07, 0x03, 0x03,
  0x03, 0x00, 0x80, 0x00, 0x3E, 0x18, 0x6C, 0x0A, 0x03, 0x00, 0xC0, 0x20,
  0x08, 0x0C, 0x0E, 0x02, 0x00, 0x80, 0x20, 0x00, 0x00, 0x01, 0xC0, 0x70,
  0x1E, 0x18, 0x64, 0x0B, 0x03, 0x80, 0x63, 0xD8, 0x96, 0x43, 0x90, 0x64,
  0x19, 0x06, 0x41, 0x98, 0xE3, 0xD8, 0x03, 0x00, 0x40, 0x08, 0x01, 0xF8,
  0x06, 0x00, 0x60, 0x0B, 0x00, 0x90, 0x09, 0x01, 0x98, 0x10, 0x81, 0x08,
  0x30, 0xC2, 0x0C, 0x3F, 0xC6, 0x04, 0x40, 0x64, 0x02, 0xC0, 0x28, 0x03,
  0xFF, 0x30, 0x6C, 0x0B, 0x03, 0xC0, 0xF0, 0x2C, 0x1B, 0xFC, 0xC0, 0xB0,
  0x3C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0B, 0xFC, 0x1F, 0x08, 0x64, 0x0F,
  0x01, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC0,
  0x50, 0x32, 0x18, 0x7C, 0xFE, 0x30, 0x6C, 0x0B, 0x03, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x2C, 0x1B, 0xF8,
  0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xF0, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFE, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x0F, 0x86, 0x18, 0x81, 0xA0, 0x24, 0x00, 0x80,
  0x10, 0x06, 0x00, 0xC3, 0xE8, 0x05, 0x00, 0xA0, 0x14, 0x06, 0xC0, 0xCC,
  0x28, 0xF9, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xC3,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0x7F, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1E, 0x0D, 0x0C, 0x7C,
  0xC0, 0x78, 0x1B, 0x06, 0x61, 0x8C, 0x61, 0x88, 0x32, 0x06, 0xE0, 0xE4,
  0x1C, 0xC3, 0x08, 0x60, 0x8C, 0x19, 0x81, 0x30, 0x36, 0x03, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0xFF, 0xC0, 0xF0, 0x3E, 0x16, 0x85, 0xA3, 0x64, 0x99,
  0x26, 0x71, 0x8C, 0x62, 0x18, 0x86, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0xC0, 0x78, 0x1A, 0x06, 0xC1, 0x90, 0x64, 0x18, 0x86, 0x21, 0x8C, 0x61,
  0x18, 0x66, 0x09, 0x83, 0x60, 0x58, 0x1E, 0x03, 0x1F, 0x06, 0x19, 0x81,
  0x20, 0x34, 0x02, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x05, 0x00, 0xA0,
  0x14, 0x06, 0xC0, 0x8C, 0x30, 0xF8, 0xFF, 0x30, 0x2C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x02, 0xFF, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0x1F, 0x06, 0x19, 0x81, 0x20, 0x34, 0x02, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x05, 0x00, 0xA0, 0x14, 0x06, 0xC0, 0x8C, 0x30, 0xF8,
  0x06, 0x00, 0xC0, 0x0F, 0x00, 0xFF, 0x30, 0x2C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x02, 0xFF, 0x31, 0x0C, 0x23, 0x0C, 0xC1, 0x30, 0x6C, 0x0B,
  0x01, 0x1F, 0x86, 0x1D, 0x00, 0xA0, 0x04, 0x00, 0x80, 0x18, 0x00, 0xF0,
  0x01, 0xC0, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x80, 0xD8, 0x30, 0xFC, 0xFF,
  0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0xC0, 0xF0, 0x26, 0x18, 0xFC, 0xC0, 0x3C, 0x02, 0x40, 0x26,
  0x06, 0x60, 0x42, 0x04, 0x20, 0xC3, 0x08, 0x10, 0x81, 0x08, 0x19, 0x80,
  0x90, 0x09, 0x00, 0xF0, 0x0E, 0x00, 0x60, 0x80, 0x18, 0x03, 0x80, 0x3C,
  0x02, 0xC6, 0x2C, 0x62, 0x46, 0x24, 0xB2, 0x49, 0x24, 0x92, 0x49, 0x25,
  0x12, 0x50, 0xA5, 0x0E, 0x50, 0xE7, 0x0C, 0xC0, 0x36, 0x06, 0x20, 0x43,
  0x0C, 0x19, 0x80, 0x90, 0x0F, 0x00, 0x60, 0x06, 0x00, 0xF0, 0x19, 0x01,
  0x08, 0x30, 0xC6, 0x04, 0x40, 0x6C, 0x03, 0xC0, 0x1B, 0x00, 0x8C, 0x0C,
  0x20, 0x41, 0x86, 0x04, 0x60, 0x32, 0x00, 0xF0, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x7F, 0xE0, 0x06,
  0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80,
  0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x0F, 0xFF, 0xFE, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3F,
  0xC0, 0x10, 0x04, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x60, 0x08,
  0x03, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x7F, 0x06, 0x00, 0xE0, 0x09, 0x01, 0x18, 0x10, 0x82,
  0x0C, 0x60, 0x44, 0x02, 0xC0, 0x30, 0xFF, 0xE0, 0xC6, 0x21, 0x3E, 0x30,
  0xC8, 0x18, 0x06, 0x01, 0x9F, 0xEC, 0x1A, 0x06, 0x81, 0xA0, 0x6C, 0x29,
  0xF3, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x37, 0xCE, 0x1B, 0x03, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x86, 0xDF, 0x00, 0x1F,
  0x08, 0x64, 0x0F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x32,
  0x18, 0x7C, 0x00, 0x80, 0x40, 0x20, 0x10, 0x09, 0xE5, 0x8F, 0x81, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x02, 0xC3, 0x3E, 0x80, 0x1E, 0x18,
  0x64, 0x0A, 0x03, 0x80, 0x7F, 0xF8, 0x02, 0x00, 0x80, 0x90, 0x36, 0x18,
  0x78, 0x07, 0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xF0, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xC0, 0x01,
  0xE3, 0xE1, 0x84, 0x20, 0x44, 0x08, 0x81, 0x10, 0x23, 0x08, 0x1E, 0x0C,
  0x01, 0x00, 0x20, 0x03, 0xF9, 0x80, 0xA0, 0x1C, 0x03, 0xC0, 0xC7, 0xF0,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0xFB, 0x87, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x80, 0x0C, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x7F, 0xC0, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0xFE, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x68,
  0x32, 0x18, 0x8C, 0x26, 0x0B, 0x83, 0x30, 0x86, 0x20, 0x88, 0x12, 0x06,
  0x80, 0xC0, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xC0,
  0xDD, 0xFC, 0xC7, 0x18, 0xE3, 0x1C, 0x63, 0x8C, 0x71, 0x8E, 0x31, 0xC6,
  0x38, 0xC7, 0x18, 0xE3, 0x10, 0xDF, 0x70, 0xF0, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x10, 0x3E, 0x18, 0x6C, 0x0A, 0x03,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xF0, 0x26, 0x18, 0xF8, 0xDF, 0x38,
  0x6C, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3E, 0x1B,
  0x7C, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x3C, 0xB1, 0xF0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x58, 0x67, 0xD0, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0xF9, 0xE1, 0xC0, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x7F, 0xE0, 0x3F, 0x18, 0x6C,
  0x0F, 0x00, 0x40, 0x0F, 0x00, 0x38, 0x03, 0x00, 0x60, 0x16, 0x08, 0xFC,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x0F, 0xFE, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x3F, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xA0, 0x58, 0x67, 0xD0,
  0x80, 0x70, 0x34, 0x09, 0x02, 0x61, 0x08, 0x42, 0x30, 0xC8, 0x12, 0x05,
  0x80, 0xC0, 0x30, 0x86, 0x18, 0x61, 0x86, 0x18, 0xA2, 0x49, 0x24, 0x92,
  0x49, 0x24, 0x92, 0x50, 0xA5, 0x0C, 0x70, 0xC3, 0x0C, 0xC0, 0xD0, 0x62,
  0x10, 0xC8, 0x1E, 0x03, 0x00, 0xC0, 0x58, 0x33, 0x08, 0x44, 0x1B, 0x03,
  0xC0, 0x28, 0x0D, 0x81, 0x10, 0x23, 0x0C, 0x21, 0x04, 0x60, 0xC8, 0x09,
  0x01, 0xE0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x78, 0x00,
  0xFF, 0x80, 0x20, 0x10, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x40, 0x30, 0x18,
  0x0C, 0x03, 0xFF, 0x0F, 0x84, 0x02, 0x01, 0x00, 0x80, 0x20, 0x18, 0x04,
  0x04, 0x7C, 0x03, 0x00, 0x40, 0x20, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02,
  0x01, 0xF0, 0xFF, 0xFF, 0xF0, 0xFC, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40,
  0x40, 0x20, 0x18, 0x03, 0xC7, 0x02, 0x01, 0x00, 0x40, 0x30, 0x08, 0x04,
  0x02, 0x01, 0x1F, 0x80, 0x38, 0x34, 0x42, 0x42, 0x68, 0x1C,
};

const GFXglyph IBMPlexMono_Light23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 2, 16, 14, 6, -16 },
  { 5, 5, 6, 14, 4, -17 },
  { 9, 13, 16, 14, 0, -16 },
  { 35, 11, 20, 14, 1, -18 },
  { 63, 13, 16, 14, 0, -16 },
  { 89, 12, 16, 14, 1, -16 },
  { 113, 2, 6, 14, 6, -17 },
  { 115, 6, 20, 14, 5, -17 },
  { 130, 6, 20, 14, 3, -17 },
  { 145, 12, 11, 14, 1, -13 },
  { 162, 11, 11, 14, 1, -13 },
  { 178, 3, 7, 14, 5, -3 },
  { 181, 6, 1, 14, 4, -8 },
  { 182, 2, 2, 14, 6, -2 },
  { 183, 10, 20, 14, 2, -17 },
  { 208, 11, 16, 14, 1, -16 },
  { 230, 11, 16, 14, 2, -16 },
  { 252, 10, 16, 14, 2, -16 },
  { 272, 11, 16, 14, 1, -16 },
  { 294, 12, 16, 14, 1, -16 },
  { 318, 10, 16, 14, 2, -16 },
  { 338, 10, 16, 14, 2, -16 },
  { 358, 10, 16, 14, 2, -16 },
  { 378, 11, 16, 14, 1, -16 },
  { 400, 10, 16, 14, 2, -16 },
  { 420, 2, 12, 14, 6, -12 },
  { 423, 3, 16, 14, 5, -12 },
  { 429, 10, 13, 14, 2, -14 },
  { 446, 11, 6, 14, 1, -10 },
  { 455, 10, 13, 14, 2, -14 },
  { 472, 10, 16, 14, 2, -16 },
  { 492, 10, 19, 14, 2, -16 },
  { 516, 12, 16, 14, 1, -16 },
  { 540, 10, 16, 14, 2, -16 },
  { 560, 10, 16, 14, 2, -16 },
  { 580, 10, 16, 14, 2, -16 },
  { 600, 10, 16, 14, 2, -16 },
  { 620, 10, 16, 14, 2, -16 },
  { 640, 11, 16, 14, 1, -16 },
  { 662, 10, 16, 14, 2, -16 },
  { 682, 10, 16, 14, 2, -16 },
  { 702, 9, 16, 14, 2, -16 },
  { 720, 11, 16, 14, 2, -16 },
  { 742, 9, 16, 14, 3, -16 },
  { 760, 10, 16, 14, 2, -16 },
  { 780, 10, 16, 14, 2, -16 },
  { 800, 11, 16, 14, 1, -16 },
  { 822, 10, 16, 14, 2, -16 },
  { 842, 11, 19, 14, 1, -16 },
  { 869, 10, 16, 14, 2, -16 },
  { 889, 11, 16, 14, 1, -16 },
  { 911, 12, 16, 14, 1, -16 },
  { 935, 10, 16, 14, 2, -16 },
  { 955, 12, 16, 14, 1, -16 },
  { 979, 12, 16, 14, 1, -16 },
  { 1003, 12, 16, 14, 1, -16 },
  { 1027, 13, 16, 14, 0, -16 },
  { 1053, 12, 16, 14, 1, -16 },
  { 1077, 6, 20, 14, 6, -17 },
  { 1092, 10, 20, 14, 2, -17 },
  { 1117, 6, 20, 14, 2, -17 },
  { 1132, 12, 9, 14, 1, -16 },
  { 1146, 11, 1, 14, 1, 3 },
  { 1148, 4, 4, 14, 4, -18 },
  { 1150, 10, 12, 14, 2, -12 },
  { 1165, 10, 17, 14, 2, -17 },
  { 1187, 10, 12, 14, 2, -12 },
  { 1202, 9, 17, 14, 2, -17 },
  { 1222, 10, 12, 14, 2, -12 },
  { 1237, 10, 17, 14, 2, -17 },
  { 1259, 11, 18, 14, 2, -13 },
  { 1284, 9, 17, 14, 2, -17 },
  { 1304, 9, 18, 14, 3, -18 },
  { 1325, 8, 23, 14, 2, -18 },
  { 1348, 10, 17, 14, 3, -17 },
  { 1370, 10, 17, 14, 2, -17 },
  { 1392, 11, 12, 14, 1, -12 },
  { 1409, 9, 12, 14, 2, -12 },
  { 1423, 10, 12, 14, 2, -12 },
  { 1438, 10, 17, 14, 2, -12 },
  { 1460, 9, 17, 14, 2, -12 },
  { 1480, 11, 12, 14, 2, -12 },
  { 1497, 10, 12, 14, 2, -12 },
  { 1512, 11, 16, 14, 1, -16 },
  { 1534, 9, 12, 14, 2, -12 },
  { 1548, 10, 12, 14, 2, -12 },
  { 1563, 12, 12, 14, 1, -12 },
  { 1581, 10, 12, 14, 2, -12 },
  { 1596, 11, 17, 14, 1, -12 },
  { 1620, 10, 12, 14, 2, -12 },
  { 1635, 9, 20, 14, 2, -17 },
  { 1658, 1, 20, 14, 6, -17 },
  { 1661, 9, 20, 14, 2, -17 },
  { 1684, 12, 4, 14, 1, -9 },
};

const GFXfont IBMPlexMono_Light23pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light23pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _IBMPLEXMONO_LIGHT23PT7B_H_
