#ifndef _IBMPLEXMONO_LIGHT11PT7B_H_
#define _IBMPLEXMONO_LIGHT11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFC, 0x28, 0xA6, 0xCA, 0x2B, 0x35, 0x14, 0x23, 0xAB, 0x4E,
  0x1C, 0xB5, 0x71, 0x00, 0x66, 0x9A, 0x98, 0x0D, 0xD5, 0x63, 0x31, 0x24,
  0x09, 0x7A, 0x68, 0x9D, 0xE0, 0x2A, 0x49, 0x24, 0x44, 0x88, 0x92, 0x49,
  0x50, 0x10, 0x4F, 0xC4, 0x68, 0x21, 0x3E, 0x42, 0x00, 0x68, 0xE0, 0x80,
  0x18, 0x84, 0x42, 0x21, 0x08, 0x84, 0x00, 0x74, 0x63, 0x1A, 0xC6, 0x2E,
  0x63, 0x28, 0x42, 0x10, 0x9F, 0x74, 0x86, 0x23, 0x13, 0x1F, 0x74, 0x84,
  0xC1, 0x06, 0x4E, 0x08, 0x62, 0x92, 0x8B, 0xF0, 0x82, 0xF4, 0x21, 0xE8,
  0x86, 0x2E, 0x32, 0x21, 0xE8, 0xC6, 0x2E, 0xFC, 0xA4, 0x22, 0x11, 0x08,
  0x74, 0x62, 0xE9, 0xC6, 0x2E, 0x74, 0x63, 0x17, 0x88, 0x4C, 0x84, 0x40,
  0x1A, 0x09, 0xB1, 0x06, 0x0C, 0xF8, 0x3E, 0x83, 0x04, 0x36, 0x40, 0x74,
  0x82, 0x22, 0x20, 0x0C, 0x74, 0xAF, 0x9C, 0xE6, 0xF0, 0x70, 0x10, 0xC3,
  0x12, 0x49, 0xE4, 0x61, 0xF4, 0x65, 0xE8, 0xC6, 0x3E, 0x74, 0x61, 0x08,
  0x42, 0x2E, 0xF4, 0x63, 0x18, 0xC6, 0x3E, 0xFC, 0x21, 0xF8, 0x42, 0x1F,
  0xFC, 0x21, 0xE8, 0x42, 0x10, 0x74, 0xA3, 0x0B, 0xC6, 0x2F, 0x8C, 0x63,
  0xF8, 0xC6, 0x31, 0xF9, 0x08, 0x42, 0x10, 0x9F, 0x71, 0x11, 0x11, 0x97,
  0x8C, 0xA9, 0x8A, 0x4A, 0x51, 0x84, 0x21, 0x08, 0x42, 0x1F, 0x8C, 0xFB,
  0x5A, 0xC6, 0x31, 0x8E, 0x73, 0x9A, 0xD6, 0x73, 0x74, 0x63, 0x18, 0xC6,
  0x2E, 0xF4, 0x63, 0x1F, 0x42, 0x10, 0x74, 0x63, 0x18, 0xC6, 0x2E, 0x21,
  0x80, 0xF4, 0x63, 0x1F, 0x52, 0x51, 0x74, 0x61, 0xC1, 0x86, 0x2E, 0xFC,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x8C, 0x63, 0x18, 0xC6, 0x4E, 0x85, 0x14,
  0x92, 0x48, 0xC3, 0x04, 0x86, 0x19, 0x65, 0xB5, 0xD4, 0xD2, 0xC5, 0x22,
  0x84, 0x10, 0xA4, 0xA1, 0x85, 0x24, 0x8C, 0x10, 0x41, 0x04, 0xF8, 0x84,
  0x44, 0x42, 0x1F, 0xF2, 0x49, 0x24, 0x9C, 0x84, 0x10, 0x84, 0x10, 0x82,
  0x10, 0xC0, 0xE4, 0x92, 0x49, 0x3C, 0x22, 0xA5, 0x10, 0xF8, 0x90, 0x74,
  0x85, 0xEB, 0x74, 0x84, 0x3D, 0x18, 0xC6, 0x3E, 0x74, 0xA3, 0x08, 0xB8,
  0x11, 0x79, 0x99, 0x97, 0x74, 0x7F, 0x08, 0xB8, 0x39, 0x3E, 0x42, 0x10,
  0x9F, 0x0B, 0xA5, 0x27, 0x41, 0xF1, 0xF8, 0x88, 0xF9, 0x99, 0x99, 0x20,
  0x38, 0x42, 0x10, 0x9F, 0x10, 0xF1, 0x11, 0x11, 0x1F, 0x84, 0x27, 0x4A,
  0x72, 0x51, 0xE1, 0x08, 0x42, 0x10, 0x9F, 0xDF, 0x6B, 0x5A, 0xD4, 0xF9,
  0x99, 0x99, 0x74, 0x63, 0x18, 0xB8, 0xF4, 0x63, 0x18, 0xFA, 0x10, 0x79,
  0x99, 0x97, 0x11, 0xD9, 0x10, 0x84, 0x7C, 0x74, 0xF8, 0x38, 0xB8, 0x20,
  0x8F, 0xC8, 0x20, 0x82, 0x0F, 0x99, 0x99, 0x97, 0x8C, 0xA4, 0xA6, 0x10,
  0x96, 0xDB, 0x6D, 0x4D, 0x20, 0x9A, 0x88, 0x45, 0x4C, 0x8C, 0xA4, 0xC2,
  0x11, 0x18, 0xF0, 0x88, 0x88, 0x7C, 0x34, 0x42, 0xC2, 0x24, 0x43, 0xFF,
  0xC0, 0xE2, 0x44, 0x16, 0x42, 0x2E, 0xCD, 0x64,
};

const GFXglyph IBMPlexMono_Light11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 8, 7, 3, -8 },
  { 2, 2, 3, 7, 2, -8 },
  { 3, 6, 8, 7, 0, -8 },
  { 9, 5, 10, 7, 1, -9 },
  { 16, 6, 8, 7, 0, -8 },
  { 22, 6, 8, 7, 0, -8 },
  { 28, 1, 3, 7, 3, -8 },
  { 29, 3, 10, 7, 2, -8 },
  { 33, 3, 10, 7, 1, -8 },
  { 37, 6, 5, 7, 0, -6 },
  { 41, 5, 5, 7, 1, -6 },
  { 45, 2, 3, 7, 2, -1 },
  { 46, 3, 1, 7, 2, -4 },
  { 47, 1, 1, 7, 3, -1 },
  { 48, 5, 10, 7, 1, -8 },
  { 55, 5, 8, 7, 1, -8 },
  { 60, 5, 8, 7, 1, -8 },
  { 65, 5, 8, 7, 1, -8 },
  { 70, 5, 8, 7, 1, -8 },
  { 75, 6, 8, 7, 0, -8 },
  { 81, 5, 8, 7, 1, -8 },
  { 86, 5, 8, 7, 1, -8 },
  { 91, 5, 8, 7, 1, -8 },
  { 96, 5, 8, 7, 1, -8 },
  { 101, 5, 8, 7, 1, -8 },
  { 106, 1, 6, 7, 3, -6 },
  { 107, 2, 8, 7, 2, -6 },
  { 109, 5, 6, 7, 1, -6 },
  { 113, 5, 3, 7, 1, -5 },
  { 115, 5, 6, 7, 1, -6 },
  { 119, 5, 8, 7, 1, -8 },
  { 124, 5, 9, 7, 1, -8 },
  { 130, 6, 8, 7, 0, -8 },
  { 136, 5, 8, 7, 1, -8 },
  { 141, 5, 8, 7, 1, -8 },
  { 146, 5, 8, 7, 1, -8 },
  { 151, 5, 8, 7, 1, -8 },
  { 156, 5, 8, 7, 1, -8 },
  { 161, 5, 8, 7, 1, -8 },
  { 166, 5, 8, 7, 1, -8 },
  { 171, 5, 8, 7, 1, -8 },
  { 176, 4, 8, 7, 1, -8 },
  { 180, 5, 8, 7, 1, -8 },
  { 185, 5, 8, 7, 1, -8 },
  { 190, 5, 8, 7, 1, -8 },
  { 195, 5, 8, 7, 1, -8 },
  { 200, 5, 8, 7, 1, -8 },
  { 205, 5, 8, 7, 1, -8 },
  { 210, 5, 10, 7, 1, -8 },
  { 217, 5, 8, 7, 1, -8 },
  { 222, 5, 8, 7, 1, -8 },
  { 227, 6, 8, 7, 0, -8 },
  { 233, 5, 8, 7, 1, -8 },
  { 238, 6, 8, 7, 0, -8 },
  { 244, 6, 8, 7, 0, -8 },
  { 250, 6, 8, 7, 0, -8 },
  { 256, 6, 8, 7, 0, -8 },
  { 262, 5, 8, 7, 1, -8 },
  { 267, 3, 10, 7, 3, -8 },
  { 271, 5, 10, 7, 1, -8 },
  { 278, 3, 10, 7, 1, -8 },
  { 282, 5, 4, 7, 1, -8 },
  { 285, 5, 1, 7, 1, 1 },
  { 286, 2, 2, 7, 2, -9 },
  { 287, 5, 6, 7, 1, -6 },
  { 291, 5, 8, 7, 1, -8 },
  { 296, 5, 6, 7, 1, -6 },
  { 300, 4, 8, 7, 1, -8 },
  { 304, 5, 6, 7, 1, -6 },
  { 308, 5, 8, 7, 1, -8 },
  { 313, 5, 9, 7, 1, -7 },
  { 319, 4, 8, 7, 1, -8 },
  { 323, 5, 8, 7, 1, -8 },
  { 328, 4, 10, 7, 1, -8 },
  { 333, 5, 8, 7, 1, -8 },
  { 338, 5, 8, 7, 1, -8 },
  { 343, 5, 6, 7, 1, -6 },
  { 347, 4, 6, 7, 1, -6 },
  { 350, 5, 6, 7, 1, -6 },
  { 354, 5, 8, 7, 1, -6 },
  { 359, 4, 8, 7, 1, -6 },
  { 363, 5, 6, 7, 1, -6 },
  { 367, 5, 6, 7, 1, -6 },
  { 371, 6, 8, 7, 0, -8 },
  { 377, 4, 6, 7, 1, -6 },
  { 380, 5, 6, 7, 1, -6 },
  { 384, 6, 6, 7, 0, -6 },
  { 389, 5, 6, 7, 1, -6 },
  { 393, 5, 8, 7, 1, -6 },
  { 398, 5, 6, 7, 1, -6 },
  { 402, 4, 10, 7, 1, -8 },
  { 407, 1, 10, 7, 3, -8 },
  { 409, 4, 10, 7, 1, -8 },
  { 414, 5, 3, 7, 1, -5 },
};

const GFXfont IBMPlexMono_Light11pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light11pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light11pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _IBMPLEXMONO_LIGHT11PT7B_H_
