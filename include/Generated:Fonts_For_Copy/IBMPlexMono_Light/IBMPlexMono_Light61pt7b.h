#ifndef _IBMPLEXMONO_LIGHT61PT7B_H_
#define _IBMPLEXMONO_LIGHT61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light61pt7bBitmaps[] PROGMEM = {
  0x00, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0x60,
  0xC1, 0x81, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xDF, 0xBF, 0xFF,
  0xFF, 0xFD, 0xF0, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xF9, 0xFF,
  0xE0, 0x1F, 0xFF, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0x80, 0x70, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xFF,
  0xE0, 0x3F, 0xFC, 0x7F, 0xF8, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xF0,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0x8E, 0x3F, 0x80, 0xF8, 0x38, 0x1F, 0x07, 0x80, 0xE0, 0x3E, 0x1E,
  0x03, 0x80, 0x7C, 0xF0, 0x0E, 0x00, 0xC3, 0xC0, 0x38, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xF0, 0x0E, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x0F, 0xC3, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0E, 0xFF, 0x80, 0x00, 0x38, 0x7F, 0x00, 0x00,
  0xE0, 0x7C, 0x00, 0x03, 0x80, 0x78, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x38,
  0x03, 0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x03, 0x80, 0x3C,
  0xC0, 0x0E, 0x00, 0xF7, 0x80, 0x38, 0x07, 0xBF, 0x00, 0xE0, 0x1E, 0x3E,
  0x03, 0x80, 0xF0, 0x7E, 0x0E, 0x0F, 0xC0, 0xFE, 0x38, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xC3, 0xFF, 0x00, 0x00, 0xE1, 0xFF, 0xF0, 0x00, 0x38, 0xF8, 0x3C, 0x00,
  0x1C, 0x38, 0x07, 0x80, 0x07, 0x1E, 0x00, 0xE0, 0x03, 0x87, 0x00, 0x1C,
  0x01, 0xE1, 0xC0, 0x07, 0x00, 0x70, 0x70, 0x01, 0xC0, 0x3C, 0x1C, 0x00,
  0x70, 0x0E, 0x07, 0x00, 0x1C, 0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x70,
  0x01, 0xC0, 0xE0, 0x1C, 0x00, 0x70, 0x38, 0x07, 0x00, 0x1C, 0x1C, 0x01,
  0xE0, 0x0E, 0x0F, 0x00, 0x38, 0x07, 0x83, 0x80, 0x0F, 0x83, 0xC1, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0x07, 0xFF, 0x80, 0x03,
  0x83, 0xE0, 0xF0, 0x01, 0xC0, 0xE0, 0x1E, 0x00, 0xF0, 0x70, 0x03, 0x80,
  0x38, 0x1C, 0x00, 0x70, 0x1C, 0x07, 0x00, 0x1C, 0x07, 0x03, 0x80, 0x07,
  0x03, 0x80, 0xE0, 0x01, 0xC0, 0xE0, 0x38, 0x00, 0x70, 0x70, 0x0E, 0x00,
  0x1C, 0x1C, 0x03, 0x80, 0x07, 0x0E, 0x00, 0x70, 0x01, 0xC7, 0x80, 0x1C,
  0x00, 0x71, 0xC0, 0x07, 0x00, 0x38, 0xE0, 0x00, 0xE0, 0x1E, 0x38, 0x00,
  0x3E, 0x0F, 0x1C, 0x00, 0x07, 0xFF, 0x87, 0x00, 0x00, 0xFF, 0xC2, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x04, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x0F, 0xBC, 0x00, 0xFF, 0x1E,
  0x1E, 0x00, 0xFF, 0x3C, 0x0F, 0x00, 0xE0, 0x38, 0x07, 0x80, 0xE0, 0x78,
  0x03, 0xC0, 0xE0, 0x70, 0x01, 0xE0, 0xE0, 0xF0, 0x01, 0xE0, 0xE0, 0xF0,
  0x00, 0xF1, 0xC0, 0xF0, 0x00, 0x79, 0xC0, 0xF0, 0x00, 0x3D, 0xC0, 0xF0,
  0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x07, 0xC0, 0x70, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x0D, 0xE0, 0x7C,
  0x00, 0x1C, 0xF0, 0x3E, 0x00, 0x38, 0x78, 0x1F, 0x80, 0xF0, 0x3C, 0x0F,
  0xFF, 0xE0, 0x1E, 0x07, 0xFF, 0xC0, 0x0F, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x37,
  0xE0, 0x1C, 0x03, 0xEF, 0xF8, 0x38, 0x3F, 0xE7, 0xFE, 0x77, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1F, 0x8F, 0xC7, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x3E, 0x1E,
  0x0F, 0x07, 0x03, 0x83, 0xC1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7D, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x7E, 0x00,
  0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x78, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x38, 0xF0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x1E, 0x00, 0xFF, 0x00, 0xF8,
  0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0xC0, 0x7E, 0x01, 0xFE, 0x01, 0xF0, 0x0F,
  0xF0, 0x0F, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x0F,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xE0,
  0x3F, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0x7C, 0x3C, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF8,
  0x0F, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x70, 0x03,
  0xC0, 0x00, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x03, 0xE0,
  0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0xF0, 0x00,
  0x07, 0x9C, 0x00, 0x00, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x0F,
  0x80, 0x0F, 0x81, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x1E, 0x08, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF2,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0xC3, 0xF0, 0x00, 0xF8, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x3C, 0x03, 0x80, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00, 0xF0, 0x03, 0x80, 0x00,
  0xE0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x03, 0x80, 0x0F, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x03, 0x80, 0x1E, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x03, 0x80, 0x78, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x07, 0xF8, 0x00,
  0xE3, 0xFF, 0xE0, 0x1C, 0xFF, 0xFE, 0x07, 0xB8, 0x07, 0xE0, 0xFC, 0x00,
  0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x10, 0x00, 0x01,
  0xE6, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xE3, 0xF0,
  0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC1, 0xFE, 0x00, 0x3C, 0x7F, 0xFC, 0x03, 0x8F,
  0xFF, 0xE0, 0x7B, 0xE0, 0x3F, 0x87, 0xB0, 0x00, 0xF8, 0x76, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x0E, 0x38, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0xF8,
  0x07, 0xE0, 0x3F, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x7F, 0x01,
  0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00,
  0x38, 0xF0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0xF8,
  0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF8, 0x1F, 0xC0,
  0x3F, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x7E,
  0x78, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0x70, 0xFE, 0x03, 0xCE, 0x0F, 0xFF,
  0xF3, 0xC0, 0x7F, 0xFC, 0x78, 0x03, 0xFC, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7D, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF7, 0xEF, 0xFF, 0xFF, 0xFF, 0x7C, 0x1F, 0x1F, 0x8F, 0xE7,
  0xF3, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE3, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x0F,
  0x87, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0x01, 0xF8, 0x1F, 0x00,
  0x1F, 0x0F, 0x80, 0x03, 0xE7, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x0E, 0x70,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xF1, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0xC3, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x03, 0xE1, 0xF8,
  0x03, 0xFE, 0x7E, 0x01, 0xFF, 0xDF, 0x80, 0xF8, 0x37, 0xE0, 0x3C, 0x03,
  0xF8, 0x1E, 0x00, 0xFE, 0x07, 0x00, 0x1F, 0x81, 0xC0, 0x07, 0xE0, 0x70,
  0x01, 0xF8, 0x3C, 0x00, 0x7E, 0x0F, 0x00, 0x1F, 0x83, 0xC0, 0x07, 0xE0,
  0xF0, 0x01, 0xF8, 0x3C, 0x00, 0x7E, 0x0F, 0x00, 0x1F, 0x83, 0xC0, 0x07,
  0xE0, 0xF0, 0x01, 0xF8, 0x1C, 0x00, 0x7E, 0x07, 0x00, 0x1F, 0x81, 0xC0,
  0x07, 0xE0, 0x78, 0x03, 0xF8, 0x0F, 0x01, 0xFE, 0x03, 0xF9, 0xDF, 0x80,
  0x7F, 0xF7, 0xE0, 0x0F, 0xF9, 0xFC, 0x00, 0x70, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0x0E, 0x78, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1E, 0x38, 0x00,
  0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x3C, 0x1C, 0x00,
  0x00, 0x38, 0x1E, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x78, 0x0E, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80,
  0x01, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0x80, 0x01, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x83, 0x80, 0x01, 0xF0, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0xF3, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0xB8, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x0E, 0x38,
  0x00, 0x07, 0x8E, 0x00, 0x07, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x0E, 0x00, 0x03, 0xE3, 0x80, 0x00, 0x3C, 0xE0, 0x00,
  0x07, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xF0,
  0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF1,
  0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x19, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x1C, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x7C, 0x07, 0xE0, 0x3F, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x78, 0x00, 0xFC, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x77, 0x80, 0x00, 0x0E, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7E, 0x03,
  0xF0, 0x0F, 0x80, 0x0F, 0x80, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0C, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x3F,
  0x1F, 0x00, 0x06, 0xF0, 0xF8, 0x00, 0xEF, 0x07, 0xE0, 0x3C, 0xF0, 0x3F,
  0xFF, 0x8F, 0x01, 0xFF, 0xF0, 0xF0, 0x03, 0xFC, 0x00, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x10, 0x00, 0x0F, 0xF0, 0x00,
  0x0E, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0x3E, 0x00,
  0x7C, 0x1F, 0x01, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0xE0, 0x00, 0x01, 0xF7, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x83, 0x80,
  0x00, 0xF8, 0x1C, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x7C, 0x00,
  0x70, 0x07, 0xC0, 0x03, 0x80, 0x7C, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0xE0,
  0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x38, 0x3E, 0x00, 0x01, 0xC3, 0xF8,
  0x00, 0x0E, 0x3F, 0xC0, 0x00, 0x71, 0xEF, 0x00, 0x03, 0x9E, 0x7C, 0x00,
  0x1D, 0xE1, 0xE0, 0x00, 0xFE, 0x07, 0x80, 0x07, 0xE0, 0x3C, 0x00, 0x3E,
  0x00, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x70, 0x00,
  0x78, 0x03, 0x80, 0x03, 0xE0, 0x1C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x3C,
  0x07, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1F, 0x1C, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0F, 0xB8, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFB, 0x80, 0x03, 0xBF, 0x70, 0x00,
  0xF7, 0xE7, 0x00, 0x1C, 0xFC, 0xE0, 0x07, 0x9F, 0x9E, 0x00, 0xE3, 0xF1,
  0xC0, 0x1C, 0x7E, 0x38, 0x07, 0x8F, 0xC3, 0x80, 0xE1, 0xF8, 0x70, 0x3C,
  0x3F, 0x0F, 0x07, 0x07, 0xE0, 0xE0, 0xE0, 0xFC, 0x1E, 0x38, 0x1F, 0x81,
  0xC7, 0x03, 0xF0, 0x39, 0xE0, 0x7E, 0x03, 0xB8, 0x0F, 0xC0, 0x77, 0x01,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1E, 0x00, 0xFC, 0x01,
  0xC0, 0x1F, 0x80, 0x38, 0x03, 0xF0, 0x02, 0x00, 0x7E, 0x00, 0x40, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x80,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x70, 0x00, 0x1F, 0xDE,
  0x00, 0x07, 0xF3, 0x80, 0x01, 0xFC, 0xF0, 0x00, 0x7F, 0x1C, 0x00, 0x1F,
  0xC7, 0x80, 0x07, 0xF1, 0xE0, 0x01, 0xFC, 0x3C, 0x00, 0x7F, 0x0F, 0x00,
  0x1F, 0xC1, 0xC0, 0x07, 0xF0, 0x78, 0x01, 0xFC, 0x0E, 0x00, 0x7F, 0x03,
  0xC0, 0x1F, 0xC0, 0x70, 0x07, 0xF0, 0x1E, 0x01, 0xFC, 0x07, 0x80, 0x7F,
  0x00, 0xF0, 0x1F, 0xC0, 0x3C, 0x07, 0xF0, 0x07, 0x01, 0xFC, 0x01, 0xE0,
  0x7F, 0x00, 0x38, 0x1F, 0xC0, 0x0F, 0x07, 0xF0, 0x01, 0xC1, 0xFC, 0x00,
  0x78, 0x7F, 0x00, 0x0E, 0x1F, 0xC0, 0x03, 0xC7, 0xF0, 0x00, 0xF1, 0xFC,
  0x00, 0x1E, 0x7F, 0x00, 0x07, 0x9F, 0xC0, 0x00, 0xE7, 0xF0, 0x00, 0x3D,
  0xFC, 0x00, 0x07, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0xF8,
  0x00, 0xF8, 0x0F, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x38,
  0xF0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x0F, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xE0, 0x3F,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x78, 0x00,
  0x1F, 0x8F, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xF1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xC0,
  0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x78,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x01,
  0xF0, 0x01, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x78, 0x00, 0x1F, 0x8F, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xCF, 0x00,
  0x03, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00,
  0xF0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x07,
  0x80, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3E, 0x3C,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0x80, 0x03, 0xF0,
  0x78, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0C, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x7B,
  0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0E, 0x78, 0x00, 0x07,
  0x8F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x1F, 0x80,
  0x7E, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00,
  0xE0, 0x07, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0x70, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x0E, 0x00,
  0x03, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x3C, 0x1C, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x07, 0x78, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x7C, 0x01,
  0xCE, 0x00, 0xF8, 0x03, 0x9C, 0x01, 0xF0, 0x07, 0x38, 0x07, 0xE0, 0x1E,
  0x70, 0x0F, 0xE0, 0x3C, 0xE0, 0x1D, 0xC0, 0x71, 0xC0, 0x3B, 0x80, 0xE3,
  0xC0, 0xE7, 0x01, 0xC7, 0x81, 0xCF, 0x03, 0x87, 0x03, 0x8E, 0x07, 0x0E,
  0x07, 0x1C, 0x0E, 0x1C, 0x1C, 0x38, 0x1C, 0x38, 0x38, 0x78, 0x38, 0x70,
  0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE1, 0xC3, 0x81, 0xC3, 0xC3, 0x87,
  0x03, 0xC7, 0x07, 0x0E, 0x03, 0x8E, 0x0E, 0x1C, 0x07, 0x1C, 0x1E, 0x78,
  0x0E, 0x38, 0x3C, 0xE0, 0x1C, 0x70, 0x39, 0xC0, 0x1C, 0xE0, 0x73, 0x80,
  0x39, 0xC0, 0xEF, 0x00, 0x73, 0x81, 0xDC, 0x00, 0xE7, 0x03, 0xB8, 0x00,
  0xEE, 0x07, 0x70, 0x01, 0xDC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x07,
  0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x0F, 0xBC, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xB8,
  0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0x80, 0x78, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x70, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0E, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x03,
  0xE8, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x20, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1C,
  0x07, 0x03, 0xC0, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0x01, 0xF8, 0x01, 0xE0, 0x03, 0xE0, 0x1E, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x06, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x01,
  0xC0, 0xF8, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x70, 0x38, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x07, 0x80,
  0x00, 0x38, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x03,
  0x70, 0x1F, 0x80, 0xF3, 0xFC, 0x7F, 0xFF, 0x0F, 0xE1, 0xFF, 0xF0, 0x3F,
  0x01, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x03, 0xFC, 0x03,
  0x87, 0xFF, 0x81, 0xC7, 0xFF, 0xE0, 0xE7, 0x01, 0xFC, 0x76, 0x00, 0x3E,
  0x3E, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xEF, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x1E,
  0x76, 0x00, 0x3E, 0x39, 0xC0, 0x7F, 0x1C, 0x7F, 0xFF, 0x0E, 0x1F, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x01, 0xF8, 0x0F, 0x81, 0xF0, 0x01, 0xE1, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x1C, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x02, 0x3C, 0x00,
  0x01, 0xCF, 0x00, 0x01, 0xE7, 0xC0, 0x01, 0xE1, 0xF0, 0x01, 0xF0, 0x7E,
  0x03, 0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0xC0, 0x70, 0x1F, 0xFE,
  0x1C, 0x1F, 0xFF, 0xC7, 0x0F, 0xC0, 0x79, 0xC7, 0xC0, 0x07, 0x71, 0xE0,
  0x00, 0x5C, 0xF0, 0x00, 0x1F, 0x38, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x1F, 0x1E, 0x00,
  0x05, 0xC7, 0xC0, 0x07, 0x70, 0xFC, 0x07, 0x9C, 0x1F, 0xFF, 0xC7, 0x01,
  0xFF, 0xE1, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x3C,
  0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x08, 0x78, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x0E, 0x0F, 0x00, 0x03, 0xC1, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0x18, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x38,
  0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x78, 0x1C,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x38, 0x07, 0x80, 0x03, 0xC0, 0x3E, 0x00, 0x3C,
  0x00, 0xFC, 0x07, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x07, 0x00, 0x00, 0xF8, 0x70, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x3D,
  0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x0F, 0xE0, 0x38, 0x7F,
  0xF8, 0x71, 0xFF, 0xF8, 0xE7, 0x01, 0xF9, 0xD8, 0x00, 0xFB, 0xA0, 0x00,
  0xF7, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xCF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x7C,
  0x00, 0xF0, 0x0F, 0x80, 0x0F, 0x01, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x1F, 0xC0, 0x00, 0xF7, 0xFE,
  0x00, 0x0F, 0xF1, 0xE0, 0x00, 0xFE, 0x0F, 0x00, 0x0F, 0xC0, 0x78, 0x00,
  0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3E,
  0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xF0, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xF0, 0x1F, 0x87, 0x3F, 0xE1, 0xFF, 0x3B, 0xFF, 0x9F, 0xFD,
  0xD8, 0x7D, 0xC3, 0xEF, 0x80, 0xE8, 0x07, 0x78, 0x07, 0xC0, 0x3F, 0x80,
  0x3C, 0x01, 0xFC, 0x00, 0xE0, 0x0F, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x38,
  0x01, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x0E, 0x00, 0x7E, 0x00, 0x70, 0x03,
  0xF0, 0x03, 0x80, 0x1F, 0x80, 0x1C, 0x00, 0xFC, 0x00, 0xE0, 0x07, 0xE0,
  0x07, 0x00, 0x3F, 0x00, 0x38, 0x01, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x0E,
  0x00, 0x7E, 0x00, 0x70, 0x03, 0xF0, 0x03, 0x80, 0x1F, 0x80, 0x1C, 0x00,
  0xFC, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x38, 0x01, 0xF8,
  0x01, 0xC0, 0x0F, 0xC0, 0x0E, 0x00, 0x7E, 0x00, 0x70, 0x03, 0xF0, 0x03,
  0x80, 0x1F, 0x80, 0x1C, 0x00, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0x7F, 0x01,
  0xC3, 0xFF, 0xC3, 0x8F, 0xFF, 0xC7, 0x38, 0x0F, 0xCE, 0xC0, 0x07, 0xDD,
  0x00, 0x07, 0xBC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x78, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x77, 0x80,
  0x00, 0x0E, 0x70, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1E,
  0x1E, 0x00, 0x07, 0x81, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x70, 0xFF, 0xF0, 0x38, 0xFF, 0xFC, 0x1C, 0xE0, 0x3F, 0x8E, 0xC0, 0x07,
  0xC7, 0xC0, 0x00, 0xF3, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x1E, 0xE0, 0x00,
  0x07, 0x70, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDF, 0x00, 0x03,
  0xCE, 0xC0, 0x07, 0xC7, 0x38, 0x0F, 0xE3, 0x8F, 0xFF, 0xE1, 0xC3, 0xFF,
  0xC0, 0xE0, 0x7F, 0x80, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF8, 0x70, 0x7F, 0xFF,
  0x1C, 0x3F, 0x01, 0xE7, 0x1F, 0x00, 0x1D, 0xC7, 0x80, 0x01, 0x73, 0xC0,
  0x00, 0x7C, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x7C, 0x78, 0x00, 0x17, 0x1F, 0x00,
  0x1D, 0xC3, 0xF0, 0x1E, 0x70, 0x7F, 0xFF, 0x1C, 0x07, 0xFF, 0x87, 0x00,
  0x7F, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFE, 0x00, 0x73, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x00, 0xE8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xC0, 0x3F, 0x83, 0xE0, 0x00, 0xF8,
  0x78, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x43, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xEC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0x7C, 0x00, 0x01, 0xE7, 0xE0, 0x00, 0x78, 0x3F, 0x80, 0x7E,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x3E, 0x00, 0x2F, 0x1F, 0x81, 0xEF, 0x0F, 0xFF, 0xCF, 0x07,
  0xFF, 0x8F, 0x01, 0xFE, 0x00, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x38, 0x70, 0x00,
  0x07, 0x0E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0x03,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0x38, 0x07, 0x00, 0x0F, 0x00, 0xF0, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xC0, 0x03,
  0x80, 0x38, 0x00, 0x70, 0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xE0, 0x38,
  0x00, 0x1E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0xF0, 0x01, 0xF0, 0x03, 0xBC, 0x00,
  0xF8, 0x01, 0xCE, 0x00, 0x7C, 0x00, 0xE7, 0x00, 0x76, 0x00, 0x73, 0x80,
  0x3B, 0x80, 0x39, 0xC0, 0x1D, 0xC0, 0x3C, 0xE0, 0x0C, 0xE0, 0x1C, 0x70,
  0x0E, 0x30, 0x0E, 0x1C, 0x07, 0x1C, 0x07, 0x0E, 0x03, 0x8E, 0x03, 0x87,
  0x01, 0x87, 0x01, 0xC3, 0x81, 0xC1, 0x80, 0xC1, 0xC0, 0xE0, 0xC0, 0xE0,
  0xE0, 0x70, 0x70, 0x70, 0x38, 0x30, 0x38, 0x38, 0x1C, 0x18, 0x1C, 0x1C,
  0x0E, 0x1C, 0x06, 0x0E, 0x07, 0x0E, 0x03, 0x86, 0x03, 0x87, 0x01, 0xC7,
  0x01, 0xC3, 0x00, 0xE3, 0x80, 0x73, 0x80, 0x31, 0xC0, 0x39, 0xC0, 0x18,
  0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x0E, 0x60, 0x07, 0x30, 0x07, 0x30, 0x03,
  0x98, 0x01, 0xB8, 0x00, 0xDC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78,
  0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x3C,
  0x03, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0xF0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x39, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x1E, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x7C,
  0x3C, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x3C, 0x03,
  0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x03, 0x80, 0x01, 0xC0, 0x3C,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x7E, 0x01,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x1C, 0x1F, 0xE0, 0x00, 0x70, 0xFF, 0xC0, 0x01, 0xC7, 0x8F, 0x80, 0x07,
  0x3C, 0x0F, 0x00, 0x38, 0xE0, 0x1E, 0x00, 0xE3, 0x80, 0x3C, 0x07, 0x9C,
  0x00, 0x78, 0x1C, 0x70, 0x01, 0xF0, 0xF1, 0xC0, 0x03, 0xFF, 0x8E, 0x00,
  0x03, 0xFC, 0x18, 0x00, 0x07, 0xC0,
};

const GFXglyph IBMPlexMono_Light61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 7, 43, 37, 15, -43 },
  { 39, 13, 16, 37, 12, -45 },
  { 65, 35, 43, 37, 1, -43 },
  { 254, 30, 56, 37, 3, -49 },
  { 464, 34, 44, 37, 1, -43 },
  { 651, 32, 44, 37, 2, -43 },
  { 827, 3, 16, 37, 17, -45 },
  { 833, 16, 54, 37, 13, -46 },
  { 941, 16, 54, 37, 7, -46 },
  { 1049, 31, 30, 37, 3, -33 },
  { 1166, 29, 29, 37, 4, -33 },
  { 1272, 9, 16, 37, 13, -7 },
  { 1290, 17, 3, 37, 10, -20 },
  { 1297, 7, 7, 37, 15, -7 },
  { 1304, 25, 54, 37, 6, -46 },
  { 1473, 29, 44, 37, 4, -43 },
  { 1633, 30, 43, 37, 4, -43 },
  { 1795, 27, 43, 37, 5, -43 },
  { 1941, 28, 44, 37, 3, -43 },
  { 2095, 32, 43, 37, 2, -43 },
  { 2267, 27, 44, 37, 5, -43 },
  { 2416, 28, 44, 37, 4, -43 },
  { 2570, 28, 43, 37, 4, -43 },
  { 2721, 29, 44, 37, 4, -43 },
  { 2881, 27, 43, 37, 5, -43 },
  { 3027, 7, 33, 37, 15, -33 },
  { 3056, 9, 42, 37, 13, -33 },
  { 3104, 26, 34, 37, 5, -36 },
  { 3215, 29, 15, 37, 4, -26 },
  { 3270, 26, 34, 37, 5, -36 },
  { 3381, 26, 43, 37, 5, -43 },
  { 3521, 26, 50, 37, 5, -43 },
  { 3684, 32, 43, 37, 2, -43 },
  { 3856, 26, 43, 37, 6, -43 },
  { 3996, 27, 44, 37, 5, -43 },
  { 4145, 27, 43, 37, 6, -43 },
  { 4291, 26, 43, 37, 6, -43 },
  { 4431, 26, 43, 37, 6, -43 },
  { 4571, 28, 44, 37, 4, -43 },
  { 4725, 26, 43, 37, 5, -43 },
  { 4865, 26, 43, 37, 5, -43 },
  { 5005, 24, 44, 37, 5, -43 },
  { 5137, 29, 43, 37, 6, -43 },
  { 5293, 24, 43, 37, 8, -43 },
  { 5422, 27, 43, 37, 5, -43 },
  { 5568, 26, 43, 37, 5, -43 },
  { 5708, 29, 44, 37, 4, -43 },
  { 5868, 27, 43, 37, 6, -43 },
  { 6014, 29, 53, 37, 4, -43 },
  { 6207, 27, 43, 37, 6, -43 },
  { 6353, 30, 44, 37, 3, -43 },
  { 6518, 33, 43, 37, 2, -43 },
  { 6696, 26, 44, 37, 5, -43 },
  { 6839, 31, 43, 37, 3, -43 },
  { 7006, 31, 43, 37, 3, -43 },
  { 7173, 33, 43, 37, 2, -43 },
  { 7351, 34, 43, 37, 1, -43 },
  { 7534, 31, 43, 37, 3, -43 },
  { 7701, 16, 54, 37, 15, -46 },
  { 7809, 25, 54, 37, 6, -46 },
  { 7978, 16, 54, 37, 6, -46 },
  { 8086, 30, 24, 37, 3, -43 },
  { 8176, 29, 3, 37, 4, 7 },
  { 8187, 9, 11, 37, 12, -47 },
  { 8200, 29, 33, 37, 4, -32 },
  { 8320, 25, 46, 37, 7, -45 },
  { 8464, 25, 33, 37, 6, -32 },
  { 8568, 26, 46, 37, 4, -45 },
  { 8718, 27, 33, 37, 5, -32 },
  { 8830, 28, 45, 37, 5, -45 },
  { 8988, 29, 48, 37, 5, -35 },
  { 9162, 23, 45, 37, 7, -45 },
  { 9292, 26, 45, 37, 7, -45 },
  { 9439, 22, 57, 37, 6, -45 },
  { 9596, 28, 45, 37, 7, -45 },
  { 9754, 26, 45, 37, 5, -45 },
  { 9901, 29, 32, 37, 4, -32 },
  { 10017, 23, 32, 37, 7, -32 },
  { 10109, 27, 33, 37, 5, -32 },
  { 10221, 25, 44, 37, 7, -32 },
  { 10359, 26, 44, 37, 4, -32 },
  { 10502, 29, 31, 37, 5, -31 },
  { 10615, 27, 33, 37, 5, -32 },
  { 10727, 30, 43, 37, 2, -43 },
  { 10889, 24, 32, 37, 6, -31 },
  { 10985, 27, 31, 37, 5, -31 },
  { 11090, 33, 31, 37, 2, -31 },
  { 11218, 28, 31, 37, 4, -31 },
  { 11327, 29, 43, 37, 4, -31 },
  { 11483, 25, 31, 37, 6, -31 },
  { 11580, 23, 54, 37, 7, -46 },
  { 11736, 3, 54, 37, 17, -46 },
  { 11757, 23, 54, 37, 7, -46 },
  { 11913, 30, 12, 37, 3, -25 },
};

const GFXfont IBMPlexMono_Light61pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light61pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light61pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _IBMPLEXMONO_LIGHT61PT7B_H_
