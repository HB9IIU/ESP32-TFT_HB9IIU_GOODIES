#ifndef _IBMPLEXMONO_LIGHT29PT7B_H_
#define _IBMPLEXMONO_LIGHT29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light29pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x49, 0x24, 0x00, 0x1F, 0xF0, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x03, 0x18, 0x02, 0x18, 0x02, 0x10, 0x06, 0x10, 0x06,
  0x10, 0x06, 0x30, 0x7C, 0x3F, 0x7C, 0x3F, 0x04, 0x20, 0x0C, 0x20, 0x0C,
  0x60, 0x0C, 0x60, 0xF8, 0x7E, 0xF8, 0x7E, 0x08, 0x40, 0x18, 0x40, 0x18,
  0xC0, 0x18, 0xC0, 0x10, 0xC0, 0x10, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x03, 0xF0, 0x3F, 0xF1, 0xCC, 0xEC, 0x31, 0xB0, 0xC5, 0xC3, 0x03, 0x0C,
  0x06, 0x30, 0x1F, 0xC0, 0x3F, 0xE0, 0x1F, 0xC0, 0x33, 0x80, 0xC6, 0x03,
  0x0C, 0x0C, 0x38, 0x30, 0xF0, 0xC6, 0x73, 0x38, 0xFF, 0xC0, 0xFC, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3C, 0x03, 0x7E, 0x06, 0xC3, 0x04, 0x81,
  0x0C, 0x81, 0x08, 0x81, 0x18, 0x81, 0x10, 0xC3, 0x30, 0x7E, 0x20, 0x3C,
  0x40, 0x00, 0x7C, 0x0C, 0xFE, 0x08, 0xC6, 0x19, 0x82, 0x11, 0x83, 0x31,
  0x83, 0x21, 0x83, 0x60, 0xC6, 0xC0, 0xFE, 0x80, 0x7C, 0x0F, 0x80, 0x3F,
  0x80, 0xE1, 0x81, 0x81, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x38, 0x3C, 0xD8, 0x7B, 0x18, 0xCC, 0x19, 0x98, 0x1A, 0x30,
  0x3C, 0x60, 0x38, 0xC0, 0x30, 0xC1, 0xB1, 0xFE, 0x30, 0xF8, 0x30, 0xFF,
  0xFF, 0x03, 0x04, 0x08, 0x18, 0x30, 0x20, 0x20, 0x60, 0x40, 0x40, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x60, 0x20, 0x20, 0x30, 0x18,
  0x08, 0x04, 0x03, 0xE0, 0x30, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x02,
  0x03, 0x03, 0x03, 0x01, 0x01, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0x04,
  0x0C, 0x08, 0x18, 0x30, 0xE0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x1C, 0x21, 0xCF, 0xDF, 0x03, 0xF0, 0x03, 0x80, 0x0D, 0x80,
  0x19, 0x80, 0x61, 0x01, 0x83, 0x02, 0x03, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x0F, 0xFF, 0xFF, 0xFF, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x3B, 0x9C, 0xC6,
  0x23, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x0F, 0x80, 0xFF,
  0x87, 0x07, 0x18, 0x0C, 0x40, 0x1B, 0x00, 0x6C, 0x00, 0xB0, 0x02, 0xC0,
  0x0F, 0x0C, 0x3C, 0x70, 0xF0, 0xC3, 0xC0, 0x0B, 0x00, 0x2C, 0x01, 0x90,
  0x06, 0x60, 0x31, 0xC1, 0xC3, 0xFE, 0x03, 0xF0, 0x07, 0x00, 0x3C, 0x01,
  0xD0, 0x0E, 0x40, 0x71, 0x03, 0x84, 0x0C, 0x10, 0x20, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x07, 0xFF, 0xDF, 0xFF, 0x0F, 0x81, 0xFF, 0x0C, 0x1C,
  0xC0, 0x6C, 0x01, 0x20, 0x08, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0x81, 0xFF, 0x1C, 0x1C, 0xC0, 0x6C, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0C, 0x0F, 0x80, 0x7E, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x70, 0x03, 0xC0, 0x33, 0x03, 0x8F, 0xF8, 0x3F,
  0x00, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x0D, 0x80, 0x13, 0x00, 0x66,
  0x01, 0x8C, 0x02, 0x18, 0x08, 0x30, 0x30, 0x60, 0x40, 0xC1, 0x01, 0x86,
  0x03, 0x08, 0x06, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x3F, 0xF1, 0xFF, 0x88, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0xF8, 0x7F, 0xE3, 0x83, 0x98, 0x0E, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x68, 0x03, 0xE0, 0x33, 0x83, 0x8F, 0xF8, 0x1F, 0x00,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x10, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C,
  0xF8, 0x5F, 0xE7, 0x83, 0xB8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0x60, 0x1B, 0x83, 0x8F, 0xF8, 0x1F, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0x80, 0x2C, 0x03, 0x60, 0x10, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x00, 0x0F, 0xC0, 0xFF, 0x87, 0x07, 0x18,
  0x06, 0xC0, 0x1B, 0x00, 0x64, 0x01, 0x98, 0x04, 0x30, 0x70, 0x7F, 0x01,
  0xFE, 0x1C, 0x0C, 0xC0, 0x1B, 0x00, 0x2C, 0x00, 0xF0, 0x03, 0xC0, 0x19,
  0xC0, 0xE3, 0xFF, 0x07, 0xF0, 0x0F, 0xC1, 0xFF, 0x1C, 0x1C, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x38, 0x03, 0xC0, 0x1B, 0x00, 0xDC, 0x1E, 0x7F,
  0xB0, 0xF9, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x3C, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x73, 0x9C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xB9, 0xCC, 0x62, 0x30, 0x00, 0x08, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x10, 0x00, 0x0F, 0xC0, 0xFF, 0x0C, 0x1C, 0xC0, 0x64, 0x01, 0xE0, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x0E, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x0E, 0x00, 0x0F,
  0x80, 0xFF, 0x0C, 0x1C, 0xC0, 0x66, 0x01, 0xA0, 0x0F, 0x0F, 0x78, 0xFF,
  0xC6, 0x1E, 0x60, 0xF3, 0x07, 0x98, 0x3C, 0xC1, 0xE6, 0x0F, 0x18, 0x78,
  0xFF, 0xC3, 0xDA, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x80, 0x0F, 0xF0, 0x3F,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x0B, 0x00, 0x36, 0x00, 0x64, 0x00, 0x8C,
  0x03, 0x18, 0x06, 0x10, 0x08, 0x30, 0x30, 0x60, 0x60, 0x40, 0x80, 0xC1,
  0xFF, 0x87, 0xFF, 0x0C, 0x03, 0x10, 0x06, 0x60, 0x0C, 0xC0, 0x09, 0x00,
  0x1E, 0x00, 0x30, 0xFF, 0x8F, 0xFC, 0x80, 0xE8, 0x06, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x06, 0x80, 0xEF, 0xF8, 0xFF, 0xC8, 0x07, 0x80, 0x38, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x38, 0x07, 0xFF, 0xEF, 0xFC, 0x07, 0xC0, 0xFF,
  0x0E, 0x0C, 0xE0, 0x36, 0x01, 0xA0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x03, 0x70,
  0x19, 0xC1, 0x87, 0xF8, 0x1F, 0x80, 0xFF, 0x07, 0xFE, 0x30, 0x39, 0x80,
  0xCC, 0x03, 0x60, 0x1B, 0x00, 0x58, 0x02, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0x60, 0x0B, 0x00, 0xD8, 0x06, 0xC0, 0x66, 0x07, 0x3F,
  0xF1, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFE,
  0xFF, 0xEC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x0F, 0x81, 0xFF, 0x0E, 0x1C, 0xC0, 0x66, 0x01, 0xE0,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x7F, 0x83, 0xFC, 0x01,
  0xE0, 0x0F, 0x00, 0x6C, 0x03, 0x60, 0x1B, 0x83, 0xCF, 0xF6, 0x1F, 0x30,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0x3F, 0xF3, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3C, 0x03,
  0x60, 0x67, 0x0E, 0x3F, 0xC1, 0xF8, 0x80, 0x1C, 0x01, 0xA0, 0x19, 0x01,
  0x88, 0x18, 0x41, 0x82, 0x0C, 0x10, 0xC0, 0x8C, 0x04, 0xF0, 0x2D, 0x81,
  0xC6, 0x0C, 0x18, 0x40, 0xC2, 0x03, 0x10, 0x18, 0x80, 0x64, 0x01, 0xA0,
  0x0D, 0x00, 0x30, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0xFF, 0xFF, 0xF0, 0xE0, 0x1F, 0x01, 0xFC, 0x0B,
  0xE0, 0xDD, 0x04, 0xEC, 0x27, 0x23, 0x39, 0x91, 0xC5, 0x8E, 0x38, 0x70,
  0xC3, 0x84, 0x1C, 0x20, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x10, 0xC0, 0x3E, 0x03, 0xE0, 0x3B, 0x03, 0xB0, 0x39,
  0x83, 0x98, 0x38, 0x83, 0x8C, 0x38, 0x43, 0x86, 0x38, 0x63, 0x83, 0x38,
  0x33, 0x81, 0xB8, 0x1B, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x0F, 0x80,
  0xFF, 0x87, 0x07, 0x18, 0x0C, 0x40, 0x1B, 0x00, 0x6C, 0x00, 0xB0, 0x02,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0B, 0x00, 0x2C, 0x01,
  0x90, 0x06, 0x60, 0x31, 0xC1, 0xC3, 0xFE, 0x03, 0xF0, 0xFF, 0xC7, 0xFF,
  0x30, 0x1D, 0x80, 0x6C, 0x01, 0x60, 0x0F, 0x00, 0x78, 0x02, 0xC0, 0x36,
  0x03, 0xBF, 0xF9, 0xFF, 0x8C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0F, 0x80, 0xFF, 0x87, 0x07, 0x18,
  0x0C, 0x40, 0x1B, 0x00, 0x6C, 0x00, 0xB0, 0x02, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0B, 0x00, 0x2C, 0x01, 0x90, 0x06, 0x60, 0x39,
  0xC1, 0xC3, 0xFE, 0x03, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFC,
  0x01, 0xF0, 0xFF, 0xC7, 0xFF, 0x30, 0x1D, 0x80, 0x6C, 0x01, 0x60, 0x0F,
  0x00, 0x78, 0x02, 0xC0, 0x36, 0x03, 0xBF, 0xF9, 0xFF, 0x0C, 0x30, 0x61,
  0x83, 0x06, 0x18, 0x18, 0xC0, 0xC6, 0x03, 0x30, 0x0D, 0x80, 0x70, 0x0F,
  0xC0, 0xFF, 0x87, 0x03, 0xB0, 0x06, 0xC0, 0x13, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x7C, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xE0, 0x02, 0xC0, 0x19, 0xC0, 0xE3, 0xFF, 0x03, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x3C, 0x03, 0xC0, 0x6E, 0x0E, 0x7F, 0xC3, 0xF8, 0xC0, 0x06, 0xC0, 0x0D,
  0x80, 0x13, 0x00, 0x62, 0x00, 0xC6, 0x01, 0x0C, 0x06, 0x08, 0x0C, 0x18,
  0x18, 0x30, 0x60, 0x20, 0xC0, 0x61, 0x80, 0xC2, 0x01, 0x8C, 0x01, 0x98,
  0x03, 0x20, 0x06, 0xC0, 0x05, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x1A, 0x00, 0x34, 0x00, 0x68, 0x00, 0xD0, 0x61, 0xA1,
  0xC2, 0x63, 0x84, 0xC5, 0x89, 0x8B, 0x13, 0x32, 0x26, 0x64, 0x4C, 0x8D,
  0x89, 0x1B, 0x16, 0x16, 0x2C, 0x2C, 0x50, 0x78, 0xE0, 0xF1, 0xC0, 0xC0,
  0xE0, 0x06, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0xC1, 0x83, 0x01, 0x86, 0x01,
  0x98, 0x03, 0x60, 0x03, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x16, 0x00, 0x66,
  0x01, 0x8C, 0x03, 0x0C, 0x0C, 0x0C, 0x30, 0x18, 0x60, 0x19, 0x80, 0x36,
  0x00, 0x30, 0xC0, 0x03, 0x60, 0x06, 0x60, 0x0C, 0x30, 0x0C, 0x30, 0x18,
  0x18, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x06, 0x60, 0x06, 0xC0, 0x03, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x03, 0xFF, 0xFC, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0xFF, 0xFC,
  0x07, 0x00, 0x1C, 0x00, 0xD8, 0x02, 0x30, 0x18, 0xC0, 0x41, 0x83, 0x02,
  0x18, 0x0C, 0x60, 0x13, 0x00, 0x68, 0x00, 0xE0, 0x04, 0xFF, 0xFF, 0xFF,
  0xF0, 0xCC, 0x62, 0x30, 0x1F, 0x81, 0xFF, 0x04, 0x0E, 0x00, 0x08, 0x00,
  0x30, 0x00, 0xC1, 0xFF, 0x1F, 0xFC, 0xE0, 0x33, 0x00, 0xCC, 0x03, 0x30,
  0x1C, 0xE0, 0xB1, 0xFE, 0xF1, 0xE1, 0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xCF, 0x8D, 0xFC, 0xF0, 0xEC, 0x03, 0xC0, 0x3C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xF0, 0xED,
  0xFC, 0xCF, 0x80, 0x1F, 0x83, 0xFC, 0x70, 0xEE, 0x02, 0xC0, 0x5C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x2E, 0x03, 0x70, 0x63, 0xFC,
  0x1F, 0x80, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x1F,
  0x13, 0xF9, 0x70, 0x56, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x16, 0x03, 0x70, 0x53, 0xF9, 0x1F, 0x10, 0x0F, 0x81,
  0xFF, 0x0C, 0x1C, 0xC0, 0x24, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x23, 0x03, 0x9F, 0xF8, 0x3F, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x0F, 0xFF, 0xFF,
  0xFF, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x1F, 0xFE, 0x7F, 0xF8,
  0x00, 0x3C, 0x00, 0xF0, 0xFA, 0x07, 0xF8, 0x30, 0x71, 0x80, 0xC6, 0x03,
  0x18, 0x0C, 0x60, 0x30, 0xC1, 0xC1, 0xFE, 0x03, 0xE0, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x0F, 0xFC, 0x3F, 0xF9, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xE0,
  0x1D, 0xFF, 0xE1, 0xFE, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x33, 0xE6, 0xFE, 0xD0, 0xFC, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x02, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xC0,
  0x70, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x2F, 0xFB, 0xFE, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x03, 0xB0, 0x18, 0xC0,
  0xC3, 0x06, 0x0C, 0x30, 0x31, 0x80, 0xDE, 0x03, 0xCC, 0x0E, 0x30, 0x30,
  0x60, 0xC0, 0xC3, 0x01, 0x8C, 0x07, 0x30, 0x0C, 0xC0, 0x1C, 0xFF, 0x07,
  0xF8, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC1, 0xFF, 0xFF, 0xFF, 0x80, 0x9C, 0x72, 0xFB,
  0xEC, 0x71, 0xB0, 0xC3, 0x82, 0x0E, 0x08, 0x38, 0x20, 0xE0, 0x83, 0x82,
  0x0E, 0x08, 0x38, 0x20, 0xE0, 0x83, 0x82, 0x0E, 0x08, 0x38, 0x20, 0xC0,
  0xCF, 0x9B, 0xFB, 0x43, 0xF0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x08, 0x0F, 0x81, 0xFF,
  0x1C, 0x1C, 0xC0, 0x64, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xD0, 0x06, 0xC0, 0x67, 0x07, 0x1F, 0xF0, 0x3E, 0x00, 0xCF, 0x8D,
  0xFC, 0xF0, 0xEC, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0xF0, 0xED, 0xFC, 0xCF, 0x8C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x1F, 0x13, 0xF9, 0x70, 0x56, 0x03,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x16, 0x03,
  0x70, 0x53, 0xF9, 0x1F, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0xFE, 0x7F, 0xFB, 0xF0, 0x78, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x0F, 0xC1, 0xFF, 0x9C, 0x0E, 0xC0, 0x26,
  0x00, 0x30, 0x00, 0xFC, 0x03, 0xFE, 0x00, 0xF8, 0x00, 0xC0, 0x06, 0x80,
  0x3F, 0x03, 0x9F, 0xF8, 0x3F, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x36, 0x0A, 0xFF,
  0x47, 0x88, 0xC0, 0x1A, 0x00, 0xD8, 0x04, 0xC0, 0x62, 0x03, 0x18, 0x10,
  0x41, 0x83, 0x08, 0x18, 0x40, 0x46, 0x03, 0x20, 0x1B, 0x00, 0x58, 0x03,
  0x80, 0x1C, 0x00, 0xC1, 0x83, 0x87, 0x07, 0x0A, 0x0A, 0x14, 0x34, 0x2C,
  0x68, 0x48, 0xD1, 0x91, 0x32, 0x22, 0x64, 0x64, 0x48, 0x48, 0xB0, 0xB1,
  0x41, 0x62, 0x82, 0x85, 0x07, 0x0E, 0x06, 0x00, 0xE0, 0x1B, 0x01, 0x8C,
  0x18, 0x30, 0xC0, 0xCC, 0x06, 0xC0, 0x1C, 0x00, 0x60, 0x07, 0x80, 0x6C,
  0x06, 0x30, 0x30, 0xC3, 0x06, 0x30, 0x1B, 0x00, 0x60, 0xC0, 0x0F, 0x00,
  0x66, 0x01, 0x98, 0x0C, 0x20, 0x30, 0xC0, 0x81, 0x06, 0x06, 0x10, 0x18,
  0xC0, 0x23, 0x00, 0xC8, 0x01, 0x60, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0xFF, 0xEF,
  0xFE, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xE1, 0xFC,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x0C,
  0x03, 0x8F, 0xE1, 0xFC, 0x01, 0xC0, 0x18, 0x01, 0x00, 0x40, 0x18, 0x02,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0F, 0xE0, 0xFC, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFE, 0x1F, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20,
  0x08, 0x03, 0x00, 0x60, 0x06, 0x00, 0x7E, 0x0F, 0xC3, 0x00, 0xC0, 0x18,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0xFE, 0x1F,
  0xC0, 0x38, 0x0D, 0xF8, 0x3C, 0x70, 0xB0, 0xE6, 0x81, 0xF2, 0x03, 0x80,
};

const GFXglyph IBMPlexMono_Light29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 3, 20, 17, 7, -20 },
  { 9, 6, 8, 17, 6, -21 },
  { 15, 16, 20, 17, 1, -20 },
  { 55, 14, 26, 17, 2, -23 },
  { 101, 16, 20, 17, 1, -20 },
  { 141, 15, 20, 17, 1, -20 },
  { 179, 2, 8, 17, 8, -21 },
  { 181, 8, 26, 17, 6, -22 },
  { 207, 8, 26, 17, 3, -22 },
  { 233, 15, 14, 17, 1, -16 },
  { 260, 14, 14, 17, 2, -16 },
  { 285, 5, 7, 17, 6, -3 },
  { 290, 8, 2, 17, 5, -10 },
  { 292, 3, 3, 17, 7, -3 },
  { 294, 12, 26, 17, 3, -22 },
  { 333, 14, 20, 17, 2, -20 },
  { 368, 14, 20, 17, 2, -20 },
  { 403, 13, 20, 17, 2, -20 },
  { 436, 13, 20, 17, 2, -20 },
  { 469, 15, 20, 17, 1, -20 },
  { 507, 13, 20, 17, 2, -20 },
  { 540, 13, 20, 17, 2, -20 },
  { 573, 13, 20, 17, 2, -20 },
  { 606, 14, 20, 17, 2, -20 },
  { 641, 13, 20, 17, 2, -20 },
  { 674, 3, 15, 17, 7, -15 },
  { 680, 5, 19, 17, 6, -15 },
  { 692, 13, 16, 17, 2, -17 },
  { 718, 14, 8, 17, 2, -13 },
  { 732, 13, 16, 17, 2, -17 },
  { 758, 13, 20, 17, 2, -20 },
  { 791, 13, 23, 17, 2, -20 },
  { 829, 15, 20, 17, 1, -20 },
  { 867, 12, 20, 17, 3, -20 },
  { 897, 13, 20, 17, 2, -20 },
  { 930, 13, 20, 17, 3, -20 },
  { 963, 12, 20, 17, 3, -20 },
  { 993, 12, 20, 17, 3, -20 },
  { 1023, 13, 20, 17, 2, -20 },
  { 1056, 12, 20, 17, 3, -20 },
  { 1086, 12, 20, 17, 3, -20 },
  { 1116, 12, 20, 17, 2, -20 },
  { 1146, 13, 20, 17, 3, -20 },
  { 1179, 11, 20, 17, 4, -20 },
  { 1207, 13, 20, 17, 2, -20 },
  { 1240, 12, 20, 17, 3, -20 },
  { 1270, 14, 20, 17, 2, -20 },
  { 1305, 13, 20, 17, 3, -20 },
  { 1338, 14, 25, 17, 2, -20 },
  { 1382, 13, 20, 17, 3, -20 },
  { 1415, 14, 20, 17, 2, -20 },
  { 1450, 16, 20, 17, 1, -20 },
  { 1490, 12, 20, 17, 3, -20 },
  { 1520, 15, 20, 17, 1, -20 },
  { 1558, 15, 20, 17, 1, -20 },
  { 1596, 15, 20, 17, 1, -20 },
  { 1634, 16, 20, 17, 1, -20 },
  { 1674, 15, 20, 17, 1, -20 },
  { 1712, 8, 26, 17, 7, -22 },
  { 1738, 12, 26, 17, 3, -22 },
  { 1777, 7, 26, 17, 3, -22 },
  { 1800, 14, 12, 17, 2, -20 },
  { 1821, 14, 2, 17, 2, 3 },
  { 1825, 4, 5, 17, 6, -22 },
  { 1828, 14, 15, 17, 2, -15 },
  { 1855, 12, 21, 17, 3, -21 },
  { 1887, 12, 15, 17, 3, -15 },
  { 1910, 12, 21, 17, 2, -21 },
  { 1942, 13, 15, 17, 2, -15 },
  { 1967, 14, 21, 17, 2, -21 },
  { 2004, 14, 23, 17, 2, -17 },
  { 2045, 11, 21, 17, 3, -21 },
  { 2074, 13, 22, 17, 3, -22 },
  { 2110, 10, 28, 17, 3, -22 },
  { 2145, 14, 21, 17, 3, -21 },
  { 2182, 13, 21, 17, 2, -21 },
  { 2217, 14, 15, 17, 2, -15 },
  { 2244, 11, 15, 17, 3, -15 },
  { 2265, 13, 15, 17, 2, -15 },
  { 2290, 12, 21, 17, 3, -15 },
  { 2322, 12, 21, 17, 2, -15 },
  { 2354, 14, 15, 17, 2, -15 },
  { 2381, 13, 15, 17, 2, -15 },
  { 2406, 14, 20, 17, 1, -20 },
  { 2441, 11, 15, 17, 3, -15 },
  { 2462, 13, 15, 17, 2, -15 },
  { 2487, 15, 15, 17, 1, -15 },
  { 2516, 13, 15, 17, 2, -15 },
  { 2541, 14, 21, 17, 2, -15 },
  { 2578, 12, 15, 17, 3, -15 },
  { 2601, 11, 26, 17, 3, -22 },
  { 2637, 1, 26, 17, 8, -22 },
  { 2641, 11, 26, 17, 3, -22 },
  { 2677, 14, 6, 17, 2, -12 },
};

const GFXfont IBMPlexMono_Light29pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light29pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _IBMPLEXMONO_LIGHT29PT7B_H_
