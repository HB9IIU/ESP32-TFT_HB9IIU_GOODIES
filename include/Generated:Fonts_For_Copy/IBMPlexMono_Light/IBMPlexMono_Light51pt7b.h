#ifndef _IBMPLEXMONO_LIGHT51PT7B_H_
#define _IBMPLEXMONO_LIGHT51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light51pt7bBitmaps[] PROGMEM = {
  0x00, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xC3, 0x0C, 0x30, 0x41, 0x04, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x9F, 0xFF, 0xF7, 0xDE, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xC0,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x38, 0x1C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x0C, 0x06, 0x00, 0x7F, 0xE0, 0x3F, 0xF3, 0xFF, 0x03, 0xFF, 0x9F,
  0xF8, 0x1F, 0xFC, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x07, 0x01, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x60, 0x38, 0x03, 0xFF, 0x01, 0xFF, 0x9F,
  0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xE0, 0x0E, 0x07, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x18, 0x0E, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x1F, 0x8C, 0xFC, 0x1E, 0x06, 0x0F, 0x0E, 0x03, 0x03, 0xCF, 0x01, 0x80,
  0xC7, 0x00, 0xC0, 0x03, 0x80, 0x60, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0x18,
  0x00, 0x70, 0x0C, 0x00, 0x3C, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x07, 0x81,
  0x80, 0x01, 0xF0, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x06, 0x7F, 0x00, 0x03, 0x07, 0x80,
  0x01, 0x81, 0xE0, 0x00, 0xC0, 0x70, 0x00, 0x60, 0x38, 0x00, 0x30, 0x0E,
  0x00, 0x18, 0x07, 0x00, 0x0C, 0x03, 0x80, 0x06, 0x01, 0xD8, 0x03, 0x01,
  0xDE, 0x01, 0x80, 0xE7, 0x80, 0xC0, 0xF3, 0xE0, 0x60, 0xF0, 0x7E, 0x31,
  0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x07, 0xE0, 0x00, 0x31, 0xFF, 0x00, 0x07, 0x3F, 0xF8, 0x00,
  0xE3, 0x83, 0xC0, 0x0E, 0x70, 0x1C, 0x01, 0xC6, 0x00, 0xE0, 0x18, 0x60,
  0x0E, 0x03, 0x8E, 0x00, 0xE0, 0x30, 0xE0, 0x06, 0x07, 0x0E, 0x00, 0x60,
  0x60, 0xE0, 0x0E, 0x0E, 0x06, 0x00, 0xE1, 0xC0, 0x60, 0x0E, 0x1C, 0x07,
  0x01, 0xC3, 0x80, 0x38, 0x3C, 0x30, 0x03, 0xFF, 0x84, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x0E, 0x1F, 0xFC, 0x00, 0xC1, 0xE1, 0xE0, 0x1C,
  0x38, 0x07, 0x01, 0x83, 0x80, 0x70, 0x38, 0x30, 0x03, 0x07, 0x03, 0x00,
  0x30, 0x70, 0x30, 0x03, 0x0E, 0x03, 0x00, 0x30, 0xC0, 0x30, 0x03, 0x1C,
  0x03, 0x00, 0x31, 0x80, 0x38, 0x07, 0x38, 0x03, 0x80, 0x73, 0x00, 0x1E,
  0x1E, 0x70, 0x01, 0xFF, 0xCE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0xE0, 0x0E, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x10, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x01,
  0xF8, 0x7F, 0xC0, 0x3F, 0x1E, 0x38, 0x07, 0xE3, 0x87, 0x80, 0xC0, 0xE0,
  0x78, 0x18, 0x1C, 0x07, 0x87, 0x07, 0x00, 0x78, 0xE0, 0xE0, 0x07, 0x9C,
  0x1C, 0x00, 0x73, 0x83, 0x80, 0x07, 0x60, 0x70, 0x00, 0x7C, 0x0E, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x1F, 0x07, 0x80, 0x06, 0xF0,
  0x78, 0x01, 0xCF, 0x07, 0xC0, 0xF0, 0xE0, 0xFF, 0xFC, 0x0E, 0x07, 0xFF,
  0x00, 0xE0, 0x3F, 0x80, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x60, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0xF0, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x40, 0x0E, 0x00, 0x5E, 0x03, 0x80, 0xFF, 0xF0, 0xE3, 0xFC, 0x7F,
  0xBF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x1E,
  0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0xC0, 0x3C, 0x00, 0x70, 0x06, 0x00, 0x08, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x3F, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x70, 0x70, 0x70, 0xE0,
  0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x79, 0xFF, 0xFF, 0x7D,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F,
  0x81, 0xF8, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x38,
  0x00, 0x0E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xE0,
  0x3E, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x0E, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x1C, 0x1C,
  0x00, 0x3C, 0x1E, 0x00, 0x78, 0x0F, 0x81, 0xF8, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x3C, 0x70, 0x00,
  0x3C, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x07, 0x00,
  0x3C, 0x03, 0x80, 0x0C, 0x01, 0xC0, 0x04, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x01, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xF8, 0x1F, 0x03, 0xC0, 0x0F,
  0x0F, 0x00, 0x0F, 0x1C, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0xF8, 0x0F, 0x83, 0xC0, 0x07, 0x87, 0x00, 0x07, 0x1C,
  0x00, 0x0F, 0x08, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE8, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x78, 0x7E, 0x03, 0xE0, 0x7F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x0E,
  0x0E, 0x00, 0x03, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x38, 0x00,
  0x30, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x30, 0x00, 0xE0, 0x1C, 0x00,
  0x38, 0x0E, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x60,
  0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x3F, 0xC0, 0x19, 0xFF, 0xE0,
  0x77, 0xFF, 0xE0, 0xFE, 0x03, 0xE1, 0xF0, 0x01, 0xE3, 0xC0, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC4, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0x78, 0x00, 0x1C, 0x78, 0x00,
  0xF8, 0x7E, 0x07, 0xE0, 0x7F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x1F, 0xC0, 0x38, 0xFF, 0xE0, 0x73,
  0xFF, 0xE1, 0xEE, 0x03, 0xE3, 0xB0, 0x01, 0xE7, 0xC0, 0x01, 0xEF, 0x00,
  0x01, 0xDE, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xCC, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x78,
  0x3E, 0x03, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xEC,
  0x00, 0x01, 0xD8, 0x00, 0x07, 0xB0, 0x00, 0x0E, 0x60, 0x00, 0x1C, 0xC0,
  0x00, 0x71, 0x80, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0x80, 0xF8, 0x3E, 0x00, 0x3C, 0x3C,
  0x00, 0x1E, 0x38, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x3C,
  0x00, 0x1C, 0x1E, 0x00, 0x38, 0x0F, 0x80, 0xF8, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x38,
  0x00, 0x0E, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0x3C, 0x00, 0x3E, 0x1F,
  0x80, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xF8, 0x0F, 0x83, 0xC0,
  0x07, 0x8F, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x78, 0x00, 0x0E, 0xE0, 0x00,
  0x1D, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x70, 0x00, 0x1E,
  0xF0, 0x00, 0x5C, 0xF0, 0x01, 0xF1, 0xF8, 0x0E, 0xE1, 0xFF, 0xF9, 0xC0,
  0xFF, 0xE7, 0x00, 0x7F, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x79, 0xFF, 0xFF, 0x7D, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x9F, 0xFF, 0xF7, 0xDE, 0x3C, 0x3E, 0x7E, 0x7E, 0x3E, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x70, 0x70,
  0x70, 0xE0, 0xE0, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xC0, 0x7C, 0x3C, 0x00,
  0x78, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0F, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xC0,
  0x7C, 0x1C, 0x00, 0xF0, 0xE0, 0x01, 0xE3, 0x80, 0x03, 0x9C, 0x00, 0x07,
  0x70, 0x00, 0x1D, 0xC0, 0x00, 0x76, 0x01, 0xF1, 0xF8, 0x0F, 0xF7, 0xE0,
  0x7F, 0xFF, 0x83, 0xE1, 0xBE, 0x0E, 0x01, 0xF8, 0x38, 0x07, 0xE1, 0xC0,
  0x1F, 0x87, 0x00, 0x3E, 0x1C, 0x00, 0xF8, 0x70, 0x03, 0xE1, 0xC0, 0x0F,
  0x87, 0x00, 0x3E, 0x1C, 0x00, 0xF8, 0x70, 0x03, 0xE1, 0xC0, 0x1F, 0x83,
  0x00, 0x7E, 0x0E, 0x01, 0xF8, 0x3C, 0x0B, 0xE0, 0x7F, 0xEF, 0x81, 0xFF,
  0x3E, 0x03, 0xF8, 0xD8, 0x01, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x67, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x70, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x1C,
  0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x70, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0C, 0x00, 0x38,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0x80,
  0x01, 0xC0, 0x70, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70,
  0x70, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1C, 0x70, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x00, 0xF0,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x38, 0x00, 0xF8, 0xE0,
  0x00, 0xF3, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1E, 0xE0, 0x00,
  0x7B, 0x80, 0x01, 0xEE, 0x00, 0x07, 0xB8, 0x00, 0x1C, 0xE0, 0x00, 0x73,
  0x80, 0x01, 0xCE, 0x00, 0x0E, 0x38, 0x00, 0xF0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x38, 0x00, 0x7C, 0xE0, 0x00, 0x7B, 0x80, 0x00,
  0xEE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xB8, 0x00, 0x1E, 0xE0, 0x01, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x7C, 0x0F, 0x81, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x8E, 0x00, 0x07, 0x3C,
  0x00, 0x07, 0x70, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0xCF, 0x00, 0x01, 0xCE, 0x00, 0x07, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x78, 0x1F, 0x01, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x38, 0x01,
  0xF8, 0xE0, 0x01, 0xE3, 0x80, 0x03, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1E,
  0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x01,
  0xCE, 0x00, 0x0F, 0x38, 0x00, 0x78, 0xE0, 0x07, 0xE3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x7E, 0x07, 0xC1, 0xF0, 0x03, 0x83, 0x80, 0x03,
  0x8F, 0x00, 0x07, 0x9C, 0x00, 0x07, 0x78, 0x00, 0x0C, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x0D, 0xC0, 0x00,
  0x1B, 0x80, 0x00, 0x77, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCF, 0x00, 0x07,
  0x8E, 0x00, 0x0B, 0x1E, 0x00, 0x36, 0x1F, 0x01, 0xCC, 0x1F, 0xFF, 0x18,
  0x1F, 0xFC, 0x30, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x20, 0x00,
  0x7E, 0x00, 0x07, 0x70, 0x00, 0xF7, 0x00, 0x0E, 0x78, 0x01, 0xE3, 0xE0,
  0x7C, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF0,
  0xE0, 0x01, 0xE0, 0xE0, 0x03, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x00,
  0xE0, 0x0F, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x78, 0x00,
  0xE0, 0xF0, 0x00, 0xE0, 0xE0, 0x00, 0xE1, 0xE0, 0x00, 0xE3, 0xF0, 0x00,
  0xE7, 0xF0, 0x00, 0xEF, 0x78, 0x00, 0xFE, 0x38, 0x00, 0xFC, 0x1C, 0x00,
  0xF8, 0x1E, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x07, 0x80,
  0xE0, 0x03, 0x80, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xE0,
  0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x3C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0D, 0xFB, 0x00, 0x3B, 0xF7,
  0x00, 0x77, 0xE6, 0x01, 0xCF, 0xCE, 0x03, 0x9F, 0x9C, 0x06, 0x3F, 0x1C,
  0x1C, 0x7E, 0x38, 0x30, 0xFC, 0x30, 0xE1, 0xF8, 0x71, 0xC3, 0xF0, 0x63,
  0x07, 0xE0, 0xEE, 0x0F, 0xC1, 0xD8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xC0,
  0x7E, 0x03, 0x80, 0xFC, 0x07, 0x01, 0xF8, 0x0C, 0x03, 0xF0, 0x08, 0x07,
  0xE0, 0x20, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x70, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xEE, 0x00,
  0x1F, 0xB8, 0x00, 0x7E, 0x70, 0x01, 0xF9, 0xC0, 0x07, 0xE7, 0x80, 0x1F,
  0x8E, 0x00, 0x7E, 0x38, 0x01, 0xF8, 0x70, 0x07, 0xE1, 0xC0, 0x1F, 0x83,
  0x80, 0x7E, 0x0E, 0x01, 0xF8, 0x1C, 0x07, 0xE0, 0x70, 0x1F, 0x80, 0xE0,
  0x7E, 0x03, 0x81, 0xF8, 0x0F, 0x07, 0xE0, 0x1C, 0x1F, 0x80, 0x70, 0x7E,
  0x00, 0xE1, 0xF8, 0x03, 0x87, 0xE0, 0x07, 0x1F, 0x80, 0x1C, 0x7E, 0x00,
  0x39, 0xF8, 0x00, 0xE7, 0xE0, 0x03, 0xDF, 0x80, 0x07, 0x7E, 0x00, 0x1D,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F,
  0x81, 0xF8, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x38,
  0x00, 0x0E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x0E, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x1C, 0x1C,
  0x00, 0x3C, 0x1E, 0x00, 0x78, 0x0F, 0x81, 0xF8, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0x7B, 0x80, 0x00, 0xEE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0E, 0xE0, 0x00, 0x7B, 0x80, 0x03, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0x81, 0xF8, 0x1E, 0x00, 0x78, 0x1C,
  0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x0F,
  0x81, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x38, 0x00, 0x3C, 0xE0, 0x00,
  0x7B, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0xE0, 0x00, 0x7B, 0x80, 0x03,
  0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0x80, 0xE0, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0x3C, 0x0E, 0x00,
  0x70, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x0E,
  0x38, 0x00, 0x3C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xEE, 0x00, 0x03, 0xB8,
  0x00, 0x07, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F,
  0x00, 0xFC, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x0F, 0x70, 0x00, 0x06, 0x70,
  0x00, 0x04, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x60, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0E, 0x7C, 0x00, 0x3E, 0x3F, 0x80, 0xFC, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x07,
  0x70, 0x00, 0x1D, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0x8E, 0x00, 0x1E, 0x3C,
  0x00, 0x78, 0x7C, 0x07, 0xC1, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0x00, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xE0,
  0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x70,
  0xF0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0x70,
  0x01, 0xC0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x0E, 0x00,
  0x38, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0x70, 0x1C,
  0x00, 0x1C, 0x07, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38,
  0x38, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x1C, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x60,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07,
  0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x01, 0xE0, 0x19, 0xC0, 0x78,
  0x06, 0x70, 0x1F, 0x01, 0x9C, 0x07, 0xC0, 0x67, 0x03, 0xB0, 0x38, 0xC0,
  0xEC, 0x0E, 0x30, 0x33, 0x83, 0x8C, 0x0C, 0xE0, 0xE3, 0x83, 0x18, 0x38,
  0xE1, 0xC6, 0x0E, 0x38, 0x71, 0xC3, 0x8E, 0x18, 0x70, 0xE3, 0x86, 0x0C,
  0x30, 0xE3, 0x83, 0x0C, 0x38, 0xE0, 0xE3, 0x0E, 0x30, 0x38, 0xC3, 0x8C,
  0x0E, 0x30, 0x67, 0x01, 0x9C, 0x19, 0xC0, 0x77, 0x06, 0x60, 0x1D, 0xC1,
  0x98, 0x07, 0x70, 0x7E, 0x00, 0xDC, 0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x0F,
  0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0xF0,
  0x1C, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0x80,
  0x38, 0x00, 0x78, 0x0E, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x70, 0x70, 0x00,
  0x0F, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x3C, 0x70,
  0x00, 0x07, 0x07, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x38, 0x0E, 0x00, 0x0E,
  0x01, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x3C,
  0x07, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x38, 0x78, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0xF0, 0x07,
  0x00, 0x03, 0x80, 0x78, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x78, 0x38, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x1C,
  0x00, 0x07, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x03, 0x80,
  0x70, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0F, 0x00, 0xC0, 0x03, 0x80, 0xE0,
  0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38,
  0x00, 0x03, 0xB8, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x61, 0xE1, 0xC1, 0xC3, 0x83,
  0x83, 0x07, 0x04, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x3E, 0x07, 0xC0, 0x70, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0x20, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x7C, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xF0,
  0xF0, 0x01, 0x70, 0x7C, 0x0F, 0x7F, 0x3F, 0xFE, 0x3F, 0x1F, 0xFC, 0x3F,
  0x07, 0xF0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x1F, 0x80,
  0xE1, 0xFF, 0x83, 0x9F, 0xFF, 0x0E, 0x70, 0x3E, 0x3B, 0x00, 0x3C, 0xF8,
  0x00, 0x7B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xE0, 0x01,
  0xEE, 0xC0, 0x0F, 0x3B, 0xC0, 0xF8, 0xE7, 0xFF, 0xC3, 0x87, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3E,
  0x07, 0xC3, 0xC0, 0x0F, 0x1C, 0x00, 0x39, 0xC0, 0x00, 0xEE, 0x00, 0x08,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x02, 0x38, 0x00,
  0x1C, 0xE0, 0x01, 0xE7, 0x80, 0x1E, 0x1F, 0x03, 0xE0, 0x7F, 0xFE, 0x01,
  0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x3F, 0x07, 0x07, 0xFF, 0x1C, 0x3F, 0xFE, 0x71, 0xF8, 0x1D, 0xC7, 0x80,
  0x1F, 0x3C, 0x00, 0x3C, 0xE0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x07,
  0x70, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00,
  0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x38, 0x00, 0x1C,
  0xF0, 0x00, 0xF1, 0xE0, 0x07, 0xC7, 0xE0, 0x77, 0x0F, 0xFF, 0x9C, 0x1F,
  0xFC, 0x70, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0xF8, 0x0F, 0x03, 0xC0, 0x0F, 0x07, 0x00, 0x07, 0x1C, 0x00,
  0x0E, 0x38, 0x00, 0x0E, 0x60, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00,
  0x37, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x8E, 0x00, 0x03, 0x8E, 0x00, 0x0F, 0x1E,
  0x00, 0x3C, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x40, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x1F, 0x01, 0xE0, 0x1C, 0x00, 0xF0, 0x38, 0x00, 0x70, 0x38,
  0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38,
  0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x70, 0x1C, 0x00, 0xF0, 0x1F,
  0x01, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x18,
  0x00, 0x1E, 0x70, 0x00, 0x07, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0E, 0x7C,
  0x00, 0x7E, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0xFE, 0x0C, 0x3F, 0xF1, 0x8F, 0xFF, 0x33, 0x81, 0xF6, 0xC0,
  0x1E, 0xD0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xBF, 0xFF, 0xEF, 0xFF,
  0xF3, 0xFF, 0xF8, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x07, 0xDC, 0x00, 0x1E, 0x38, 0x00, 0x78, 0x70, 0x01,
  0xE0, 0xE0, 0x07, 0x81, 0xC0, 0x1E, 0x03, 0x80, 0x78, 0x07, 0x01, 0xC0,
  0x0E, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0xF8, 0x00, 0x73, 0xF0, 0x00,
  0xEE, 0x70, 0x01, 0xF8, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0x80, 0xF0, 0x0E,
  0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0x70, 0x01, 0xE0, 0xE0,
  0x01, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0xCE, 0x00,
  0x03, 0xDC, 0x00, 0x03, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xE0, 0x7C, 0xE7, 0xF1, 0xFE, 0xEF, 0xF3, 0xFF, 0xE8,
  0x7B, 0x0F, 0xF0, 0x3E, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x03, 0xE0,
  0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xE0,
  0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xE0,
  0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xE0,
  0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xE0,
  0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03, 0x01,
  0xFC, 0x18, 0x7F, 0xE3, 0x1F, 0xFE, 0x67, 0x03, 0xED, 0x80, 0x3D, 0xA0,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0xF8, 0x1F, 0x83, 0xC0, 0x0F, 0x07, 0x00, 0x0F, 0x1C, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x77, 0x00,
  0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x07, 0x0E, 0x00, 0x1E, 0x1E, 0x00,
  0x78, 0x1F, 0x03, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x03, 0x87, 0xFE, 0x0E, 0x7F, 0xFC, 0x39, 0xC0, 0xF8,
  0xEC, 0x00, 0xF3, 0xE0, 0x01, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3B, 0xC0,
  0x00, 0xEF, 0x80, 0x07, 0xBB, 0x00, 0x3C, 0xEF, 0x03, 0xE3, 0x9F, 0xFF,
  0x0E, 0x1F, 0xF8, 0x38, 0x3F, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFC,
  0x70, 0xFF, 0xF9, 0xC7, 0xE0, 0x77, 0x1E, 0x00, 0x7C, 0xF0, 0x00, 0xF3,
  0x80, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00,
  0x01, 0xDC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC,
  0x00, 0x07, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0xC0, 0x03, 0xC7, 0x80,
  0x1F, 0x1F, 0x81, 0xDC, 0x3F, 0xFE, 0x70, 0x7F, 0xF1, 0xC0, 0x7F, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xE3, 0xFF, 0x00, 0xE7,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0xE8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0xF8, 0x0F, 0xC3, 0xC0, 0x03, 0xC7, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xEC, 0x00, 0x03, 0xBC, 0x00,
  0x07, 0x3C, 0x00, 0x1E, 0x3F, 0x00, 0xF8, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x70,
  0x00, 0x77, 0x00, 0x0F, 0x78, 0x01, 0xF3, 0xE0, 0x77, 0x1F, 0xFE, 0x70,
  0xFF, 0xC7, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x39, 0xC0,
  0x00, 0x73, 0x80, 0x00, 0xC7, 0x00, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00,
  0x0C, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x60,
  0x01, 0x81, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x06, 0x00, 0x06, 0x1C, 0x00,
  0x0E, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0xC0, 0x0E, 0x00, 0xFC,
  0x03, 0xC0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0D, 0x80, 0x6E, 0x01, 0xB0,
  0x0C, 0xC0, 0x76, 0x03, 0x98, 0x0C, 0xE0, 0x73, 0x01, 0x9C, 0x0E, 0x70,
  0x31, 0x81, 0xCE, 0x0E, 0x30, 0x31, 0xC1, 0xC6, 0x06, 0x18, 0x30, 0xE0,
  0xC3, 0x06, 0x0C, 0x38, 0x60, 0xC1, 0x87, 0x0E, 0x38, 0x30, 0xC1, 0xC6,
  0x07, 0x18, 0x38, 0xC0, 0xE3, 0x03, 0x18, 0x0C, 0x60, 0x67, 0x01, 0x9C,
  0x0C, 0xC0, 0x3B, 0x81, 0xD8, 0x07, 0x60, 0x3B, 0x00, 0x6C, 0x07, 0xE0,
  0x0D, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x00, 0x3E, 0x01, 0xE0, 0x07, 0xC0,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x78, 0xE0, 0x00, 0xE0, 0xE0, 0x03, 0x81,
  0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x01, 0xC0, 0x70, 0x01, 0xC1, 0xC0, 0x03,
  0xC7, 0x00, 0x03, 0x9C, 0x00, 0x03, 0xB8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x77, 0x00, 0x01, 0xCF,
  0x00, 0x07, 0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x1E,
  0x03, 0x80, 0x1E, 0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x3D,
  0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x03, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x81, 0xC0,
  0x01, 0xC1, 0xC0, 0x01, 0xC1, 0x80, 0x00, 0xC3, 0x80, 0x00, 0xE3, 0x80,
  0x00, 0xE7, 0x00, 0x00, 0x77, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x0F, 0x01, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xF8, 0x07, 0xFF, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0x80,
  0x03, 0x8F, 0xF0, 0x01, 0xCF, 0xFC, 0x00, 0xC7, 0x1E, 0x00, 0x67, 0x07,
  0x80, 0x73, 0x81, 0xE0, 0x39, 0x80, 0x78, 0x39, 0xC0, 0x1E, 0x3C, 0xE0,
  0x07, 0xFC, 0x60, 0x01, 0xFC, 0x30, 0x00, 0x3C, 0x00,
};

const GFXglyph IBMPlexMono_Light51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 6, 36, 31, 12, -36 },
  { 28, 11, 14, 31, 10, -38 },
  { 48, 29, 36, 31, 1, -36 },
  { 179, 25, 47, 31, 3, -41 },
  { 326, 28, 37, 31, 1, -36 },
  { 456, 27, 37, 31, 2, -36 },
  { 581, 3, 14, 31, 14, -38 },
  { 587, 14, 46, 31, 11, -39 },
  { 668, 13, 46, 31, 6, -39 },
  { 743, 26, 25, 31, 2, -28 },
  { 825, 24, 25, 31, 3, -28 },
  { 900, 8, 14, 31, 11, -6 },
  { 914, 14, 3, 31, 8, -17 },
  { 920, 6, 6, 31, 12, -6 },
  { 925, 21, 46, 31, 5, -39 },
  { 1046, 24, 37, 31, 3, -36 },
  { 1157, 25, 36, 31, 3, -36 },
  { 1270, 23, 36, 31, 4, -36 },
  { 1374, 23, 37, 31, 3, -36 },
  { 1481, 26, 36, 31, 2, -36 },
  { 1598, 23, 37, 31, 4, -36 },
  { 1705, 23, 37, 31, 4, -36 },
  { 1812, 23, 36, 31, 4, -36 },
  { 1916, 24, 37, 31, 3, -36 },
  { 2027, 23, 36, 31, 4, -36 },
  { 2131, 6, 28, 31, 12, -28 },
  { 2152, 8, 36, 31, 11, -28 },
  { 2188, 22, 29, 31, 4, -30 },
  { 2268, 24, 13, 31, 3, -22 },
  { 2307, 22, 29, 31, 4, -30 },
  { 2387, 22, 36, 31, 4, -36 },
  { 2486, 22, 42, 31, 4, -36 },
  { 2602, 27, 36, 31, 2, -36 },
  { 2724, 22, 36, 31, 5, -36 },
  { 2823, 23, 37, 31, 4, -36 },
  { 2930, 22, 36, 31, 5, -36 },
  { 3029, 21, 36, 31, 5, -36 },
  { 3124, 22, 36, 31, 5, -36 },
  { 3223, 23, 37, 31, 3, -36 },
  { 3330, 22, 36, 31, 4, -36 },
  { 3429, 22, 36, 31, 4, -36 },
  { 3528, 20, 37, 31, 4, -36 },
  { 3621, 24, 36, 31, 5, -36 },
  { 3729, 20, 36, 31, 7, -36 },
  { 3819, 23, 36, 31, 4, -36 },
  { 3923, 22, 36, 31, 4, -36 },
  { 4022, 24, 37, 31, 3, -36 },
  { 4133, 22, 36, 31, 5, -36 },
  { 4232, 24, 45, 31, 3, -36 },
  { 4367, 22, 36, 31, 5, -36 },
  { 4466, 24, 37, 31, 3, -36 },
  { 4577, 27, 36, 31, 2, -36 },
  { 4699, 22, 37, 31, 4, -36 },
  { 4801, 26, 36, 31, 2, -36 },
  { 4918, 26, 36, 31, 2, -36 },
  { 5035, 27, 36, 31, 2, -36 },
  { 5157, 29, 36, 31, 1, -36 },
  { 5288, 26, 36, 31, 2, -36 },
  { 5405, 14, 46, 31, 12, -39 },
  { 5486, 21, 46, 31, 5, -39 },
  { 5607, 13, 46, 31, 5, -39 },
  { 5682, 25, 20, 31, 3, -36 },
  { 5745, 25, 3, 31, 3, 5 },
  { 5755, 7, 9, 31, 10, -39 },
  { 5763, 24, 28, 31, 4, -27 },
  { 5847, 22, 39, 31, 5, -38 },
  { 5955, 21, 28, 31, 5, -27 },
  { 6029, 22, 39, 31, 3, -38 },
  { 6137, 23, 28, 31, 4, -27 },
  { 6218, 24, 38, 31, 4, -38 },
  { 6332, 24, 41, 31, 4, -30 },
  { 6455, 19, 38, 31, 6, -38 },
  { 6546, 22, 38, 31, 6, -38 },
  { 6651, 18, 48, 31, 5, -38 },
  { 6759, 23, 38, 31, 6, -38 },
  { 6869, 22, 38, 31, 4, -38 },
  { 6974, 24, 27, 31, 3, -27 },
  { 7055, 19, 27, 31, 6, -27 },
  { 7120, 23, 28, 31, 4, -27 },
  { 7201, 22, 37, 31, 5, -27 },
  { 7303, 22, 37, 31, 3, -27 },
  { 7405, 24, 26, 31, 4, -26 },
  { 7483, 23, 28, 31, 4, -27 },
  { 7564, 25, 36, 31, 2, -36 },
  { 7677, 20, 27, 31, 5, -26 },
  { 7745, 23, 26, 31, 4, -26 },
  { 7820, 27, 26, 31, 2, -26 },
  { 7908, 23, 26, 31, 4, -26 },
  { 7983, 24, 36, 31, 3, -26 },
  { 8091, 21, 26, 31, 5, -26 },
  { 8160, 19, 46, 31, 6, -39 },
  { 8270, 3, 46, 31, 14, -39 },
  { 8288, 19, 46, 31, 6, -39 },
  { 8398, 25, 11, 31, 3, -21 },
};

const GFXfont IBMPlexMono_Light51pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light51pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light51pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _IBMPLEXMONO_LIGHT51PT7B_H_
