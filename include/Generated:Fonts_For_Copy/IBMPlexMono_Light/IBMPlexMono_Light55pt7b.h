#ifndef _IBMPLEXMONO_LIGHT55PT7B_H_
#define _IBMPLEXMONO_LIGHT55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light55pt7bBitmaps[] PROGMEM = {
  0x00, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x83, 0x04, 0x08, 0x10, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFB, 0xFF, 0xF7, 0xCF, 0x80, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x38, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x03, 0xFF, 0x80, 0xFF, 0xE7, 0xFF,
  0x01, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0x80, 0x1C, 0x07, 0x00, 0x00, 0x30,
  0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0xFF, 0xE0, 0x3F, 0xF9, 0xFF, 0xC0, 0x7F,
  0xF0, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x01, 0xF8, 0xC7, 0xE0, 0x78, 0x18,
  0x3E, 0x1E, 0x03, 0x01, 0xE3, 0x80, 0x60, 0x1C, 0x70, 0x0C, 0x01, 0x1E,
  0x01, 0x80, 0x03, 0xC0, 0x30, 0x00, 0x70, 0x06, 0x00, 0x0F, 0x00, 0xC0,
  0x01, 0xE0, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x7C,
  0x0C, 0x00, 0x07, 0xC1, 0x80, 0x00, 0x7F, 0xB0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0x7F, 0x80, 0x00,
  0x61, 0xF8, 0x00, 0x0C, 0x0F, 0x80, 0x01, 0x80, 0xF0, 0x00, 0x30, 0x0E,
  0x00, 0x06, 0x01, 0xE0, 0x00, 0xC0, 0x3C, 0x00, 0x18, 0x03, 0x80, 0x03,
  0x00, 0x70, 0x00, 0x60, 0x0E, 0x40, 0x0C, 0x03, 0xD8, 0x01, 0x80, 0x77,
  0x80, 0x30, 0x1E, 0x7C, 0x06, 0x03, 0xC7, 0xC0, 0xC1, 0xF0, 0x7F, 0x18,
  0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x1C, 0x7F, 0xF0, 0x00, 0x71, 0xE0, 0xF0, 0x00, 0xC7,
  0x80, 0xE0, 0x03, 0x8E, 0x00, 0xE0, 0x0E, 0x18, 0x01, 0xC0, 0x1C, 0x30,
  0x03, 0x80, 0x70, 0xE0, 0x03, 0x00, 0xE1, 0xC0, 0x06, 0x03, 0x83, 0x80,
  0x0C, 0x07, 0x03, 0x00, 0x38, 0x1C, 0x06, 0x00, 0x70, 0x30, 0x0E, 0x00,
  0xE0, 0xE0, 0x1E, 0x03, 0x83, 0x80, 0x1E, 0x0F, 0x07, 0x00, 0x1F, 0xFC,
  0x1C, 0x00, 0x1F, 0xF0, 0x38, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1C, 0x0F,
  0xF8, 0x00, 0x38, 0x3F, 0xF8, 0x00, 0xE0, 0xF0, 0x78, 0x01, 0xC1, 0xC0,
  0x78, 0x07, 0x07, 0x00, 0x70, 0x0C, 0x0E, 0x00, 0x60, 0x38, 0x18, 0x00,
  0xC0, 0xE0, 0x30, 0x01, 0xC1, 0xC0, 0x60, 0x03, 0x87, 0x00, 0xC0, 0x07,
  0x0E, 0x01, 0x80, 0x0C, 0x38, 0x03, 0x80, 0x18, 0x70, 0x07, 0x00, 0x71,
  0xC0, 0x07, 0x01, 0xE3, 0x00, 0x0F, 0x07, 0x8E, 0x00, 0x0F, 0xFE, 0x38,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x70, 0x07,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x50, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xE1, 0xF7, 0x80, 0x7F, 0x1E,
  0x1E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x0F, 0x01, 0xC0, 0xE0, 0x70, 0x0F,
  0x07, 0x07, 0x80, 0x3C, 0x38, 0x38, 0x00, 0xF1, 0xC1, 0xC0, 0x03, 0xCC,
  0x0E, 0x00, 0x0F, 0x60, 0x70, 0x00, 0x3F, 0x03, 0x80, 0x00, 0xF8, 0x1C,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xF8, 0x1E, 0x00,
  0x1D, 0xE0, 0xF8, 0x01, 0xC7, 0x83, 0xF0, 0x3C, 0x1E, 0x0F, 0xFF, 0xC0,
  0x78, 0x3F, 0xFC, 0x01, 0xC0, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x03, 0x00, 0x38, 0x01, 0x9F, 0x81,
  0xC0, 0x7D, 0xFF, 0x8E, 0x3F, 0xF1, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x78, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x38, 0x00, 0x38, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x3E, 0x3E, 0x3E,
  0x3C, 0x3C, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7C, 0xFB, 0xFF, 0xF7, 0xCF, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xE0, 0x3E, 0x00,
  0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x3C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3F, 0xC0,
  0x38, 0x07, 0xF8, 0x0F, 0x80, 0xFF, 0x01, 0xF0, 0x1F, 0xE0, 0x3E, 0x03,
  0xFC, 0x03, 0x80, 0x7F, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x3C, 0x00,
  0x07, 0x83, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00,
  0x7C, 0x07, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0xF8, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x00, 0xF0,
  0x01, 0x80, 0x3C, 0x00, 0x40, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x07, 0xC1, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0E, 0x10, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xF0, 0x1F, 0x81, 0xE0, 0x03, 0xE1, 0xE0,
  0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x20, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x20,
  0x00, 0x07, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x07, 0x87, 0x80, 0x07, 0xC1,
  0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0E,
  0x78, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x07, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x38, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xC0,
  0x1E, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0xE0, 0x01, 0xE0, 0x07, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x78, 0x03,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xF0, 0x18, 0x00,
  0x07, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x83, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x7F, 0x00, 0x39, 0xFF, 0xE0, 0x1D,
  0xFF, 0xFC, 0x0F, 0xE0, 0x3F, 0x07, 0xC0, 0x07, 0xC3, 0xC0, 0x01, 0xE0,
  0x40, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x40, 0x00, 0x1E, 0xF0, 0x00,
  0x0F, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x03, 0xF0, 0x1F, 0x80, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x7F, 0x00, 0x78, 0xFF,
  0xF0, 0x39, 0xFF, 0xFC, 0x1D, 0xE0, 0x3F, 0x1E, 0xC0, 0x07, 0xCF, 0xC0,
  0x01, 0xF7, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E,
  0x78, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x81, 0xF0, 0x1F,
  0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x3C, 0xE0,
  0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xE0, 0x3F, 0x01, 0xF0,
  0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1C,
  0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x00, 0xFC, 0x07,
  0x80, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01,
  0xCF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0xC1, 0xFC,
  0x07, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xF0, 0x1F,
  0x81, 0xE0, 0x03, 0xC1, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0xE0, 0x00,
  0x0E, 0x70, 0x00, 0x07, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0x70, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xCF, 0x00, 0x06, 0xE7,
  0xC0, 0x06, 0xF1, 0xF8, 0x0F, 0x70, 0x7F, 0xFF, 0x38, 0x1F, 0xFE, 0x3C,
  0x01, 0xFC, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0xFB, 0xFF, 0xF7, 0xCF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7D,
  0xFF, 0xFB, 0xE7, 0xC0, 0x3E, 0x3E, 0x7F, 0x7F, 0x3E, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x78, 0x78, 0x78,
  0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0xF8, 0x0F, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x07, 0x9C, 0x00,
  0x07, 0x78, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x40, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x03, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0x00,
  0x3C, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x07, 0xC7, 0x70, 0x1F,
  0xE7, 0x60, 0x3F, 0xF7, 0xE0, 0x3C, 0x1F, 0xE0, 0x78, 0x0F, 0xE0, 0x70,
  0x07, 0xE0, 0xE0, 0x07, 0xE0, 0xE0, 0x07, 0xE0, 0xE0, 0x07, 0xE0, 0xE0,
  0x07, 0xE0, 0xE0, 0x07, 0xE0, 0xE0, 0x07, 0xE0, 0xE0, 0x07, 0xE0, 0xE0,
  0x07, 0xE0, 0xE0, 0x07, 0xE0, 0xE0, 0x07, 0xE0, 0xE0, 0x07, 0xE0, 0x70,
  0x07, 0xE0, 0x70, 0x07, 0xE0, 0x78, 0x0F, 0x60, 0x3F, 0x7F, 0x70, 0x1F,
  0xF7, 0x70, 0x0F, 0xE7, 0x70, 0x03, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x87,
  0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x01,
  0xC0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1C, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x07, 0x07, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0xF8, 0xE0, 0x00, 0x7C, 0xE0, 0x00,
  0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00,
  0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x7C, 0xE0, 0x00,
  0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x1E, 0xE0, 0x00, 0x7C, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xF8,
  0x0F, 0x80, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x78,
  0x00, 0x0F, 0x38, 0x00, 0x03, 0xBC, 0x00, 0x02, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x10, 0x70, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x8E, 0x00, 0x03, 0x87,
  0x80, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x1E, 0x00, 0x7E, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x01,
  0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0E, 0x78, 0x00,
  0x07, 0x3C, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x77, 0x80,
  0x00, 0x3B, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x07,
  0x78, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x73, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x78, 0xF0, 0x00,
  0x3C, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFC,
  0x0F, 0x80, 0xF8, 0x01, 0xE0, 0xF8, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x0F, 0x3C, 0x00, 0x03, 0x9C, 0x00, 0x01, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x1F, 0xFD, 0xC0, 0x0F,
  0xFE, 0xE0, 0x07, 0xFF, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x77, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x1C, 0xE0,
  0x00, 0x0E, 0x78, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7,
  0x80, 0x03, 0xE1, 0xF0, 0x03, 0x70, 0x7E, 0x07, 0xB8, 0x1F, 0xFF, 0x9C,
  0x07, 0xFF, 0x8E, 0x00, 0xFF, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1D, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x77, 0x80, 0x07, 0x9E, 0x00, 0x78, 0x7C, 0x0F, 0xC1, 0xFF, 0xFC, 0x07,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0xF3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x1E,
  0x0E, 0x00, 0x0F, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0x38, 0x00,
  0xF0, 0x0E, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x00, 0xE0, 0x1E, 0x00, 0x38,
  0x0F, 0x00, 0x0E, 0x07, 0x80, 0x03, 0x83, 0xC0, 0x00, 0xE0, 0xF0, 0x00,
  0x38, 0x7E, 0x00, 0x0E, 0x3F, 0xC0, 0x03, 0x9E, 0xF0, 0x00, 0xEF, 0x1E,
  0x00, 0x3F, 0x83, 0x80, 0x0F, 0xC0, 0xF0, 0x03, 0xE0, 0x1E, 0x00, 0xF0,
  0x03, 0x80, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x1E, 0x03, 0x80, 0x03, 0x80,
  0xE0, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x00,
  0xF0, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x1E, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x70, 0x01,
  0xDF, 0xB8, 0x00, 0xEF, 0xCE, 0x00, 0x67, 0xE7, 0x00, 0x73, 0xF3, 0x80,
  0x39, 0xF8, 0xE0, 0x38, 0xFC, 0x70, 0x1C, 0x7E, 0x1C, 0x1C, 0x3F, 0x0E,
  0x0E, 0x1F, 0x83, 0x86, 0x0F, 0xC1, 0xC7, 0x07, 0xE0, 0xE3, 0x83, 0xF0,
  0x3B, 0x81, 0xF8, 0x1D, 0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F,
  0x00, 0xE0, 0x1F, 0x80, 0x70, 0x0F, 0xC0, 0x38, 0x07, 0xE0, 0x08, 0x03,
  0xF0, 0x04, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1C, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFD, 0xC0, 0x01, 0xFB, 0x80,
  0x03, 0xF3, 0x80, 0x07, 0xE7, 0x00, 0x0F, 0xCF, 0x00, 0x1F, 0x8E, 0x00,
  0x3F, 0x1E, 0x00, 0x7E, 0x1C, 0x00, 0xFC, 0x3C, 0x01, 0xF8, 0x38, 0x03,
  0xF0, 0x78, 0x07, 0xE0, 0x70, 0x0F, 0xC0, 0xF0, 0x1F, 0x80, 0xE0, 0x3F,
  0x01, 0xC0, 0x7E, 0x03, 0xC0, 0xFC, 0x03, 0x81, 0xF8, 0x07, 0x83, 0xF0,
  0x07, 0x07, 0xE0, 0x0F, 0x0F, 0xC0, 0x0E, 0x1F, 0x80, 0x1E, 0x3F, 0x00,
  0x1C, 0x7E, 0x00, 0x3C, 0xFC, 0x00, 0x39, 0xF8, 0x00, 0x73, 0xF0, 0x00,
  0x77, 0xE0, 0x00, 0xEF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x01, 0xE0,
  0x3C, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x3C, 0x38, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x0E, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x07, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x83, 0x80,
  0x00, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0x7C, 0x07, 0xC0,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x7C, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x1E,
  0x07, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x71, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0xF0, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0E, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE0, 0x78,
  0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1E, 0x00, 0x0F, 0x8F, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x73, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x0E, 0xF0,
  0x00, 0x07, 0x78, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xDE, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x1E,
  0xF0, 0x00, 0x0E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x1F, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x1C,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0xE0, 0x1E, 0x00,
  0x78, 0x0F, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x03, 0xC0, 0x03, 0xC1, 0xE0,
  0x00, 0xE0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x1E,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3C, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x7E, 0x00, 0xFC, 0x1E, 0x00,
  0x0F, 0x8F, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x19, 0xE0, 0x00, 0x04, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1D, 0x00, 0x00, 0x07, 0x60, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x1F, 0xC0, 0x3F, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xB8, 0x00, 0x0E, 0x70, 0x00, 0x1C,
  0xF0, 0x00, 0x78, 0xF0, 0x01, 0xE1, 0xF8, 0x0F, 0xC1, 0xFF, 0xFF, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x03, 0x9E, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x38, 0x1C,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x78, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xF0, 0x03, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0,
  0x0E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x07, 0x87, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x0F, 0x00, 0xE3, 0x00, 0xF8, 0x07, 0x1C,
  0x07, 0xC0, 0x30, 0xE0, 0x3E, 0x03, 0x87, 0x01, 0xB8, 0x1C, 0x38, 0x1D,
  0xC0, 0xE1, 0xC0, 0xEE, 0x07, 0x0E, 0x06, 0x30, 0x38, 0x70, 0x31, 0xC1,
  0xC3, 0x83, 0x8E, 0x0E, 0x1C, 0x1C, 0x70, 0x70, 0xE0, 0xC1, 0x83, 0x87,
  0x0E, 0x0E, 0x1C, 0x18, 0x70, 0x70, 0xC0, 0xE3, 0x83, 0x86, 0x07, 0x18,
  0x0C, 0x70, 0x39, 0xC0, 0x73, 0x81, 0xCE, 0x03, 0x9C, 0x0E, 0x70, 0x1C,
  0xE0, 0x73, 0x00, 0x67, 0x03, 0xB8, 0x03, 0xB8, 0x1D, 0xC0, 0x1D, 0xC0,
  0xEE, 0x00, 0xEE, 0x07, 0x60, 0x03, 0x70, 0x3F, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x3C,
  0x07, 0x80, 0x03, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x07, 0x07, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x03, 0xBC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x3C, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x1C, 0x00, 0x1C, 0x01, 0xE0,
  0x00, 0xF0, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0x78, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0x38, 0x00, 0x0F, 0x07, 0x80,
  0x01, 0xC0, 0x70, 0x00, 0x78, 0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x07, 0x80, 0x03, 0xC0,
  0xE0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x87, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x07, 0x38, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0x40, 0x00, 0x01, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x60,
  0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1C, 0x0E, 0x06, 0x07, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xF8, 0x0F, 0xC0, 0x78, 0x00,
  0xF0, 0x1C, 0x00, 0x1E, 0x02, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x7E, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0xF0, 0xF0, 0x00, 0x5C, 0x1E, 0x00, 0x37, 0x07, 0xE0, 0x39,
  0xFC, 0xFF, 0xFC, 0x7F, 0x1F, 0xFE, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x07, 0xF0,
  0x1C, 0x3F, 0xF8, 0x39, 0xFF, 0xF8, 0x77, 0x81, 0xF8, 0xEC, 0x00, 0xF9,
  0xF0, 0x00, 0xF3, 0xC0, 0x00, 0xF7, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x77, 0x80, 0x01, 0xEF, 0x80, 0x07, 0x9D, 0x80, 0x1F,
  0x3B, 0xC0, 0xFC, 0x73, 0xFF, 0xF0, 0xE1, 0xFF, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7C, 0x07, 0xC1,
  0xE0, 0x03, 0xC7, 0x80, 0x03, 0x8E, 0x00, 0x07, 0xBC, 0x00, 0x04, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x03, 0x1C, 0x00, 0x07, 0x3C, 0x00, 0x1C,
  0x3C, 0x00, 0x78, 0x3E, 0x03, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x1F, 0xC0, 0xE0, 0xFF, 0xE1, 0xC3, 0xFF, 0xF3, 0x8F, 0xC0,
  0xF7, 0x3E, 0x00, 0x6E, 0x78, 0x00, 0x7D, 0xE0, 0x00, 0x7B, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0xC0, 0x00, 0xF3, 0xC0,
  0x03, 0xE7, 0xC0, 0x0D, 0xC7, 0xE0, 0x7B, 0x87, 0xFF, 0xE7, 0x07, 0xFF,
  0x0E, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x01, 0xF8, 0x1F, 0x01, 0xE0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xE0,
  0x00, 0x38, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x0E, 0x3C, 0x00, 0x0F, 0x0F, 0x00,
  0x0F, 0x03, 0xF0, 0x3F, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x3F, 0x98, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x01, 0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x80,
  0x03, 0xC0, 0xF0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0,
  0x70, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00, 0xF0, 0x1C, 0x00,
  0x1C, 0x03, 0xC0, 0x07, 0x80, 0x3E, 0x03, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x60, 0x00, 0x3C, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x39, 0x80,
  0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0x7E, 0x00, 0x1F, 0x87, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x0F, 0xE0, 0x71, 0xFF, 0xC3, 0x9F, 0xFF,
  0x9C, 0xE0, 0x7C, 0xEC, 0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0xF0,
  0x0F, 0x01, 0xF0, 0x07, 0x81, 0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xE1, 0xE0,
  0x00, 0xF1, 0xF0, 0x00, 0x79, 0xFC, 0x00, 0x3D, 0xCF, 0x00, 0x1F, 0xC3,
  0xC0, 0x0F, 0xC1, 0xE0, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x07, 0x80, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79,
  0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x3E, 0x1C, 0xFF, 0x0F, 0xF3,
  0x9F, 0xF3, 0xFF, 0x76, 0x1E, 0xE1, 0xEE, 0x81, 0xD0, 0x1D, 0xE0, 0x1E,
  0x03, 0xBC, 0x03, 0x80, 0x3F, 0x00, 0x70, 0x07, 0xE0, 0x0E, 0x00, 0xFC,
  0x01, 0xC0, 0x1F, 0x80, 0x38, 0x03, 0xF0, 0x07, 0x00, 0x7E, 0x00, 0xE0,
  0x0F, 0xC0, 0x1C, 0x01, 0xF8, 0x03, 0x80, 0x3F, 0x00, 0x70, 0x07, 0xE0,
  0x0E, 0x00, 0xFC, 0x01, 0xC0, 0x1F, 0x80, 0x38, 0x03, 0xF0, 0x07, 0x00,
  0x7E, 0x00, 0xE0, 0x0F, 0xC0, 0x1C, 0x01, 0xF8, 0x03, 0x80, 0x3F, 0x00,
  0x70, 0x07, 0xE0, 0x0E, 0x00, 0xFC, 0x01, 0xC0, 0x1F, 0x80, 0x38, 0x03,
  0xF0, 0x07, 0x00, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xFE, 0x07, 0x1F, 0xFC,
  0x39, 0xFF, 0xF9, 0xCE, 0x07, 0xCE, 0xC0, 0x0F, 0x78, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x38, 0xF0, 0x00,
  0x1E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x39, 0xE0, 0x00, 0x3C,
  0x70, 0x00, 0x1C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x03, 0xE0, 0x3E,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x01, 0xC3, 0xFF, 0x83, 0x9F, 0xFF, 0x87, 0x78, 0x1F, 0x8E, 0xC0, 0x0F,
  0x9F, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x79, 0xD8, 0x01,
  0xF3, 0xBC, 0x0F, 0xC7, 0x3F, 0xFF, 0x0E, 0x1F, 0xFC, 0x1C, 0x0F, 0xC0,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFE, 0x1C, 0x3F,
  0xFF, 0x38, 0xFC, 0x0F, 0x73, 0xE0, 0x06, 0xE7, 0x80, 0x07, 0xDE, 0x00,
  0x07, 0xB8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xBC,
  0x00, 0x0F, 0x3C, 0x00, 0x3E, 0x7C, 0x00, 0xDC, 0x7E, 0x07, 0xB8, 0x7F,
  0xFE, 0x70, 0x7F, 0xF0, 0xE0, 0x3F, 0x81, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0x80, 0x39,
  0xE0, 0x00, 0x07, 0x30, 0x00, 0x00, 0xE8, 0x00, 0x00, 0x1D, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0xC1,
  0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x10, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1D, 0x00, 0x00, 0x1E, 0xC0,
  0x00, 0x0E, 0xF8, 0x00, 0x07, 0x3E, 0x00, 0x0F, 0x8F, 0xE0, 0x1F, 0x81,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0x78, 0x01, 0xB9,
  0xF0, 0x3D, 0xCF, 0xFF, 0xCE, 0x1F, 0xFC, 0x70, 0x3F, 0x80, 0x00, 0xF0,
  0x00, 0x03, 0xB8, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCF, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38,
  0x1C, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07, 0x01,
  0xC0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1B, 0x00, 0x76, 0x00, 0xD8, 0x03, 0x38, 0x0E, 0xE0,
  0x19, 0xC0, 0x77, 0x01, 0xCE, 0x03, 0x18, 0x0E, 0x70, 0x18, 0xC0, 0x73,
  0x80, 0xC7, 0x03, 0x8C, 0x0E, 0x38, 0x18, 0x60, 0x70, 0xC0, 0xC3, 0x83,
  0x06, 0x0E, 0x1C, 0x18, 0x30, 0x70, 0xE1, 0xC1, 0xC3, 0x87, 0x0E, 0x0E,
  0x1C, 0x18, 0x60, 0x30, 0xC0, 0xC3, 0x01, 0x86, 0x07, 0x38, 0x0E, 0x70,
  0x39, 0xC0, 0x73, 0x81, 0xCC, 0x01, 0x9C, 0x0E, 0x60, 0x0C, 0xE0, 0x33,
  0x00, 0x76, 0x01, 0xB8, 0x03, 0xB0, 0x0F, 0xC0, 0x1D, 0x80, 0x7C, 0x00,
  0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07,
  0xBC, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x83, 0xC0, 0x03, 0x80, 0xE0, 0x03,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x07, 0x81, 0xC0, 0x01, 0xC1,
  0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x78, 0x3C, 0x00,
  0x38, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x3C, 0x00, 0x78,
  0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x38,
  0x00, 0x38, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x1E, 0x03, 0x80, 0x0E, 0x01,
  0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x03, 0x80,
  0x07, 0x01, 0xC0, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70,
  0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xF0,
  0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xF8, 0x03, 0xFF, 0xC0, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0xE1, 0xFE,
  0x00, 0x1C, 0x7F, 0xE0, 0x03, 0x9E, 0x3E, 0x00, 0x63, 0x83, 0xE0, 0x1C,
  0xE0, 0x3E, 0x03, 0x9C, 0x03, 0xE0, 0xE3, 0x00, 0x3E, 0x3C, 0xE0, 0x03,
  0xFF, 0x1C, 0x00, 0x3F, 0xC3, 0x80, 0x01, 0xF0, 0x00,
};

const GFXglyph IBMPlexMono_Light55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 7, 38, 33, 13, -38 },
  { 35, 11, 15, 33, 11, -41 },
  { 56, 31, 38, 33, 1, -38 },
  { 204, 27, 52, 33, 3, -45 },
  { 380, 31, 40, 33, 1, -39 },
  { 535, 29, 40, 33, 2, -39 },
  { 680, 3, 15, 33, 15, -41 },
  { 686, 15, 50, 33, 12, -42 },
  { 780, 15, 50, 33, 6, -42 },
  { 874, 29, 27, 33, 2, -30 },
  { 972, 27, 27, 33, 3, -30 },
  { 1064, 8, 14, 33, 12, -6 },
  { 1078, 15, 3, 33, 9, -18 },
  { 1084, 7, 6, 33, 13, -6 },
  { 1090, 23, 50, 33, 5, -42 },
  { 1234, 27, 40, 33, 3, -39 },
  { 1369, 26, 38, 33, 4, -38 },
  { 1493, 25, 39, 33, 4, -39 },
  { 1615, 25, 40, 33, 3, -39 },
  { 1740, 29, 38, 33, 2, -38 },
  { 1878, 25, 39, 33, 4, -38 },
  { 2000, 25, 39, 33, 4, -38 },
  { 2122, 25, 38, 33, 4, -38 },
  { 2241, 27, 40, 33, 3, -39 },
  { 2376, 25, 39, 33, 4, -39 },
  { 2498, 7, 29, 33, 13, -29 },
  { 2524, 8, 37, 33, 12, -29 },
  { 2561, 23, 31, 33, 5, -32 },
  { 2651, 27, 14, 33, 3, -24 },
  { 2699, 23, 31, 33, 5, -32 },
  { 2789, 23, 39, 33, 5, -39 },
  { 2902, 24, 45, 33, 4, -39 },
  { 3037, 29, 38, 33, 2, -38 },
  { 3175, 24, 38, 33, 5, -38 },
  { 3289, 25, 40, 33, 4, -39 },
  { 3414, 25, 38, 33, 5, -38 },
  { 3533, 23, 38, 33, 5, -38 },
  { 3643, 24, 38, 33, 5, -38 },
  { 3757, 25, 40, 33, 3, -39 },
  { 3882, 23, 38, 33, 5, -38 },
  { 3992, 23, 38, 33, 5, -38 },
  { 4102, 21, 39, 33, 5, -38 },
  { 4205, 26, 38, 33, 5, -38 },
  { 4329, 22, 38, 33, 7, -38 },
  { 4434, 25, 38, 33, 4, -38 },
  { 4553, 23, 38, 33, 5, -38 },
  { 4663, 27, 40, 33, 3, -39 },
  { 4798, 24, 38, 33, 5, -38 },
  { 4912, 27, 48, 33, 3, -39 },
  { 5074, 25, 38, 33, 5, -38 },
  { 5193, 26, 40, 33, 3, -39 },
  { 5323, 29, 38, 33, 2, -38 },
  { 5461, 23, 39, 33, 5, -38 },
  { 5574, 29, 38, 33, 2, -38 },
  { 5712, 29, 38, 33, 2, -38 },
  { 5850, 29, 38, 33, 2, -38 },
  { 5988, 31, 38, 33, 1, -38 },
  { 6136, 27, 38, 33, 3, -38 },
  { 6265, 15, 50, 33, 13, -42 },
  { 6359, 23, 50, 33, 5, -42 },
  { 6503, 15, 50, 33, 5, -42 },
  { 6597, 27, 22, 33, 3, -38 },
  { 6672, 27, 3, 33, 3, 6 },
  { 6683, 8, 10, 33, 11, -42 },
  { 6693, 26, 30, 33, 4, -29 },
  { 6791, 23, 42, 33, 6, -41 },
  { 6912, 23, 30, 33, 5, -29 },
  { 6999, 23, 42, 33, 4, -41 },
  { 7120, 25, 30, 33, 4, -29 },
  { 7214, 26, 41, 33, 4, -41 },
  { 7348, 27, 44, 33, 4, -32 },
  { 7497, 21, 41, 33, 6, -41 },
  { 7605, 24, 41, 33, 6, -41 },
  { 7728, 20, 52, 33, 5, -41 },
  { 7858, 25, 41, 33, 6, -41 },
  { 7987, 23, 41, 33, 5, -41 },
  { 8105, 27, 29, 33, 3, -29 },
  { 8203, 21, 29, 33, 6, -29 },
  { 8280, 25, 30, 33, 4, -29 },
  { 8374, 23, 40, 33, 6, -29 },
  { 8489, 23, 40, 33, 4, -29 },
  { 8604, 27, 28, 33, 4, -28 },
  { 8699, 25, 30, 33, 4, -29 },
  { 8793, 27, 38, 33, 2, -38 },
  { 8922, 21, 29, 33, 6, -28 },
  { 8999, 25, 28, 33, 4, -28 },
  { 9087, 29, 28, 33, 2, -28 },
  { 9189, 25, 28, 33, 4, -28 },
  { 9277, 25, 39, 33, 4, -28 },
  { 9399, 23, 28, 33, 5, -28 },
  { 9480, 21, 50, 33, 6, -42 },
  { 9612, 3, 50, 33, 15, -42 },
  { 9631, 21, 50, 33, 6, -42 },
  { 9763, 27, 11, 33, 3, -22 },
};

const GFXfont IBMPlexMono_Light55pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light55pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light55pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _IBMPLEXMONO_LIGHT55PT7B_H_
