#ifndef _IBMPLEXMONO_LIGHT9PT7B_H_
#define _IBMPLEXMONO_LIGHT9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x36, 0x54, 0xAD, 0xB0, 0x23, 0xAA, 0xC1, 0xD5, 0xC4,
  0x6D, 0x9C, 0xB6, 0xCC, 0x64, 0x93, 0x69, 0x34, 0xC0, 0x6A, 0xA9, 0x95,
  0x56, 0x25, 0x5C, 0xA0, 0x44, 0xF4, 0x40, 0xC0, 0xE0, 0x80, 0x32, 0x24,
  0x48, 0x88, 0xE9, 0x9D, 0x9E, 0x4C, 0xC4, 0x4F, 0x6A, 0x32, 0xCF, 0x6A,
  0x42, 0x9E, 0x31, 0x95, 0x2F, 0x88, 0xE8, 0xE9, 0x96, 0x68, 0xE9, 0x9E,
  0xFA, 0x24, 0x48, 0xE9, 0x69, 0x9E, 0xE9, 0x9F, 0x24, 0x88, 0x8C, 0x16,
  0x84, 0x30, 0xF0, 0xF0, 0x84, 0x36, 0x80, 0x69, 0x24, 0x04, 0xE9, 0xF9,
  0xF8, 0xE0, 0x22, 0x94, 0xA7, 0xC4, 0xE9, 0xE9, 0x9E, 0xE9, 0x88, 0x9E,
  0xE9, 0x99, 0x9E, 0xF8, 0xF8, 0x8F, 0xF8, 0xE8, 0x88, 0xEA, 0x9B, 0x9F,
  0x99, 0xF9, 0x99, 0xF4, 0x44, 0x4F, 0xE4, 0x9B, 0xC0, 0x9A, 0xCC, 0xA9,
  0x88, 0x88, 0x8F, 0x9B, 0xBD, 0x99, 0x99, 0xDD, 0xB9, 0xE9, 0x99, 0x9E,
  0xE9, 0x9E, 0x88, 0xE9, 0x99, 0x9E, 0x42, 0xE9, 0x9E, 0xAB, 0x74, 0x58,
  0x38, 0xB8, 0xF9, 0x08, 0x42, 0x10, 0x99, 0x99, 0x9E, 0x8C, 0x54, 0xA5,
  0x10, 0x8C, 0x6B, 0xDD, 0xA4, 0x8A, 0x88, 0x45, 0x44, 0x8A, 0x94, 0x42,
  0x10, 0x78, 0x88, 0x88, 0x7C, 0xF2, 0x49, 0x27, 0x88, 0x84, 0x42, 0x23,
  0xD5, 0x57, 0x22, 0x95, 0x10, 0xF0, 0xC0, 0xE2, 0xEA, 0xD0, 0x88, 0xE9,
  0x99, 0xE0, 0x6A, 0x99, 0x60, 0x27, 0xDB, 0x78, 0xE9, 0xF8, 0xF0, 0x74,
  0xF4, 0x44, 0xF0, 0x1E, 0xAE, 0x8F, 0x9F, 0x93, 0xDB, 0x68, 0x40, 0xC4,
  0x44, 0xF0, 0x23, 0x92, 0x49, 0xE0, 0x88, 0xBC, 0xCA, 0x90, 0xC4, 0x44,
  0x44, 0xF0, 0xFD, 0xDD, 0xD0, 0xF6, 0xDA, 0xE9, 0x99, 0xE0, 0xE9, 0x99,
  0xE8, 0x80, 0xF6, 0xDE, 0x48, 0xF4, 0x44, 0xF0, 0xE9, 0xE1, 0xE0, 0x27,
  0xC8, 0x42, 0x1C, 0xB6, 0xDE, 0x9A, 0xAA, 0x40, 0xAF, 0x7B, 0xBD, 0x00,
  0xBA, 0x4A, 0xB0, 0x9A, 0xAC, 0x44, 0x80, 0xE2, 0x48, 0xF0, 0x69, 0x64,
  0x93, 0xFF, 0xCA, 0x3C, 0x96, 0x6C, 0x80,
};

const GFXglyph IBMPlexMono_Light9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 2, 2, 5, 2, -7 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 5, 8, 5, 0, -7 },
  { 12, 5, 6, 5, 0, -6 },
  { 16, 5, 6, 5, 0, -6 },
  { 20, 1, 2, 5, 2, -7 },
  { 21, 2, 8, 5, 2, -7 },
  { 23, 2, 8, 5, 1, -7 },
  { 25, 5, 4, 5, 0, -5 },
  { 28, 4, 5, 5, 1, -5 },
  { 31, 1, 2, 5, 2, -1 },
  { 32, 3, 1, 5, 1, -3 },
  { 33, 1, 1, 5, 2, -1 },
  { 34, 4, 8, 5, 1, -7 },
  { 38, 4, 6, 5, 1, -6 },
  { 41, 4, 6, 5, 1, -6 },
  { 44, 4, 6, 5, 1, -6 },
  { 47, 4, 6, 5, 1, -6 },
  { 50, 5, 6, 5, 0, -6 },
  { 54, 4, 6, 5, 1, -6 },
  { 57, 4, 6, 5, 1, -6 },
  { 60, 4, 6, 5, 1, -6 },
  { 63, 4, 6, 5, 1, -6 },
  { 66, 4, 6, 5, 1, -6 },
  { 69, 1, 5, 5, 2, -5 },
  { 70, 1, 6, 5, 2, -5 },
  { 71, 4, 5, 5, 1, -5 },
  { 74, 4, 3, 5, 1, -4 },
  { 76, 4, 5, 5, 1, -5 },
  { 79, 4, 6, 5, 1, -6 },
  { 82, 4, 7, 5, 1, -6 },
  { 86, 5, 6, 5, 0, -6 },
  { 90, 4, 6, 5, 1, -6 },
  { 93, 4, 6, 5, 1, -6 },
  { 96, 4, 6, 5, 1, -6 },
  { 99, 4, 6, 5, 1, -6 },
  { 102, 4, 6, 5, 1, -6 },
  { 105, 4, 6, 5, 1, -6 },
  { 108, 4, 6, 5, 1, -6 },
  { 111, 4, 6, 5, 1, -6 },
  { 114, 3, 6, 5, 1, -6 },
  { 117, 4, 6, 5, 1, -6 },
  { 120, 4, 6, 5, 1, -6 },
  { 123, 4, 6, 5, 1, -6 },
  { 126, 4, 6, 5, 1, -6 },
  { 129, 4, 6, 5, 1, -6 },
  { 132, 4, 6, 5, 1, -6 },
  { 135, 4, 8, 5, 1, -6 },
  { 139, 4, 6, 5, 1, -6 },
  { 142, 5, 6, 5, 0, -6 },
  { 146, 5, 6, 5, 0, -6 },
  { 150, 4, 6, 5, 1, -6 },
  { 153, 5, 6, 5, 0, -6 },
  { 157, 5, 6, 5, 0, -6 },
  { 161, 5, 6, 5, 0, -6 },
  { 165, 5, 6, 5, 0, -6 },
  { 169, 5, 6, 5, 0, -6 },
  { 173, 3, 8, 5, 2, -7 },
  { 176, 4, 8, 5, 1, -7 },
  { 180, 2, 8, 5, 1, -7 },
  { 182, 5, 4, 5, 0, -6 },
  { 185, 4, 1, 5, 1, 1 },
  { 186, 1, 2, 5, 2, -8 },
  { 187, 4, 5, 5, 1, -5 },
  { 190, 4, 7, 5, 1, -7 },
  { 194, 4, 5, 5, 1, -5 },
  { 197, 3, 7, 5, 1, -7 },
  { 200, 4, 5, 5, 1, -5 },
  { 203, 4, 7, 5, 1, -7 },
  { 207, 4, 8, 5, 1, -6 },
  { 211, 3, 7, 5, 1, -7 },
  { 214, 4, 7, 5, 1, -7 },
  { 218, 3, 9, 5, 1, -7 },
  { 222, 4, 7, 5, 1, -7 },
  { 226, 4, 7, 5, 1, -7 },
  { 230, 4, 5, 5, 1, -5 },
  { 233, 3, 5, 5, 1, -5 },
  { 235, 4, 5, 5, 1, -5 },
  { 238, 4, 7, 5, 1, -5 },
  { 242, 3, 7, 5, 1, -5 },
  { 245, 4, 5, 5, 1, -5 },
  { 248, 4, 5, 5, 1, -5 },
  { 251, 5, 6, 5, 0, -6 },
  { 255, 3, 5, 5, 1, -5 },
  { 257, 4, 5, 5, 1, -5 },
  { 260, 5, 5, 5, 0, -5 },
  { 264, 4, 5, 5, 1, -5 },
  { 267, 4, 7, 5, 1, -5 },
  { 271, 4, 5, 5, 1, -5 },
  { 274, 3, 8, 5, 1, -7 },
  { 277, 1, 8, 5, 2, -7 },
  { 278, 3, 8, 5, 1, -7 },
  { 281, 5, 2, 5, 0, -4 },
};

const GFXfont IBMPlexMono_Light9pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light9pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _IBMPLEXMONO_LIGHT9PT7B_H_
