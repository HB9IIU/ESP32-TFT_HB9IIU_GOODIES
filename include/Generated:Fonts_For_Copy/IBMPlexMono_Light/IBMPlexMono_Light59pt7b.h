#ifndef _IBMPLEXMONO_LIGHT59PT7B_H_
#define _IBMPLEXMONO_LIGHT59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light59pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE7, 0xFF, 0xFF, 0xFF,
  0x7C, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x78, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x01, 0xFF, 0xE0, 0x1F,
  0xFC, 0xFF, 0xF0, 0x1F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0x9F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01,
  0xC0, 0x78, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0x1C, 0xFE, 0x07, 0xC0, 0xE0, 0xF8, 0x3C, 0x07, 0x03,
  0xE3, 0xC0, 0x38, 0x0F, 0x9E, 0x01, 0xC0, 0x30, 0xE0, 0x0E, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x70, 0x07, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0x78, 0x0E, 0x00, 0x03, 0xF0, 0x70, 0x00, 0x0F, 0xE3, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xCF, 0xE0, 0x00, 0x0E, 0x0F, 0x80, 0x00, 0x70,
  0x3E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1E,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x70, 0x0F, 0x20, 0x03, 0x80, 0x7B, 0x80, 0x1C,
  0x03, 0xBE, 0x00, 0xE0, 0x3C, 0xFC, 0x07, 0x03, 0xC3, 0xF0, 0x38, 0x3E,
  0x07, 0xF1, 0xCF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xC7, 0xFF, 0x80,
  0x01, 0xC7, 0xC3, 0xE0, 0x00, 0xE3, 0x80, 0x70, 0x00, 0xE3, 0x80, 0x1C,
  0x00, 0x71, 0xC0, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x00, 0x78, 0x70, 0x01,
  0xC0, 0x38, 0x30, 0x00, 0xE0, 0x38, 0x18, 0x00, 0x70, 0x1C, 0x0C, 0x00,
  0x38, 0x1C, 0x07, 0x00, 0x18, 0x0E, 0x03, 0x80, 0x1C, 0x0E, 0x01, 0xC0,
  0x0E, 0x07, 0x00, 0x70, 0x0E, 0x07, 0x00, 0x3E, 0x0F, 0x07, 0x00, 0x0F,
  0xFF, 0x03, 0x80, 0x03, 0xFF, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x38, 0x1F, 0xF8, 0x00, 0x3C, 0x1F, 0xFE,
  0x00, 0x1C, 0x1F, 0x07, 0x80, 0x1C, 0x0E, 0x01, 0xE0, 0x0E, 0x0F, 0x00,
  0x70, 0x0E, 0x07, 0x00, 0x18, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x01, 0xC0,
  0x07, 0x03, 0x80, 0xE0, 0x03, 0x83, 0x80, 0x70, 0x01, 0xC3, 0xC0, 0x38,
  0x00, 0xE1, 0xC0, 0x1C, 0x00, 0x71, 0xC0, 0x0E, 0x00, 0x30, 0xE0, 0x07,
  0x80, 0x38, 0xE0, 0x01, 0xC0, 0x3C, 0x70, 0x00, 0xF8, 0x3C, 0x70, 0x00,
  0x3F, 0xFC, 0x38, 0x00, 0x0F, 0xFC, 0x20, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x04, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xE1, 0xFF, 0x00, 0x3F,
  0xC7, 0xCF, 0x00, 0x7F, 0x8E, 0x0F, 0x00, 0xE0, 0x3C, 0x0F, 0x01, 0xC0,
  0xF0, 0x0F, 0x03, 0x81, 0xC0, 0x0F, 0x07, 0x07, 0x80, 0x1E, 0x0E, 0x0F,
  0x00, 0x1E, 0x18, 0x1C, 0x00, 0x1E, 0x30, 0x38, 0x00, 0x1E, 0xE0, 0x70,
  0x00, 0x1F, 0xC0, 0xE0, 0x00, 0x1F, 0x81, 0xC0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x3E, 0x07, 0x80, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xBC, 0x0F, 0x00,
  0x07, 0x3C, 0x0F, 0x80, 0x1C, 0x3C, 0x0F, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF,
  0xC0, 0x3C, 0x0F, 0xFF, 0x00, 0x3C, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1F, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x02, 0x00, 0x1C,
  0x00, 0x2F, 0x00, 0x70, 0x03, 0xBF, 0x81, 0xC0, 0x7E, 0xFF, 0xC7, 0x1F,
  0xFC, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x0F, 0x38, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x78, 0x07, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xE0, 0x02, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x3F, 0x3F, 0x3E, 0x3E,
  0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0xFF, 0xFF, 0xFF, 0xEF, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0xF0,
  0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x1C, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0xF0,
  0x0F, 0xE0, 0x1F, 0x00, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0xFE,
  0x00, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x1C, 0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF7, 0x00,
  0x00, 0x1F, 0x38, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x1F, 0x0E, 0x00, 0x03,
  0xF0, 0x70, 0x00, 0x3E, 0x03, 0x80, 0x03, 0xE0, 0x1C, 0x00, 0x3E, 0x00,
  0xE0, 0x01, 0xE0, 0x07, 0x00, 0x06, 0x00, 0x38, 0x00, 0x20, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0E,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x70, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x01,
  0xE0, 0xC0, 0x00, 0x1E, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x80, 0x00, 0x07, 0x38,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x07,
  0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x07, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x80,
  0x1E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x3F,
  0x80, 0x1C, 0x7F, 0xFC, 0x07, 0x3F, 0xFF, 0x81, 0xDE, 0x03, 0xF8, 0x7E,
  0x00, 0x3E, 0x1E, 0x00, 0x03, 0xC3, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x90, 0x00, 0x01, 0xE6, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x83, 0xF8, 0x0F,
  0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x1F, 0xE0, 0x07, 0x0F, 0xFF, 0x01,
  0xE7, 0xFF, 0xF8, 0x3D, 0xE0, 0x3F, 0x87, 0x70, 0x01, 0xF8, 0xEC, 0x00,
  0x0F, 0x1F, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F, 0x70,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x03, 0xF0, 0x1F, 0x80, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x07, 0x9C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0x78, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0x1C, 0x78, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x1C, 0x78, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38,
  0x1C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xC0, 0x3E,
  0x01, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1C, 0x70,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x81, 0xFC, 0x03, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xE0, 0x3F,
  0x01, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x1E, 0x78, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x0F, 0x9E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x7E, 0x3E, 0x00,
  0x1B, 0x83, 0xF0, 0x1E, 0x70, 0x3F, 0xFF, 0x8E, 0x03, 0xFF, 0xE3, 0xC0,
  0x0F, 0xF0, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0xFF, 0xFF,
  0xFF, 0xEF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF9, 0xFF, 0xFF, 0xFF, 0xDF,
  0x00, 0x3E, 0x3F, 0x7F, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78,
  0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x83, 0xE0,
  0x03, 0xE1, 0xE0, 0x00, 0xF9, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x0E, 0xF0,
  0x00, 0x07, 0xB8, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0x81, 0xF8, 0x0F,
  0x80, 0x1F, 0x03, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x0E,
  0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1D, 0xC0, 0x00,
  0x07, 0x70, 0x03, 0xF1, 0xDC, 0x03, 0xFE, 0x77, 0x01, 0xFF, 0xDD, 0xC0,
  0x78, 0x3F, 0x70, 0x3C, 0x03, 0xDC, 0x0E, 0x00, 0x77, 0x07, 0x80, 0x1F,
  0xC1, 0xC0, 0x07, 0xF0, 0x70, 0x01, 0xFC, 0x1C, 0x00, 0x7F, 0x07, 0x00,
  0x1F, 0xC1, 0xC0, 0x07, 0xF0, 0x70, 0x01, 0xFC, 0x1C, 0x00, 0x7F, 0x07,
  0x00, 0x1F, 0xC1, 0xC0, 0x07, 0xF0, 0x70, 0x01, 0xDC, 0x1C, 0x00, 0x77,
  0x03, 0x80, 0x1D, 0xC0, 0xE0, 0x0F, 0x70, 0x3C, 0x03, 0xDC, 0x07, 0xE7,
  0x77, 0x00, 0xFF, 0xDD, 0xC0, 0x1F, 0xE7, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x07, 0x9C,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x78, 0x07, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x1C, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0x80, 0x03, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xF0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x38, 0x1E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1E, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xC0,
  0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x8F,
  0x00, 0x07, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x0F, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0xF0, 0x00,
  0x0F, 0xBC, 0x00, 0x0F, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x10, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x10, 0xF0, 0x00,
  0x03, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x81,
  0xE0, 0x03, 0xE0, 0x1F, 0x81, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x03, 0x80, 0x07, 0xE0, 0xE0, 0x00, 0x7C, 0x38, 0x00, 0x0F,
  0x0E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0F, 0x38, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0xB8,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E,
  0xE0, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x1C, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0xF0, 0xE0, 0x00, 0x7C, 0x38, 0x00, 0x7E, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF3, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03,
  0xF0, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE1, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x31, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x0F, 0x9E,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x7E, 0x3C, 0x00, 0x1F, 0xC3, 0xE0, 0x07,
  0x78, 0x3F, 0x03, 0xCF, 0x03, 0xFF, 0xF1, 0xE0, 0x3F, 0xFC, 0x3C, 0x00,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x77, 0x80, 0x01, 0xE7, 0x80, 0x07, 0x87, 0x80, 0x1F, 0x0F, 0xC0,
  0xFC, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x07, 0x8E,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x1E, 0x07, 0x00, 0x07,
  0xC0, 0xE0, 0x01, 0xF0, 0x1C, 0x00, 0x3C, 0x03, 0x80, 0x0F, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0xF0, 0x01, 0xC0, 0x3C, 0x00, 0x38, 0x0F, 0x80,
  0x07, 0x03, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0x87,
  0xE0, 0x00, 0x71, 0xFE, 0x00, 0x0E, 0x7B, 0xC0, 0x01, 0xDE, 0x3C, 0x00,
  0x3F, 0x87, 0xC0, 0x07, 0xF0, 0x78, 0x00, 0xFC, 0x07, 0x80, 0x1F, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x70, 0x00, 0xF0, 0x0E, 0x00, 0x1E, 0x01,
  0xC0, 0x01, 0xE0, 0x38, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x3C, 0x1C, 0x00, 0x07, 0xC3, 0x80, 0x00, 0x78, 0x70, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0xF9, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1D, 0xFD,
  0xC0, 0x03, 0xBF, 0xB8, 0x00, 0xE7, 0xF7, 0x80, 0x1C, 0xFE, 0x70, 0x07,
  0x1F, 0xCF, 0x00, 0xE3, 0xF8, 0xE0, 0x1C, 0x7F, 0x1C, 0x07, 0x0F, 0xE1,
  0xC0, 0xE1, 0xFC, 0x38, 0x38, 0x3F, 0x87, 0x87, 0x07, 0xF0, 0x71, 0xC0,
  0xFE, 0x0F, 0x38, 0x1F, 0xC0, 0xE7, 0x03, 0xF8, 0x1D, 0xC0, 0x7F, 0x01,
  0xF8, 0x0F, 0xE0, 0x3E, 0x01, 0xFC, 0x07, 0xC0, 0x3F, 0x80, 0x70, 0x07,
  0xF0, 0x0E, 0x00, 0xFE, 0x00, 0xC0, 0x1F, 0xC0, 0x10, 0x03, 0xF8, 0x02,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xE0, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0x78, 0x00, 0x1F, 0x9C, 0x00, 0x0F, 0xCF, 0x00, 0x07, 0xE7,
  0x80, 0x03, 0xF1, 0xC0, 0x01, 0xF8, 0xF0, 0x00, 0xFC, 0x38, 0x00, 0x7E,
  0x1E, 0x00, 0x3F, 0x07, 0x00, 0x1F, 0x83, 0xC0, 0x0F, 0xC0, 0xE0, 0x07,
  0xE0, 0x78, 0x03, 0xF0, 0x1C, 0x01, 0xF8, 0x0F, 0x00, 0xFC, 0x07, 0x80,
  0x7E, 0x01, 0xE0, 0x3F, 0x00, 0xF0, 0x1F, 0x80, 0x38, 0x0F, 0xC0, 0x1E,
  0x07, 0xE0, 0x07, 0x03, 0xF0, 0x03, 0xC1, 0xF8, 0x00, 0xE0, 0xFC, 0x00,
  0x78, 0x7E, 0x00, 0x1C, 0x3F, 0x00, 0x0F, 0x1F, 0x80, 0x07, 0x8F, 0xC0,
  0x01, 0xE7, 0xE0, 0x00, 0xF3, 0xF0, 0x00, 0x39, 0xF8, 0x00, 0x1E, 0xFC,
  0x00, 0x07, 0x7E, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x38, 0x38,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1E, 0x70,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x38, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x1F, 0x00,
  0x7C, 0x07, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3,
  0x80, 0x00, 0xF8, 0xE0, 0x00, 0x1F, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x03,
  0xCE, 0x00, 0x01, 0xF3, 0x80, 0x00, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0xF0, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38, 0x3C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x1F, 0x00, 0x7C, 0x07, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC3, 0x80, 0x00, 0xF8, 0xE0, 0x00, 0x1F, 0x38, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1E, 0xE0, 0x00,
  0x07, 0xB8, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xF3, 0x80, 0x00, 0xF8, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x03, 0x80, 0x78, 0x00,
  0xE0, 0x0F, 0x00, 0x38, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0x80, 0x0E,
  0x00, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x1E, 0x03, 0x80,
  0x03, 0xC0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0xF0, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0x81, 0xF0,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x08, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x88,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F, 0x3E, 0x00,
  0x00, 0xF0, 0xFC, 0x00, 0x1F, 0x03, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xB8,
  0x00, 0x03, 0xDE, 0x00, 0x01, 0xCF, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF1,
  0xF0, 0x00, 0xF0, 0x7E, 0x01, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x71, 0xE0,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x70, 0x1E, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x38,
  0x03, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x0F,
  0x00, 0x38, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x01, 0xE0,
  0x1C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x3C, 0x0E,
  0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x87, 0x00,
  0x00, 0x1E, 0x1C, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x03, 0x9C, 0x01, 0xE0, 0x0E, 0x70,
  0x0F, 0x80, 0x39, 0xC0, 0x3E, 0x00, 0xE7, 0x00, 0xFC, 0x03, 0x9C, 0x03,
  0x70, 0x1C, 0x70, 0x1D, 0xC0, 0x71, 0xC0, 0x77, 0x01, 0xC7, 0x01, 0xCE,
  0x07, 0x1C, 0x07, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xE0, 0xE3, 0x81,
  0xC3, 0x83, 0x87, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x70, 0x70, 0x70,
  0xE1, 0xC1, 0xC1, 0xC3, 0x87, 0x03, 0x87, 0x0E, 0x1C, 0x0E, 0x38, 0x38,
  0xE0, 0x38, 0xE0, 0xE3, 0x80, 0xE3, 0x83, 0x8E, 0x01, 0xCE, 0x0E, 0x38,
  0x07, 0x38, 0x39, 0xC0, 0x1C, 0xE0, 0xF7, 0x00, 0x73, 0x81, 0xDC, 0x01,
  0xEE, 0x07, 0x70, 0x03, 0xB8, 0x1F, 0x80, 0x0E, 0xE0, 0x7E, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xC0,
  0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0xC0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x78, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x70, 0x07, 0x80,
  0x07, 0x80, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0x80, 0x1C,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x70, 0x1E, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x10, 0x38, 0x3E, 0x07, 0x03,
  0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x3C, 0x00,
  0x3C, 0x07, 0x80, 0x01, 0xE0, 0x30, 0x00, 0x1E, 0x01, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0xF0, 0x7C,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F,
  0x00, 0x01, 0xF0, 0x70, 0x00, 0x3F, 0x07, 0x80, 0x06, 0xF0, 0x3F, 0x01,
  0xE7, 0xF1, 0xFF, 0xFC, 0x7F, 0x0F, 0xFF, 0x03, 0xF0, 0x1F, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xFC, 0x03, 0xC3, 0xFF, 0x81, 0xE7,
  0xFF, 0xF0, 0xF7, 0x80, 0xFC, 0x7F, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0x9F,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x77, 0x80, 0x00, 0x7B, 0xE0,
  0x00, 0x3D, 0xF0, 0x00, 0x3C, 0xFE, 0x00, 0x3C, 0x7B, 0xC0, 0x7E, 0x3C,
  0xFF, 0xFE, 0x1E, 0x1F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0x80, 0xFC, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x1E, 0x38, 0x00, 0x0F, 0x78, 0x00, 0x04, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x04, 0x78, 0x00, 0x06,
  0x38, 0x00, 0x0F, 0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x3E, 0x0F, 0x80, 0xFC,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x07, 0xF8, 0x1C, 0x0F, 0xFF, 0x0E, 0x0F, 0xFF, 0xC7, 0x0F,
  0xC0, 0xF3, 0x8F, 0x80, 0x0D, 0xCF, 0x00, 0x03, 0xE7, 0x80, 0x00, 0xF7,
  0x80, 0x00, 0x7B, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x77, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78,
  0x00, 0x1F, 0x1F, 0x00, 0x1B, 0x87, 0xE0, 0x39, 0xC1, 0xFF, 0xF8, 0xE0,
  0x7F, 0xF8, 0x70, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x03, 0xF0, 0x1E, 0x00, 0x3E, 0x0F, 0x00,
  0x07, 0x83, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x08,
  0x78, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x78, 0x0F, 0xC0, 0x7E, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0x98, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x38,
  0x03, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x07, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x1F, 0x06, 0x00,
  0x00, 0x3C, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x78, 0x7E, 0x00, 0x1F, 0xC1, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x0F, 0xF0, 0x3C, 0x7F, 0xF8, 0x79, 0xFF, 0xF8, 0xF7, 0x81, 0xF9, 0xEC,
  0x00, 0xFB, 0xE0, 0x00, 0xF7, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xE7, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x1C,
  0x00, 0x0F, 0x03, 0x80, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x0E, 0x00, 0x7C,
  0x01, 0xC0, 0x1F, 0x00, 0x38, 0x07, 0xC0, 0x07, 0x01, 0xF0, 0x00, 0xE0,
  0x78, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0x87, 0xE0, 0x00, 0x71, 0xFC, 0x00,
  0x0E, 0xFB, 0xC0, 0x01, 0xFC, 0x3C, 0x00, 0x3F, 0x03, 0xC0, 0x07, 0xC0,
  0x7C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0x78, 0x03, 0x80, 0x07, 0x80,
  0x70, 0x00, 0x78, 0x0E, 0x00, 0x0F, 0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xF3,
  0x80, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xF0, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xF0, 0x1F, 0x0E, 0x7F, 0x87, 0xFC, 0xEF, 0xFC, 0xFF, 0xEE,
  0xC3, 0xCC, 0x3E, 0xF0, 0x1F, 0x80, 0xEE, 0x00, 0xF0, 0x0E, 0xE0, 0x0F,
  0x00, 0xFE, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07,
  0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00,
  0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00,
  0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0,
  0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0,
  0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E,
  0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E,
  0x00, 0x70, 0x00, 0x7F, 0x81, 0xE3, 0xFF, 0xC3, 0xCF, 0xFF, 0xC7, 0xBC,
  0x0F, 0xCF, 0x60, 0x07, 0xDF, 0x00, 0x07, 0xBE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0xF0, 0x01,
  0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07,
  0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0x9E, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0x87, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x78,
  0x7F, 0xF0, 0x3C, 0xFF, 0xFE, 0x1E, 0xF0, 0x1F, 0x8F, 0xE0, 0x03, 0xC7,
  0xC0, 0x00, 0xF3, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07,
  0x78, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0E, 0xF0,
  0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBE, 0x00, 0x07, 0x9F, 0xC0, 0x07, 0x8F,
  0x78, 0x0F, 0xC7, 0x9F, 0xFF, 0xC3, 0xC3, 0xFF, 0x81, 0xE0, 0x7F, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0xE1, 0xC1, 0xFF, 0xF8, 0xE1, 0xF8, 0x1E, 0x71,
  0xF0, 0x01, 0xB9, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0x78, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xF0,
  0x00, 0x07, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xE3,
  0xE0, 0x03, 0x70, 0xFC, 0x07, 0x38, 0x3F, 0xFF, 0x1C, 0x0F, 0xFF, 0x0E,
  0x01, 0xFE, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF9, 0xFF,
  0xF0, 0x07, 0x9C, 0x00, 0x00, 0x7B, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xE0, 0x1F,
  0x81, 0xE0, 0x00, 0xFC, 0x38, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x41, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x20, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0x3B, 0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xC1, 0xFC, 0x03,
  0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x7C, 0xF0, 0x01, 0xB9, 0xF8, 0x0E,
  0x71, 0xFF, 0xFC, 0xE1, 0xFF, 0xE1, 0xC0, 0x7F, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x38, 0x78, 0x00, 0x07, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x38, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x3C, 0x00, 0x38, 0x03,
  0x80, 0x0F, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x0F,
  0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x1C, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07,
  0x78, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x3B, 0x80, 0x3F, 0x00, 0x77, 0x00, 0x6E, 0x00, 0xEE,
  0x00, 0xDC, 0x01, 0xDC, 0x03, 0x98, 0x07, 0x38, 0x07, 0x30, 0x0E, 0x70,
  0x0C, 0x70, 0x1C, 0x60, 0x18, 0xE0, 0x38, 0xE0, 0x71, 0xC0, 0x71, 0xC0,
  0xE1, 0x80, 0xE3, 0x81, 0xC3, 0x81, 0x87, 0x03, 0x07, 0x07, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0C, 0x1C, 0x0C, 0x1C, 0x1C, 0x38, 0x18, 0x38, 0x38, 0x60,
  0x38, 0x70, 0x70, 0xC0, 0x70, 0xC0, 0xE3, 0x80, 0x63, 0x81, 0xC7, 0x00,
  0xC7, 0x01, 0x8E, 0x01, 0xCE, 0x03, 0x98, 0x03, 0x9C, 0x07, 0x70, 0x07,
  0x30, 0x0E, 0xE0, 0x06, 0x60, 0x1D, 0xC0, 0x0D, 0xC0, 0x3B, 0x00, 0x1F,
  0x80, 0x3E, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0x78, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x1E, 0x01, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x3D, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x1E,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xC0, 0x03, 0x80, 0x3C, 0x00,
  0x3C, 0x03, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x1E, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x38, 0x7F, 0x80, 0x01, 0xC7, 0xFF, 0x00, 0x0E, 0x3C, 0x7C, 0x00,
  0x73, 0xC1, 0xE0, 0x07, 0x1C, 0x07, 0x80, 0x39, 0xC0, 0x1E, 0x03, 0xCE,
  0x00, 0x78, 0x1C, 0x70, 0x01, 0xE1, 0xE3, 0x00, 0x07, 0xFE, 0x38, 0x00,
  0x1F, 0xE0, 0xC0, 0x00, 0x3C, 0x00,
};

const GFXglyph IBMPlexMono_Light59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 7, 41, 35, 14, -41 },
  { 37, 13, 16, 35, 11, -44 },
  { 63, 33, 41, 35, 1, -41 },
  { 233, 29, 55, 35, 3, -48 },
  { 433, 33, 43, 35, 1, -42 },
  { 611, 31, 43, 35, 2, -42 },
  { 778, 3, 16, 35, 16, -44 },
  { 784, 16, 53, 35, 13, -45 },
  { 890, 16, 53, 35, 7, -45 },
  { 996, 30, 29, 35, 3, -32 },
  { 1105, 28, 29, 35, 4, -33 },
  { 1207, 8, 16, 35, 13, -7 },
  { 1223, 17, 3, 35, 9, -19 },
  { 1230, 7, 6, 35, 14, -6 },
  { 1236, 24, 53, 35, 6, -45 },
  { 1395, 28, 43, 35, 4, -42 },
  { 1546, 29, 41, 35, 4, -41 },
  { 1695, 27, 42, 35, 4, -42 },
  { 1837, 27, 43, 35, 3, -42 },
  { 1983, 31, 41, 35, 2, -41 },
  { 2142, 26, 42, 35, 5, -41 },
  { 2279, 27, 42, 35, 4, -41 },
  { 2421, 27, 41, 35, 4, -41 },
  { 2560, 28, 43, 35, 4, -42 },
  { 2711, 27, 42, 35, 4, -42 },
  { 2853, 7, 31, 35, 14, -31 },
  { 2881, 8, 40, 35, 13, -31 },
  { 2921, 25, 33, 35, 5, -34 },
  { 3025, 28, 14, 35, 4, -25 },
  { 3074, 25, 33, 35, 5, -34 },
  { 3178, 25, 42, 35, 5, -42 },
  { 3310, 26, 48, 35, 4, -42 },
  { 3466, 31, 41, 35, 2, -41 },
  { 3625, 26, 41, 35, 5, -41 },
  { 3759, 27, 43, 35, 4, -42 },
  { 3905, 26, 41, 35, 6, -41 },
  { 4039, 25, 41, 35, 6, -41 },
  { 4168, 25, 41, 35, 6, -41 },
  { 4297, 27, 43, 35, 4, -42 },
  { 4443, 25, 41, 35, 5, -41 },
  { 4572, 25, 41, 35, 5, -41 },
  { 4701, 23, 42, 35, 5, -41 },
  { 4822, 27, 41, 35, 6, -41 },
  { 4961, 23, 41, 35, 8, -41 },
  { 5079, 27, 41, 35, 4, -41 },
  { 5218, 25, 41, 35, 5, -41 },
  { 5347, 28, 43, 35, 4, -42 },
  { 5498, 26, 41, 35, 6, -41 },
  { 5632, 28, 52, 35, 4, -42 },
  { 5814, 26, 41, 35, 6, -41 },
  { 5948, 29, 43, 35, 3, -42 },
  { 6104, 32, 41, 35, 2, -41 },
  { 6268, 25, 42, 35, 5, -41 },
  { 6400, 30, 41, 35, 3, -41 },
  { 6554, 30, 41, 35, 3, -41 },
  { 6708, 31, 41, 35, 2, -41 },
  { 6867, 33, 41, 35, 1, -41 },
  { 7037, 30, 41, 35, 3, -41 },
  { 7191, 16, 53, 35, 14, -45 },
  { 7297, 24, 53, 35, 6, -45 },
  { 7456, 15, 53, 35, 6, -45 },
  { 7556, 29, 23, 35, 3, -41 },
  { 7640, 28, 3, 35, 4, 6 },
  { 7651, 9, 11, 35, 11, -46 },
  { 7664, 28, 32, 35, 4, -31 },
  { 7776, 25, 45, 35, 6, -44 },
  { 7917, 24, 32, 35, 6, -31 },
  { 8013, 25, 45, 35, 4, -44 },
  { 8154, 26, 32, 35, 5, -31 },
  { 8258, 27, 44, 35, 5, -44 },
  { 8407, 29, 47, 35, 4, -34 },
  { 8578, 23, 44, 35, 6, -44 },
  { 8705, 26, 43, 35, 6, -43 },
  { 8845, 21, 55, 35, 6, -43 },
  { 8990, 27, 44, 35, 7, -44 },
  { 9139, 25, 44, 35, 5, -44 },
  { 9277, 28, 31, 35, 4, -31 },
  { 9386, 23, 31, 35, 6, -31 },
  { 9476, 27, 32, 35, 4, -31 },
  { 9584, 25, 43, 35, 6, -31 },
  { 9719, 25, 43, 35, 4, -31 },
  { 9854, 28, 30, 35, 5, -30 },
  { 9959, 27, 32, 35, 4, -31 },
  { 10067, 29, 41, 35, 2, -41 },
  { 10216, 23, 31, 35, 6, -30 },
  { 10306, 27, 30, 35, 4, -30 },
  { 10408, 31, 30, 35, 2, -30 },
  { 10525, 27, 30, 35, 4, -30 },
  { 10627, 28, 42, 35, 4, -30 },
  { 10774, 25, 30, 35, 5, -30 },
  { 10868, 23, 53, 35, 6, -45 },
  { 11021, 3, 53, 35, 16, -45 },
  { 11041, 23, 53, 35, 6, -45 },
  { 11194, 29, 12, 35, 3, -24 },
};

const GFXfont IBMPlexMono_Light59pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light59pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light59pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _IBMPLEXMONO_LIGHT59PT7B_H_
