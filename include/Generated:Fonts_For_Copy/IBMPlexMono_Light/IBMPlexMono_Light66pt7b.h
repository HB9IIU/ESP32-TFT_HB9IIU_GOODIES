#ifndef _IBMPLEXMONO_LIGHT66PT7B_H_
#define _IBMPLEXMONO_LIGHT66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light66pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0x1C, 0x03, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x7F, 0xFC, 0x01,
  0xFF, 0xF3, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xF1, 0xCF, 0xF0,
  0x0F, 0x81, 0xC1, 0xFC, 0x1F, 0x01, 0xC0, 0x7C, 0x3E, 0x01, 0xC0, 0x3E,
  0x3C, 0x01, 0xC0, 0x1C, 0x3C, 0x01, 0xC0, 0x08, 0x78, 0x01, 0xC0, 0x00,
  0x78, 0x01, 0xC0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0x78, 0x01, 0xC0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0x3C, 0x01, 0xC0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0x1F, 0x81, 0xC0, 0x00, 0x0F, 0xE1, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xC3, 0xF8, 0x00, 0x01, 0xC0, 0xFC,
  0x00, 0x01, 0xC0, 0x3C, 0x00, 0x01, 0xC0, 0x3E, 0x00, 0x01, 0xC0, 0x1E,
  0x00, 0x01, 0xC0, 0x1E, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x01, 0xC0, 0x0F,
  0x00, 0x01, 0xC0, 0x0F, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x01, 0xC0, 0x0F,
  0x00, 0x01, 0xC0, 0x0F, 0x20, 0x01, 0xC0, 0x1E, 0x70, 0x01, 0xC0, 0x1E,
  0xF8, 0x01, 0xC0, 0x1E, 0xFC, 0x01, 0xC0, 0x3C, 0x7E, 0x01, 0xC0, 0x7C,
  0x3F, 0x81, 0xC1, 0xF8, 0x0F, 0xF1, 0xC7, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xC3, 0xFF, 0xE0,
  0x00, 0x1C, 0x3E, 0x0F, 0x80, 0x01, 0xE3, 0xC0, 0x3C, 0x00, 0x0E, 0x1C,
  0x00, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x70, 0x00, 0xF0, 0x03, 0x83, 0x80, 0x07, 0x80, 0x38, 0x1C, 0x00,
  0x3C, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0x1C, 0x07, 0x00, 0x0F, 0x01, 0xE0,
  0x38, 0x00, 0x78, 0x0E, 0x01, 0xC0, 0x03, 0xC0, 0xF0, 0x0E, 0x00, 0x1C,
  0x07, 0x00, 0x78, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0x0F, 0x03, 0x80, 0x0F,
  0x00, 0xF0, 0x38, 0x00, 0x3E, 0x0F, 0x83, 0xC0, 0x00, 0xFF, 0xF8, 0x1C,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3C, 0x0F, 0xFF, 0x80, 0x01, 0xC0,
  0xF8, 0x3E, 0x00, 0x1E, 0x0F, 0x00, 0xF0, 0x00, 0xE0, 0x70, 0x03, 0xC0,
  0x0F, 0x07, 0x80, 0x0E, 0x00, 0x70, 0x38, 0x00, 0x70, 0x07, 0x01, 0xC0,
  0x03, 0xC0, 0x78, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x70, 0x00, 0x70, 0x3C,
  0x03, 0x80, 0x03, 0x81, 0xC0, 0x1C, 0x00, 0x1C, 0x1E, 0x00, 0xE0, 0x00,
  0xE0, 0xE0, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x38, 0x00, 0x70, 0x70, 0x01,
  0xE0, 0x03, 0x87, 0x00, 0x07, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x03, 0xC3,
  0x80, 0x00, 0xF8, 0x3E, 0x3C, 0x00, 0x03, 0xFF, 0xE1, 0xC0, 0x00, 0x0F,
  0xFE, 0x10, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x08, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x07, 0x9F, 0x00, 0x3F, 0xE1, 0xE1, 0xE0, 0x07, 0xFC,
  0x78, 0x1E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x1E, 0x03,
  0x80, 0xF0, 0x03, 0xE0, 0x70, 0x1E, 0x00, 0x3C, 0x0E, 0x03, 0x80, 0x03,
  0xC1, 0xC0, 0xF0, 0x00, 0x3C, 0x38, 0x1E, 0x00, 0x03, 0xCE, 0x03, 0xC0,
  0x00, 0x3D, 0xC0, 0x78, 0x00, 0x07, 0xF8, 0x0F, 0x00, 0x00, 0x7F, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x03, 0x78, 0x0F, 0x80, 0x00, 0xE7, 0x80, 0xF8, 0x00,
  0x38, 0x78, 0x0F, 0x80, 0x0F, 0x0F, 0x81, 0xFC, 0x07, 0xC0, 0xF8, 0x0F,
  0xFF, 0xF0, 0x0F, 0x80, 0xFF, 0xF8, 0x00, 0xF8, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0xFE, 0x01, 0xE0, 0x1F, 0xBF,
  0xF0, 0x78, 0x3F, 0xF3, 0xFF, 0x9E, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x0F,
  0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x03,
  0xC0, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7C, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0x80, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x03, 0xC0, 0x1E, 0xF0, 0x07, 0xE0, 0x1E, 0xF0, 0x07, 0xE0,
  0x1F, 0xF0, 0x07, 0xE0, 0x1F, 0xF0, 0x07, 0xE0, 0x1F, 0xF0, 0x03, 0xC0,
  0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x3C, 0x38, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00,
  0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x1F,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x01, 0xF8, 0xF0,
  0x00, 0x03, 0xF0, 0xF0, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0x30, 0x00, 0xF0, 0x00, 0x20, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x78, 0xF8,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0xC7, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3E, 0x08, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE4,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x81, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xE0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x0E,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x03, 0xFC, 0x00, 0x70, 0xFF, 0xFC,
  0x03, 0x8F, 0xFF, 0xF0, 0x1C, 0xF0, 0x1F, 0xC0, 0xEC, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x1E, 0xF8, 0x00, 0x01, 0xE3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0,
  0x3F, 0x80, 0x7F, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0xFF, 0x00, 0x1E, 0x1F, 0xFF, 0x80, 0x78, 0xFF, 0xFF, 0x01, 0xE7, 0x80,
  0x7F, 0x07, 0xB8, 0x00, 0x7E, 0x3D, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01,
  0xF0, 0x78, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03, 0xEE, 0x00,
  0x00, 0x0F, 0x38, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0x3E, 0x38, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0x03,
  0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x03,
  0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x01,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x07, 0xC0,
  0x78, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x71, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x1B, 0x8F, 0x80, 0x00, 0xFE, 0x1F,
  0x80, 0x07, 0x78, 0x3F, 0x80, 0x79, 0xE0, 0x7F, 0xFF, 0xC7, 0x00, 0x7F,
  0xFC, 0x3C, 0x00, 0x3F, 0xC0, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7C, 0x1F, 0x0F, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xE1, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F,
  0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xE0, 0x1F, 0x83,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3D, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x78,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x07,
  0xB8, 0x00, 0x00, 0x3D, 0xC0, 0x07, 0xE1, 0xEE, 0x00, 0x7F, 0xCF, 0xF0,
  0x0F, 0xFF, 0x7F, 0x80, 0x7C, 0x1F, 0xFC, 0x07, 0x80, 0x3F, 0xE0, 0x38,
  0x00, 0xFF, 0x03, 0xC0, 0x07, 0xF0, 0x1C, 0x00, 0x3F, 0x80, 0xE0, 0x01,
  0xFC, 0x07, 0x00, 0x0F, 0xE0, 0x38, 0x00, 0x7F, 0x03, 0xC0, 0x03, 0xF8,
  0x1E, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0xFE, 0x07, 0x80, 0x07, 0xF0, 0x3C,
  0x00, 0x3F, 0x81, 0xE0, 0x01, 0xFC, 0x07, 0x00, 0x0F, 0xE0, 0x38, 0x00,
  0x7F, 0x81, 0xC0, 0x03, 0xFC, 0x0F, 0x00, 0x1F, 0xE0, 0x78, 0x00, 0xFF,
  0x01, 0xE0, 0x0F, 0xF8, 0x0F, 0x80, 0xFD, 0xC0, 0x3F, 0x1D, 0xEE, 0x00,
  0xFF, 0xEF, 0x70, 0x03, 0xFE, 0x7B, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0x78, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x87, 0x00, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xE0, 0x00, 0x7E, 0x0F,
  0x00, 0x00, 0xF8, 0x78, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x1E, 0x3C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x03,
  0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0,
  0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xF1, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x07,
  0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x87, 0x80,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x02, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x83, 0xC0, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xE0, 0x01, 0xF8, 0x0F, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F,
  0x07, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x3F, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFE,
  0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x0F, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x02, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x1F, 0xC1, 0xF0, 0x00, 0xEF, 0x03, 0xF8, 0x0F, 0x3C,
  0x07, 0xFF, 0xF8, 0xF0, 0x07, 0xFF, 0xC3, 0xC0, 0x07, 0xF8, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0x8F, 0x80,
  0x03, 0xC3, 0xF0, 0x01, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0x3E, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x7C, 0x03, 0xC0, 0x01, 0xF0,
  0x07, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0xF8, 0x00, 0x78, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x80, 0x01,
  0xE0, 0x3E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x0F,
  0x07, 0xE0, 0x00, 0x1E, 0x1F, 0xE0, 0x00, 0x3C, 0x7B, 0xC0, 0x00, 0x79,
  0xF7, 0xC0, 0x00, 0xF7, 0xC7, 0xC0, 0x01, 0xFF, 0x07, 0x80, 0x03, 0xFC,
  0x0F, 0x80, 0x07, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x7C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00,
  0xF8, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3B, 0xFD, 0xC0, 0x01, 0xEF, 0xF7, 0x80, 0x07, 0xBF, 0xDE, 0x00, 0x1C,
  0xFF, 0x3C, 0x00, 0xF3, 0xFC, 0xF0, 0x03, 0x8F, 0xF1, 0xC0, 0x1E, 0x3F,
  0xC7, 0x80, 0x70, 0xFF, 0x0E, 0x01, 0xC3, 0xFC, 0x3C, 0x0F, 0x0F, 0xF0,
  0xF0, 0x38, 0x3F, 0xC1, 0xC1, 0xE0, 0xFF, 0x07, 0x87, 0x03, 0xFC, 0x0E,
  0x3C, 0x0F, 0xF0, 0x3C, 0xE0, 0x3F, 0xC0, 0x73, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xC0, 0x3F, 0xC0, 0x3E, 0x00,
  0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xC0, 0x0F, 0xF0, 0x03, 0x00, 0x3F,
  0xC0, 0x0C, 0x00, 0xFF, 0x00, 0x20, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xF0, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFE, 0xF0, 0x00,
  0x0F, 0xEF, 0x00, 0x00, 0xFE, 0x78, 0x00, 0x0F, 0xE7, 0x80, 0x00, 0xFE,
  0x3C, 0x00, 0x0F, 0xE3, 0xC0, 0x00, 0xFE, 0x1E, 0x00, 0x0F, 0xE1, 0xE0,
  0x00, 0xFE, 0x1F, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0xFE, 0x0F, 0x00, 0x0F,
  0xE0, 0x78, 0x00, 0xFE, 0x07, 0x80, 0x0F, 0xE0, 0x3C, 0x00, 0xFE, 0x03,
  0xC0, 0x0F, 0xE0, 0x1E, 0x00, 0xFE, 0x01, 0xE0, 0x0F, 0xE0, 0x0F, 0x00,
  0xFE, 0x00, 0xF0, 0x0F, 0xE0, 0x0F, 0x00, 0xFE, 0x00, 0x78, 0x0F, 0xE0,
  0x07, 0x80, 0xFE, 0x00, 0x3C, 0x0F, 0xE0, 0x03, 0xC0, 0xFE, 0x00, 0x1E,
  0x0F, 0xE0, 0x01, 0xE0, 0xFE, 0x00, 0x0F, 0x0F, 0xE0, 0x00, 0xF0, 0xFE,
  0x00, 0x07, 0x8F, 0xE0, 0x00, 0x78, 0xFE, 0x00, 0x07, 0x8F, 0xE0, 0x00,
  0x3C, 0xFE, 0x00, 0x03, 0xCF, 0xE0, 0x00, 0x1E, 0xFE, 0x00, 0x01, 0xEF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x1F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x01,
  0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE1, 0xE0, 0x00, 0x1F, 0x8F,
  0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x3E, 0x78, 0x00, 0x07, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x1F, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x01, 0xE0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3C, 0x00, 0x03, 0xF0, 0xF0,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x7C, 0xF0,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3F, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x7C, 0x03,
  0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00,
  0x08, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x10, 0x00, 0x00,
  0x0F, 0x30, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0xFE, 0x00, 0x00,
  0x3E, 0x3F, 0x00, 0x00, 0x7C, 0x1F, 0xC0, 0x00, 0xF8, 0x0F, 0xF0, 0x07,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3E,
  0x7C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x81, 0xFC,
  0x03, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x3E,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0,
  0x7C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x07, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0x03, 0xBC, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0xF8, 0x01, 0xE7, 0x80, 0x3E, 0x00, 0x71, 0xE0, 0x0F, 0xC0,
  0x1C, 0x78, 0x03, 0xF0, 0x07, 0x1E, 0x01, 0xFC, 0x01, 0xC7, 0x80, 0x77,
  0x00, 0x70, 0xE0, 0x1D, 0xE0, 0x1C, 0x38, 0x07, 0x38, 0x07, 0x0E, 0x03,
  0xCE, 0x03, 0xC3, 0x80, 0xE3, 0xC0, 0xF0, 0xE0, 0x38, 0xF0, 0x3C, 0x38,
  0x0E, 0x1C, 0x0F, 0x0F, 0x07, 0x87, 0x03, 0xC3, 0xC1, 0xE1, 0xE0, 0xE0,
  0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x0E, 0x0E, 0x0F, 0x0F, 0x03, 0x83,
  0x81, 0xC3, 0xC0, 0xF0, 0xE0, 0x70, 0xE0, 0x3C, 0x38, 0x1C, 0x38, 0x07,
  0x0E, 0x07, 0x1E, 0x01, 0xC7, 0x81, 0xC7, 0x80, 0x79, 0xE0, 0x71, 0xC0,
  0x1E, 0x78, 0x1C, 0x70, 0x03, 0x9E, 0x07, 0xBC, 0x00, 0xE7, 0x01, 0xEF,
  0x00, 0x3D, 0xC0, 0x7B, 0x80, 0x0F, 0x70, 0x1E, 0xE0, 0x01, 0xDC, 0x07,
  0xF8, 0x00, 0x77, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x07, 0xF0,
  0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x00, 0x3D, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0x1F, 0x0F, 0x00, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0x60, 0x00, 0x00,
  0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x20, 0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x03,
  0xC0, 0xE0, 0x20, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0x80,
  0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0x10, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF8, 0x1E,
  0x00, 0x02, 0xF0, 0x3E, 0x00, 0x1D, 0xE0, 0x3F, 0x00, 0xF1, 0xFE, 0x3F,
  0xFF, 0xC3, 0xFC, 0x3F, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x1F, 0xC0, 0x0F, 0x0F, 0xFF, 0x80, 0xF1, 0xFF, 0xFC, 0x0F, 0x3C,
  0x07, 0xF0, 0xF7, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x1E, 0xF8, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x7C, 0xFC, 0x00, 0x0F,
  0x8F, 0x70, 0x01, 0xF0, 0xF3, 0xC0, 0x7F, 0x0F, 0x1F, 0xFF, 0xC0, 0xF0,
  0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0,
  0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0E, 0x3C, 0x00,
  0x00, 0x87, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x04, 0x3C, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x07, 0xF0,
  0x1F, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0xFF, 0x01, 0xE0, 0x1F, 0xFE, 0x0F, 0x03, 0xFF,
  0xFC, 0x78, 0x3F, 0x80, 0xF3, 0xC3, 0xE0, 0x01, 0xDE, 0x3E, 0x00, 0x06,
  0xF1, 0xE0, 0x00, 0x1F, 0x9E, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03, 0xE7,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x0F, 0x38, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3E,
  0x3C, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x37, 0x87, 0xC0, 0x03, 0xBC, 0x1F,
  0xC0, 0x79, 0xE0, 0x7F, 0xFF, 0x8F, 0x00, 0xFF, 0xF0, 0x78, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x70,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x02, 0x0F, 0x00, 0x00, 0x1C, 0x3C,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1E, 0x03, 0xE0,
  0x01, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xE3, 0x00, 0x00, 0xFF, 0xFB, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x03, 0xC0, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x1E, 0x00, 0x00, 0xFC, 0x3C,
  0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x7C, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xFC, 0x03, 0xC3, 0xFF, 0xE0, 0xF1,
  0xFF, 0xFC, 0x3C, 0xF0, 0x1F, 0x8F, 0x60, 0x01, 0xF3, 0xF0, 0x00, 0x3C,
  0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x0F, 0x00,
  0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x03,
  0xE0, 0x0F, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0x80,
  0x03, 0xC0, 0x7C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x03, 0xC7, 0xF0, 0x00, 0x0F, 0x3F, 0xE0, 0x00, 0x3D,
  0xE7, 0xC0, 0x00, 0xFF, 0x0F, 0x80, 0x03, 0xF8, 0x1E, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x03,
  0xE0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x1F, 0x3C,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xF8, 0x03, 0xE0, 0xF3, 0xFE, 0x0F, 0xF8, 0xF7, 0xFF, 0x1F, 0xFC, 0xFE,
  0x0F, 0x38, 0x3C, 0xF8, 0x07, 0xA0, 0x1E, 0xF8, 0x07, 0xE0, 0x1E, 0xF0,
  0x03, 0xC0, 0x0E, 0xF0, 0x03, 0xC0, 0x0E, 0xF0, 0x03, 0xC0, 0x0F, 0xF0,
  0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0,
  0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0,
  0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0,
  0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0,
  0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0,
  0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0,
  0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0,
  0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0,
  0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xC0, 0x3C, 0x3F,
  0xFE, 0x0F, 0x1F, 0xFF, 0xC3, 0xCF, 0x01, 0xF8, 0xF6, 0x00, 0x1F, 0x3F,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3C, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x01,
  0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0x0F, 0xFF, 0x80, 0xF1,
  0xFF, 0xFC, 0x0F, 0x3C, 0x07, 0xF0, 0xF7, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0xF8, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xCF, 0x80, 0x00,
  0x7C, 0xFC, 0x00, 0x0F, 0x8F, 0x70, 0x01, 0xF0, 0xF3, 0xC0, 0x7F, 0x0F,
  0x1F, 0xFF, 0xC0, 0xF0, 0xFF, 0xF8, 0x0F, 0x01, 0xFC, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0x83, 0xC0,
  0xFF, 0xFF, 0x1E, 0x0F, 0xE0, 0x3C, 0xF0, 0xF8, 0x00, 0x77, 0x8F, 0x80,
  0x01, 0xBC, 0x78, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x1F, 0x3C, 0x00, 0x00,
  0xF9, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x0F, 0x8F, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x0D, 0xE1, 0xF0, 0x00, 0xEF,
  0x07, 0xF0, 0x1E, 0x78, 0x1F, 0xFF, 0xE3, 0xC0, 0x3F, 0xFC, 0x1E, 0x00,
  0x7F, 0x80, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x1E, 0x60, 0x00, 0x00, 0x1E, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xC0, 0x3F, 0x81, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x01, 0x87, 0x80, 0x00, 0x08, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x40, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3D, 0xF0, 0x00, 0x03, 0xC7, 0xE0, 0x00, 0x7C, 0x1F, 0xE0,
  0x0F, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0xDC, 0xF8, 0x00, 0xEE, 0x3F, 0x01, 0xE7, 0x0F, 0xFF, 0xE3,
  0x83, 0xFF, 0xE1, 0xC0, 0x7F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x0F,
  0x00, 0x38, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0,
  0x1C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1D,
  0xC0, 0x07, 0xE0, 0x03, 0xB8, 0x00, 0xFC, 0x00, 0x77, 0x00, 0x1F, 0x80,
  0x1E, 0xE0, 0x07, 0x70, 0x03, 0xDE, 0x00, 0xE6, 0x00, 0x73, 0xC0, 0x1C,
  0xE0, 0x0E, 0x38, 0x03, 0x9C, 0x01, 0xC7, 0x00, 0x63, 0x80, 0x38, 0xE0,
  0x1C, 0x30, 0x07, 0x1C, 0x03, 0x87, 0x01, 0xE3, 0x80, 0x70, 0xE0, 0x38,
  0x78, 0x0E, 0x1C, 0x07, 0x07, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x70, 0x30,
  0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x30,
  0x1C, 0x1C, 0x0F, 0x0E, 0x03, 0x83, 0x80, 0xE1, 0xC0, 0x38, 0x70, 0x1C,
  0x38, 0x07, 0x0E, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x71, 0xC0, 0x1C, 0x38,
  0x0E, 0x38, 0x01, 0x8E, 0x01, 0xE7, 0x00, 0x39, 0xC0, 0x1C, 0xE0, 0x07,
  0x38, 0x03, 0x98, 0x00, 0xE7, 0x00, 0x77, 0x00, 0x1C, 0xE0, 0x0E, 0xE0,
  0x01, 0xDC, 0x01, 0xDC, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x78, 0x1F,
  0x00, 0x03, 0xC0, 0x3E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3D, 0xF0, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C,
  0x0F, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xFB,
  0xC0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xC0,
  0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x06, 0x0F, 0xF8, 0x00, 0x07, 0x1F,
  0xFC, 0x00, 0x07, 0x1E, 0x3E, 0x00, 0x0E, 0x3C, 0x0F, 0x00, 0x0E, 0x38,
  0x07, 0x80, 0x0E, 0x70, 0x03, 0xC0, 0x1C, 0x70, 0x01, 0xE0, 0x1C, 0xF0,
  0x01, 0xF0, 0x3C, 0xE0, 0x00, 0xF8, 0x78, 0xE0, 0x00, 0x7F, 0xF0, 0xE0,
  0x00, 0x1F, 0xE0, 0xE0, 0x00, 0x0F, 0xC0,
};

const GFXglyph IBMPlexMono_Light66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 8, 46, 40, 16, -46 },
  { 47, 14, 18, 40, 13, -49 },
  { 79, 37, 46, 40, 1, -46 },
  { 292, 32, 62, 40, 4, -54 },
  { 540, 37, 48, 40, 1, -47 },
  { 762, 35, 48, 40, 2, -47 },
  { 972, 4, 18, 40, 18, -49 },
  { 981, 18, 59, 40, 14, -50 },
  { 1114, 17, 59, 40, 8, -50 },
  { 1240, 34, 33, 40, 3, -36 },
  { 1381, 32, 31, 40, 4, -36 },
  { 1505, 10, 17, 40, 14, -7 },
  { 1527, 18, 3, 40, 11, -22 },
  { 1534, 8, 7, 40, 16, -7 },
  { 1541, 27, 59, 40, 6, -50 },
  { 1741, 32, 48, 40, 4, -47 },
  { 1933, 32, 46, 40, 4, -46 },
  { 2117, 30, 47, 40, 5, -47 },
  { 2294, 29, 48, 40, 4, -47 },
  { 2468, 34, 46, 40, 3, -46 },
  { 2664, 29, 47, 40, 5, -46 },
  { 2835, 30, 47, 40, 5, -46 },
  { 3012, 30, 46, 40, 5, -46 },
  { 3185, 32, 48, 40, 4, -47 },
  { 3377, 30, 47, 40, 5, -47 },
  { 3554, 8, 35, 40, 16, -35 },
  { 3589, 10, 45, 40, 14, -35 },
  { 3646, 28, 37, 40, 6, -39 },
  { 3776, 32, 16, 40, 4, -28 },
  { 3840, 28, 37, 40, 6, -39 },
  { 3970, 27, 47, 40, 6, -47 },
  { 4129, 29, 54, 40, 5, -47 },
  { 4325, 34, 46, 40, 3, -46 },
  { 4521, 29, 46, 40, 6, -46 },
  { 4688, 30, 48, 40, 5, -47 },
  { 4868, 29, 46, 40, 7, -46 },
  { 5035, 28, 46, 40, 6, -46 },
  { 5196, 29, 46, 40, 6, -46 },
  { 5363, 30, 48, 40, 4, -47 },
  { 5543, 28, 46, 40, 6, -46 },
  { 5704, 28, 46, 40, 6, -46 },
  { 5865, 26, 47, 40, 5, -46 },
  { 6018, 31, 46, 40, 6, -46 },
  { 6197, 26, 46, 40, 9, -46 },
  { 6347, 30, 46, 40, 5, -46 },
  { 6520, 28, 46, 40, 6, -46 },
  { 6681, 32, 48, 40, 4, -47 },
  { 6873, 29, 46, 40, 6, -46 },
  { 7040, 32, 57, 40, 4, -47 },
  { 7268, 30, 46, 40, 6, -46 },
  { 7441, 32, 48, 40, 3, -47 },
  { 7633, 36, 46, 40, 2, -46 },
  { 7840, 28, 47, 40, 6, -46 },
  { 8005, 34, 46, 40, 3, -46 },
  { 8201, 34, 46, 40, 3, -46 },
  { 8397, 35, 46, 40, 2, -46 },
  { 8599, 37, 46, 40, 1, -46 },
  { 8812, 33, 46, 40, 3, -46 },
  { 9002, 17, 59, 40, 16, -50 },
  { 9128, 27, 59, 40, 6, -50 },
  { 9328, 18, 59, 40, 6, -50 },
  { 9461, 32, 26, 40, 4, -46 },
  { 9565, 32, 3, 40, 4, 7 },
  { 9577, 9, 12, 40, 13, -51 },
  { 9591, 31, 36, 40, 5, -35 },
  { 9731, 28, 50, 40, 7, -49 },
  { 9906, 28, 36, 40, 6, -35 },
  { 10032, 29, 50, 40, 4, -49 },
  { 10214, 30, 36, 40, 5, -35 },
  { 10349, 31, 49, 40, 5, -49 },
  { 10539, 32, 52, 40, 5, -38 },
  { 10747, 26, 49, 40, 7, -49 },
  { 10907, 29, 49, 40, 7, -49 },
  { 11085, 24, 62, 40, 6, -49 },
  { 11271, 30, 49, 40, 8, -49 },
  { 11455, 28, 49, 40, 6, -49 },
  { 11627, 32, 35, 40, 4, -35 },
  { 11767, 26, 35, 40, 7, -35 },
  { 11881, 30, 36, 40, 5, -35 },
  { 12016, 28, 48, 40, 7, -35 },
  { 12184, 29, 48, 40, 4, -35 },
  { 12358, 32, 34, 40, 5, -34 },
  { 12494, 29, 36, 40, 5, -35 },
  { 12625, 32, 46, 40, 3, -46 },
  { 12809, 25, 35, 40, 7, -34 },
  { 12919, 30, 34, 40, 5, -34 },
  { 13047, 35, 34, 40, 2, -34 },
  { 13196, 30, 34, 40, 5, -34 },
  { 13324, 31, 47, 40, 4, -34 },
  { 13507, 28, 34, 40, 6, -34 },
  { 13626, 25, 59, 40, 7, -50 },
  { 13811, 3, 59, 40, 18, -50 },
  { 13834, 25, 59, 40, 7, -50 },
  { 14019, 32, 13, 40, 4, -27 },
};

const GFXfont IBMPlexMono_Light66pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light66pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light66pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _IBMPLEXMONO_LIGHT66PT7B_H_
