#ifndef _IBMPLEXMONO_LIGHT12PT7B_H_
#define _IBMPLEXMONO_LIGHT12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light12pt7bBitmaps[] PROGMEM = {
  0x00, 0xF9, 0xB6, 0x80, 0x34, 0x51, 0x99, 0x42, 0x9D, 0xD2, 0x28, 0x21,
  0xCA, 0xA8, 0xE0, 0xE2, 0xAB, 0x78, 0x80, 0x63, 0x2A, 0x53, 0x42, 0xCA,
  0x54, 0xC6, 0x30, 0x91, 0x01, 0x35, 0x51, 0xA3, 0x3B, 0xE0, 0x72, 0x49,
  0x24, 0x91, 0x80, 0xC4, 0x22, 0x11, 0x12, 0x24, 0xC0, 0x20, 0x8A, 0xDC,
  0x52, 0x20, 0x21, 0x09, 0xF2, 0x10, 0x80, 0xE0, 0xE0, 0x80, 0x08, 0x84,
  0x22, 0x10, 0x88, 0x44, 0x20, 0x74, 0x63, 0x1A, 0xC6, 0x2E, 0x21, 0x8A,
  0x08, 0x20, 0x82, 0x3F, 0x74, 0x62, 0x11, 0x13, 0x1F, 0x74, 0x42, 0xE1,
  0x86, 0x2E, 0x08, 0x30, 0xA2, 0x44, 0x9F, 0xC2, 0x04, 0xFC, 0x21, 0xE8,
  0x86, 0x2E, 0x32, 0x21, 0xE8, 0xC6, 0x2E, 0xFC, 0x64, 0x21, 0x10, 0x88,
  0x7C, 0x62, 0xE8, 0xC6, 0x2E, 0x74, 0x63, 0x17, 0x84, 0x4C, 0x84, 0x87,
  0x08, 0x99, 0x04, 0x18, 0x20, 0xF8, 0x3E, 0x82, 0x0C, 0x11, 0x32, 0x00,
  0x74, 0x62, 0x22, 0x00, 0x04, 0x74, 0x6F, 0x9C, 0xE6, 0xF0, 0x78, 0x10,
  0x50, 0xA1, 0x44, 0x4F, 0x91, 0x41, 0xF4, 0x63, 0xE8, 0xC6, 0x3F, 0x74,
  0x61, 0x08, 0x42, 0x2E, 0xF4, 0x63, 0x18, 0xC6, 0x3E, 0xFC, 0x21, 0xF8,
  0x42, 0x1F, 0xFC, 0x21, 0xF8, 0x42, 0x10, 0x74, 0x61, 0x09, 0xC6, 0x2F,
  0x8C, 0x63, 0xF8, 0xC6, 0x31, 0xF9, 0x08, 0x42, 0x10, 0x9F, 0x78, 0x42,
  0x10, 0x86, 0x2E, 0x8E, 0x4A, 0x28, 0xE2, 0x48, 0xA3, 0x88, 0x88, 0x88,
  0x8F, 0x8C, 0xF7, 0xDA, 0xD6, 0x31, 0x8E, 0x73, 0x5A, 0xCE, 0x71, 0x74,
  0x63, 0x18, 0xC6, 0x2E, 0xFC, 0x63, 0x1F, 0xC2, 0x10, 0x74, 0x63, 0x18,
  0xC6, 0x2E, 0x21, 0xC0, 0xFC, 0x63, 0x1F, 0xCA, 0x51, 0x74, 0x61, 0xC1,
  0x86, 0x2F, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x8C, 0x63, 0x18,
  0xC6, 0x2E, 0x86, 0x28, 0xA2, 0x51, 0x45, 0x08, 0x86, 0x1A, 0xBA, 0xDB,
  0x6C, 0xA2, 0x46, 0x88, 0xA0, 0x81, 0x05, 0x11, 0x63, 0x82, 0x88, 0xA1,
  0x41, 0x02, 0x04, 0x08, 0xF8, 0x21, 0x08, 0x41, 0x08, 0x3F, 0xF2, 0x49,
  0x24, 0x93, 0x80, 0x84, 0x10, 0x82, 0x10, 0x82, 0x10, 0x82, 0xE4, 0x92,
  0x49, 0x27, 0x80, 0x21, 0x49, 0x22, 0x84, 0xF8, 0x90, 0x72, 0x20, 0xBE,
  0x8B, 0xF0, 0x84, 0x21, 0x6C, 0xC6, 0x31, 0xF0, 0x74, 0x61, 0x08, 0xB8,
  0x08, 0x42, 0xF8, 0xC6, 0x31, 0x78, 0x74, 0x7F, 0x08, 0xB8, 0x39, 0x09,
  0xF2, 0x10, 0x84, 0xF8, 0x0D, 0xC8, 0xA2, 0x72, 0x07, 0xA1, 0xF8, 0x84,
  0x21, 0x6C, 0xC6, 0x31, 0x88, 0x30, 0x00, 0x38, 0x20, 0x82, 0x08, 0xFC,
  0x10, 0x0F, 0x11, 0x11, 0x11, 0xF0, 0x82, 0x08, 0x23, 0x92, 0x8D, 0x22,
  0x8C, 0xE1, 0x08, 0x42, 0x10, 0x84, 0xF8, 0xDD, 0x6B, 0x5A, 0xD4, 0xB6,
  0x63, 0x18, 0xC4, 0x74, 0x63, 0x18, 0xB8, 0xB6, 0x63, 0x18, 0xFA, 0x10,
  0x7C, 0x63, 0x18, 0xBC, 0x21, 0xFC, 0x82, 0x08, 0x23, 0xE0, 0x74, 0x78,
  0x38, 0xBC, 0x20, 0x8F, 0xC8, 0x20, 0x82, 0x07, 0x8C, 0x63, 0x18, 0xBC,
  0x8C, 0x54, 0xA5, 0x10, 0x93, 0x66, 0xB3, 0x66, 0x48, 0x80, 0x8A, 0x88,
  0xC5, 0x44, 0x8C, 0x54, 0xA6, 0x10, 0x98, 0xF8, 0x4C, 0x88, 0x7C, 0x39,
  0x08, 0x41, 0x70, 0xC4, 0x21, 0x0E, 0xFF, 0xE0, 0xE1, 0x08, 0x84, 0x1D,
  0x88, 0x21, 0x38, 0xCE, 0xA9, 0x80,
};

const GFXglyph IBMPlexMono_Light12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 8, 7, 3, -8 },
  { 2, 3, 3, 7, 2, -9 },
  { 4, 7, 8, 7, 0, -8 },
  { 11, 6, 10, 7, 1, -9 },
  { 19, 7, 8, 7, 0, -8 },
  { 26, 7, 8, 7, 0, -8 },
  { 33, 1, 3, 7, 3, -9 },
  { 34, 3, 11, 7, 3, -9 },
  { 39, 4, 11, 7, 1, -9 },
  { 45, 6, 6, 7, 1, -7 },
  { 50, 5, 7, 7, 1, -7 },
  { 55, 1, 3, 7, 3, -1 },
  { 56, 3, 1, 7, 2, -4 },
  { 57, 1, 1, 7, 3, -1 },
  { 58, 5, 11, 7, 1, -9 },
  { 65, 5, 8, 7, 1, -8 },
  { 70, 6, 8, 7, 1, -8 },
  { 76, 5, 8, 7, 1, -8 },
  { 81, 5, 8, 7, 1, -8 },
  { 86, 7, 8, 7, 0, -8 },
  { 93, 5, 8, 7, 1, -8 },
  { 98, 5, 8, 7, 1, -8 },
  { 103, 5, 8, 7, 1, -8 },
  { 108, 5, 8, 7, 1, -8 },
  { 113, 5, 8, 7, 1, -8 },
  { 118, 1, 6, 7, 3, -6 },
  { 119, 1, 8, 7, 3, -6 },
  { 120, 5, 7, 7, 1, -7 },
  { 125, 5, 3, 7, 1, -5 },
  { 127, 5, 7, 7, 1, -7 },
  { 132, 5, 8, 7, 1, -8 },
  { 137, 5, 9, 7, 1, -8 },
  { 143, 7, 8, 7, 0, -8 },
  { 150, 5, 8, 7, 1, -8 },
  { 155, 5, 8, 7, 1, -8 },
  { 160, 5, 8, 7, 1, -8 },
  { 165, 5, 8, 7, 1, -8 },
  { 170, 5, 8, 7, 1, -8 },
  { 175, 5, 8, 7, 1, -8 },
  { 180, 5, 8, 7, 1, -8 },
  { 185, 5, 8, 7, 1, -8 },
  { 190, 5, 8, 7, 1, -8 },
  { 195, 6, 8, 7, 1, -8 },
  { 201, 4, 8, 7, 2, -8 },
  { 205, 5, 8, 7, 1, -8 },
  { 210, 5, 8, 7, 1, -8 },
  { 215, 5, 8, 7, 1, -8 },
  { 220, 5, 8, 7, 1, -8 },
  { 225, 5, 10, 7, 1, -8 },
  { 232, 5, 8, 7, 1, -8 },
  { 237, 5, 8, 7, 1, -8 },
  { 242, 7, 8, 7, 0, -8 },
  { 249, 5, 8, 7, 1, -8 },
  { 254, 6, 8, 7, 1, -8 },
  { 260, 6, 8, 7, 1, -8 },
  { 266, 7, 8, 7, 0, -8 },
  { 273, 7, 8, 7, 0, -8 },
  { 280, 6, 8, 7, 1, -8 },
  { 286, 3, 11, 7, 3, -9 },
  { 291, 5, 11, 7, 1, -9 },
  { 298, 3, 11, 7, 1, -9 },
  { 303, 6, 5, 7, 1, -8 },
  { 307, 5, 1, 7, 1, 1 },
  { 308, 2, 2, 7, 2, -10 },
  { 309, 6, 6, 7, 1, -6 },
  { 314, 5, 9, 7, 1, -9 },
  { 320, 5, 6, 7, 1, -6 },
  { 324, 5, 9, 7, 1, -9 },
  { 330, 5, 6, 7, 1, -6 },
  { 334, 5, 9, 7, 1, -9 },
  { 340, 6, 9, 7, 1, -7 },
  { 347, 5, 9, 7, 1, -9 },
  { 353, 6, 9, 7, 1, -9 },
  { 360, 4, 11, 7, 1, -9 },
  { 366, 6, 9, 7, 1, -9 },
  { 373, 5, 9, 7, 1, -9 },
  { 379, 5, 6, 7, 1, -6 },
  { 383, 5, 6, 7, 1, -6 },
  { 387, 5, 6, 7, 1, -6 },
  { 391, 5, 8, 7, 1, -6 },
  { 396, 5, 8, 7, 1, -6 },
  { 401, 6, 6, 7, 1, -6 },
  { 406, 5, 6, 7, 1, -6 },
  { 410, 6, 8, 7, 0, -8 },
  { 416, 5, 6, 7, 1, -6 },
  { 420, 5, 6, 7, 1, -6 },
  { 424, 7, 6, 7, 0, -6 },
  { 430, 5, 6, 7, 1, -6 },
  { 434, 5, 8, 7, 1, -6 },
  { 439, 5, 6, 7, 1, -6 },
  { 443, 5, 11, 7, 1, -9 },
  { 450, 1, 11, 7, 3, -9 },
  { 452, 5, 11, 7, 1, -9 },
  { 459, 6, 3, 7, 1, -5 },
};

const GFXfont IBMPlexMono_Light12pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light12pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _IBMPLEXMONO_LIGHT12PT7B_H_
