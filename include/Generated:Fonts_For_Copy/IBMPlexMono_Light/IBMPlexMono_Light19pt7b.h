#ifndef _IBMPLEXMONO_LIGHT19PT7B_H_
#define _IBMPLEXMONO_LIGHT19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light19pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0x83, 0xC0, 0x99, 0x99, 0x90, 0x04, 0x81, 0x10, 0x22,
  0x04, 0x87, 0x9E, 0x12, 0x04, 0x40, 0x88, 0xF1, 0xC2, 0x40, 0x48, 0x09,
  0x02, 0x20, 0x08, 0x04, 0x0F, 0x8D, 0x34, 0x8E, 0x41, 0x20, 0xD0, 0x1F,
  0x04, 0xC2, 0x21, 0x18, 0x8B, 0x4C, 0xF8, 0x10, 0x08, 0x00, 0x38, 0x28,
  0x8A, 0x11, 0x42, 0x44, 0x50, 0x72, 0x00, 0x00, 0xDE, 0x12, 0x24, 0x84,
  0x90, 0xA1, 0x1C, 0x3C, 0x3C, 0x18, 0x84, 0x01, 0x00, 0x40, 0x08, 0x07,
  0x1E, 0x24, 0x8D, 0x21, 0xC8, 0x33, 0x14, 0x78, 0xC0, 0xF8, 0x18, 0x88,
  0x84, 0x42, 0x10, 0x84, 0x21, 0x04, 0x20, 0x82, 0x18, 0xC1, 0x04, 0x20,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x88, 0x44, 0xC0, 0x08, 0x02, 0x00, 0x83,
  0x22, 0x7F, 0x43, 0x01, 0x40, 0x88, 0x61, 0x00, 0x08, 0x04, 0x02, 0x01,
  0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x00, 0x69, 0x68, 0xF8, 0xF0, 0x03,
  0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x40, 0x40, 0x80, 0x80, 0x1E, 0x30, 0x90, 0x78, 0x18, 0x0C, 0x66, 0x33,
  0x01, 0x80, 0xE0, 0x50, 0x6C, 0x21, 0xE0, 0x1C, 0x1A, 0x19, 0x18, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x87, 0xF8, 0x3E, 0x31,
  0x90, 0x50, 0x20, 0x18, 0x08, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x0F,
  0xF8, 0x3E, 0x31, 0x90, 0x40, 0x20, 0x10, 0x18, 0x70, 0x06, 0x01, 0x00,
  0xE0, 0x68, 0x63, 0xE0, 0x03, 0x01, 0xC0, 0xB0, 0x2C, 0x13, 0x08, 0xC6,
  0x31, 0x0C, 0x83, 0x3F, 0xF0, 0x30, 0x0C, 0x03, 0x00, 0x7F, 0x20, 0x10,
  0x08, 0x04, 0x02, 0xF1, 0x84, 0x03, 0x00, 0x80, 0x50, 0x7C, 0x23, 0xE0,
  0x06, 0x0C, 0x0C, 0x04, 0x04, 0x02, 0xF1, 0x85, 0x81, 0xC0, 0xE0, 0x50,
  0x2C, 0x21, 0xE0, 0xFF, 0xC0, 0x60, 0x50, 0x20, 0x20, 0x10, 0x18, 0x08,
  0x0C, 0x04, 0x02, 0x02, 0x03, 0x00, 0x3E, 0x30, 0x90, 0x28, 0x14, 0x0B,
  0x08, 0x78, 0xC6, 0xC0, 0xC0, 0x70, 0x28, 0x33, 0xE0, 0x3E, 0x30, 0x90,
  0x38, 0x1C, 0x0A, 0x05, 0x8E, 0x7B, 0x01, 0x01, 0x80, 0x80, 0x81, 0x80,
  0xF0, 0x00, 0xF0, 0x6C, 0x00, 0x00, 0x69, 0x68, 0x01, 0x06, 0x0C, 0x30,
  0xC0, 0x80, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x80, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x06, 0x08, 0x30, 0xC0, 0x80, 0x3C,
  0xC2, 0x83, 0x03, 0x02, 0x06, 0x18, 0x10, 0x10, 0x00, 0x00, 0x30, 0x30,
  0x1E, 0x10, 0x90, 0x48, 0x14, 0xEC, 0xCE, 0x43, 0x21, 0x90, 0xCC, 0x53,
  0xE8, 0x04, 0x01, 0x00, 0x7C, 0x0C, 0x07, 0x01, 0x40, 0x58, 0x32, 0x08,
  0x82, 0x30, 0x84, 0x7F, 0x10, 0x64, 0x0A, 0x02, 0x80, 0xC0, 0xFC, 0x82,
  0x82, 0x83, 0x82, 0x82, 0xFC, 0x83, 0x81, 0x81, 0x81, 0x83, 0xFE, 0x1E,
  0x10, 0x90, 0x28, 0x04, 0x06, 0x03, 0x01, 0x80, 0x40, 0x20, 0x10, 0x24,
  0x21, 0xE0, 0xFC, 0x86, 0x83, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x83, 0x86, 0xFC, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFE, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x1E, 0x30, 0x90, 0x68, 0x08, 0x04, 0x02,
  0x01, 0x0F, 0x80, 0xA0, 0x50, 0x2C, 0x73, 0xE8, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x7E, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x06, 0x0E, 0x27, 0x80, 0x81, 0xC1,
  0x21, 0x11, 0x89, 0x85, 0x82, 0xE1, 0x90, 0x84, 0x42, 0x20, 0x90, 0x68,
  0x18, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xFF, 0xC1, 0xF0, 0xE8, 0xB6, 0x59, 0x4C, 0xE6, 0x23, 0x11, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x08, 0x81, 0xC1, 0xC1, 0xA1, 0xA1, 0x91, 0x91,
  0x89, 0x89, 0x85, 0x85, 0x87, 0x83, 0x1E, 0x30, 0x90, 0x78, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xE0, 0x50, 0x6C, 0x21, 0xE0, 0xFE, 0x83, 0x81,
  0x81, 0x81, 0x83, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1E, 0x30,
  0x90, 0x78, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x50, 0x6C, 0x23,
  0xE0, 0x40, 0x20, 0x0E, 0xFE, 0x83, 0x81, 0x81, 0x81, 0x83, 0xFE, 0x88,
  0x8C, 0x84, 0x86, 0x82, 0x81, 0x3E, 0x30, 0xF0, 0x58, 0x04, 0x03, 0x00,
  0x78, 0x03, 0x00, 0x80, 0x60, 0x28, 0x33, 0xE0, 0xFF, 0xC2, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x00, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82,
  0xC2, 0x7C, 0x80, 0xE0, 0x24, 0x09, 0x04, 0x41, 0x08, 0x42, 0x30, 0x88,
  0x32, 0x05, 0x81, 0x40, 0x70, 0x0C, 0x00, 0x80, 0x60, 0x28, 0x0A, 0x02,
  0x88, 0xA3, 0x29, 0x4A, 0x52, 0x52, 0x94, 0xA6, 0x29, 0x8A, 0x61, 0x00,
  0xC0, 0xD0, 0x62, 0x10, 0x88, 0x16, 0x03, 0x00, 0xC0, 0x70, 0x12, 0x08,
  0x86, 0x11, 0x06, 0x80, 0xC0, 0xC0, 0x6C, 0x08, 0x83, 0x18, 0x41, 0x10,
  0x12, 0x02, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0xFF,
  0x80, 0x40, 0x40, 0x40, 0x60, 0x20, 0x20, 0x20, 0x30, 0x10, 0x10, 0x18,
  0x0F, 0xF8, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0xF8, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08,
  0x08, 0x04, 0x04, 0x02, 0x02, 0x03, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0xF8, 0x0C, 0x0A, 0x04, 0x84, 0x42, 0x12, 0x0A,
  0x03, 0x01, 0xFF, 0x80, 0x94, 0x3C, 0x21, 0x00, 0x40, 0x23, 0xF2, 0x0B,
  0x05, 0x02, 0x47, 0x1E, 0xC0, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xC2, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0xC2, 0xBC, 0x3C, 0x42, 0x83, 0x80, 0x80,
  0x80, 0x80, 0x82, 0x43, 0x3C, 0x01, 0x01, 0x01, 0x01, 0x3D, 0x63, 0x41,
  0xC1, 0x81, 0x81, 0xC1, 0x41, 0x63, 0x3D, 0x1E, 0x30, 0x90, 0x28, 0x1F,
  0xFE, 0x01, 0x00, 0x81, 0x61, 0x0F, 0x00, 0x0F, 0x84, 0x02, 0x01, 0x0F,
  0xF8, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x83, 0xFC, 0x01,
  0xC7, 0x82, 0x31, 0x04, 0x41, 0x10, 0x42, 0x30, 0x78, 0x60, 0x10, 0x03,
  0xF9, 0x02, 0xC0, 0xD0, 0x23, 0xF0, 0x81, 0x02, 0x04, 0x0B, 0xD8, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x18, 0x18, 0x00, 0x00, 0xF8,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x06, 0x0C, 0x00,
  0x0F, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x05,
  0xF8, 0x80, 0x40, 0x20, 0x10, 0x08, 0x34, 0x32, 0x31, 0x30, 0xB8, 0x64,
  0x21, 0x10, 0x48, 0x34, 0x0C, 0xF0, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0xB3, 0xE6, 0x62, 0x31, 0x18,
  0x8C, 0x46, 0x23, 0x11, 0x88, 0xC4, 0x40, 0xBD, 0x86, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x04, 0x1E, 0x30, 0x90, 0x68, 0x1C, 0x0E, 0x05, 0x02,
  0x83, 0x61, 0x0F, 0x00, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0xC2, 0xBC, 0x80, 0x80, 0x80, 0x80, 0x3D, 0x63, 0x41, 0xC1, 0x81, 0x81,
  0xC1, 0x41, 0x63, 0x3D, 0x01, 0x01, 0x01, 0x01, 0xFB, 0xC3, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x3F, 0xE0, 0x3E, 0x30, 0xD0,
  0x08, 0x03, 0xC0, 0x38, 0x03, 0x01, 0x61, 0x9F, 0x00, 0x10, 0x08, 0x04,
  0x1F, 0xF1, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0xF8,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC6, 0xF4, 0xC0, 0xA0, 0x90,
  0x44, 0x22, 0x21, 0x10, 0x48, 0x28, 0x14, 0x06, 0x00, 0x88, 0x63, 0x19,
  0x4A, 0x52, 0x94, 0xA4, 0xA6, 0x29, 0x8A, 0x63, 0x18, 0x40, 0xC1, 0x90,
  0x8C, 0x82, 0x80, 0xC0, 0x60, 0x50, 0x44, 0x61, 0x60, 0xC0, 0xC0, 0xA0,
  0xD0, 0x44, 0x22, 0x21, 0x90, 0x48, 0x28, 0x0C, 0x04, 0x02, 0x03, 0x01,
  0x03, 0x80, 0xFE, 0x02, 0x04, 0x08, 0x18, 0x10, 0x20, 0x40, 0x80, 0xFF,
  0x1E, 0x20, 0x40, 0x81, 0x01, 0x02, 0x04, 0xF0, 0x30, 0x20, 0x41, 0x02,
  0x04, 0x08, 0x1E, 0xFF, 0xFF, 0x80, 0xF8, 0x10, 0x20, 0x41, 0x04, 0x08,
  0x18, 0x0E, 0x60, 0x81, 0x01, 0x01, 0x02, 0x04, 0xF8, 0x70, 0xA4, 0x63,
  0x30, 0xE0,
};

const GFXglyph IBMPlexMono_Light19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 2, 13, 11, 5, -13 },
  { 5, 4, 5, 11, 4, -14 },
  { 8, 11, 13, 11, 0, -13 },
  { 26, 9, 17, 11, 1, -15 },
  { 46, 11, 13, 11, 0, -13 },
  { 64, 10, 13, 11, 1, -13 },
  { 81, 1, 5, 11, 5, -14 },
  { 82, 5, 17, 11, 4, -14 },
  { 93, 5, 17, 11, 2, -14 },
  { 104, 10, 9, 11, 1, -10 },
  { 116, 9, 9, 11, 1, -10 },
  { 127, 3, 5, 11, 4, -2 },
  { 129, 5, 1, 11, 3, -6 },
  { 130, 2, 2, 11, 5, -2 },
  { 131, 8, 17, 11, 2, -14 },
  { 148, 9, 13, 11, 1, -13 },
  { 163, 9, 13, 11, 1, -13 },
  { 178, 9, 13, 11, 1, -13 },
  { 193, 9, 13, 11, 1, -13 },
  { 208, 10, 13, 11, 1, -13 },
  { 225, 9, 13, 11, 1, -13 },
  { 240, 9, 13, 11, 1, -13 },
  { 255, 9, 13, 11, 1, -13 },
  { 270, 9, 13, 11, 1, -13 },
  { 285, 9, 13, 11, 1, -13 },
  { 300, 2, 10, 11, 5, -10 },
  { 303, 3, 13, 11, 4, -10 },
  { 308, 8, 11, 11, 2, -11 },
  { 319, 9, 4, 11, 1, -8 },
  { 324, 8, 11, 11, 2, -11 },
  { 335, 8, 13, 11, 2, -13 },
  { 348, 9, 15, 11, 1, -13 },
  { 365, 10, 13, 11, 1, -13 },
  { 382, 8, 13, 11, 2, -13 },
  { 395, 9, 13, 11, 1, -13 },
  { 410, 8, 13, 11, 2, -13 },
  { 423, 8, 13, 11, 2, -13 },
  { 436, 8, 13, 11, 2, -13 },
  { 449, 9, 13, 11, 1, -13 },
  { 464, 8, 13, 11, 2, -13 },
  { 477, 8, 13, 11, 2, -13 },
  { 490, 7, 13, 11, 2, -13 },
  { 502, 9, 13, 11, 2, -13 },
  { 517, 8, 13, 11, 2, -13 },
  { 530, 9, 13, 11, 1, -13 },
  { 545, 8, 13, 11, 2, -13 },
  { 558, 9, 13, 11, 1, -13 },
  { 573, 8, 13, 11, 2, -13 },
  { 586, 9, 16, 11, 1, -13 },
  { 604, 8, 13, 11, 2, -13 },
  { 617, 9, 13, 11, 1, -13 },
  { 632, 10, 13, 11, 1, -13 },
  { 649, 8, 13, 11, 2, -13 },
  { 662, 10, 13, 11, 1, -13 },
  { 679, 10, 13, 11, 1, -13 },
  { 696, 10, 13, 11, 1, -13 },
  { 713, 11, 13, 11, 0, -13 },
  { 731, 9, 13, 11, 1, -13 },
  { 746, 5, 17, 11, 5, -14 },
  { 757, 8, 17, 11, 2, -14 },
  { 774, 5, 17, 11, 2, -14 },
  { 785, 9, 8, 11, 1, -13 },
  { 794, 9, 1, 11, 1, 2 },
  { 796, 2, 3, 11, 4, -14 },
  { 797, 9, 10, 11, 1, -10 },
  { 809, 8, 14, 11, 2, -14 },
  { 823, 8, 10, 11, 2, -10 },
  { 833, 8, 14, 11, 1, -14 },
  { 847, 9, 10, 11, 1, -10 },
  { 859, 9, 14, 11, 1, -14 },
  { 875, 10, 15, 11, 1, -11 },
  { 894, 7, 14, 11, 2, -14 },
  { 907, 8, 14, 11, 2, -14 },
  { 921, 7, 18, 11, 2, -14 },
  { 937, 9, 14, 11, 2, -14 },
  { 953, 8, 14, 11, 2, -14 },
  { 967, 9, 10, 11, 1, -10 },
  { 979, 7, 10, 11, 2, -10 },
  { 988, 9, 10, 11, 1, -10 },
  { 1000, 8, 14, 11, 2, -10 },
  { 1014, 8, 14, 11, 1, -10 },
  { 1028, 10, 10, 11, 1, -10 },
  { 1041, 9, 10, 11, 1, -10 },
  { 1053, 9, 13, 11, 1, -13 },
  { 1068, 7, 10, 11, 2, -10 },
  { 1077, 9, 10, 11, 1, -10 },
  { 1089, 10, 10, 11, 1, -10 },
  { 1102, 9, 10, 11, 1, -10 },
  { 1114, 9, 14, 11, 1, -10 },
  { 1130, 8, 10, 11, 2, -10 },
  { 1140, 7, 17, 11, 2, -14 },
  { 1155, 1, 17, 11, 5, -14 },
  { 1158, 7, 17, 11, 2, -14 },
  { 1173, 9, 4, 11, 1, -8 },
};

const GFXfont IBMPlexMono_Light19pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light19pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _IBMPLEXMONO_LIGHT19PT7B_H_
