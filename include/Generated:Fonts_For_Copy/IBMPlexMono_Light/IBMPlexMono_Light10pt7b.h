#ifndef _IBMPLEXMONO_LIGHT10PT7B_H_
#define _IBMPLEXMONO_LIGHT10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light10pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0x8C, 0xFC, 0x28, 0xC6, 0xD4, 0xD9, 0x45, 0x00, 0x4E, 0xDC,
  0x75, 0xD7, 0x40, 0x66, 0xA7, 0x00, 0x59, 0x99, 0x80, 0x71, 0x44, 0x1B,
  0x9A, 0x27, 0xC0, 0xE0, 0x72, 0x49, 0x24, 0x60, 0x89, 0x12, 0x52, 0x80,
  0x20, 0x8F, 0xCC, 0x48, 0x44, 0xF4, 0x40, 0xE8, 0xC0, 0xC0, 0x12, 0x22,
  0x44, 0x88, 0x80, 0x69, 0x9D, 0x99, 0x60, 0x65, 0x28, 0x42, 0x13, 0xE0,
  0x69, 0x11, 0x2C, 0xF0, 0x69, 0x16, 0x19, 0x60, 0x10, 0xC3, 0x14, 0x93,
  0xF1, 0x00, 0xF8, 0xF9, 0x19, 0x60, 0x68, 0xF9, 0x99, 0xE0, 0xF9, 0x22,
  0x24, 0x40, 0xF9, 0x96, 0x99, 0xF0, 0x79, 0x99, 0xF2, 0x40, 0xC0, 0xC0,
  0xC0, 0xE8, 0x12, 0xC8, 0x61, 0xF0, 0xF0, 0x84, 0x31, 0x68, 0x79, 0x12,
  0x40, 0x40, 0x69, 0xBD, 0xDF, 0x87, 0x30, 0xC5, 0x12, 0x79, 0x28, 0xC0,
  0xF9, 0x9E, 0x99, 0xF0, 0x69, 0x88, 0x89, 0x60, 0xE9, 0x99, 0x99, 0xE0,
  0xF8, 0x8F, 0x88, 0xF0, 0xF8, 0x8F, 0x88, 0x80, 0x69, 0x8B, 0x99, 0x70,
  0x99, 0x9F, 0x99, 0x90, 0xF4, 0x44, 0x44, 0xF0, 0xF1, 0x11, 0x19, 0x60,
  0x9D, 0x31, 0x8A, 0x4A, 0x60, 0x88, 0x88, 0x88, 0xF0, 0x9B, 0xFF, 0xD9,
  0x90, 0x99, 0xDD, 0xBB, 0x90, 0x69, 0x99, 0x99, 0x60, 0xF9, 0x9F, 0x88,
  0x80, 0x69, 0x99, 0x99, 0x64, 0x30, 0xF9, 0x9F, 0xAA, 0x90, 0xE9, 0x87,
  0x19, 0x70, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x00, 0x99, 0x99, 0x99, 0xF0,
  0x8D, 0x24, 0x94, 0x50, 0xC3, 0x00, 0x86, 0x2A, 0xAE, 0xBB, 0x64, 0x80,
  0x8D, 0x23, 0x08, 0x31, 0x28, 0xC0, 0x85, 0x25, 0x0C, 0x20, 0x82, 0x00,
  0x78, 0x21, 0x08, 0x41, 0x0F, 0xC0, 0xF2, 0x49, 0x24, 0xE0, 0x88, 0x84,
  0x42, 0x22, 0x10, 0xE4, 0x92, 0x49, 0xE0, 0x6A, 0x99, 0xF0, 0xC0, 0xE1,
  0xF9, 0xF0, 0x88, 0xF9, 0x99, 0xF0, 0x69, 0x89, 0x60, 0x11, 0xF9, 0x99,
  0xF0, 0x69, 0xF8, 0x70, 0x34, 0xF4, 0x44, 0xF0, 0x1B, 0x25, 0xC8, 0x7A,
  0x3E, 0x88, 0xF9, 0x99, 0x90, 0x20, 0xE2, 0x22, 0xF0, 0x10, 0xE2, 0x22,
  0x22, 0xE0, 0x84, 0x25, 0x4E, 0x52, 0x60, 0xC4, 0x44, 0x44, 0xF0, 0xDF,
  0xDD, 0xD0, 0xF9, 0x99, 0x90, 0x69, 0x99, 0x60, 0xF9, 0x99, 0xF8, 0x80,
  0xF9, 0x99, 0xF1, 0x10, 0xDB, 0x10, 0x8F, 0x00, 0xF8, 0xF1, 0xF0, 0x21,
  0x3E, 0x42, 0x10, 0xE0, 0x99, 0x99, 0xF0, 0x99, 0xA6, 0x60, 0xA6, 0xEB,
  0xB6, 0x48, 0x96, 0x4A, 0x90, 0x99, 0xA6, 0x44, 0xC0, 0xF2, 0x48, 0xF0,
  0x74, 0x42, 0xC2, 0x44, 0x70, 0xFF, 0x80, 0xE2, 0x44, 0x34, 0x42, 0xE0,
  0xDD, 0xB0,
};

const GFXglyph IBMPlexMono_Light10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 2, 3, 6, 2, -7 },
  { 4, 6, 7, 6, 0, -7 },
  { 10, 4, 9, 6, 1, -8 },
  { 15, 6, 7, 6, 0, -7 },
  { 21, 6, 7, 6, 0, -7 },
  { 27, 1, 3, 6, 3, -7 },
  { 28, 3, 9, 6, 2, -8 },
  { 32, 3, 9, 6, 1, -8 },
  { 36, 6, 5, 6, 0, -5 },
  { 40, 4, 5, 6, 1, -6 },
  { 43, 2, 3, 6, 2, -1 },
  { 44, 2, 1, 6, 2, -4 },
  { 45, 2, 1, 6, 2, -1 },
  { 46, 4, 9, 6, 1, -8 },
  { 51, 4, 7, 6, 1, -7 },
  { 55, 5, 7, 6, 1, -7 },
  { 60, 4, 7, 6, 1, -7 },
  { 64, 4, 7, 6, 1, -7 },
  { 68, 6, 7, 6, 0, -7 },
  { 74, 4, 7, 6, 1, -7 },
  { 78, 4, 7, 6, 1, -7 },
  { 82, 4, 7, 6, 1, -7 },
  { 86, 4, 7, 6, 1, -7 },
  { 90, 4, 7, 6, 1, -7 },
  { 94, 2, 5, 6, 2, -5 },
  { 96, 2, 7, 6, 2, -5 },
  { 98, 4, 6, 6, 1, -6 },
  { 101, 4, 3, 6, 1, -5 },
  { 103, 4, 6, 6, 1, -6 },
  { 106, 4, 7, 6, 1, -7 },
  { 110, 4, 8, 6, 1, -7 },
  { 114, 6, 7, 6, 0, -7 },
  { 120, 4, 7, 6, 1, -7 },
  { 124, 4, 7, 6, 1, -7 },
  { 128, 4, 7, 6, 1, -7 },
  { 132, 4, 7, 6, 1, -7 },
  { 136, 4, 7, 6, 1, -7 },
  { 140, 4, 7, 6, 1, -7 },
  { 144, 4, 7, 6, 1, -7 },
  { 148, 4, 7, 6, 1, -7 },
  { 152, 4, 7, 6, 1, -7 },
  { 156, 5, 7, 6, 1, -7 },
  { 161, 4, 7, 6, 1, -7 },
  { 165, 4, 7, 6, 1, -7 },
  { 169, 4, 7, 6, 1, -7 },
  { 173, 4, 7, 6, 1, -7 },
  { 177, 4, 7, 6, 1, -7 },
  { 181, 4, 9, 6, 1, -7 },
  { 186, 4, 7, 6, 1, -7 },
  { 190, 4, 7, 6, 1, -7 },
  { 194, 6, 7, 6, 0, -7 },
  { 200, 4, 7, 6, 1, -7 },
  { 204, 6, 7, 6, 0, -7 },
  { 210, 6, 7, 6, 0, -7 },
  { 216, 6, 7, 6, 0, -7 },
  { 222, 6, 7, 6, 0, -7 },
  { 228, 6, 7, 6, 0, -7 },
  { 234, 3, 9, 6, 2, -8 },
  { 238, 4, 9, 6, 1, -8 },
  { 243, 3, 9, 6, 1, -8 },
  { 247, 4, 4, 6, 1, -7 },
  { 249, 4, 1, 6, 1, 1 },
  { 250, 1, 2, 6, 2, -8 },
  { 251, 4, 5, 6, 1, -5 },
  { 254, 4, 7, 6, 1, -7 },
  { 258, 4, 5, 6, 1, -5 },
  { 261, 4, 7, 6, 1, -7 },
  { 265, 4, 5, 6, 1, -5 },
  { 268, 4, 7, 6, 1, -7 },
  { 272, 5, 8, 6, 1, -6 },
  { 277, 4, 7, 6, 1, -7 },
  { 281, 4, 7, 6, 1, -7 },
  { 285, 4, 9, 6, 1, -7 },
  { 290, 5, 7, 6, 1, -7 },
  { 295, 4, 7, 6, 1, -7 },
  { 299, 4, 5, 6, 1, -5 },
  { 302, 4, 5, 6, 1, -5 },
  { 305, 4, 5, 6, 1, -5 },
  { 308, 4, 7, 6, 1, -5 },
  { 312, 4, 7, 6, 1, -5 },
  { 316, 5, 5, 6, 1, -5 },
  { 320, 4, 5, 6, 1, -5 },
  { 323, 5, 7, 6, 0, -7 },
  { 328, 4, 5, 6, 1, -5 },
  { 331, 4, 5, 6, 1, -5 },
  { 334, 6, 5, 6, 0, -5 },
  { 338, 4, 5, 6, 1, -5 },
  { 341, 4, 7, 6, 1, -5 },
  { 345, 4, 5, 6, 1, -5 },
  { 348, 4, 9, 6, 1, -8 },
  { 353, 1, 9, 6, 3, -8 },
  { 355, 4, 9, 6, 1, -8 },
  { 360, 4, 3, 6, 1, -4 },
};

const GFXfont IBMPlexMono_Light10pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light10pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _IBMPLEXMONO_LIGHT10PT7B_H_
