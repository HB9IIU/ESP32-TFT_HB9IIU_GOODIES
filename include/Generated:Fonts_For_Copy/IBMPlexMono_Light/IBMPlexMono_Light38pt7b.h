#ifndef _IBMPLEXMONO_LIGHT38PT7B_H_
#define _IBMPLEXMONO_LIGHT38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light38pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x98, 0xC2, 0x10, 0x84, 0x21,
  0x00, 0x00, 0x00, 0x0E, 0xFF, 0xDC, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xC0, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00,
  0x30, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C,
  0x00, 0x30, 0x60, 0x01, 0x83, 0x03, 0xFC, 0x3F, 0xDF, 0xE1, 0xFE, 0x06,
  0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x61, 0x80,
  0xFE, 0x0F, 0xF7, 0xF0, 0x7F, 0x81, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x60,
  0xC0, 0x03, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00,
  0x60, 0xC0, 0x03, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x0F, 0x19, 0xE1, 0xC3, 0x0E,
  0x70, 0x60, 0xCC, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x06, 0x06, 0x00,
  0xE0, 0xC0, 0x0E, 0x18, 0x00, 0xF3, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0x31, 0xC0, 0x06, 0x1C, 0x00, 0xC1, 0x80, 0x18, 0x38,
  0x03, 0x07, 0x00, 0x60, 0xE8, 0x0C, 0x1B, 0x81, 0x83, 0x38, 0x30, 0xE3,
  0xC6, 0x78, 0x3F, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x19, 0xFC, 0x01, 0x9C, 0x70,
  0x0D, 0x81, 0xC0, 0xCC, 0x06, 0x0C, 0x60, 0x30, 0x63, 0x01, 0x86, 0x18,
  0x0C, 0x30, 0xC0, 0x63, 0x06, 0x07, 0x18, 0x1C, 0x71, 0x80, 0x7F, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFC, 0x03,
  0x18, 0x70, 0x31, 0x81, 0x81, 0x8C, 0x06, 0x18, 0x60, 0x31, 0x83, 0x01,
  0x8C, 0x18, 0x0C, 0xC0, 0xC0, 0x66, 0x06, 0x06, 0x60, 0x18, 0x73, 0x00,
  0xFF, 0x30, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0E, 0x1C, 0x01,
  0xC0, 0x60, 0x18, 0x04, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x01,
  0xF1, 0xF8, 0x1F, 0x39, 0xC1, 0x87, 0x0E, 0x18, 0x60, 0x71, 0x8E, 0x03,
  0x18, 0xE0, 0x39, 0x8C, 0x01, 0xD0, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0x60,
  0x07, 0x87, 0x00, 0xD8, 0x38, 0x18, 0xC1, 0xFF, 0x06, 0x0F, 0xC0, 0x70,
  0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0xE0, 0x70, 0x18, 0x0C, 0x06, 0x01, 0x80,
  0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0xE0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x01,
  0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x30,
  0x30, 0x1F, 0xC6, 0x1F, 0x7F, 0xDF, 0x80, 0xFF, 0x80, 0x03, 0x80, 0x00,
  0xF8, 0x00, 0x3B, 0x00, 0x06, 0x30, 0x01, 0x87, 0x00, 0x70, 0x70, 0x1C,
  0x06, 0x03, 0x00, 0x60, 0x40, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x3C, 0xE3, 0x9C, 0x71, 0xC6, 0x18, 0xE3, 0x00, 0xFF, 0xFF, 0xFC, 0x77,
  0xFE, 0xE0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xE0,
  0xF0, 0xE0, 0x0C, 0x30, 0x03, 0x9C, 0x00, 0x66, 0x00, 0x1D, 0x80, 0x03,
  0x60, 0x00, 0xD8, 0x00, 0x3E, 0x00, 0x0F, 0x83, 0x83, 0xE0, 0xE0, 0xF8,
  0x38, 0x3E, 0x0E, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xD8, 0x00, 0x36, 0x00,
  0x0D, 0x80, 0x03, 0x60, 0x01, 0xDC, 0x00, 0x63, 0x00, 0x38, 0xE0, 0x0C,
  0x1E, 0x0F, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x01, 0xE0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x7B, 0x80, 0x3C, 0xE0, 0x1E, 0x38, 0x0F, 0x0E, 0x03, 0x03,
  0x80, 0x80, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x0F, 0xFC,
  0x0E, 0x07, 0x0E, 0x01, 0xCE, 0x00, 0x66, 0x00, 0x39, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x03,
  0x87, 0x00, 0xE7, 0x00, 0x31, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x7F, 0x80, 0x3F, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x1A, 0x00, 0x0F, 0x80, 0x0E, 0xE0, 0x0E, 0x3C, 0x0E, 0x0F,
  0xFE, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1B, 0x00,
  0x01, 0xB0, 0x00, 0x33, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0C, 0x30,
  0x01, 0x83, 0x00, 0x18, 0x30, 0x03, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0x1C, 0x03, 0x01, 0x80, 0x30, 0x30, 0x03, 0x07, 0x00,
  0x30, 0x60, 0x03, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x3F, 0xFF, 0x1F, 0xFF, 0x8C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0xFC, 0x0D,
  0xFF, 0x87, 0x81, 0xE3, 0x80, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3A, 0x00, 0x1B, 0x80,
  0x1C, 0xE0, 0x0C, 0x78, 0x1E, 0x0F, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0xFC, 0x0D, 0xFF, 0x8F,
  0x81, 0xE6, 0x80, 0x3B, 0x80, 0x0D, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x19, 0x80, 0x0C, 0xE0,
  0x0E, 0x3C, 0x1E, 0x0F, 0xFE, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF8, 0x00, 0x6C, 0x00, 0x76, 0x00, 0x33, 0x00, 0x19, 0x80,
  0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xC0,
  0xF0, 0xE0, 0x0E, 0x70, 0x01, 0x9C, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07,
  0x70, 0x01, 0x8C, 0x00, 0x63, 0x80, 0x30, 0x70, 0x38, 0x07, 0xFC, 0x01,
  0xFF, 0x01, 0xC0, 0x70, 0xC0, 0x0E, 0x60, 0x01, 0xD8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x1D, 0xC0, 0x0E,
  0x3C, 0x07, 0x87, 0xFF, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0x07, 0x8E, 0x00, 0xC6, 0x00, 0x37, 0x00, 0x1B, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x76, 0x00, 0x3B, 0x80,
  0x2C, 0xF0, 0x7C, 0x3F, 0xF6, 0x07, 0xE3, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x00, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x77, 0xFE, 0xE0, 0x39, 0xF7, 0xCE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xE3, 0x9C, 0x71, 0xC6, 0x18,
  0xE3, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x30,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3C, 0x1E, 0x70,
  0x06, 0x60, 0x07, 0xE0, 0x03, 0x40, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x3C, 0x03, 0xF0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x07,
  0xF0, 0x0F, 0xF8, 0x1C, 0x1E, 0x30, 0x06, 0x70, 0x07, 0x60, 0x03, 0x60,
  0x03, 0xC0, 0x03, 0xC0, 0xFB, 0xC1, 0xFD, 0xC3, 0x85, 0xC3, 0x03, 0xC3,
  0x03, 0xC6, 0x01, 0xC6, 0x01, 0xC6, 0x01, 0xC6, 0x01, 0xC6, 0x01, 0xC7,
  0x03, 0xC3, 0x03, 0xC3, 0x83, 0xC1, 0xFD, 0xC0, 0xF9, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFE, 0x03,
  0xFE, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xD8, 0x00, 0x0D, 0x80, 0x00,
  0xD8, 0x00, 0x19, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x0E, 0x00,
  0x30, 0x60, 0x03, 0x06, 0x00, 0x70, 0x70, 0x06, 0x07, 0x00, 0x60, 0x30,
  0x0E, 0x03, 0x00, 0xC0, 0x38, 0x0C, 0x01, 0x81, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC1, 0x80, 0x0C, 0x18, 0x00, 0xC3, 0x80, 0x0E, 0x30, 0x00, 0x63, 0x00,
  0x06, 0x70, 0x00, 0x76, 0x00, 0x07, 0xE0, 0x00, 0x30, 0xFF, 0xF0, 0x7F,
  0xFE, 0x38, 0x03, 0x9C, 0x00, 0xCE, 0x00, 0x77, 0x00, 0x1B, 0x80, 0x0D,
  0xC0, 0x06, 0xE0, 0x03, 0x70, 0x03, 0xB8, 0x01, 0x9C, 0x01, 0x8F, 0xFF,
  0x87, 0xFF, 0xE3, 0x80, 0x39, 0xC0, 0x06, 0xE0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x06,
  0xE0, 0x0F, 0x7F, 0xFF, 0x3F, 0xFE, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07,
  0x83, 0x87, 0x00, 0xE7, 0x00, 0x3B, 0x00, 0x0D, 0x80, 0x09, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x23, 0x00, 0x0D, 0xC0, 0x0E, 0x70, 0x0E, 0x1E, 0x0E,
  0x07, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xC0, 0x38, 0xC0,
  0x1C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x06, 0xC0, 0x0E, 0xC0, 0x1C, 0xC0, 0x38, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03,
  0xF8, 0x01, 0xFF, 0x81, 0xE0, 0xF0, 0x60, 0x0E, 0x38, 0x01, 0x8C, 0x00,
  0x77, 0x00, 0x11, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x70, 0x01, 0xDC, 0x00,
  0x73, 0x80, 0x1C, 0xE0, 0x0B, 0x1E, 0x0E, 0xC3, 0xFF, 0x30, 0x3F, 0x0C,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x3F, 0xFC,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x78,
  0x01, 0xF8, 0x03, 0x38, 0x0E, 0x38, 0x38, 0x3F, 0xE0, 0x3F, 0x00, 0xC0,
  0x03, 0xB0, 0x01, 0xCC, 0x00, 0xE3, 0x00, 0x30, 0xC0, 0x1C, 0x30, 0x0E,
  0x0C, 0x07, 0x03, 0x03, 0x80, 0xC1, 0xC0, 0x30, 0x60, 0x0C, 0x30, 0x03,
  0x1C, 0x00, 0xCF, 0x00, 0x37, 0xE0, 0x0F, 0x9C, 0x03, 0xC3, 0x00, 0xE0,
  0xE0, 0x30, 0x1C, 0x0C, 0x03, 0x03, 0x00, 0xE0, 0xC0, 0x18, 0x30, 0x07,
  0x0C, 0x00, 0xE3, 0x00, 0x18, 0xC0, 0x07, 0x30, 0x00, 0xEC, 0x00, 0x1C,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0xE0, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFD,
  0x80, 0xDE, 0xC0, 0x6F, 0x60, 0x77, 0x98, 0x33, 0xCC, 0x19, 0xE3, 0x18,
  0xF1, 0x8C, 0x78, 0xCC, 0x3C, 0x36, 0x1E, 0x1B, 0x0F, 0x07, 0x07, 0x83,
  0x83, 0xC0, 0x81, 0xE0, 0x40, 0xF0, 0x40, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x60, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFB, 0x00, 0x7D, 0xC0, 0x3E,
  0x60, 0x1F, 0x30, 0x0F, 0x8C, 0x07, 0xC6, 0x03, 0xE3, 0x81, 0xF0, 0xC0,
  0xF8, 0x70, 0x7C, 0x18, 0x3E, 0x0E, 0x1F, 0x03, 0x0F, 0x81, 0x87, 0xC0,
  0x63, 0xE0, 0x31, 0xF0, 0x1C, 0xF8, 0x06, 0x7C, 0x03, 0xBE, 0x00, 0xDF,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xE0, 0x03,
  0xF8, 0x03, 0xFF, 0x01, 0xE0, 0xF0, 0xE0, 0x0C, 0x30, 0x03, 0x9C, 0x00,
  0x66, 0x00, 0x1D, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x01, 0xDC, 0x00,
  0x63, 0x00, 0x38, 0xE0, 0x0C, 0x1E, 0x0F, 0x03, 0xFF, 0x80, 0x3F, 0x80,
  0xFF, 0xF0, 0xFF, 0xFC, 0xC0, 0x0E, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x0E, 0xFF, 0xFC, 0xFF, 0xF0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xE0,
  0xF0, 0xE0, 0x0C, 0x30, 0x03, 0x8C, 0x00, 0x66, 0x00, 0x1D, 0x80, 0x03,
  0x60, 0x00, 0xD8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xD8, 0x00, 0x36, 0x00,
  0x0D, 0x80, 0x03, 0x60, 0x01, 0xCC, 0x00, 0x63, 0x00, 0x38, 0xE0, 0x0C,
  0x1E, 0x0F, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0xF0, 0xFF,
  0xFC, 0xC0, 0x0E, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x0E, 0xFF,
  0xFC, 0xFF, 0xF0, 0xC1, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xC0, 0x60, 0xC0,
  0x30, 0xC0, 0x38, 0xC0, 0x18, 0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0,
  0x07, 0xC0, 0x03, 0x03, 0xF8, 0x07, 0xFF, 0xC3, 0xC0, 0x78, 0xC0, 0x07,
  0x70, 0x00, 0x98, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x01,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xD0, 0x00, 0x3E, 0x00, 0x1D, 0xC0, 0x0E, 0x3C, 0x07, 0x87,
  0xFF, 0x80, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0x70, 0x01, 0xB8, 0x00, 0xDC, 0x00, 0x66, 0x00, 0x33,
  0x00, 0x19, 0x80, 0x1C, 0xE0, 0x0C, 0x38, 0x1E, 0x0F, 0xFE, 0x01, 0xFC,
  0x00, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00,
  0x1C, 0xE0, 0x03, 0x8C, 0x00, 0x61, 0x80, 0x0C, 0x38, 0x03, 0x83, 0x00,
  0x60, 0x60, 0x0C, 0x0C, 0x03, 0x81, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01,
  0x80, 0x70, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x1C, 0x70, 0x01, 0x8C,
  0x00, 0x31, 0x80, 0x06, 0x70, 0x00, 0xEC, 0x00, 0x0D, 0x80, 0x01, 0xB0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x07,
  0x03, 0xC0, 0xE0, 0xD8, 0x1C, 0x19, 0x86, 0xC3, 0x30, 0xD8, 0x66, 0x1B,
  0x0C, 0xC2, 0x61, 0x98, 0xC6, 0x33, 0x18, 0xC6, 0x63, 0x18, 0xCC, 0x63,
  0x19, 0x98, 0x23, 0x33, 0x06, 0x46, 0x60, 0xD8, 0xCC, 0x1B, 0x0F, 0x03,
  0x61, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xE0, 0x1E, 0x00, 0x70,
  0x00, 0x71, 0x80, 0x03, 0x0E, 0x00, 0x38, 0x38, 0x03, 0x80, 0xC0, 0x18,
  0x07, 0x01, 0xC0, 0x18, 0x0C, 0x00, 0xE0, 0xC0, 0x03, 0x8E, 0x00, 0x0C,
  0x60, 0x00, 0x77, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xE0, 0x00, 0x1B, 0x00, 0x01, 0x9C, 0x00, 0x1C, 0x70, 0x00, 0xC1,
  0x80, 0x0E, 0x0E, 0x00, 0xE0, 0x30, 0x06, 0x00, 0xC0, 0x70, 0x07, 0x03,
  0x00, 0x18, 0x30, 0x00, 0xE3, 0x80, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00,
  0x3B, 0x00, 0x01, 0x9C, 0x00, 0x1C, 0x60, 0x01, 0xC3, 0x80, 0x0C, 0x0E,
  0x00, 0xE0, 0x30, 0x06, 0x01, 0xC0, 0x70, 0x06, 0x03, 0x00, 0x38, 0x30,
  0x00, 0xC3, 0x80, 0x07, 0x18, 0x00, 0x19, 0xC0, 0x00, 0x6C, 0x00, 0x03,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xF0, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x06, 0xC0, 0x01, 0x9C, 0x00, 0x31, 0x80, 0x0C, 0x38, 0x03, 0x83,
  0x00, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x00, 0x60, 0xC0, 0x0E, 0x18, 0x00,
  0xC6, 0x00, 0x1D, 0xC0, 0x01, 0x90, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x63, 0x87, 0x0C, 0x18, 0x60, 0xC0, 0x0F, 0xE0, 0x0F, 0xFE, 0x07,
  0x83, 0xC1, 0x80, 0x70, 0xC0, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x03, 0xFF, 0x87, 0xFF, 0xE1, 0xC0, 0x18, 0xE0, 0x06,
  0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x38, 0xC0, 0x16, 0x1C, 0x0D, 0x87,
  0xFE, 0x7C, 0x7E, 0x0F, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC3, 0xE0, 0xCF, 0xF8,
  0xD8, 0x3C, 0xE0, 0x0E, 0xE0, 0x06, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0xD8, 0x3C, 0xCF, 0xF8, 0xC3, 0xE0,
  0x07, 0xE0, 0x3F, 0xF0, 0xE0, 0x73, 0x80, 0x76, 0x00, 0x78, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x01, 0x30, 0x03, 0x70, 0x0E, 0x70, 0x38, 0x7F, 0xE0,
  0x3F, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x0F, 0xC3, 0x1F, 0xF3, 0x38, 0x1B,
  0x70, 0x0B, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xE0, 0x07, 0x70, 0x0B, 0x38, 0x1B, 0x1F, 0xF3, 0x07, 0xC3, 0x07, 0xF0,
  0x07, 0xFE, 0x0F, 0x07, 0x86, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x1B, 0x00,
  0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x04, 0xC0, 0x06, 0x30, 0x07, 0x1E, 0x0F,
  0x07, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x7E, 0xC0, 0x3F, 0xF0, 0x1C, 0x1C, 0x0C, 0x03, 0x83, 0x00, 0x61,
  0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x60, 0xC0, 0x38, 0x3C,
  0x1C, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x07, 0x00, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x8C, 0x00, 0xE6, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x1D, 0xC0, 0x1E, 0x3F,
  0xFF, 0x03, 0xFE, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC7, 0xE1, 0x9F, 0xF3, 0x60,
  0xF7, 0x00, 0x6E, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x30, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x38, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0D, 0xFF, 0xEF, 0xFE, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x07, 0xB8, 0x03, 0x8E, 0x01,
  0xC3, 0x80, 0xE0, 0xE0, 0x70, 0x38, 0x38, 0x0E, 0x1C, 0x03, 0x8E, 0x00,
  0xE7, 0x80, 0x3B, 0x70, 0x0F, 0x8C, 0x03, 0xC3, 0x80, 0xE0, 0x70, 0x38,
  0x0E, 0x0E, 0x01, 0x83, 0x80, 0x70, 0xE0, 0x0E, 0x38, 0x01, 0xCE, 0x00,
  0x33, 0x80, 0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xCF, 0x0F, 0xB7, 0xE7, 0xFD, 0x1D, 0x1F, 0x83, 0x83,
  0xE0, 0xE0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0, 0xC0, 0xF0,
  0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C,
  0x0F, 0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03,
  0xC7, 0xE1, 0x9F, 0xF3, 0x60, 0xF7, 0x00, 0x6E, 0x00, 0xFC, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x30, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0x07, 0x8E, 0x00, 0xC6, 0x00,
  0x37, 0x00, 0x1B, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0C, 0xC0, 0x06,
  0x70, 0x06, 0x1E, 0x0F, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0xC3, 0xE0, 0xCF,
  0xF8, 0xD8, 0x3C, 0xE0, 0x0E, 0xE0, 0x06, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0xD8, 0x3C, 0xCF, 0xF8, 0xC3,
  0xE0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x0F, 0xC3, 0x1F, 0xF3, 0x38, 0x1B, 0x70,
  0x0B, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0,
  0x07, 0x70, 0x0B, 0x38, 0x1B, 0x1F, 0xF3, 0x07, 0xC3, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0xFF, 0x0F, 0xFF, 0xCF, 0xF0, 0x33, 0x00, 0x0D, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0x07, 0xF0,
  0x0F, 0xFE, 0x0E, 0x03, 0xCE, 0x00, 0x66, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x80, 0x07, 0xE0, 0x03, 0x3C, 0x07,
  0x87, 0xFF, 0x80, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x07, 0x60, 0x1E, 0xF0, 0x7C, 0xFF, 0xB8, 0x7C, 0x70,
  0xC0, 0x01, 0xF0, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x67, 0x00, 0x61, 0x80,
  0x30, 0xC0, 0x18, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x0E, 0x03, 0x06, 0x01,
  0x83, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0xC0, 0x03, 0x60,
  0x01, 0xB0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0xC0, 0x70, 0x1E, 0x03, 0x81,
  0x98, 0x14, 0x0C, 0xC1, 0xA0, 0x66, 0x0D, 0x83, 0x30, 0x6C, 0x19, 0x82,
  0x60, 0xCC, 0x11, 0x0C, 0x31, 0x8C, 0x61, 0x8C, 0x63, 0x0C, 0x63, 0x18,
  0x62, 0x08, 0xC3, 0x30, 0x46, 0x19, 0x83, 0x20, 0x4C, 0x1B, 0x03, 0x40,
  0xD8, 0x1A, 0x02, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x00,
  0xE0, 0x03, 0xB8, 0x03, 0x8C, 0x01, 0x87, 0x01, 0x81, 0xC1, 0xC0, 0x61,
  0xC0, 0x18, 0xC0, 0x0E, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x7C, 0x00, 0x77, 0x00, 0x31, 0x80, 0x30, 0xE0, 0x38, 0x38, 0x38, 0x0E,
  0x18, 0x03, 0x18, 0x01, 0xDC, 0x00, 0x70, 0xE0, 0x00, 0xD8, 0x00, 0x37,
  0x00, 0x18, 0xC0, 0x06, 0x30, 0x03, 0x86, 0x00, 0xC1, 0x80, 0x30, 0x70,
  0x18, 0x0C, 0x06, 0x03, 0x03, 0x80, 0x60, 0xC0, 0x18, 0x30, 0x07, 0x18,
  0x00, 0xC6, 0x00, 0x33, 0x80, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0xFF, 0x01, 0xFE, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0x81, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xFE, 0x03,
  0xFC, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0xFF, 0x81, 0xFF, 0x00, 0x1E, 0x00, 0x67, 0xE0, 0x0C,
  0xC6, 0x03, 0x30, 0x60, 0x66, 0x06, 0x0D, 0x80, 0xE3, 0x30, 0x0F, 0xE6,
  0x00, 0x70,
};

const GFXglyph IBMPlexMono_Light38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 5, 27, 23, 9, -27 },
  { 18, 9, 10, 23, 7, -28 },
  { 30, 21, 27, 23, 1, -27 },
  { 101, 19, 35, 23, 2, -31 },
  { 185, 21, 27, 23, 1, -27 },
  { 256, 20, 27, 23, 1, -27 },
  { 324, 2, 10, 23, 10, -28 },
  { 327, 10, 34, 23, 8, -29 },
  { 370, 11, 34, 23, 4, -29 },
  { 417, 19, 19, 23, 2, -21 },
  { 463, 18, 18, 23, 2, -21 },
  { 504, 6, 10, 23, 8, -4 },
  { 512, 11, 2, 23, 6, -13 },
  { 515, 5, 4, 23, 9, -4 },
  { 518, 15, 34, 23, 4, -29 },
  { 582, 18, 27, 23, 2, -27 },
  { 643, 18, 27, 23, 3, -27 },
  { 704, 17, 27, 23, 3, -27 },
  { 762, 17, 27, 23, 2, -27 },
  { 820, 20, 27, 23, 1, -27 },
  { 888, 17, 27, 23, 3, -27 },
  { 946, 17, 27, 23, 3, -27 },
  { 1004, 17, 27, 23, 3, -27 },
  { 1062, 18, 27, 23, 2, -27 },
  { 1123, 17, 27, 23, 3, -27 },
  { 1181, 5, 20, 23, 9, -20 },
  { 1194, 6, 26, 23, 8, -20 },
  { 1214, 17, 21, 23, 3, -22 },
  { 1259, 18, 9, 23, 2, -16 },
  { 1280, 17, 21, 23, 3, -22 },
  { 1325, 16, 27, 23, 3, -27 },
  { 1379, 16, 31, 23, 3, -27 },
  { 1441, 20, 27, 23, 1, -27 },
  { 1509, 17, 27, 23, 3, -27 },
  { 1567, 17, 27, 23, 3, -27 },
  { 1625, 16, 27, 23, 4, -27 },
  { 1679, 16, 27, 23, 4, -27 },
  { 1733, 16, 27, 23, 4, -27 },
  { 1787, 18, 27, 23, 2, -27 },
  { 1848, 17, 27, 23, 3, -27 },
  { 1906, 17, 27, 23, 3, -27 },
  { 1964, 15, 27, 23, 3, -27 },
  { 2015, 18, 27, 23, 4, -27 },
  { 2076, 15, 27, 23, 5, -27 },
  { 2127, 17, 27, 23, 3, -27 },
  { 2185, 17, 27, 23, 3, -27 },
  { 2243, 18, 27, 23, 2, -27 },
  { 2304, 16, 27, 23, 4, -27 },
  { 2358, 18, 33, 23, 2, -27 },
  { 2433, 16, 27, 23, 4, -27 },
  { 2487, 18, 27, 23, 2, -27 },
  { 2548, 21, 27, 23, 1, -27 },
  { 2619, 17, 27, 23, 3, -27 },
  { 2677, 19, 27, 23, 2, -27 },
  { 2742, 19, 27, 23, 2, -27 },
  { 2807, 21, 27, 23, 1, -27 },
  { 2878, 21, 27, 23, 1, -27 },
  { 2949, 19, 27, 23, 2, -27 },
  { 3014, 10, 34, 23, 9, -29 },
  { 3057, 15, 34, 23, 4, -29 },
  { 3121, 10, 34, 23, 4, -29 },
  { 3164, 19, 15, 23, 2, -27 },
  { 3200, 19, 2, 23, 2, 4 },
  { 3205, 6, 7, 23, 7, -29 },
  { 3211, 18, 20, 23, 3, -20 },
  { 3256, 16, 28, 23, 4, -28 },
  { 3312, 15, 20, 23, 4, -20 },
  { 3350, 16, 28, 23, 3, -28 },
  { 3406, 17, 20, 23, 3, -20 },
  { 3449, 18, 28, 23, 3, -28 },
  { 3512, 18, 30, 23, 3, -22 },
  { 3580, 15, 28, 23, 4, -28 },
  { 3633, 17, 29, 23, 4, -29 },
  { 3695, 13, 37, 23, 4, -29 },
  { 3756, 18, 28, 23, 4, -28 },
  { 3819, 17, 28, 23, 3, -28 },
  { 3879, 18, 20, 23, 2, -20 },
  { 3924, 15, 20, 23, 4, -20 },
  { 3962, 17, 20, 23, 3, -20 },
  { 4005, 16, 28, 23, 4, -20 },
  { 4061, 16, 28, 23, 3, -20 },
  { 4117, 18, 20, 23, 3, -20 },
  { 4162, 17, 20, 23, 3, -20 },
  { 4205, 19, 27, 23, 1, -27 },
  { 4270, 15, 20, 23, 4, -20 },
  { 4308, 17, 20, 23, 3, -20 },
  { 4351, 21, 20, 23, 1, -20 },
  { 4404, 17, 20, 23, 3, -20 },
  { 4447, 18, 28, 23, 2, -20 },
  { 4510, 16, 20, 23, 3, -20 },
  { 4550, 15, 34, 23, 4, -29 },
  { 4614, 2, 34, 23, 10, -29 },
  { 4623, 15, 34, 23, 4, -29 },
  { 4687, 19, 8, 23, 2, -15 },
};

const GFXfont IBMPlexMono_Light38pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light38pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light38pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _IBMPLEXMONO_LIGHT38PT7B_H_
