#ifndef _IBMPLEXMONO_LIGHT14PT7B_H_
#define _IBMPLEXMONO_LIGHT14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light14pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x60, 0xF0, 0xB6, 0xD0, 0x12, 0x14, 0x14, 0x77, 0x24, 0x24,
  0xE7, 0x28, 0x28, 0x28, 0x10, 0xF2, 0x54, 0x99, 0x0E, 0x07, 0x09, 0x13,
  0x29, 0xE0, 0x80, 0x71, 0x92, 0x92, 0x94, 0x70, 0x06, 0x29, 0x49, 0x49,
  0x86, 0x38, 0x44, 0x40, 0x20, 0x23, 0x52, 0x8A, 0x84, 0x46, 0x7B, 0xF0,
  0x34, 0x48, 0x88, 0x88, 0x88, 0x44, 0x30, 0x89, 0x12, 0x49, 0x25, 0x28,
  0x10, 0x22, 0x4B, 0xE3, 0x09, 0x11, 0x00, 0x10, 0x20, 0x47, 0xF1, 0x02,
  0x04, 0x00, 0x7A, 0xF0, 0xF0, 0x04, 0x20, 0x82, 0x10, 0x41, 0x08, 0x21,
  0x04, 0x10, 0x80, 0x78, 0x8A, 0x14, 0x28, 0x32, 0x61, 0x42, 0x44, 0xF0,
  0x30, 0xE3, 0x44, 0x81, 0x02, 0x04, 0x08, 0x11, 0xFC, 0x79, 0x18, 0x41,
  0x04, 0x21, 0x08, 0x43, 0xF0, 0x7A, 0x10, 0x41, 0x38, 0x30, 0x41, 0x85,
  0xE0, 0x08, 0x30, 0xA1, 0x44, 0x91, 0x22, 0x7F, 0x08, 0x10, 0x7E, 0x08,
  0x20, 0xBB, 0x10, 0x41, 0x85, 0xE0, 0x18, 0x84, 0x10, 0xBB, 0x18, 0x61,
  0xC5, 0xE0, 0xFE, 0x18, 0x42, 0x08, 0x41, 0x08, 0x21, 0x80, 0x79, 0x0A,
  0x14, 0x27, 0x99, 0xA1, 0x41, 0x84, 0xF0, 0x7B, 0x18, 0x61, 0xC5, 0xF0,
  0x42, 0x10, 0x80, 0xF0, 0x0F, 0xF0, 0x07, 0xA0, 0x04, 0x23, 0x30, 0xC0,
  0x81, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x81, 0x81, 0x03, 0x04, 0x66, 0x20,
  0x39, 0x18, 0x41, 0x38, 0x80, 0x00, 0x30, 0xC0, 0x39, 0x18, 0x67, 0xA6,
  0x9A, 0x69, 0x9E, 0x04, 0x0E, 0x10, 0x60, 0xA2, 0x44, 0x89, 0x1F, 0x42,
  0x85, 0x04, 0xFA, 0x18, 0x61, 0xFA, 0x18, 0x61, 0x87, 0xE0, 0x39, 0x18,
  0x60, 0x82, 0x08, 0x21, 0x44, 0xE0, 0xF9, 0x0A, 0x14, 0x28, 0x30, 0x61,
  0x42, 0x85, 0xF0, 0xFE, 0x08, 0x20, 0xFE, 0x08, 0x20, 0x83, 0xF0, 0xFE,
  0x08, 0x20, 0xFE, 0x08, 0x20, 0x82, 0x00, 0x79, 0x18, 0x60, 0x82, 0x78,
  0x61, 0x45, 0xF0, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x86, 0x10, 0xFC,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x13, 0xF0, 0x7C, 0x10, 0x41, 0x04, 0x10,
  0x61, 0x89, 0xE0, 0x87, 0x0A, 0x24, 0x8A, 0x1A, 0x22, 0x44, 0x85, 0x04,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xC0, 0x87, 0x3C, 0xED, 0xB6, 0x58,
  0x61, 0x86, 0x10, 0xC7, 0x1A, 0x69, 0xA6, 0x59, 0x63, 0x8E, 0x10, 0x78,
  0x8A, 0x14, 0x28, 0x30, 0x61, 0x42, 0x44, 0xF0, 0xFD, 0x0A, 0x14, 0x38,
  0x5F, 0xA0, 0x40, 0x81, 0x00, 0x78, 0x8A, 0x14, 0x28, 0x30, 0x61, 0x42,
  0x44, 0xF0, 0x40, 0xE0, 0xFD, 0x0A, 0x14, 0x38, 0x5F, 0x24, 0x44, 0x85,
  0x0C, 0x79, 0x0A, 0x04, 0x07, 0x01, 0x81, 0x03, 0x84, 0xF0, 0xFF, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x45, 0xE0, 0x83, 0x0A, 0x12, 0x24, 0x89, 0x12, 0x14, 0x30,
  0x60, 0x83, 0x06, 0x0C, 0xAB, 0x56, 0xAB, 0x66, 0xCD, 0x88, 0x43, 0x22,
  0x24, 0x14, 0x18, 0x18, 0x14, 0x24, 0x42, 0xC1, 0xC1, 0x42, 0x22, 0x24,
  0x18, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFC, 0x08, 0x20, 0x41, 0x04, 0x10,
  0x20, 0x81, 0xFC, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x81, 0x04,
  0x10, 0x20, 0x81, 0x04, 0x10, 0x20, 0x82, 0x04, 0xF1, 0x11, 0x11, 0x11,
  0x11, 0x11, 0xF0, 0x30, 0x61, 0x22, 0x28, 0x50, 0xC0, 0xFE, 0xA4, 0x79,
  0x10, 0x13, 0xE8, 0x51, 0x9D, 0x80, 0x82, 0x08, 0x2E, 0xC6, 0x18, 0x61,
  0xC6, 0xE0, 0x39, 0x18, 0x20, 0x81, 0x13, 0x80, 0x04, 0x10, 0x5D, 0x8E,
  0x18, 0x61, 0x85, 0xF0, 0x79, 0x18, 0x7F, 0x81, 0x17, 0x80, 0x1E, 0x20,
  0x47, 0xF1, 0x02, 0x04, 0x08, 0x11, 0xF8, 0x06, 0xF1, 0x14, 0x24, 0x47,
  0x30, 0x3E, 0x83, 0x05, 0xF0, 0x84, 0x21, 0xE8, 0xC6, 0x31, 0x8C, 0x40,
  0x20, 0x00, 0x38, 0x20, 0x82, 0x08, 0x23, 0xF0, 0x08, 0x01, 0xF0, 0x84,
  0x21, 0x08, 0x42, 0x1F, 0x80, 0x82, 0x08, 0x23, 0x92, 0x8E, 0x24, 0x8A,
  0x10, 0xF0, 0x41, 0x04, 0x10, 0x41, 0x04, 0x13, 0xF0, 0xED, 0x66, 0x4C,
  0x99, 0x32, 0x64, 0x80, 0xF4, 0x63, 0x18, 0xC6, 0x20, 0x7B, 0x18, 0x61,
  0x87, 0x17, 0x80, 0xBB, 0x18, 0x61, 0x87, 0x1B, 0xA0, 0x82, 0x00, 0x76,
  0x38, 0x61, 0x86, 0x17, 0xC1, 0x04, 0x10, 0xEE, 0x60, 0x81, 0x02, 0x04,
  0x3F, 0x00, 0x7A, 0x1C, 0x1F, 0x06, 0x17, 0x80, 0x20, 0x82, 0x3F, 0x20,
  0x82, 0x08, 0x20, 0xF0, 0x86, 0x18, 0x61, 0x85, 0x17, 0xC0, 0x86, 0x14,
  0x92, 0x28, 0xC1, 0x00, 0x89, 0x99, 0x59, 0x56, 0x66, 0x66, 0x22, 0x85,
  0x23, 0x04, 0x29, 0x28, 0x40, 0x86, 0x14, 0x92, 0x28, 0xC1, 0x08, 0x23,
  0x80, 0xFC, 0x10, 0x84, 0x21, 0x0F, 0xC0, 0x3A, 0x10, 0x42, 0x13, 0x04,
  0x21, 0x10, 0x83, 0x80, 0xFF, 0xF8, 0xE1, 0x08, 0x84, 0x20, 0xEC, 0x42,
  0x08, 0x4E, 0x00, 0x63, 0x2A, 0x30,
};

const GFXglyph IBMPlexMono_Light14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 3, 4, 8, 3, -10 },
  { 6, 8, 10, 8, 0, -10 },
  { 16, 7, 12, 8, 1, -11 },
  { 27, 8, 10, 8, 0, -10 },
  { 37, 8, 10, 8, 0, -10 },
  { 47, 1, 4, 8, 4, -10 },
  { 48, 4, 13, 8, 3, -11 },
  { 55, 3, 13, 8, 2, -11 },
  { 60, 7, 7, 8, 1, -8 },
  { 67, 7, 7, 8, 1, -8 },
  { 74, 2, 4, 8, 3, -2 },
  { 75, 4, 1, 8, 2, -5 },
  { 76, 2, 2, 8, 3, -2 },
  { 77, 6, 13, 8, 1, -11 },
  { 87, 7, 10, 8, 1, -10 },
  { 96, 7, 10, 8, 1, -10 },
  { 105, 6, 10, 8, 1, -10 },
  { 113, 6, 10, 8, 1, -10 },
  { 121, 7, 10, 8, 1, -10 },
  { 130, 6, 10, 8, 1, -10 },
  { 138, 6, 10, 8, 1, -10 },
  { 146, 6, 10, 8, 1, -10 },
  { 154, 7, 10, 8, 1, -10 },
  { 163, 6, 10, 8, 1, -10 },
  { 171, 2, 8, 8, 3, -8 },
  { 173, 2, 10, 8, 3, -8 },
  { 176, 6, 8, 8, 1, -8 },
  { 182, 7, 4, 8, 1, -6 },
  { 186, 6, 8, 8, 1, -8 },
  { 192, 6, 10, 8, 1, -10 },
  { 200, 6, 12, 8, 1, -10 },
  { 209, 7, 10, 8, 1, -10 },
  { 218, 6, 10, 8, 1, -10 },
  { 226, 6, 10, 8, 1, -10 },
  { 234, 7, 10, 8, 1, -10 },
  { 243, 6, 10, 8, 1, -10 },
  { 251, 6, 10, 8, 1, -10 },
  { 259, 6, 10, 8, 1, -10 },
  { 267, 6, 10, 8, 1, -10 },
  { 275, 6, 10, 8, 1, -10 },
  { 283, 6, 10, 8, 1, -10 },
  { 291, 7, 10, 8, 1, -10 },
  { 300, 5, 10, 8, 2, -10 },
  { 307, 6, 10, 8, 1, -10 },
  { 315, 6, 10, 8, 1, -10 },
  { 323, 7, 10, 8, 1, -10 },
  { 332, 7, 10, 8, 1, -10 },
  { 341, 7, 12, 8, 1, -10 },
  { 352, 7, 10, 8, 1, -10 },
  { 361, 7, 10, 8, 1, -10 },
  { 370, 8, 10, 8, 0, -10 },
  { 380, 6, 10, 8, 1, -10 },
  { 388, 7, 10, 8, 1, -10 },
  { 397, 7, 10, 8, 1, -10 },
  { 406, 8, 10, 8, 0, -10 },
  { 416, 8, 10, 8, 0, -10 },
  { 426, 7, 10, 8, 1, -10 },
  { 435, 4, 13, 8, 3, -11 },
  { 442, 6, 13, 8, 1, -11 },
  { 452, 4, 13, 8, 1, -11 },
  { 459, 7, 6, 8, 1, -10 },
  { 465, 7, 1, 8, 1, 1 },
  { 466, 2, 3, 8, 3, -12 },
  { 467, 7, 7, 8, 1, -7 },
  { 474, 6, 10, 8, 1, -10 },
  { 482, 6, 7, 8, 1, -7 },
  { 488, 6, 10, 8, 1, -10 },
  { 496, 6, 7, 8, 1, -7 },
  { 502, 7, 10, 8, 1, -10 },
  { 511, 7, 11, 8, 1, -8 },
  { 521, 5, 10, 8, 2, -10 },
  { 528, 6, 10, 8, 2, -10 },
  { 536, 5, 13, 8, 1, -10 },
  { 545, 6, 10, 8, 2, -10 },
  { 553, 6, 10, 8, 1, -10 },
  { 561, 7, 7, 8, 1, -7 },
  { 568, 5, 7, 8, 2, -7 },
  { 573, 6, 7, 8, 1, -7 },
  { 579, 6, 10, 8, 1, -7 },
  { 587, 6, 10, 8, 1, -7 },
  { 595, 7, 7, 8, 1, -7 },
  { 602, 6, 7, 8, 1, -7 },
  { 608, 6, 10, 8, 1, -10 },
  { 616, 6, 7, 8, 1, -7 },
  { 622, 6, 7, 8, 1, -7 },
  { 628, 8, 7, 8, 0, -7 },
  { 635, 6, 7, 8, 1, -7 },
  { 641, 6, 10, 8, 1, -7 },
  { 649, 6, 7, 8, 1, -7 },
  { 655, 5, 13, 8, 2, -11 },
  { 664, 1, 13, 8, 4, -11 },
  { 666, 5, 13, 8, 2, -11 },
  { 675, 7, 3, 8, 1, -6 },
};

const GFXfont IBMPlexMono_Light14pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light14pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _IBMPLEXMONO_LIGHT14PT7B_H_
