#ifndef _IBMPLEXMONO_LIGHT63PT7B_H_
#define _IBMPLEXMONO_LIGHT63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light63pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0x7E, 0x7C, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00,
  0x70, 0x0F, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF3, 0xFF,
  0xE0, 0x1F, 0xFF, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xE0, 0x1C, 0x00,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x03, 0x80, 0x78, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xF8, 0x07,
  0xFF, 0x8F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1E,
  0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x3C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0x8E, 0x7F, 0x81, 0xF0,
  0x38, 0x3F, 0x0F, 0x80, 0xE0, 0x3E, 0x3C, 0x03, 0x80, 0x7D, 0xE0, 0x0E,
  0x00, 0xC7, 0x80, 0x38, 0x02, 0x1E, 0x00, 0xE0, 0x00, 0x78, 0x03, 0x80,
  0x01, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0x38, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x78, 0x03, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0F,
  0x80, 0xE0, 0x00, 0x1F, 0x03, 0x80, 0x00, 0x3F, 0x0E, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xE1, 0xF8, 0x00, 0x03, 0x81,
  0xF0, 0x00, 0x0E, 0x03, 0xE0, 0x00, 0x38, 0x07, 0x80, 0x00, 0xE0, 0x0F,
  0x00, 0x03, 0x80, 0x3C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x38, 0x03, 0xC0,
  0x00, 0xE0, 0x0F, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x0E, 0x00, 0xF4, 0x00,
  0x38, 0x03, 0xD8, 0x00, 0xE0, 0x0F, 0xF0, 0x03, 0x80, 0x7B, 0xE0, 0x0E,
  0x01, 0xE7, 0xC0, 0x38, 0x0F, 0x0F, 0xC0, 0xE0, 0xFC, 0x1F, 0xE3, 0x8F,
  0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1C, 0x7F, 0xFC, 0x00, 0x07,
  0x8F, 0x07, 0xC0, 0x00, 0xE3, 0xC0, 0x38, 0x00, 0x38, 0x70, 0x03, 0x80,
  0x07, 0x1C, 0x00, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x00, 0x38, 0x70, 0x00,
  0xE0, 0x0E, 0x0E, 0x00, 0x1C, 0x03, 0xC1, 0xC0, 0x03, 0x80, 0x70, 0x38,
  0x00, 0x70, 0x1E, 0x07, 0x00, 0x0E, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0xE0,
  0x1C, 0x00, 0x70, 0x1C, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x38, 0x01, 0xC1,
  0xE0, 0x07, 0x80, 0x70, 0x38, 0x00, 0x78, 0x3E, 0x0F, 0x00, 0x0F, 0xFF,
  0x81, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x70, 0x3F, 0xFC, 0x00, 0x1C, 0x0F,
  0x83, 0xC0, 0x03, 0x83, 0xC0, 0x3C, 0x00, 0xE0, 0x70, 0x03, 0x80, 0x3C,
  0x0E, 0x00, 0x78, 0x07, 0x03, 0x80, 0x07, 0x01, 0xE0, 0x70, 0x00, 0xE0,
  0x38, 0x0E, 0x00, 0x1C, 0x0F, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x38, 0x00,
  0x70, 0x70, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0xE0, 0x01, 0xC3, 0x80, 0x1C,
  0x00, 0x38, 0xF0, 0x01, 0xC0, 0x0F, 0x1C, 0x00, 0x38, 0x01, 0xC7, 0x80,
  0x07, 0x80, 0x78, 0xE0, 0x00, 0x7C, 0x1E, 0x3C, 0x00, 0x07, 0xFF, 0x87,
  0x00, 0x00, 0x7F, 0xE1, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0x3C, 0x00, 0xFF,
  0x1F, 0x0F, 0x00, 0x7F, 0x8F, 0x07, 0x80, 0x38, 0x0F, 0x01, 0xE0, 0x1C,
  0x0F, 0x00, 0x78, 0x0E, 0x07, 0x80, 0x1E, 0x07, 0x03, 0x80, 0x07, 0x87,
  0x83, 0xC0, 0x03, 0xE3, 0x81, 0xE0, 0x00, 0xF1, 0xC0, 0xF0, 0x00, 0x3C,
  0xE0, 0x78, 0x00, 0x0F, 0x70, 0x3C, 0x00, 0x03, 0xF8, 0x1E, 0x00, 0x00,
  0xF8, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x1F, 0xC0, 0xF0, 0x00, 0x0D, 0xF0, 0x3C, 0x00, 0x0C, 0x78, 0x1F, 0x00,
  0x1E, 0x1E, 0x07, 0xE0, 0x3E, 0x07, 0x81, 0xFF, 0xFE, 0x01, 0xE0, 0x3F,
  0xFC, 0x00, 0x78, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x40, 0x03, 0xC0, 0x02, 0xF8, 0x03, 0xC0, 0x1E,
  0xFF, 0x03, 0xC0, 0xFF, 0x7F, 0xE3, 0xC7, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x01, 0xE0,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0xC3, 0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3E,
  0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0x7E,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x07,
  0x80, 0x3F, 0xC0, 0x3F, 0x00, 0xFF, 0x00, 0xFC, 0x03, 0xFC, 0x03, 0xF0,
  0x0F, 0xF0, 0x0F, 0xC0, 0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1C, 0x3C, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x78, 0x0F, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xEE, 0x00, 0x00, 0x0F, 0x9C, 0x00, 0x00, 0x3E, 0x38, 0x00, 0x00,
  0xF8, 0x70, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x1F, 0x81, 0xC0, 0x00, 0x7E,
  0x03, 0x80, 0x01, 0xF8, 0x07, 0x00, 0x07, 0xC0, 0x0E, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x04, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF8,
  0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x3C, 0x20, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x78, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x10, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF2, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x3C, 0x7C, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x7F, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x3C, 0x03, 0x80, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x07, 0x80, 0x01, 0xC0, 0x07, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x70, 0x03, 0xC0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x81, 0xFE, 0x00, 0x38, 0x7F, 0xF8, 0x03, 0x9F, 0xFF, 0xE0, 0x3B, 0xC0,
  0x7F, 0x03, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x20, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x81,
  0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x81, 0xFE, 0x00, 0x78, 0xFF, 0xFC, 0x07, 0x1F, 0xFF, 0xE0,
  0x73, 0xC0, 0x3F, 0x0F, 0x70, 0x00, 0xF8, 0xFE, 0x00, 0x07, 0xCF, 0xC0,
  0x00, 0x3E, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00,
  0x0F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x1F,
  0x80, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xC7, 0x80, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9F, 0x00,
  0x00, 0x3C, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x80, 0xFE, 0x01,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x78, 0x3C, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0x78,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xF1, 0xF0, 0x00,
  0xEE, 0x0F, 0xC0, 0x3C, 0xE0, 0x7F, 0xFF, 0x9E, 0x03, 0xFF, 0xF1, 0xE0,
  0x07, 0xF8, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0x7E, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0x7E,
  0x7C, 0x0F, 0x07, 0xE3, 0xF8, 0xFF, 0x3F, 0xC7, 0xE1, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0x83, 0xE0, 0xF8, 0x3C, 0x0F,
  0x03, 0xC1, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x07, 0xE0, 0x1F, 0x81, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x3C, 0x40, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xF0, 0x1F,
  0x00, 0xF8, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x1E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07,
  0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x07, 0xE1, 0xFC, 0x01,
  0xFF, 0x3F, 0x00, 0x7F, 0xF7, 0xE0, 0x1F, 0x06, 0xFC, 0x07, 0x80, 0x3F,
  0x80, 0xE0, 0x07, 0xF0, 0x3C, 0x00, 0x7E, 0x07, 0x80, 0x0F, 0xC0, 0xE0,
  0x01, 0xF8, 0x1C, 0x00, 0x3F, 0x03, 0x80, 0x07, 0xE0, 0x70, 0x00, 0xFC,
  0x0E, 0x00, 0x1F, 0x81, 0xC0, 0x03, 0xF0, 0x38, 0x00, 0x7E, 0x07, 0x00,
  0x0F, 0xC0, 0xE0, 0x01, 0xF8, 0x1C, 0x00, 0x3F, 0x03, 0x80, 0x07, 0xE0,
  0x78, 0x00, 0xFC, 0x07, 0x00, 0x1F, 0x80, 0xF0, 0x07, 0xF0, 0x1F, 0x01,
  0xFE, 0x01, 0xF8, 0xEF, 0xE0, 0x1F, 0xF9, 0xDC, 0x01, 0xFE, 0x3B, 0x80,
  0x0F, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x3C, 0xE0, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1C,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x07, 0xE0, 0xF0,
  0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x03, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x1F, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x07,
  0xC0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0xF3, 0x80, 0x00, 0x06, 0x78, 0x00, 0x00, 0x87, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x08, 0x38, 0x00, 0x00, 0x63, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x07, 0xF0,
  0x1F, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0x00,
  0x0F, 0xC0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F,
  0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x7C,
  0x00, 0x7C, 0x07, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x20,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x9E, 0x00,
  0x00, 0x7C, 0x78, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3F, 0x0F, 0x00, 0x03,
  0x78, 0x7E, 0x00, 0x3B, 0xC1, 0xFC, 0x07, 0x9E, 0x07, 0xFF, 0xF8, 0xF0,
  0x0F, 0xFF, 0x87, 0x80, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE6, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0x3E, 0x00,
  0x3C, 0x0F, 0xC0, 0x7E, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3E,
  0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x7C, 0x03,
  0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x3C, 0x07,
  0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x3C, 0x3F, 0x00, 0x00, 0xF1, 0xFE, 0x00, 0x03, 0xCF, 0xF8, 0x00,
  0x0F, 0x3C, 0xF0, 0x00, 0x3D, 0xE3, 0xE0, 0x00, 0xFF, 0x07, 0x80, 0x03,
  0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1F,
  0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xEE, 0x00, 0x07, 0x7E, 0xF0,
  0x00, 0xF7, 0xE7, 0x00, 0x0E, 0x7E, 0x78, 0x01, 0xE7, 0xE3, 0x80, 0x1C,
  0x7E, 0x38, 0x01, 0xC7, 0xE3, 0xC0, 0x38, 0x7E, 0x1C, 0x03, 0x87, 0xE1,
  0xE0, 0x78, 0x7E, 0x0E, 0x07, 0x07, 0xE0, 0xF0, 0xF0, 0x7E, 0x07, 0x0E,
  0x07, 0xE0, 0x70, 0xE0, 0x7E, 0x07, 0x9C, 0x07, 0xE0, 0x39, 0xC0, 0x7E,
  0x03, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0x00, 0x7E, 0x00, 0xF0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0x60, 0x07,
  0xE0, 0x06, 0x00, 0x7E, 0x00, 0x40, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFD, 0xE0, 0x00, 0x3F, 0xBC, 0x00, 0x07, 0xF3,
  0xC0, 0x00, 0xFE, 0x78, 0x00, 0x1F, 0xC7, 0x80, 0x03, 0xF8, 0xF0, 0x00,
  0x7F, 0x0F, 0x00, 0x0F, 0xE1, 0xE0, 0x01, 0xFC, 0x1C, 0x00, 0x3F, 0x83,
  0xC0, 0x07, 0xF0, 0x78, 0x00, 0xFE, 0x07, 0x80, 0x1F, 0xC0, 0xF0, 0x03,
  0xF8, 0x0F, 0x00, 0x7F, 0x01, 0xE0, 0x0F, 0xE0, 0x1E, 0x01, 0xFC, 0x03,
  0xC0, 0x3F, 0x80, 0x3C, 0x07, 0xF0, 0x07, 0x80, 0xFE, 0x00, 0x70, 0x1F,
  0xC0, 0x0F, 0x03, 0xF8, 0x01, 0xE0, 0x7F, 0x00, 0x1E, 0x0F, 0xE0, 0x03,
  0xC1, 0xFC, 0x00, 0x3C, 0x3F, 0x80, 0x07, 0x87, 0xF0, 0x00, 0x78, 0xFE,
  0x00, 0x0F, 0x1F, 0xC0, 0x00, 0xE3, 0xF8, 0x00, 0x1E, 0x7F, 0x00, 0x01,
  0xCF, 0xE0, 0x00, 0x3D, 0xFC, 0x00, 0x07, 0xBF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x1E, 0x70, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x3E,
  0x00, 0x3E, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x3C,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x1E, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00,
  0x03, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x8F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x8F,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0xF8, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0C,
  0x3C, 0x00, 0x00, 0x10, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF2, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F,
  0x7E, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0,
  0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F, 0x70,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x1C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xF0,
  0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x81, 0xF8, 0x07, 0xE0, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xE0, 0x07,
  0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01,
  0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x78, 0x1C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x3C, 0x38, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x0E, 0x70, 0x03, 0xC0, 0x0E, 0x70, 0x07, 0xC0, 0x0E, 0x70,
  0x07, 0xE0, 0x0E, 0x70, 0x07, 0xE0, 0x1E, 0x78, 0x07, 0xE0, 0x1E, 0x78,
  0x0F, 0xE0, 0x1E, 0x78, 0x0E, 0x70, 0x1C, 0x78, 0x0E, 0x70, 0x1C, 0x38,
  0x0E, 0x70, 0x1C, 0x38, 0x1E, 0x70, 0x1C, 0x38, 0x1C, 0x78, 0x1C, 0x38,
  0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x3C, 0x38, 0x1C, 0x38,
  0x38, 0x3C, 0x1C, 0x38, 0x38, 0x1C, 0x3C, 0x3C, 0x38, 0x1C, 0x3C, 0x3C,
  0x78, 0x1C, 0x3C, 0x3C, 0x70, 0x1E, 0x38, 0x3C, 0x70, 0x0E, 0x38, 0x1C,
  0x70, 0x0E, 0x38, 0x1C, 0xF0, 0x0E, 0x38, 0x1C, 0xE0, 0x0F, 0x38, 0x1C,
  0xE0, 0x07, 0x38, 0x1C, 0xE0, 0x07, 0x38, 0x1C, 0xE0, 0x07, 0x38, 0x1D,
  0xC0, 0x07, 0xB8, 0x1D, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F,
  0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x7C,
  0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x01, 0xF0,
  0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03,
  0xC0, 0x1F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x78,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x01, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03, 0xC7, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0x30, 0x00,
  0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x70, 0x7C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x38, 0x0E, 0x07,
  0x81, 0xC0, 0x40, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x1E, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x3C, 0x03, 0x80, 0x00, 0x78, 0x04, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xF8,
  0x00, 0x38, 0x0F, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x0B, 0x80, 0xF0, 0x00, 0xEE, 0x03, 0xF0, 0x0F, 0x3F, 0xC7,
  0xFF, 0xF8, 0x7F, 0x07, 0xFF, 0xC0, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x0F,
  0xE0, 0x07, 0x07, 0xFF, 0x80, 0xE3, 0xFF, 0xF8, 0x1C, 0xF0, 0x1F, 0x83,
  0xB8, 0x00, 0xF8, 0x74, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF1, 0xE0, 0x00,
  0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9F, 0x00, 0x01, 0xE3, 0xA0, 0x00, 0x7C,
  0x77, 0x00, 0x1F, 0x0E, 0x78, 0x0F, 0xC1, 0xC7, 0xFF, 0xF0, 0x38, 0x3F,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE3, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x02, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x43, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x0F,
  0x1E, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0xE0, 0x78, 0x0F,
  0xFF, 0x0F, 0x07, 0xFF, 0xF9, 0xE1, 0xFC, 0x07, 0xBC, 0x3E, 0x00, 0x37,
  0x8F, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x3C,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x87, 0xC0, 0x06,
  0xF0, 0xFE, 0x03, 0xDE, 0x0F, 0xFF, 0xF3, 0xC0, 0x7F, 0xF8, 0x78, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x7E, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x1E, 0x70, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x08, 0x38, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x07,
  0xE0, 0x3F, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF1, 0x80, 0x01, 0xFF, 0xF6, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x38, 0x0F, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x07, 0x80, 0x00, 0x7E, 0x78, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1E, 0x7C, 0x00, 0x00, 0xF9, 0xFC, 0x00, 0x1F, 0xC1, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x7F, 0x80, 0xE1, 0xFF, 0xE0, 0xE3, 0xFF, 0xF8, 0xE7,
  0x80, 0xFC, 0xEE, 0x00, 0x3C, 0xE8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x0F,
  0x00, 0x0F, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x1E, 0x01,
  0xF0, 0x00, 0xF0, 0x1F, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3C, 0x1F, 0x00,
  0x01, 0xE1, 0xF8, 0x00, 0x0F, 0x1F, 0xE0, 0x00, 0x79, 0xEF, 0x00, 0x03,
  0xDE, 0x3C, 0x00, 0x1F, 0xE1, 0xF0, 0x00, 0xFE, 0x07, 0xC0, 0x07, 0xE0,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0x03, 0xE0, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1,
  0xF8, 0x0F, 0xC3, 0x8F, 0xF0, 0x7F, 0xCE, 0x7F, 0xE3, 0xFF, 0x3B, 0x07,
  0x9C, 0x3E, 0xE8, 0x0F, 0x40, 0x7B, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78,
  0x03, 0xF8, 0x01, 0xE0, 0x0F, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x1E, 0x00,
  0x7E, 0x00, 0x78, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0xE0, 0x07, 0x80, 0x1F,
  0x80, 0x1E, 0x00, 0x7E, 0x00, 0x78, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0xE0,
  0x07, 0x80, 0x1F, 0x80, 0x1E, 0x00, 0x7E, 0x00, 0x78, 0x01, 0xF8, 0x01,
  0xE0, 0x07, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x1E, 0x00, 0x7E, 0x00, 0x78,
  0x01, 0xF8, 0x01, 0xE0, 0x07, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x1E, 0x00,
  0x7E, 0x00, 0x78, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0xE0, 0x07, 0x80, 0x1F,
  0x80, 0x1E, 0x00, 0x7E, 0x00, 0x78, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0xE0,
  0x07, 0x80, 0x1C, 0xE0, 0x7F, 0x80, 0xE1, 0xFF, 0xE0, 0xE3, 0xFF, 0xF8,
  0xE7, 0x80, 0xFC, 0xEE, 0x00, 0x3C, 0xE8, 0x00, 0x1E, 0xF8, 0x00, 0x1E,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x3C, 0x78, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x1E, 0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0xE0, 0x3F, 0x80, 0x1C, 0x1F, 0xFE, 0x03,
  0x8F, 0xFF, 0xE0, 0x73, 0xC0, 0x7E, 0x0E, 0xE0, 0x03, 0xE1, 0xD0, 0x00,
  0x3E, 0x3E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9C,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E,
  0x7C, 0x00, 0x07, 0x8E, 0x80, 0x01, 0xF1, 0xDC, 0x00, 0x7C, 0x39, 0xE0,
  0x3F, 0x07, 0x1F, 0xFF, 0xC0, 0xE0, 0xFF, 0xF0, 0x1C, 0x07, 0xF8, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xE0, 0x3F, 0xFC, 0x3C,
  0x1F, 0xFF, 0xE7, 0x87, 0xF0, 0x1E, 0xF0, 0xF8, 0x00, 0xDE, 0x3C, 0x00,
  0x0F, 0xCF, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07,
  0x9E, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x1B, 0xC3, 0xF8,
  0x0F, 0x78, 0x3F, 0xFF, 0xCF, 0x01, 0xFF, 0xE1, 0xE0, 0x0F, 0xF0, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xC0, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xC0, 0x00,
  0x00, 0xF6, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFC, 0x03, 0xF8, 0x1E,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x60, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0x7C,
  0x00, 0x01, 0xE3, 0xE0, 0x00, 0x7C, 0x1F, 0xC0, 0x1F, 0x80, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0x70, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF,
  0x00, 0x01, 0xF3, 0xC0, 0x01, 0xF9, 0xF0, 0x01, 0xBC, 0x7E, 0x03, 0xDE,
  0x1F, 0xFF, 0xCF, 0x07, 0xFF, 0x87, 0x80, 0x7F, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E,
  0x78, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xE0, 0x07,
  0x00, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x3C, 0x03,
  0xC0, 0x03, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xFC, 0x00,
  0x78, 0x00, 0xEF, 0x00, 0x3F, 0x00, 0x39, 0xC0, 0x0F, 0xC0, 0x0E, 0x70,
  0x03, 0xF0, 0x03, 0x9C, 0x00, 0xCC, 0x00, 0xE7, 0x00, 0x73, 0x00, 0x39,
  0xC0, 0x1C, 0xE0, 0x1E, 0x78, 0x07, 0x38, 0x07, 0x0E, 0x01, 0xCE, 0x01,
  0xC3, 0x80, 0x61, 0x80, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x1C,
  0x07, 0x0E, 0x03, 0x87, 0x01, 0xC3, 0xC0, 0xC1, 0xC0, 0xE0, 0x70, 0x70,
  0x30, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x03, 0x83, 0x81, 0xC1,
  0xC0, 0xE0, 0xE0, 0x70, 0x60, 0x18, 0x38, 0x1C, 0x38, 0x07, 0x1C, 0x03,
  0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xC0, 0x1C, 0x70,
  0x0E, 0x30, 0x03, 0x1C, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0xE7, 0x00, 0x39,
  0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x60, 0x03, 0xB8, 0x01, 0xF8, 0x00,
  0x6E, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0x3C, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x7C,
  0x7C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x07, 0x8E, 0x00,
  0x00, 0x1C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0x80, 0x01,
  0xC0, 0x0E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x7E,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x0E,
  0x0F, 0xF0, 0x00, 0x1C, 0x3F, 0xF0, 0x00, 0x38, 0xF0, 0xF0, 0x00, 0x71,
  0xC0, 0xF0, 0x00, 0xE7, 0x80, 0xF0, 0x03, 0x8E, 0x00, 0xF0, 0x07, 0x1C,
  0x00, 0xF0, 0x1E, 0x70, 0x00, 0xF0, 0x38, 0xE0, 0x01, 0xF1, 0xE1, 0xC0,
  0x01, 0xFF, 0xC3, 0x80, 0x00, 0xFF, 0x0E, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_Light63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 8, 44, 38, 15, -44 },
  { 45, 14, 17, 38, 12, -47 },
  { 75, 36, 44, 38, 1, -44 },
  { 273, 30, 58, 38, 4, -51 },
  { 491, 35, 46, 38, 1, -45 },
  { 693, 33, 46, 38, 2, -45 },
  { 883, 4, 17, 38, 17, -47 },
  { 892, 16, 57, 38, 14, -48 },
  { 1006, 17, 57, 38, 7, -48 },
  { 1128, 32, 31, 38, 3, -35 },
  { 1252, 30, 31, 38, 4, -35 },
  { 1369, 10, 17, 38, 13, -7 },
  { 1391, 18, 3, 38, 10, -21 },
  { 1398, 8, 7, 38, 15, -7 },
  { 1405, 26, 57, 38, 6, -48 },
  { 1591, 30, 46, 38, 4, -45 },
  { 1764, 31, 44, 38, 4, -44 },
  { 1935, 28, 45, 38, 5, -45 },
  { 2093, 28, 46, 38, 4, -45 },
  { 2254, 33, 44, 38, 2, -44 },
  { 2436, 28, 45, 38, 5, -44 },
  { 2594, 28, 45, 38, 5, -44 },
  { 2752, 29, 44, 38, 4, -44 },
  { 2912, 30, 46, 38, 4, -45 },
  { 3085, 28, 45, 38, 5, -45 },
  { 3243, 8, 34, 38, 15, -34 },
  { 3277, 10, 44, 38, 13, -34 },
  { 3332, 27, 35, 38, 5, -37 },
  { 3451, 30, 15, 38, 4, -27 },
  { 3508, 27, 35, 38, 5, -37 },
  { 3627, 27, 45, 38, 5, -45 },
  { 3779, 27, 52, 38, 5, -45 },
  { 3955, 33, 44, 38, 2, -44 },
  { 4137, 28, 44, 38, 6, -44 },
  { 4291, 28, 46, 38, 5, -45 },
  { 4452, 28, 44, 38, 6, -44 },
  { 4606, 27, 44, 38, 6, -44 },
  { 4755, 27, 44, 38, 6, -44 },
  { 4904, 29, 46, 38, 4, -45 },
  { 5071, 27, 44, 38, 5, -44 },
  { 5220, 27, 44, 38, 5, -44 },
  { 5369, 25, 45, 38, 5, -44 },
  { 5510, 30, 44, 38, 6, -44 },
  { 5675, 26, 44, 38, 8, -44 },
  { 5818, 28, 44, 38, 5, -44 },
  { 5972, 27, 44, 38, 5, -44 },
  { 6121, 30, 46, 38, 4, -45 },
  { 6294, 28, 44, 38, 6, -44 },
  { 6448, 30, 55, 38, 4, -45 },
  { 6655, 28, 44, 38, 6, -44 },
  { 6809, 31, 46, 38, 3, -45 },
  { 6988, 34, 44, 38, 2, -44 },
  { 7175, 27, 45, 38, 5, -44 },
  { 7327, 32, 44, 38, 3, -44 },
  { 7503, 32, 44, 38, 3, -44 },
  { 7679, 34, 44, 38, 2, -44 },
  { 7866, 35, 44, 38, 1, -44 },
  { 8059, 32, 44, 38, 3, -44 },
  { 8235, 17, 57, 38, 15, -48 },
  { 8357, 26, 57, 38, 6, -48 },
  { 8543, 17, 57, 38, 6, -48 },
  { 8665, 31, 25, 38, 3, -44 },
  { 8762, 30, 3, 38, 4, 7 },
  { 8774, 9, 11, 38, 12, -48 },
  { 8787, 30, 34, 38, 4, -33 },
  { 8915, 27, 48, 38, 7, -47 },
  { 9077, 26, 34, 38, 6, -33 },
  { 9188, 27, 48, 38, 4, -47 },
  { 9350, 28, 34, 38, 5, -33 },
  { 9469, 29, 47, 38, 5, -47 },
  { 9640, 30, 49, 38, 5, -36 },
  { 9824, 24, 47, 38, 7, -47 },
  { 9965, 27, 48, 38, 7, -48 },
  { 10127, 22, 61, 38, 6, -48 },
  { 10295, 29, 47, 38, 7, -47 },
  { 10466, 28, 47, 38, 5, -47 },
  { 10631, 30, 33, 38, 4, -33 },
  { 10755, 24, 33, 38, 7, -33 },
  { 10854, 28, 34, 38, 5, -33 },
  { 10973, 27, 46, 38, 7, -33 },
  { 11129, 27, 46, 38, 4, -33 },
  { 11285, 30, 33, 38, 5, -33 },
  { 11409, 28, 34, 38, 5, -33 },
  { 11528, 31, 44, 38, 2, -44 },
  { 11699, 25, 34, 38, 6, -33 },
  { 11806, 28, 33, 38, 5, -33 },
  { 11922, 34, 33, 38, 2, -33 },
  { 12063, 28, 33, 38, 5, -33 },
  { 12179, 30, 46, 38, 4, -33 },
  { 12352, 26, 33, 38, 6, -33 },
  { 12460, 24, 57, 38, 7, -48 },
  { 12631, 3, 57, 38, 17, -48 },
  { 12653, 24, 57, 38, 7, -48 },
  { 12824, 31, 13, 38, 3, -25 },
};

const GFXfont IBMPlexMono_Light63pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light63pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light63pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _IBMPLEXMONO_LIGHT63PT7B_H_
