#ifndef _IBMPLEXMONO_LIGHT54PT7B_H_
#define _IBMPLEXMONO_LIGHT54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light54pt7bBitmaps[] PROGMEM = {
  0x00, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80,
  0x3F, 0xF8, 0x0F, 0xFC, 0xFF, 0xE0, 0x3F, 0xF3, 0xFF, 0x81, 0xFF, 0xC0,
  0x0C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x0E, 0x03, 0x80, 0x3F, 0xF8, 0x0F, 0xFC, 0xFF, 0xE0, 0x3F,
  0xF3, 0xFF, 0x81, 0xFF, 0xC0, 0x0C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xF3, 0x9F, 0xC1, 0xE0,
  0xE0, 0xF8, 0xF0, 0x38, 0x1F, 0x38, 0x0E, 0x03, 0x9E, 0x03, 0x80, 0x47,
  0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80,
  0x07, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x83,
  0x80, 0x01, 0xF8, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x39, 0xFC, 0x00, 0x0E, 0x0F,
  0x80, 0x03, 0x81, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x07, 0x00, 0x0E,
  0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0x40,
  0x0E, 0x01, 0xD8, 0x03, 0x80, 0x7F, 0x00, 0xE0, 0x3D, 0xE0, 0x38, 0x1E,
  0x3E, 0x0E, 0x0F, 0x87, 0xE3, 0x8F, 0xC0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x1C, 0x3F, 0xE0, 0x00, 0x63, 0xFF, 0xC0, 0x03, 0x8F,
  0x0F, 0x80, 0x1C, 0x70, 0x0E, 0x00, 0x71, 0xC0, 0x18, 0x03, 0x86, 0x00,
  0x70, 0x0E, 0x38, 0x01, 0xC0, 0x70, 0xE0, 0x07, 0x01, 0x83, 0x80, 0x1C,
  0x0E, 0x0E, 0x00, 0x70, 0x30, 0x38, 0x01, 0xC1, 0xC0, 0x60, 0x07, 0x0E,
  0x01, 0xC0, 0x18, 0x38, 0x07, 0x00, 0xE1, 0xC0, 0x0F, 0x07, 0x87, 0x00,
  0x3F, 0xFC, 0x20, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x07,
  0x0F, 0xFF, 0x00, 0x38, 0x3C, 0x3E, 0x00, 0xE1, 0xC0, 0x38, 0x07, 0x07,
  0x00, 0x60, 0x18, 0x18, 0x01, 0xC0, 0xE0, 0xE0, 0x07, 0x07, 0x03, 0x80,
  0x1C, 0x1C, 0x0E, 0x00, 0x70, 0xE0, 0x38, 0x01, 0xC3, 0x80, 0xE0, 0x07,
  0x1C, 0x01, 0x80, 0x1C, 0x70, 0x07, 0x00, 0x63, 0x80, 0x1C, 0x03, 0x8C,
  0x00, 0x3C, 0x1E, 0x70, 0x00, 0xFF, 0xF3, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0xFF, 0x00,
  0x7F, 0x1E, 0x78, 0x07, 0xF3, 0xC3, 0xC0, 0x70, 0x78, 0x1E, 0x07, 0x07,
  0x00, 0xF0, 0x60, 0xF0, 0x07, 0x06, 0x0E, 0x00, 0x38, 0x60, 0xE0, 0x03,
  0xC6, 0x0E, 0x00, 0x1E, 0xE0, 0xE0, 0x00, 0xFE, 0x0E, 0x00, 0x07, 0xC0,
  0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3F, 0x07, 0x00,
  0x06, 0xF0, 0x7C, 0x00, 0xE7, 0x83, 0xE0, 0x3C, 0x3C, 0x1F, 0xFF, 0x81,
  0xE0, 0xFF, 0xF0, 0x0F, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C,
  0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0F, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x70, 0x06, 0x7E, 0x07, 0x03, 0xFF, 0xFC,
  0x73, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x1E, 0x03,
  0x80, 0x03, 0xC0, 0x1C, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x70, 0x02, 0x00, 0x04, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x3F,
  0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0xE0, 0xE0,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x03,
  0xF0, 0x0F, 0x00, 0x3E, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x00, 0xF0, 0xF0,
  0x00, 0x1C, 0x38, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x39,
  0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0x80, 0x7F, 0x01,
  0xF0, 0x1F, 0xC0, 0x7C, 0x07, 0xF0, 0x1F, 0x01, 0xFC, 0x07, 0x80, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x03, 0x9E, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x07,
  0x80, 0x07, 0x80, 0xF0, 0x03, 0xE0, 0x1F, 0x03, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x03, 0xCE, 0x00, 0x03,
  0xE3, 0x80, 0x01, 0xF0, 0xE0, 0x00, 0xF8, 0x38, 0x00, 0x7C, 0x0E, 0x00,
  0x3E, 0x03, 0x80, 0x0F, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x40, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xE0, 0x3F, 0x03,
  0xC0, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xC0, 0x00, 0x71, 0xE0, 0x00, 0x3C,
  0xE0, 0x00, 0x1E, 0x10, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x0F, 0x80, 0xFC, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x0E, 0x10, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x20, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3F, 0x00, 0xFC, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x0E, 0x1C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00,
  0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0,
  0x1C, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x07, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x7F, 0x80, 0x39, 0xFF, 0xE0, 0x3B,
  0xFF, 0xF0, 0x37, 0x80, 0xF8, 0x3E, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x20, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x1F, 0x01, 0xF8, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x3F, 0x80, 0x79, 0xFF, 0xE0, 0x73, 0xFF, 0xF8, 0x77,
  0x80, 0xFC, 0xFE, 0x00, 0x3C, 0xE8, 0x00, 0x1E, 0xF8, 0x00, 0x0E, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x1E,
  0x00, 0x3C, 0x1F, 0x80, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0x01, 0xF8, 0x1E, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1E, 0x38, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1E, 0x38,
  0x00, 0x07, 0x0F, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x78,
  0x07, 0xC0, 0x7C, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x0F, 0x80, 0x7C, 0x07, 0x80, 0x07, 0xC3, 0xC0, 0x00, 0x71, 0xE0,
  0x00, 0x0E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xE3, 0xE0,
  0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x03, 0xF0, 0x1F, 0x03, 0xE0, 0x03, 0xC1, 0xE0, 0x00, 0xF1, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0x78, 0x00, 0x03, 0xB8, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1D, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9F,
  0x00, 0x07, 0xC7, 0xC0, 0x06, 0xE1, 0xF8, 0x0E, 0x70, 0x7F, 0xFE, 0x70,
  0x1F, 0xFE, 0x38, 0x01, 0xFC, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0x78,
  0x3C, 0x7E, 0x7E, 0x7E, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0xE0, 0xE0,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xC0,
  0x7C, 0x3C, 0x00, 0x79, 0xE0, 0x00, 0xEF, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1C, 0x80, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0x80, 0xF8, 0x1E,
  0x00, 0x7C, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x0E, 0x30,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x70, 0x0F, 0xC7, 0x60,
  0x1F, 0xE7, 0xE0, 0x3F, 0xF7, 0xE0, 0x7C, 0x37, 0xE0, 0x70, 0x0F, 0xE0,
  0xF0, 0x0F, 0xE0, 0xE0, 0x07, 0xE0, 0xE0, 0x07, 0xE0, 0xE0, 0x07, 0xE0,
  0xE0, 0x07, 0xE0, 0xE0, 0x07, 0xE0, 0xE0, 0x07, 0xE0, 0xE0, 0x07, 0xE0,
  0xE0, 0x07, 0xE0, 0xE0, 0x07, 0xE0, 0xE0, 0x07, 0xE0, 0xE0, 0x07, 0xE0,
  0x70, 0x0F, 0xE0, 0x78, 0x1F, 0xE0, 0x7F, 0x77, 0x60, 0x3F, 0xF7, 0x70,
  0x1F, 0xE7, 0x70, 0x03, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0xE0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x1C,
  0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xE0, 0x00,
  0x78, 0x1E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xE0, 0x01, 0xF0,
  0xE0, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78,
  0xE0, 0x01, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0xE0, 0x00, 0xF8, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x01, 0xF8, 0x0F, 0x80, 0xF0, 0x03, 0xE0, 0xF0, 0x00,
  0x70, 0xF0, 0x00, 0x3C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x3C, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x0F, 0x81, 0xF8, 0x0F, 0x80, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xF0, 0x03, 0xF0, 0xF0, 0x00, 0xF8, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0xF8, 0xF0, 0x03, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEE,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x01, 0xE0, 0xF0, 0x00,
  0x78, 0x70, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x38, 0x00, 0x03, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFE, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03,
  0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x3B, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x1C, 0x00,
  0x0F, 0x8F, 0x00, 0x07, 0xC3, 0xC0, 0x06, 0xE1, 0xF8, 0x0E, 0x70, 0x7F,
  0xFF, 0x38, 0x0F, 0xFE, 0x1C, 0x01, 0xFC, 0x00, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE3, 0x00,
  0x03, 0xBC, 0x00, 0x0E, 0x70, 0x00, 0x79, 0xE0, 0x01, 0xC3, 0xC0, 0x0F,
  0x07, 0xC0, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0xE0, 0x00, 0x07, 0xB8, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0xF0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x03, 0x80,
  0x07, 0x80, 0xE0, 0x03, 0xC0, 0x38, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x03,
  0x80, 0x38, 0x00, 0xE0, 0x1E, 0x00, 0x38, 0x0F, 0x00, 0x0E, 0x07, 0x80,
  0x03, 0x83, 0xC0, 0x00, 0xE1, 0xF0, 0x00, 0x38, 0xFE, 0x00, 0x0E, 0x3F,
  0x80, 0x03, 0x9E, 0xF0, 0x00, 0xEF, 0x1C, 0x00, 0x3F, 0x87, 0x80, 0x0F,
  0xC0, 0xF0, 0x03, 0xE0, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x00, 0xF0,
  0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x00, 0xF0, 0x38, 0x00,
  0x3C, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x38,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x07,
  0xB8, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xEE, 0x00, 0x3F, 0xEE, 0x00, 0x37, 0xEE, 0x00,
  0x77, 0xE7, 0x00, 0x77, 0xE7, 0x00, 0xE7, 0xE3, 0x80, 0xE7, 0xE3, 0x81,
  0xC7, 0xE1, 0xC1, 0xC7, 0xE1, 0xC1, 0x87, 0xE1, 0xC3, 0x87, 0xE0, 0xE3,
  0x87, 0xE0, 0xE7, 0x07, 0xE0, 0x77, 0x07, 0xE0, 0x76, 0x07, 0xE0, 0x3E,
  0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x18,
  0x07, 0xE0, 0x08, 0x07, 0xE0, 0x10, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x01,
  0xFB, 0x80, 0x03, 0xF7, 0x80, 0x07, 0xE7, 0x00, 0x0F, 0xCF, 0x00, 0x1F,
  0x8E, 0x00, 0x3F, 0x1C, 0x00, 0x7E, 0x1C, 0x00, 0xFC, 0x38, 0x01, 0xF8,
  0x38, 0x03, 0xF0, 0x70, 0x07, 0xE0, 0xF0, 0x0F, 0xC0, 0xE0, 0x1F, 0x81,
  0xE0, 0x3F, 0x01, 0xC0, 0x7E, 0x03, 0xC0, 0xFC, 0x03, 0x81, 0xF8, 0x07,
  0x03, 0xF0, 0x07, 0x07, 0xE0, 0x0E, 0x0F, 0xC0, 0x1E, 0x1F, 0x80, 0x1C,
  0x3F, 0x00, 0x3C, 0x7E, 0x00, 0x38, 0xFC, 0x00, 0x79, 0xF8, 0x00, 0x73,
  0xF0, 0x00, 0xE7, 0xE0, 0x00, 0xEF, 0xC0, 0x01, 0xDF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x03, 0xF0, 0x0F, 0x00,
  0x3E, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x0E,
  0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x78, 0xF0, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x80,
  0xF0, 0x03, 0xE0, 0x1F, 0x03, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xE0, 0x00, 0x7C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3C, 0xE0, 0x00,
  0x7C, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x03, 0xF0, 0x0F,
  0x00, 0x3E, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1C,
  0x38, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x39, 0xC0, 0x00,
  0x0E, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x78, 0xF0, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x07,
  0x80, 0xF0, 0x03, 0xE0, 0x1F, 0x03, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xE0, 0x00, 0x7C, 0xE0, 0x00, 0x3C, 0xE0, 0x00,
  0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00,
  0x3C, 0xE0, 0x00, 0x7C, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0x80, 0xE0, 0x1C, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x07,
  0x00, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0xE0, 0x01,
  0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0F, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7E,
  0x01, 0xFC, 0x3E, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x3D,
  0xE0, 0x00, 0x04, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x74, 0x00, 0x00, 0x3D, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0x9E, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0xF0, 0x7E, 0x01, 0xF8, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x78, 0x00, 0x0E, 0x70, 0x00,
  0x3C, 0xF0, 0x00, 0x70, 0xF0, 0x01, 0xE1, 0xF8, 0x0F, 0x81, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x1C,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x78, 0x0F, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x70, 0x07, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0x80,
  0x01, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x67, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00,
  0xF0, 0x0E, 0x70, 0x0F, 0x00, 0xE3, 0x00, 0xF8, 0x0E, 0x30, 0x0F, 0x80,
  0xE3, 0x81, 0xF8, 0x0E, 0x38, 0x1D, 0x80, 0xE3, 0x81, 0x9C, 0x0E, 0x38,
  0x19, 0xC0, 0xC3, 0x83, 0x9C, 0x0C, 0x38, 0x38, 0xC0, 0xC3, 0x83, 0x0E,
  0x1C, 0x38, 0x30, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x61, 0xC1,
  0x86, 0x07, 0x1C, 0x18, 0x60, 0x71, 0xC1, 0xCE, 0x07, 0x1C, 0x1C, 0xE0,
  0x31, 0xC1, 0xCE, 0x03, 0x9C, 0x1C, 0xC0, 0x39, 0x81, 0xDC, 0x03, 0x98,
  0x1D, 0xC0, 0x19, 0x81, 0xDC, 0x01, 0xF8, 0x1D, 0x80, 0x1F, 0x81, 0xF8,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x78, 0x38, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x38, 0x07, 0x80, 0x03, 0xC0, 0x1C, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x78, 0x0E,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x3C, 0x70, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0F, 0x1C, 0x00,
  0x00, 0x70, 0xF0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x03,
  0x80, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x03, 0x80,
  0x00, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x03,
  0x80, 0x01, 0xC0, 0xF0, 0x00, 0xE0, 0x1C, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x00, 0xE0,
  0x70, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x1E, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x20, 0x70, 0xF8, 0x38, 0x3C, 0x1C,
  0x0E, 0x06, 0x07, 0x02, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x0F, 0x03, 0x80, 0x03, 0x80, 0x80,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7E, 0x00, 0x38, 0x3C, 0x00, 0x1C,
  0x3C, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00,
  0xDC, 0x1F, 0x01, 0xEF, 0xE7, 0xFF, 0xE3, 0xF1, 0xFF, 0xE0, 0xF8, 0x1F,
  0xC0, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x07, 0xF0,
  0x0E, 0x3F, 0xF8, 0x1C, 0xFF, 0xFC, 0x3B, 0x80, 0xFC, 0x7C, 0x00, 0x78,
  0xF0, 0x00, 0x79, 0xE0, 0x00, 0x73, 0x80, 0x00, 0xF7, 0x00, 0x00, 0xEE,
  0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00,
  0x1D, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0xE7, 0x80, 0x03, 0xCF, 0x80, 0x0F,
  0x1D, 0xE0, 0x7E, 0x39, 0xFF, 0xF8, 0x71, 0xFF, 0xC0, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7C, 0x0F, 0x81,
  0xE0, 0x07, 0x87, 0x80, 0x07, 0x8E, 0x00, 0x07, 0x3C, 0x00, 0x08, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x02, 0x1C, 0x00, 0x0F, 0x3C, 0x00, 0x1C,
  0x3C, 0x00, 0xF0, 0x3E, 0x07, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x0F,
  0xE0, 0x70, 0x7F, 0xF0, 0xE1, 0xFF, 0xF1, 0xC7, 0xE0, 0x73, 0x9F, 0x00,
  0x37, 0x38, 0x00, 0x3E, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x79, 0xC0, 0x01, 0xF3, 0xE0,
  0x06, 0xE3, 0xF0, 0x39, 0xC3, 0xFF, 0xE3, 0x83, 0xFF, 0x87, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0x81,
  0xF8, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x78, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x04, 0x38, 0x00,
  0x0F, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x0F, 0x80, 0xFC, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x07, 0xF3, 0xFC, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x70,
  0x00, 0xE0, 0x3C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0,
  0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0xC0, 0x01,
  0xC0, 0x70, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x3E, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC3, 0xC0, 0x00, 0xF9, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xDE, 0x00, 0x01, 0xE7, 0xE0, 0x03, 0xF0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC1, 0xFC,
  0x0E, 0x3F, 0xF8, 0x73, 0xFF, 0xE3, 0xB8, 0x0F, 0x9D, 0x00, 0x3E, 0xF0,
  0x00, 0xF7, 0x80, 0x03, 0xB8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x01, 0xE7, 0x00, 0x01, 0xE3, 0x80, 0x01, 0xE1, 0xC0, 0x01,
  0xE0, 0xE0, 0x03, 0xC0, 0x70, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x1C, 0x03,
  0xC0, 0x0E, 0x03, 0xC0, 0x07, 0x03, 0xC0, 0x03, 0x83, 0xC0, 0x01, 0xC3,
  0xE0, 0x00, 0xE3, 0xF8, 0x00, 0x73, 0x9C, 0x00, 0x3F, 0x8F, 0x00, 0x1F,
  0x83, 0xC0, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0x80, 0x1E, 0x01,
  0xC0, 0x07, 0x80, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0x78, 0x38, 0x00, 0x1C,
  0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x3D, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xE0, 0x3E, 0x39, 0xFE, 0x3F, 0xCE, 0xFF, 0x8F, 0xFB, 0xB0, 0xF6, 0x1E,
  0xF0, 0x1F, 0x03, 0xFC, 0x07, 0x80, 0x7E, 0x00, 0xE0, 0x1F, 0x80, 0x38,
  0x07, 0xE0, 0x0E, 0x01, 0xF8, 0x03, 0x80, 0x7E, 0x00, 0xE0, 0x1F, 0x80,
  0x38, 0x07, 0xE0, 0x0E, 0x01, 0xF8, 0x03, 0x80, 0x7E, 0x00, 0xE0, 0x1F,
  0x80, 0x38, 0x07, 0xE0, 0x0E, 0x01, 0xF8, 0x03, 0x80, 0x7E, 0x00, 0xE0,
  0x1F, 0x80, 0x38, 0x07, 0xE0, 0x0E, 0x01, 0xF8, 0x03, 0x80, 0x7E, 0x00,
  0xE0, 0x1F, 0x80, 0x38, 0x07, 0xE0, 0x0E, 0x01, 0xF8, 0x03, 0x80, 0x7E,
  0x00, 0xE0, 0x1F, 0x80, 0x38, 0x07, 0xE0, 0x0E, 0x01, 0xC0, 0x00, 0xFE,
  0x07, 0x1F, 0xFC, 0x39, 0xFF, 0xF1, 0xDC, 0x07, 0xCE, 0x80, 0x1F, 0x78,
  0x00, 0x7B, 0xC0, 0x01, 0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x0F, 0x81, 0xF8, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x38, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x7C, 0x0F, 0x81, 0xF8,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x01,
  0xC7, 0xFF, 0x03, 0x9F, 0xFF, 0x87, 0x70, 0x1F, 0x8F, 0x80, 0x0F, 0x1E,
  0x00, 0x0F, 0x3C, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x1D, 0xC0,
  0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03,
  0xB8, 0x00, 0x0F, 0x78, 0x00, 0x1C, 0xF0, 0x00, 0x79, 0xF0, 0x01, 0xE3,
  0xBC, 0x0F, 0xC7, 0x3F, 0xFF, 0x0E, 0x3F, 0xF8, 0x1C, 0x1F, 0xC0, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFE, 0x1C, 0x3F, 0xFE,
  0x38, 0xFC, 0x0E, 0x73, 0xE0, 0x06, 0xE7, 0x00, 0x07, 0xDE, 0x00, 0x07,
  0xB8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xDC, 0x00, 0x07, 0xBC, 0x00,
  0x0F, 0x38, 0x00, 0x3E, 0x7C, 0x00, 0xDC, 0x7E, 0x07, 0x38, 0x7F, 0xFC,
  0x70, 0x7F, 0xF0, 0xE0, 0x3F, 0x81, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xFC, 0x01, 0xCE, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x1D, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x1F, 0x00, 0xFC, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x0E,
  0x38, 0x00, 0x04, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x40, 0x00, 0x07, 0x60, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x1E,
  0x3F, 0x80, 0x7C, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x80,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0x78, 0x01, 0xFB, 0xF0, 0x3B,
  0xCF, 0xFF, 0xDE, 0x3F, 0xF8, 0xF0, 0x3F, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x70, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x0E,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x81, 0xC0,
  0x03, 0x81, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xC3, 0x80, 0x00, 0xC3, 0x80,
  0x00, 0xE3, 0x80, 0x00, 0xE7, 0x00, 0x00, 0x67, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x0F, 0x00,
  0x3F, 0x00, 0x78, 0x01, 0xB8, 0x03, 0xE0, 0x0D, 0xC0, 0x1F, 0x00, 0xE6,
  0x01, 0xD8, 0x07, 0x30, 0x0E, 0xC0, 0x39, 0xC0, 0x66, 0x01, 0xCE, 0x03,
  0x38, 0x0C, 0x70, 0x18, 0xC0, 0x63, 0x81, 0xC6, 0x07, 0x0C, 0x0C, 0x30,
  0x38, 0x60, 0x61, 0xC1, 0xC3, 0x83, 0x0E, 0x0E, 0x1C, 0x38, 0x30, 0x60,
  0xE1, 0xC1, 0x83, 0x07, 0x0C, 0x0E, 0x38, 0x18, 0x60, 0x71, 0xC0, 0xC3,
  0x01, 0x8E, 0x06, 0x38, 0x0C, 0x70, 0x39, 0x80, 0x63, 0x01, 0xCC, 0x03,
  0x98, 0x0E, 0x60, 0x1C, 0xC0, 0x37, 0x00, 0x6E, 0x01, 0xB8, 0x03, 0x70,
  0x0D, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x0F, 0x00, 0x07,
  0x03, 0x80, 0x07, 0x81, 0xE0, 0x07, 0x80, 0x78, 0x03, 0x80, 0x1E, 0x03,
  0x80, 0x07, 0x03, 0xC0, 0x03, 0xC1, 0xC0, 0x00, 0xF1, 0xC0, 0x00, 0x3D,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x73, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x78, 0x1E, 0x00, 0x38, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x0F,
  0x1E, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xC7, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x70, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0F,
  0x00, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x07, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x81, 0xC0,
  0x00, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x0E, 0x38,
  0x00, 0x07, 0x38, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x03,
  0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xC3,
  0xF8, 0x00, 0x31, 0xFF, 0x00, 0x1C, 0xF1, 0xE0, 0x07, 0x38, 0x3C, 0x01,
  0xDC, 0x07, 0x80, 0xE7, 0x00, 0xF0, 0x39, 0x80, 0x1E, 0x1C, 0xE0, 0x03,
  0xFF, 0x38, 0x00, 0x7F, 0x8C, 0x00, 0x07, 0x80,
};

const GFXglyph IBMPlexMono_Light54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 6, 38, 32, 13, -38 },
  { 30, 12, 14, 32, 10, -40 },
  { 51, 30, 38, 32, 1, -38 },
  { 194, 26, 51, 32, 3, -44 },
  { 360, 30, 39, 32, 1, -38 },
  { 507, 28, 39, 32, 2, -38 },
  { 644, 3, 14, 32, 15, -40 },
  { 650, 14, 48, 32, 12, -41 },
  { 734, 15, 48, 32, 6, -41 },
  { 824, 28, 27, 32, 2, -30 },
  { 919, 26, 27, 32, 3, -30 },
  { 1007, 8, 14, 32, 12, -6 },
  { 1021, 15, 3, 32, 9, -18 },
  { 1027, 6, 6, 32, 13, -6 },
  { 1032, 22, 48, 32, 5, -41 },
  { 1164, 26, 39, 32, 3, -38 },
  { 1291, 26, 38, 32, 4, -38 },
  { 1415, 25, 38, 32, 4, -38 },
  { 1534, 24, 39, 32, 3, -38 },
  { 1651, 28, 38, 32, 2, -38 },
  { 1784, 24, 39, 32, 4, -38 },
  { 1901, 24, 39, 32, 4, -38 },
  { 2018, 24, 38, 32, 4, -38 },
  { 2132, 26, 39, 32, 3, -38 },
  { 2259, 25, 38, 32, 4, -38 },
  { 2378, 6, 29, 32, 13, -29 },
  { 2400, 8, 37, 32, 12, -29 },
  { 2437, 23, 30, 32, 5, -31 },
  { 2524, 26, 13, 32, 3, -23 },
  { 2567, 23, 30, 32, 5, -31 },
  { 2654, 22, 38, 32, 5, -38 },
  { 2759, 24, 44, 32, 4, -38 },
  { 2891, 28, 38, 32, 2, -38 },
  { 3024, 24, 38, 32, 5, -38 },
  { 3138, 25, 39, 32, 4, -38 },
  { 3260, 24, 38, 32, 5, -38 },
  { 3374, 23, 38, 32, 5, -38 },
  { 3484, 23, 38, 32, 5, -38 },
  { 3594, 25, 39, 32, 3, -38 },
  { 3716, 23, 38, 32, 5, -38 },
  { 3826, 23, 38, 32, 5, -38 },
  { 3936, 22, 39, 32, 4, -38 },
  { 4044, 26, 38, 32, 5, -38 },
  { 4168, 22, 38, 32, 7, -38 },
  { 4273, 24, 38, 32, 4, -38 },
  { 4387, 23, 38, 32, 5, -38 },
  { 4497, 26, 39, 32, 3, -38 },
  { 4624, 24, 38, 32, 5, -38 },
  { 4738, 26, 47, 32, 3, -38 },
  { 4891, 24, 38, 32, 5, -38 },
  { 5005, 26, 39, 32, 3, -38 },
  { 5132, 29, 38, 32, 2, -38 },
  { 5270, 23, 39, 32, 5, -38 },
  { 5383, 28, 38, 32, 2, -38 },
  { 5516, 28, 38, 32, 2, -38 },
  { 5649, 29, 38, 32, 2, -38 },
  { 5787, 30, 38, 32, 1, -38 },
  { 5930, 27, 38, 32, 3, -38 },
  { 6059, 14, 48, 32, 13, -41 },
  { 6143, 22, 48, 32, 5, -41 },
  { 6275, 14, 48, 32, 5, -41 },
  { 6359, 26, 21, 32, 3, -38 },
  { 6428, 26, 3, 32, 3, 6 },
  { 6438, 8, 10, 32, 10, -42 },
  { 6448, 25, 30, 32, 4, -29 },
  { 6542, 23, 41, 32, 6, -40 },
  { 6660, 23, 30, 32, 5, -29 },
  { 6747, 23, 41, 32, 4, -40 },
  { 6865, 24, 30, 32, 4, -29 },
  { 6955, 25, 40, 32, 4, -40 },
  { 7080, 26, 42, 32, 4, -31 },
  { 7217, 21, 40, 32, 6, -40 },
  { 7322, 23, 40, 32, 6, -40 },
  { 7437, 19, 51, 32, 5, -40 },
  { 7559, 25, 40, 32, 6, -40 },
  { 7684, 23, 40, 32, 5, -40 },
  { 7799, 26, 29, 32, 3, -29 },
  { 7894, 21, 29, 32, 6, -29 },
  { 7971, 24, 30, 32, 4, -29 },
  { 8061, 23, 40, 32, 6, -29 },
  { 8176, 23, 40, 32, 4, -29 },
  { 8291, 26, 28, 32, 4, -28 },
  { 8382, 24, 30, 32, 4, -29 },
  { 8472, 26, 38, 32, 2, -38 },
  { 8596, 21, 29, 32, 6, -28 },
  { 8673, 24, 28, 32, 4, -28 },
  { 8757, 29, 28, 32, 2, -28 },
  { 8859, 25, 28, 32, 4, -28 },
  { 8947, 25, 39, 32, 4, -28 },
  { 9069, 22, 28, 32, 5, -28 },
  { 9146, 21, 48, 32, 6, -41 },
  { 9272, 3, 48, 32, 15, -41 },
  { 9290, 21, 48, 32, 6, -41 },
  { 9416, 26, 11, 32, 3, -22 },
};

const GFXfont IBMPlexMono_Light54pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light54pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light54pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _IBMPLEXMONO_LIGHT54PT7B_H_
