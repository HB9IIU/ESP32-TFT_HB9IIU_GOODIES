#ifndef _IBMPLEXMONO_LIGHT16PT7B_H_
#define _IBMPLEXMONO_LIGHT16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light16pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xA8, 0x3C, 0x99, 0x99, 0x09, 0x09, 0x04, 0x8E, 0x71, 0x20,
  0x90, 0x49, 0xCF, 0x24, 0x12, 0x09, 0x00, 0x10, 0x10, 0x3C, 0x52, 0x91,
  0x90, 0x50, 0x3C, 0x12, 0x11, 0x91, 0xD2, 0x3C, 0x10, 0x10, 0x70, 0xC4,
  0xA2, 0x51, 0x47, 0x20, 0x00, 0x5C, 0x49, 0x28, 0xA2, 0x61, 0xC0, 0x38,
  0x44, 0x80, 0x40, 0x40, 0x63, 0x92, 0x8C, 0x84, 0x8A, 0x73, 0xF0, 0x19,
  0x10, 0x84, 0x42, 0x10, 0x82, 0x10, 0x82, 0x0C, 0x84, 0x22, 0x11, 0x11,
  0x11, 0x22, 0x48, 0x10, 0x10, 0x10, 0xF7, 0x18, 0x28, 0x24, 0x42, 0x10,
  0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x69, 0x40, 0xF0, 0xF0, 0x04, 0x20,
  0x82, 0x10, 0x42, 0x08, 0x21, 0x04, 0x20, 0x82, 0x00, 0x3C, 0x46, 0x82,
  0x82, 0x81, 0x99, 0x81, 0x82, 0x82, 0x46, 0x3C, 0x18, 0x28, 0x48, 0x88,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x3C, 0x46, 0x82, 0x02, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0xFF, 0x3C, 0x8E, 0x08, 0x10, 0x47, 0x01,
  0x81, 0x83, 0x8D, 0xF0, 0x04, 0x0C, 0x14, 0x24, 0x24, 0x44, 0x84, 0x84,
  0xFF, 0x04, 0x04, 0x7E, 0x81, 0x02, 0x07, 0xC8, 0x40, 0x81, 0x82, 0x8C,
  0xF0, 0x0C, 0x60, 0x82, 0x07, 0xD8, 0x60, 0xC1, 0x82, 0x84, 0xF0, 0xFF,
  0x06, 0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x20, 0x80, 0x3C, 0x42, 0x82,
  0x82, 0x42, 0x3C, 0x46, 0x81, 0x81, 0xC2, 0x7C, 0x3C, 0x86, 0x0C, 0x18,
  0x28, 0x4F, 0x81, 0x04, 0x10, 0xC0, 0xF0, 0x03, 0xC0, 0x6C, 0x00, 0x03,
  0x4A, 0x00, 0x02, 0x08, 0x63, 0x08, 0x0C, 0x06, 0x02, 0x02, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0xC0, 0x60, 0x20, 0x20, 0x86, 0x30, 0x80, 0x3C, 0x86,
  0x08, 0x10, 0x43, 0x04, 0x00, 0x00, 0x20, 0x40, 0x3C, 0x8D, 0x0C, 0xF9,
  0x34, 0x68, 0xD1, 0x93, 0x3D, 0x02, 0x03, 0xC0, 0x18, 0x18, 0x28, 0x24,
  0x24, 0x44, 0x42, 0x7E, 0xC2, 0x82, 0x81, 0xFC, 0x82, 0x82, 0x82, 0x82,
  0xFC, 0x82, 0x82, 0x83, 0x82, 0xFC, 0x3C, 0x85, 0x0C, 0x08, 0x10, 0x20,
  0x40, 0x42, 0x84, 0xF0, 0xF9, 0x1A, 0x14, 0x28, 0x30, 0x60, 0xC2, 0x85,
  0x1B, 0xE0, 0xFE, 0x08, 0x20, 0x83, 0xF8, 0x20, 0x82, 0x0F, 0xC0, 0xFE,
  0x08, 0x20, 0x83, 0xF8, 0x20, 0x82, 0x08, 0x00, 0x3C, 0x8E, 0x0C, 0x08,
  0x10, 0x23, 0xC1, 0x82, 0x84, 0xF8, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0,
  0xC1, 0x83, 0x06, 0x08, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x23, 0xF8, 0x7E, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x82, 0x88, 0xE0,
  0x83, 0x82, 0x84, 0x88, 0x90, 0xB0, 0xC8, 0x84, 0x84, 0x82, 0x81, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0xF8, 0xC3, 0x8E, 0x9D,
  0x59, 0xB2, 0x64, 0xC1, 0x83, 0x06, 0x08, 0xC3, 0x86, 0x8D, 0x19, 0x32,
  0x62, 0xC5, 0x87, 0x0E, 0x08, 0x3C, 0x46, 0x82, 0x82, 0x81, 0x81, 0x81,
  0x82, 0x82, 0x46, 0x3C, 0xF9, 0x0A, 0x0C, 0x18, 0x5F, 0x20, 0x40, 0x81,
  0x02, 0x00, 0x3C, 0x46, 0x82, 0x82, 0x81, 0x81, 0x81, 0x82, 0x82, 0x46,
  0x3C, 0x10, 0x10, 0x0E, 0xF9, 0x0A, 0x0C, 0x18, 0x5F, 0x24, 0x4C, 0x89,
  0x0A, 0x18, 0x3C, 0xC2, 0x80, 0x80, 0x40, 0x3C, 0x02, 0x01, 0x81, 0xC2,
  0x3C, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x00, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x42, 0x84, 0xF0,
  0x81, 0x82, 0x82, 0x42, 0x44, 0x44, 0x24, 0x24, 0x28, 0x18, 0x18, 0x81,
  0x81, 0x81, 0x91, 0x99, 0xAA, 0xAA, 0xAA, 0xA6, 0xC6, 0x46, 0x81, 0x42,
  0x44, 0x24, 0x18, 0x10, 0x18, 0x24, 0x44, 0x42, 0x81, 0xC0, 0xA0, 0x88,
  0x44, 0x41, 0x20, 0xA0, 0x30, 0x10, 0x08, 0x04, 0x02, 0x00, 0xFF, 0x02,
  0x04, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x80, 0xFF, 0xF8, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x8F, 0x82, 0x08, 0x10, 0x40, 0x82, 0x08, 0x10, 0x40,
  0x82, 0x08, 0x10, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x18, 0x28,
  0x24, 0x44, 0x42, 0x83, 0xFF, 0x94, 0x78, 0x84, 0x04, 0x7C, 0x84, 0x84,
  0x8C, 0x7B, 0x81, 0x02, 0x04, 0x0B, 0x98, 0xA1, 0x41, 0x83, 0x0A, 0x17,
  0xC0, 0x3C, 0x85, 0x04, 0x08, 0x08, 0x50, 0x9E, 0x02, 0x04, 0x08, 0x13,
  0xA8, 0xE0, 0xC1, 0x83, 0x05, 0x19, 0xD0, 0x3C, 0x86, 0x0F, 0xF8, 0x10,
  0x10, 0x9E, 0x0F, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0xFE, 0x03, 0x3C, 0x46, 0x42, 0x42, 0x44, 0x7C, 0x40, 0x3E, 0xC1,
  0x81, 0x7E, 0x82, 0x08, 0x20, 0xBB, 0x38, 0x61, 0x86, 0x18, 0x61, 0x10,
  0x00, 0x07, 0x81, 0x02, 0x04, 0x08, 0x10, 0x23, 0xF8, 0x04, 0x00, 0x3F,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x05, 0xF0, 0x81, 0x02, 0x04, 0x08,
  0x71, 0x24, 0x50, 0xD1, 0x12, 0x14, 0x10, 0xF0, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x47, 0xF0, 0xB6, 0xD9, 0x91, 0x91, 0x91, 0x91,
  0x91, 0x91, 0xBB, 0x38, 0x61, 0x86, 0x18, 0x61, 0x3C, 0x86, 0x0C, 0x18,
  0x30, 0x50, 0x9E, 0xB9, 0x8A, 0x14, 0x18, 0x30, 0xA1, 0x7C, 0x81, 0x02,
  0x00, 0x3A, 0x8E, 0x0C, 0x18, 0x30, 0x51, 0x9D, 0x02, 0x04, 0x08, 0xF7,
  0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFE, 0x3C, 0x85, 0x03, 0xC0, 0xE0,
  0x70, 0x9E, 0x20, 0x40, 0x87, 0xF2, 0x04, 0x08, 0x10, 0x20, 0x40, 0x78,
  0x86, 0x18, 0x61, 0x86, 0x18, 0xDD, 0x82, 0x85, 0x12, 0x22, 0x45, 0x06,
  0x0C, 0x91, 0x99, 0xA9, 0xAA, 0xAA, 0xA6, 0xC6, 0x46, 0xC2, 0x88, 0xA0,
  0xC1, 0x84, 0x91, 0x61, 0x83, 0x42, 0x44, 0x44, 0x24, 0x28, 0x18, 0x10,
  0x10, 0x20, 0xE0, 0x7E, 0x04, 0x10, 0x41, 0x04, 0x10, 0x7F, 0x3C, 0x82,
  0x08, 0x10, 0x4E, 0x0C, 0x10, 0x42, 0x08, 0x20, 0xF0, 0xFF, 0xFC, 0xF0,
  0x41, 0x08, 0x40, 0x81, 0xC8, 0x40, 0x82, 0x04, 0x13, 0xC0, 0x61, 0x9A,
  0x8E,
};

const GFXglyph IBMPlexMono_Light16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 11, 10, 4, -11 },
  { 4, 4, 4, 10, 3, -12 },
  { 6, 9, 11, 10, 0, -11 },
  { 19, 8, 15, 10, 1, -13 },
  { 34, 9, 11, 10, 0, -11 },
  { 47, 8, 11, 10, 1, -11 },
  { 58, 1, 4, 10, 4, -12 },
  { 59, 5, 14, 10, 3, -12 },
  { 68, 4, 14, 10, 2, -12 },
  { 75, 8, 8, 10, 1, -9 },
  { 83, 8, 7, 10, 1, -8 },
  { 90, 3, 4, 10, 3, -2 },
  { 92, 4, 1, 10, 3, -5 },
  { 93, 2, 2, 10, 4, -2 },
  { 94, 6, 14, 10, 2, -12 },
  { 105, 8, 11, 10, 1, -11 },
  { 116, 8, 11, 10, 1, -11 },
  { 127, 8, 11, 10, 1, -11 },
  { 138, 7, 11, 10, 1, -11 },
  { 148, 8, 11, 10, 1, -11 },
  { 159, 7, 11, 10, 1, -11 },
  { 169, 7, 11, 10, 1, -11 },
  { 179, 7, 11, 10, 1, -11 },
  { 189, 8, 11, 10, 1, -11 },
  { 200, 7, 11, 10, 1, -11 },
  { 210, 2, 9, 10, 4, -9 },
  { 213, 3, 11, 10, 3, -9 },
  { 218, 7, 9, 10, 1, -9 },
  { 226, 8, 4, 10, 1, -7 },
  { 230, 7, 9, 10, 1, -9 },
  { 238, 7, 11, 10, 1, -11 },
  { 248, 7, 13, 10, 1, -11 },
  { 260, 8, 11, 10, 1, -11 },
  { 271, 8, 11, 10, 1, -11 },
  { 282, 7, 11, 10, 1, -11 },
  { 292, 7, 11, 10, 2, -11 },
  { 302, 6, 11, 10, 2, -11 },
  { 311, 6, 11, 10, 2, -11 },
  { 320, 7, 11, 10, 1, -11 },
  { 330, 7, 11, 10, 1, -11 },
  { 340, 7, 11, 10, 1, -11 },
  { 350, 7, 11, 10, 1, -11 },
  { 360, 8, 11, 10, 1, -11 },
  { 371, 7, 11, 10, 2, -11 },
  { 381, 7, 11, 10, 1, -11 },
  { 391, 7, 11, 10, 1, -11 },
  { 401, 8, 11, 10, 1, -11 },
  { 412, 7, 11, 10, 2, -11 },
  { 422, 8, 14, 10, 1, -11 },
  { 436, 7, 11, 10, 2, -11 },
  { 446, 8, 11, 10, 1, -11 },
  { 457, 9, 11, 10, 0, -11 },
  { 470, 7, 11, 10, 1, -11 },
  { 480, 8, 11, 10, 1, -11 },
  { 491, 8, 11, 10, 1, -11 },
  { 502, 8, 11, 10, 1, -11 },
  { 513, 9, 11, 10, 0, -11 },
  { 526, 8, 11, 10, 1, -11 },
  { 537, 4, 14, 10, 4, -12 },
  { 544, 6, 14, 10, 2, -12 },
  { 555, 4, 14, 10, 2, -12 },
  { 562, 8, 6, 10, 1, -11 },
  { 568, 8, 1, 10, 1, 2 },
  { 569, 2, 3, 10, 3, -13 },
  { 570, 8, 8, 10, 1, -8 },
  { 578, 7, 12, 10, 2, -12 },
  { 589, 7, 8, 10, 1, -8 },
  { 596, 7, 12, 10, 1, -12 },
  { 607, 7, 8, 10, 1, -8 },
  { 614, 8, 12, 10, 1, -12 },
  { 626, 8, 12, 10, 1, -9 },
  { 638, 6, 12, 10, 2, -12 },
  { 647, 7, 11, 10, 2, -11 },
  { 657, 6, 14, 10, 1, -11 },
  { 668, 7, 12, 10, 2, -12 },
  { 679, 7, 12, 10, 1, -12 },
  { 690, 8, 8, 10, 1, -8 },
  { 698, 6, 8, 10, 2, -8 },
  { 704, 7, 8, 10, 1, -8 },
  { 711, 7, 11, 10, 2, -8 },
  { 721, 7, 11, 10, 1, -8 },
  { 731, 8, 8, 10, 1, -8 },
  { 739, 7, 8, 10, 1, -8 },
  { 746, 7, 11, 10, 1, -11 },
  { 756, 6, 8, 10, 2, -8 },
  { 762, 7, 8, 10, 1, -8 },
  { 769, 8, 8, 10, 1, -8 },
  { 777, 7, 8, 10, 1, -8 },
  { 784, 8, 11, 10, 1, -8 },
  { 795, 7, 8, 10, 1, -8 },
  { 802, 6, 14, 10, 2, -12 },
  { 813, 1, 14, 10, 4, -12 },
  { 815, 6, 14, 10, 2, -12 },
  { 826, 8, 3, 10, 1, -7 },
};

const GFXfont IBMPlexMono_Light16pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light16pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _IBMPLEXMONO_LIGHT16PT7B_H_
