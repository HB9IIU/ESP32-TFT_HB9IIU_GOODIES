#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/IBMPlexMono_Light
// Headers: 67

#include "IBMPlexMono_Light6pt7b.h"
#include "IBMPlexMono_Light7pt7b.h"
#include "IBMPlexMono_Light8pt7b.h"
#include "IBMPlexMono_Light9pt7b.h"
#include "IBMPlexMono_Light10pt7b.h"
#include "IBMPlexMono_Light11pt7b.h"
#include "IBMPlexMono_Light12pt7b.h"
#include "IBMPlexMono_Light13pt7b.h"
#include "IBMPlexMono_Light14pt7b.h"
#include "IBMPlexMono_Light15pt7b.h"
#include "IBMPlexMono_Light16pt7b.h"
#include "IBMPlexMono_Light17pt7b.h"
#include "IBMPlexMono_Light18pt7b.h"
#include "IBMPlexMono_Light19pt7b.h"
#include "IBMPlexMono_Light20pt7b.h"
#include "IBMPlexMono_Light21pt7b.h"
#include "IBMPlexMono_Light22pt7b.h"
#include "IBMPlexMono_Light23pt7b.h"
#include "IBMPlexMono_Light24pt7b.h"
#include "IBMPlexMono_Light25pt7b.h"
#include "IBMPlexMono_Light26pt7b.h"
#include "IBMPlexMono_Light27pt7b.h"
#include "IBMPlexMono_Light28pt7b.h"
#include "IBMPlexMono_Light29pt7b.h"
#include "IBMPlexMono_Light30pt7b.h"
#include "IBMPlexMono_Light31pt7b.h"
#include "IBMPlexMono_Light32pt7b.h"
#include "IBMPlexMono_Light33pt7b.h"
#include "IBMPlexMono_Light34pt7b.h"
#include "IBMPlexMono_Light35pt7b.h"
#include "IBMPlexMono_Light36pt7b.h"
#include "IBMPlexMono_Light37pt7b.h"
#include "IBMPlexMono_Light38pt7b.h"
#include "IBMPlexMono_Light39pt7b.h"
#include "IBMPlexMono_Light40pt7b.h"
#include "IBMPlexMono_Light41pt7b.h"
#include "IBMPlexMono_Light42pt7b.h"
#include "IBMPlexMono_Light43pt7b.h"
#include "IBMPlexMono_Light44pt7b.h"
#include "IBMPlexMono_Light45pt7b.h"
#include "IBMPlexMono_Light46pt7b.h"
#include "IBMPlexMono_Light47pt7b.h"
#include "IBMPlexMono_Light48pt7b.h"
#include "IBMPlexMono_Light49pt7b.h"
#include "IBMPlexMono_Light50pt7b.h"
#include "IBMPlexMono_Light51pt7b.h"
#include "IBMPlexMono_Light52pt7b.h"
#include "IBMPlexMono_Light53pt7b.h"
#include "IBMPlexMono_Light54pt7b.h"
#include "IBMPlexMono_Light55pt7b.h"
#include "IBMPlexMono_Light56pt7b.h"
#include "IBMPlexMono_Light57pt7b.h"
#include "IBMPlexMono_Light58pt7b.h"
#include "IBMPlexMono_Light59pt7b.h"
#include "IBMPlexMono_Light60pt7b.h"
#include "IBMPlexMono_Light61pt7b.h"
#include "IBMPlexMono_Light62pt7b.h"
#include "IBMPlexMono_Light63pt7b.h"
#include "IBMPlexMono_Light64pt7b.h"
#include "IBMPlexMono_Light65pt7b.h"
#include "IBMPlexMono_Light66pt7b.h"
#include "IBMPlexMono_Light67pt7b.h"
#include "IBMPlexMono_Light68pt7b.h"
#include "IBMPlexMono_Light69pt7b.h"
#include "IBMPlexMono_Light70pt7b.h"
#include "IBMPlexMono_Light71pt7b.h"
#include "IBMPlexMono_Light72pt7b.h"
