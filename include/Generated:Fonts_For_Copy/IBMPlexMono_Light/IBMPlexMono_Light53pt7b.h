#ifndef _IBMPLEXMONO_LIGHT53PT7B_H_
#define _IBMPLEXMONO_LIGHT53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light53pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xC7,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0xFF, 0xFF, 0xFF, 0x78, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x70, 0x18,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x3F,
  0xF8, 0x1F, 0xFC, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0x01, 0xC0, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x18, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x0E, 0x03, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0xFF, 0xC0, 0x7F, 0xF3,
  0xFF, 0x01, 0xFF, 0xC0, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x18, 0x0E, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F,
  0x8E, 0x7E, 0x07, 0x83, 0x83, 0xC3, 0xC0, 0xE0, 0x78, 0xE0, 0x38, 0x0E,
  0x78, 0x0E, 0x02, 0x1C, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x38,
  0x00, 0x70, 0x0E, 0x00, 0x1E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xF0,
  0x38, 0x00, 0x3E, 0x0E, 0x00, 0x07, 0xE3, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xE7,
  0xF0, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x07, 0x80, 0x03, 0x80, 0xE0, 0x00,
  0xE0, 0x38, 0x00, 0x38, 0x0F, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x70,
  0x00, 0xE0, 0x1C, 0x00, 0x38, 0x0F, 0x60, 0x0E, 0x03, 0xBC, 0x03, 0x80,
  0xE7, 0x80, 0xE0, 0x78, 0xF8, 0x38, 0x3C, 0x1F, 0x8E, 0x7E, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x73, 0xFF, 0xC0, 0x03,
  0x8F, 0x0F, 0x00, 0x1C, 0x70, 0x0E, 0x00, 0x71, 0xC0, 0x38, 0x03, 0x86,
  0x00, 0x60, 0x0E, 0x38, 0x01, 0xC0, 0x70, 0xE0, 0x07, 0x01, 0x83, 0x80,
  0x1C, 0x0E, 0x0E, 0x00, 0x70, 0x30, 0x38, 0x01, 0xC1, 0xC0, 0x60, 0x06,
  0x0E, 0x01, 0xC0, 0x38, 0x38, 0x07, 0x00, 0xE1, 0xC0, 0x0F, 0x0F, 0x07,
  0x00, 0x3F, 0xFC, 0x38, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0x0F, 0xFE, 0x00, 0x38, 0x7C, 0x3C, 0x00, 0xC1, 0xC0, 0x78, 0x07,
  0x06, 0x00, 0xE0, 0x18, 0x38, 0x01, 0x80, 0xE0, 0xE0, 0x06, 0x07, 0x03,
  0x80, 0x18, 0x1C, 0x0E, 0x00, 0x60, 0xE0, 0x38, 0x01, 0x83, 0x80, 0xE0,
  0x06, 0x1C, 0x03, 0x80, 0x18, 0x60, 0x06, 0x00, 0xE3, 0x80, 0x1C, 0x07,
  0x8C, 0x00, 0x7C, 0x3C, 0x70, 0x00, 0xFF, 0xE3, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x20, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0xFF,
  0x00, 0x7E, 0x1E, 0x78, 0x07, 0xE3, 0xC3, 0xC0, 0xE0, 0x78, 0x1C, 0x0E,
  0x07, 0x00, 0xE0, 0xE0, 0xF0, 0x0F, 0x0E, 0x0E, 0x00, 0x78, 0xE0, 0xE0,
  0x03, 0xCE, 0x0E, 0x00, 0x1E, 0xC0, 0xE0, 0x00, 0xEC, 0x0E, 0x00, 0x07,
  0xC0, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3E, 0x07,
  0x00, 0x06, 0xF0, 0x78, 0x00, 0xC7, 0x83, 0xE0, 0x3C, 0x3C, 0x1F, 0xFF,
  0x81, 0xC0, 0xFF, 0xE0, 0x0E, 0x03, 0xF8, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x60,
  0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x0E, 0x00, 0xC0, 0x1D, 0xF8,
  0x18, 0x3F, 0xDF, 0xF3, 0x3F, 0xE0, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x07, 0x00,
  0x03, 0x80, 0x70, 0x00, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x1F, 0x1E,
  0x3E, 0x3E, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x70, 0x70, 0x60, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x07, 0x80, 0x07, 0x83, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x38, 0x00,
  0x07, 0x1E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0E, 0x70,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E,
  0xF0, 0x00, 0x03, 0xBC, 0x07, 0x80, 0xEF, 0x03, 0xE0, 0x3F, 0xC0, 0xF8,
  0x0F, 0xF0, 0x3E, 0x03, 0xFC, 0x07, 0x80, 0xEF, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x0E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x70, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x80, 0xF0,
  0x03, 0xC0, 0x3F, 0x03, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7D, 0xC0, 0x00, 0x7C, 0xE0, 0x00, 0x7C, 0x70, 0x00, 0x7C, 0x38,
  0x00, 0x7C, 0x1C, 0x00, 0x7C, 0x0E, 0x00, 0x7C, 0x07, 0x00, 0x3C, 0x03,
  0x80, 0x0C, 0x01, 0xC0, 0x04, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0x01, 0xF0, 0x3C,
  0x00, 0x78, 0x78, 0x00, 0x38, 0x70, 0x00, 0x3C, 0xF0, 0x00, 0x1C, 0xE0,
  0x00, 0x1C, 0x20, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x0F, 0x81, 0xF8, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x78,
  0x00, 0x1E, 0x10, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x20, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7C,
  0x00, 0x7C, 0x3F, 0x01, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x1C, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80,
  0x1C, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0,
  0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80,
  0x01, 0xC0, 0x70, 0x00, 0x1C, 0x06, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x7F, 0x00, 0x31, 0xFF, 0xE0,
  0x33, 0xFF, 0xF0, 0x37, 0x01, 0xF8, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x20, 0x00, 0x0E, 0xF0, 0x00, 0x1E,
  0x78, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0x3F, 0x01, 0xF8, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x7F, 0x00, 0x71, 0xFF, 0xE0, 0x73, 0xFF, 0xF0, 0x77, 0x81, 0xF8,
  0xFC, 0x00, 0x7C, 0xE8, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0E,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x7C,
  0x1F, 0x81, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x7E, 0x03, 0xF0, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x78, 0x00, 0x07, 0x1E, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x70, 0x0F, 0x80, 0x78, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0x80, 0x7C, 0x07,
  0x80, 0x07, 0x83, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x78,
  0x00, 0x07, 0x8F, 0x00, 0x03, 0xC3, 0xE0, 0x01, 0xF0, 0x7E, 0x01, 0xF8,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0x81, 0xF8, 0x3E, 0x00,
  0x78, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0xF0, 0x00,
  0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x70, 0x00,
  0x0F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x17, 0x3E, 0x00, 0x7E, 0x1F, 0x81,
  0xEE, 0x0F, 0xFF, 0xCE, 0x07, 0xFF, 0x9E, 0x01, 0xFE, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF,
  0xDE, 0x1E, 0x3F, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x1F, 0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x70, 0x70, 0x60,
  0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x0F, 0xC0,
  0xFC, 0x3C, 0x00, 0xF1, 0xE0, 0x01, 0xEF, 0x00, 0x03, 0xB8, 0x00, 0x0F,
  0xE0, 0x00, 0x3D, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7C, 0x0F, 0x81, 0xE0,
  0x07, 0x83, 0x80, 0x07, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x00, 0x7C, 0x76, 0x01, 0xFE,
  0xFC, 0x07, 0xFD, 0xF8, 0x1E, 0x0F, 0xF0, 0x78, 0x0F, 0xE0, 0xE0, 0x0F,
  0xC1, 0xC0, 0x1F, 0x83, 0x80, 0x3F, 0x06, 0x00, 0x7E, 0x0C, 0x00, 0xFC,
  0x18, 0x01, 0xF8, 0x30, 0x03, 0xF0, 0x60, 0x07, 0xE0, 0xC0, 0x0F, 0xC1,
  0xC0, 0x1F, 0x83, 0x80, 0x3F, 0x07, 0x00, 0x7E, 0x0E, 0x00, 0xFC, 0x0E,
  0x03, 0xF8, 0x1F, 0xBF, 0xB0, 0x1F, 0xF7, 0x60, 0x1F, 0xCE, 0xE0, 0x04,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x1C,
  0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x03, 0xC0, 0x03, 0x80, 0x1C,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x70, 0x00, 0xE0, 0x07,
  0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x1E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x38, 0x38, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1C, 0x78, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x87, 0x00, 0x0F, 0x8E, 0x00, 0x07, 0x9C, 0x00, 0x0F, 0x38, 0x00, 0x0E,
  0x70, 0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xF7,
  0x00, 0x01, 0xEE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x1E, 0x70,
  0x00, 0x38, 0xE0, 0x01, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x0E, 0x00, 0x0F, 0x9C, 0x00, 0x07, 0xB8, 0x00, 0x07, 0x70, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0E,
  0xE0, 0x00, 0x3D, 0xC0, 0x01, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x0F, 0xC0, 0xF8, 0x1F, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x0E,
  0x38, 0x00, 0x07, 0x78, 0x00, 0x06, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x06,
  0x38, 0x00, 0x07, 0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x1F, 0x00, 0x3C,
  0x0F, 0xC0, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0x80,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xE0, 0x03, 0xE0,
  0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x3C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78,
  0xE0, 0x00, 0xF0, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCE, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xC0, 0xFC, 0x0F, 0x00, 0x3C, 0x1E,
  0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x38, 0x00, 0x06, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x78,
  0x00, 0x07, 0x38, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x3C, 0x00, 0x0F, 0x1E,
  0x00, 0x1F, 0x0F, 0x00, 0x3F, 0x0F, 0xC0, 0xF7, 0x07, 0xFF, 0xE7, 0x01,
  0xFF, 0xC7, 0x00, 0x7F, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x90, 0x00, 0x1F,
  0xC0, 0x01, 0xEE, 0x00, 0x0E, 0x78, 0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x80,
  0xF8, 0x3F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0x38, 0x00, 0x07, 0x9C, 0x00, 0x07, 0x8E, 0x00, 0x07,
  0x87, 0x00, 0x07, 0x83, 0x80, 0x07, 0x81, 0xC0, 0x07, 0x80, 0xE0, 0x03,
  0x80, 0x70, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x0E, 0x03,
  0xC0, 0x07, 0x03, 0xC0, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0xE1,
  0xF0, 0x00, 0x71, 0xFC, 0x00, 0x39, 0xEE, 0x00, 0x1D, 0xE7, 0x80, 0x0F,
  0xE1, 0xC0, 0x07, 0xE0, 0xF0, 0x03, 0xE0, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0xE0, 0x07, 0x80, 0x70, 0x01, 0xE0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x3C,
  0x0E, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xE1, 0xC0, 0x00,
  0x78, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x03, 0x9C, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xEC, 0x00,
  0x77, 0xEE, 0x00, 0x77, 0xEE, 0x00, 0x77, 0xE7, 0x00, 0xE7, 0xE7, 0x00,
  0xE7, 0xE3, 0x81, 0xC7, 0xE3, 0x81, 0xC7, 0xE3, 0x81, 0x87, 0xE1, 0xC3,
  0x87, 0xE1, 0xC3, 0x87, 0xE0, 0xE7, 0x07, 0xE0, 0xE7, 0x07, 0xE0, 0x66,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C,
  0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x10, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x7E, 0xE0, 0x01, 0xFB, 0xC0, 0x07, 0xE7, 0x00, 0x1F, 0x9C,
  0x00, 0x7E, 0x38, 0x01, 0xF8, 0xE0, 0x07, 0xE1, 0xC0, 0x1F, 0x87, 0x00,
  0x7E, 0x1E, 0x01, 0xF8, 0x38, 0x07, 0xE0, 0xF0, 0x1F, 0x81, 0xC0, 0x7E,
  0x07, 0x81, 0xF8, 0x0E, 0x07, 0xE0, 0x38, 0x1F, 0x80, 0x70, 0x7E, 0x01,
  0xC1, 0xF8, 0x03, 0x87, 0xE0, 0x0E, 0x1F, 0x80, 0x3C, 0x7E, 0x00, 0x71,
  0xF8, 0x01, 0xE7, 0xE0, 0x03, 0x9F, 0x80, 0x0F, 0x7E, 0x00, 0x1D, 0xF8,
  0x00, 0x77, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x83,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x1E, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0x70, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70,
  0x00, 0x07, 0x9E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x3C,
  0x3C, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x3F, 0x03,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE7, 0x00, 0x07, 0xCE, 0x00,
  0x03, 0xDC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3D,
  0xC0, 0x01, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x3C,
  0x38, 0x00, 0x07, 0x1E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x79, 0xC0, 0x00,
  0x0E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x0E, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x70, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0x07, 0x80, 0x07,
  0x80, 0xF0, 0x03, 0xC0, 0x3F, 0x03, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0xE0, 0x00, 0xF8, 0xE0, 0x00, 0x3C, 0xE0, 0x00,
  0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xE0, 0x1C,
  0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x07,
  0x00, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01,
  0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x03, 0xF0, 0x0F, 0xC3, 0xE0,
  0x01, 0xF1, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x04, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x07, 0x8F, 0x80, 0x07, 0xC3,
  0xF0, 0x0F, 0xC0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0x9C,
  0x00, 0x0E, 0x78, 0x00, 0x79, 0xE0, 0x03, 0xC3, 0xE0, 0x1F, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x38, 0x1C,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x70, 0x0E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80,
  0x1C, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80,
  0x01, 0xC0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x1D, 0xC0, 0x3C, 0x03, 0xB8, 0x07, 0x80, 0x67, 0x00, 0xF0,
  0x0C, 0xE0, 0x3F, 0x01, 0x8C, 0x07, 0xE0, 0x71, 0x80, 0xDC, 0x0E, 0x38,
  0x19, 0x81, 0xC7, 0x07, 0x38, 0x38, 0xE0, 0xE7, 0x07, 0x1C, 0x18, 0xE0,
  0xE3, 0x83, 0x0C, 0x1C, 0x70, 0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0x71, 0xC3,
  0x07, 0x0C, 0x38, 0x60, 0x61, 0x83, 0x1C, 0x0E, 0x30, 0x63, 0x81, 0xCE,
  0x0C, 0x70, 0x39, 0xC1, 0xCC, 0x03, 0x38, 0x3B, 0x80, 0x77, 0x07, 0x70,
  0x0E, 0xE0, 0xEE, 0x01, 0xDC, 0x1D, 0x80, 0x3B, 0x83, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0xF0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x38,
  0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xE0, 0x78,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x00, 0xE0, 0x0F, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x70, 0x1C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x3C, 0x1C,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0xE0, 0x00, 0x70, 0x07, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x38, 0xF0, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x38, 0x70, 0x00, 0x1E, 0x1C, 0x00, 0x07,
  0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x07, 0x80,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x01, 0xC0, 0x00,
  0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x20, 0x70, 0xF0, 0x78, 0x38,
  0x1C, 0x0E, 0x0E, 0x07, 0x02, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x0F, 0x03, 0x80, 0x03, 0x80,
  0x80, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7E, 0x00, 0x38, 0x78, 0x00,
  0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00,
  0x01, 0xC3, 0x80, 0x01, 0xE1, 0xC0, 0x01, 0x70, 0xF0, 0x01, 0xB8, 0x3E,
  0x03, 0x9F, 0xCF, 0xFF, 0x8F, 0xE3, 0xFF, 0x83, 0xF0, 0x7F, 0x80, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x3F, 0x80, 0xE3, 0xFF, 0x83,
  0x9F, 0xFF, 0x0E, 0xE0, 0x7E, 0x3E, 0x00, 0x7C, 0xF0, 0x00, 0x73, 0x80,
  0x01, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3B, 0x80, 0x01, 0xEF, 0x00, 0x07,
  0x3E, 0x00, 0x3C, 0xEE, 0x07, 0xE3, 0x9F, 0xFF, 0x0E, 0x3F, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xE0,
  0x7C, 0x1E, 0x00, 0x78, 0xF0, 0x00, 0xE7, 0x80, 0x01, 0xDC, 0x00, 0x04,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x27, 0x80, 0x01, 0xCF, 0x00, 0x0F, 0x1E, 0x00, 0x78, 0x7E,
  0x07, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x7F, 0x07, 0x07, 0xFF, 0x1C, 0x3F, 0xFE,
  0x71, 0xF0, 0x1D, 0xCF, 0x00, 0x1F, 0x78, 0x00, 0x3D, 0xC0, 0x00, 0xF7,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xCF, 0x00,
  0x1F, 0x1F, 0x01, 0xDC, 0x3F, 0xFE, 0x70, 0x7F, 0xF1, 0xC0, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0x81, 0xF0,
  0x1E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x04, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x1E,
  0x1E, 0x00, 0x3C, 0x0F, 0x80, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x07, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x1F, 0xE4, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x3E, 0x07, 0xC0, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x0E,
  0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00,
  0xE0, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x70, 0x1E, 0x00, 0x78, 0x0F, 0xC0,
  0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x70, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x3D, 0xF0, 0x00, 0xFC, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x0F, 0xC0, 0xE3,
  0xFF, 0x8E, 0x7F, 0xFC, 0xEE, 0x07, 0xEE, 0x80, 0x1E, 0xF0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x73, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x3E, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF0, 0xE0, 0x01, 0xE0, 0xE0,
  0x03, 0xC0, 0xE0, 0x07, 0x80, 0xE0, 0x0F, 0x00, 0xE0, 0x1C, 0x00, 0xE0,
  0x78, 0x00, 0xE0, 0xF0, 0x00, 0xE1, 0xE0, 0x00, 0xE3, 0xF0, 0x00, 0xE7,
  0xF8, 0x00, 0xEE, 0x38, 0x00, 0xFC, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0xC0, 0xE0,
  0x01, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x3C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xE0, 0x7E, 0x39, 0xFC, 0x3F, 0xCE, 0xFF, 0x9F, 0xFB, 0xB0,
  0xF6, 0x1E, 0xF0, 0x1E, 0x03, 0xBC, 0x07, 0x80, 0xEE, 0x01, 0xC0, 0x1B,
  0x80, 0x70, 0x07, 0xE0, 0x1C, 0x01, 0xF8, 0x03, 0x00, 0x7E, 0x00, 0xC0,
  0x1F, 0x80, 0x30, 0x07, 0xE0, 0x0C, 0x01, 0xF8, 0x03, 0x00, 0x7E, 0x00,
  0xC0, 0x1F, 0x80, 0x30, 0x07, 0xE0, 0x0C, 0x01, 0xF8, 0x03, 0x00, 0x7E,
  0x00, 0xC0, 0x1F, 0x80, 0x30, 0x07, 0xE0, 0x0C, 0x01, 0xF8, 0x03, 0x00,
  0x7E, 0x00, 0xC0, 0x1F, 0x80, 0x30, 0x07, 0xE0, 0x0C, 0x01, 0xF8, 0x03,
  0x00, 0x7E, 0x00, 0xC0, 0x1F, 0x80, 0x30, 0x07, 0x00, 0xFC, 0x0E, 0x3F,
  0xF8, 0xE7, 0xFF, 0xCE, 0xE0, 0x7E, 0xE8, 0x01, 0xEF, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x1F, 0x81, 0xF0, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x3C,
  0x78, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0E,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x78, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x1F, 0x81, 0xF0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x03,
  0x8F, 0xFE, 0x0E, 0x7F, 0xFC, 0x3B, 0x81, 0xF8, 0xF8, 0x01, 0xF3, 0xC0,
  0x01, 0xCE, 0x00, 0x07, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xEE, 0x00, 0x07,
  0xBC, 0x00, 0x1C, 0xF8, 0x00, 0xF3, 0xB8, 0x1F, 0x8E, 0x7F, 0xFC, 0x38,
  0xFF, 0xE0, 0xE0, 0xFE, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0xFC, 0x70, 0xFF, 0xF9, 0xC7, 0xC0, 0x77, 0x3C, 0x00, 0x7D, 0xE0,
  0x00, 0xF7, 0x00, 0x03, 0xDC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x03,
  0xDE, 0x00, 0x0F, 0x3C, 0x00, 0x7C, 0x7C, 0x07, 0x70, 0xFF, 0xF9, 0xC1,
  0xFF, 0xC7, 0x01, 0xFC, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x3F, 0xFC, 0x01, 0xCE, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0x00,
  0xFC, 0x3C, 0x00, 0x3E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x08, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x60, 0x00, 0x0E, 0xF0, 0x00,
  0x0E, 0x7C, 0x00, 0x1E, 0x3F, 0x00, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x77, 0x00, 0x03,
  0xB8, 0x00, 0x3D, 0xE0, 0x01, 0xE7, 0x80, 0x1F, 0x3E, 0x03, 0xB8, 0xFF,
  0xF9, 0xC3, 0xFF, 0x8E, 0x07, 0xF0, 0x00, 0xE0, 0x00, 0x07, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00,
  0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x07, 0x00,
  0xE0, 0x07, 0x00, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x83,
  0x80, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xC7, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0xE0, 0x0F, 0x00, 0x7E, 0x00, 0xF0, 0x07, 0xE0,
  0x0F, 0x00, 0x7E, 0x01, 0xF8, 0x06, 0x60, 0x1F, 0x80, 0x66, 0x01, 0x98,
  0x06, 0x70, 0x19, 0x80, 0xE7, 0x03, 0x98, 0x0E, 0x70, 0x39, 0xC0, 0xE7,
  0x03, 0x0C, 0x0C, 0x30, 0x30, 0xC0, 0xC3, 0x03, 0x0C, 0x0C, 0x30, 0x70,
  0xE1, 0xC3, 0x86, 0x0E, 0x1C, 0x38, 0x60, 0x61, 0xC3, 0x86, 0x06, 0x18,
  0x18, 0xE0, 0x61, 0x81, 0x8E, 0x07, 0x18, 0x18, 0xC0, 0x33, 0x81, 0xCC,
  0x03, 0x38, 0x1D, 0xC0, 0x33, 0x81, 0xDC, 0x03, 0xB0, 0x0D, 0x80, 0x3B,
  0x00, 0xD8, 0x01, 0xB0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x0F,
  0x80, 0x1F, 0x00, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0x1C, 0x00, 0x38, 0x1E, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x07, 0x81, 0xE0,
  0x03, 0x81, 0xC0, 0x03, 0xC3, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xF7, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xC7, 0x80, 0x03, 0x83, 0xC0,
  0x07, 0x81, 0xC0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x1E, 0x00, 0x78,
  0x3C, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDE, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x1C, 0x00,
  0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x03,
  0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00,
  0x1C, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0xFF, 0xF0, 0x0F,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0x00, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xC0,
  0x01, 0xC3, 0xF8, 0x00, 0x71, 0xFF, 0x00, 0x1C, 0xF1, 0xE0, 0x06, 0x38,
  0x3C, 0x03, 0x9C, 0x07, 0x80, 0xE6, 0x00, 0xF0, 0x73, 0x80, 0x1E, 0x3C,
  0xE0, 0x03, 0xFE, 0x38, 0x00, 0x7F, 0x0C, 0x00, 0x0F, 0x80,
};

const GFXglyph IBMPlexMono_Light53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 6, 37, 32, 13, -37 },
  { 29, 12, 14, 32, 10, -39 },
  { 50, 30, 37, 32, 1, -37 },
  { 189, 26, 49, 32, 3, -43 },
  { 349, 30, 39, 32, 1, -38 },
  { 496, 28, 39, 32, 2, -38 },
  { 633, 3, 14, 32, 14, -39 },
  { 639, 14, 47, 32, 12, -40 },
  { 722, 14, 47, 32, 6, -40 },
  { 805, 27, 26, 32, 2, -29 },
  { 893, 26, 27, 32, 3, -30 },
  { 981, 8, 14, 32, 11, -6 },
  { 995, 15, 3, 32, 8, -18 },
  { 1001, 6, 6, 32, 13, -6 },
  { 1006, 22, 47, 32, 5, -40 },
  { 1136, 26, 39, 32, 3, -38 },
  { 1263, 25, 37, 32, 4, -37 },
  { 1379, 24, 38, 32, 4, -38 },
  { 1493, 24, 39, 32, 3, -38 },
  { 1610, 28, 37, 32, 2, -37 },
  { 1740, 24, 38, 32, 4, -37 },
  { 1854, 24, 38, 32, 4, -37 },
  { 1968, 24, 37, 32, 4, -37 },
  { 2079, 26, 39, 32, 3, -38 },
  { 2206, 24, 38, 32, 4, -38 },
  { 2320, 6, 28, 32, 13, -28 },
  { 2341, 8, 36, 32, 11, -28 },
  { 2377, 23, 30, 32, 4, -31 },
  { 2464, 26, 13, 32, 3, -23 },
  { 2507, 23, 30, 32, 4, -31 },
  { 2594, 22, 38, 32, 5, -38 },
  { 2699, 23, 44, 32, 4, -38 },
  { 2826, 28, 37, 32, 2, -37 },
  { 2956, 23, 37, 32, 5, -37 },
  { 3063, 24, 39, 32, 4, -38 },
  { 3180, 24, 37, 32, 5, -37 },
  { 3291, 22, 37, 32, 5, -37 },
  { 3393, 23, 37, 32, 5, -37 },
  { 3500, 24, 39, 32, 3, -38 },
  { 3617, 22, 37, 32, 5, -37 },
  { 3719, 22, 37, 32, 5, -37 },
  { 3821, 21, 38, 32, 4, -37 },
  { 3921, 25, 37, 32, 5, -37 },
  { 4037, 21, 37, 32, 7, -37 },
  { 4135, 24, 37, 32, 4, -37 },
  { 4246, 22, 37, 32, 5, -37 },
  { 4348, 26, 39, 32, 3, -38 },
  { 4475, 23, 37, 32, 5, -37 },
  { 4582, 26, 47, 32, 3, -38 },
  { 4735, 24, 37, 32, 5, -37 },
  { 4846, 25, 39, 32, 3, -38 },
  { 4968, 28, 37, 32, 2, -37 },
  { 5098, 22, 38, 32, 5, -37 },
  { 5203, 28, 37, 32, 2, -37 },
  { 5333, 27, 37, 32, 2, -37 },
  { 5458, 28, 37, 32, 2, -37 },
  { 5588, 30, 37, 32, 1, -37 },
  { 5727, 26, 37, 32, 3, -37 },
  { 5848, 14, 47, 32, 13, -40 },
  { 5931, 22, 47, 32, 5, -40 },
  { 6061, 14, 47, 32, 5, -40 },
  { 6144, 26, 21, 32, 3, -37 },
  { 6213, 26, 3, 32, 3, 5 },
  { 6223, 8, 10, 32, 10, -41 },
  { 6233, 25, 29, 32, 4, -28 },
  { 6324, 22, 40, 32, 6, -39 },
  { 6434, 22, 29, 32, 5, -28 },
  { 6514, 22, 40, 32, 4, -39 },
  { 6624, 24, 29, 32, 4, -28 },
  { 6711, 25, 39, 32, 4, -39 },
  { 6833, 25, 42, 32, 4, -31 },
  { 6965, 20, 39, 32, 6, -39 },
  { 7063, 23, 39, 32, 6, -39 },
  { 7176, 19, 50, 32, 5, -39 },
  { 7295, 24, 39, 32, 6, -39 },
  { 7412, 23, 39, 32, 4, -39 },
  { 7525, 26, 28, 32, 3, -28 },
  { 7616, 20, 28, 32, 6, -28 },
  { 7686, 24, 29, 32, 4, -28 },
  { 7773, 22, 39, 32, 6, -28 },
  { 7881, 22, 39, 32, 4, -28 },
  { 7989, 26, 27, 32, 4, -27 },
  { 8077, 24, 29, 32, 4, -28 },
  { 8164, 26, 37, 32, 2, -37 },
  { 8285, 21, 28, 32, 5, -27 },
  { 8359, 24, 27, 32, 4, -27 },
  { 8440, 28, 27, 32, 2, -27 },
  { 8535, 24, 27, 32, 4, -27 },
  { 8616, 25, 38, 32, 3, -27 },
  { 8735, 22, 27, 32, 5, -27 },
  { 8810, 20, 47, 32, 6, -40 },
  { 8928, 2, 47, 32, 15, -40 },
  { 8940, 20, 47, 32, 6, -40 },
  { 9058, 26, 11, 32, 3, -22 },
};

const GFXfont IBMPlexMono_Light53pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light53pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light53pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _IBMPLEXMONO_LIGHT53PT7B_H_
