#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_SemiCondensed_MediumItalic
// Headers: 67

#include "NotoSans_SemiCondensed_MediumItalic6pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic7pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic8pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic9pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic10pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic11pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic12pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic13pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic14pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic15pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic16pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic17pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic18pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic19pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic20pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic21pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic22pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic23pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic24pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic25pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic26pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic27pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic28pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic29pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic30pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic31pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic32pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic33pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic34pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic35pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic36pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic37pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic38pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic39pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic40pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic41pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic42pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic43pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic44pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic45pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic46pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic47pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic48pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic49pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic50pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic51pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic52pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic53pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic54pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic55pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic56pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic57pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic58pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic59pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic60pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic61pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic62pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic63pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic64pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic65pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic66pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic67pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic68pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic69pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic70pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic71pt7b.h"
#include "NotoSans_SemiCondensed_MediumItalic72pt7b.h"
