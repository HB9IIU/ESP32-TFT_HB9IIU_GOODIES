#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC19PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x73, 0x18, 0xC6, 0x23, 0x00, 0x0E, 0x70, 0x6D, 0x3C,
  0xB6, 0xD8, 0x06, 0x40, 0x98, 0x13, 0x06, 0x43, 0xFE, 0xFF, 0xC6, 0x40,
  0xC8, 0x13, 0x1F, 0xF8, 0xC8, 0x13, 0x02, 0x60, 0xC8, 0x00, 0x02, 0x07,
  0xC7, 0xE6, 0x83, 0x41, 0xA0, 0x70, 0x1C, 0x0B, 0x05, 0x82, 0xDD, 0xE7,
  0xC0, 0x80, 0x40, 0x18, 0x33, 0xE3, 0x1B, 0x10, 0x99, 0x8C, 0xD8, 0x64,
  0x83, 0x6D, 0xDF, 0xD2, 0x65, 0x98, 0x6C, 0x86, 0x64, 0x22, 0x63, 0x1A,
  0x30, 0xF0, 0x07, 0x01, 0xF0, 0x66, 0x0C, 0xC1, 0x98, 0x3E, 0x03, 0x81,
  0xE3, 0x66, 0x6C, 0xDB, 0x0E, 0x61, 0xC6, 0x78, 0xF9, 0x80, 0x6B, 0x6C,
  0x0C, 0x63, 0x0C, 0x61, 0x8C, 0x30, 0xC3, 0x08, 0x20, 0x82, 0x0C, 0x30,
  0x40, 0x18, 0x20, 0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x21, 0x86, 0x10, 0xC6,
  0x18, 0xC0, 0x10, 0x18, 0x98, 0xF8, 0x3F, 0x38, 0xE8, 0x4C, 0x08, 0x18,
  0x18, 0x18, 0x18, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x36, 0x6C, 0x7F, 0xC0,
  0xFC, 0x00, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x08,
  0x0C, 0x04, 0x06, 0x06, 0x00, 0x0E, 0x3F, 0x33, 0x63, 0x63, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC6, 0xC6, 0xC6, 0xFC, 0x78, 0x0C, 0x73, 0xFA, 0x58, 0x61,
  0x86, 0x30, 0xC3, 0x0C, 0x31, 0x80, 0x0E, 0x1F, 0xC4, 0x60, 0x30, 0x18,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0F, 0xF7, 0xF0, 0x0E, 0x1F,
  0xC4, 0x60, 0x30, 0x18, 0x18, 0x78, 0x3C, 0x03, 0x01, 0x80, 0xC0, 0x6C,
  0xE7, 0xE0, 0x01, 0x81, 0xC0, 0xE0, 0xB0, 0xD0, 0xD8, 0xCC, 0x46, 0x63,
  0x7F, 0xFF, 0xE0, 0xC0, 0x60, 0x60, 0x1F, 0x8F, 0xC6, 0x02, 0x03, 0x01,
  0x80, 0xF8, 0x46, 0x03, 0x01, 0x80, 0xC0, 0x6E, 0xE7, 0xE0, 0x07, 0x8F,
  0x8E, 0x06, 0x06, 0x03, 0x63, 0x79, 0xCE, 0xC3, 0x61, 0xB1, 0x98, 0xCE,
  0xC3, 0xC0, 0x7F, 0xBF, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18,
  0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x00, 0x07, 0x0F, 0xC6, 0x66, 0x13, 0x18,
  0xDC, 0x78, 0x7C, 0x73, 0x31, 0xB0, 0xD8, 0x66, 0x71, 0xF0, 0x1C, 0x3E,
  0x63, 0x63, 0xC3, 0xC3, 0xC7, 0x7F, 0x7A, 0x06, 0x06, 0x0C, 0xB8, 0xF0,
  0x33, 0x00, 0x00, 0x00, 0xEE, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x33, 0x19,
  0x80, 0x01, 0x07, 0x1C, 0x70, 0xE0, 0x78, 0x0E, 0x03, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x0E, 0x78, 0xE0, 0x80,
  0x38, 0xFD, 0x18, 0x30, 0x61, 0x86, 0x18, 0x60, 0xC0, 0x00, 0x0E, 0x18,
  0x00, 0x01, 0x80, 0x7F, 0x06, 0x0C, 0x60, 0x36, 0x3C, 0xA3, 0x67, 0x22,
  0x3B, 0x13, 0x99, 0x9C, 0xCC, 0xA6, 0xED, 0x19, 0xCC, 0x00, 0x30, 0x00,
  0xFE, 0x01, 0xC0, 0x01, 0x80, 0xE0, 0x38, 0x1E, 0x05, 0x83, 0x60, 0x88,
  0x62, 0x1F, 0x8F, 0xF3, 0x0D, 0x83, 0x60, 0xF0, 0x30, 0x1F, 0x07, 0xF1,
  0x8C, 0x63, 0x30, 0xCC, 0x33, 0xF8, 0xFC, 0x31, 0x98, 0x66, 0x19, 0x86,
  0x7F, 0x3F, 0x80, 0x07, 0x87, 0xF3, 0x84, 0xC0, 0x60, 0x18, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x7E, 0x0F, 0x80, 0x1E, 0x03, 0xF8,
  0x63, 0x0C, 0x33, 0x06, 0x60, 0xCC, 0x19, 0x83, 0x30, 0xEC, 0x19, 0x87,
  0x31, 0xC7, 0xF1, 0xF8, 0x00, 0x1F, 0xC7, 0xE1, 0x80, 0x60, 0x30, 0x0C,
  0x03, 0xF0, 0xFC, 0x30, 0x18, 0x06, 0x01, 0x80, 0x7E, 0x3F, 0x80, 0x1F,
  0xC7, 0xE1, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xFC, 0x30, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x30, 0x00, 0x07, 0x83, 0xFC, 0xE1, 0x18, 0x06, 0x00,
  0xC0, 0x30, 0x06, 0x1E, 0xC4, 0xD8, 0x33, 0x06, 0x70, 0xC7, 0xF8, 0x7E,
  0x00, 0x18, 0x31, 0x83, 0x18, 0x31, 0x86, 0x30, 0x63, 0x06, 0x3F, 0xE3,
  0xFC, 0x30, 0xC6, 0x0C, 0x60, 0xC6, 0x0C, 0x61, 0x8C, 0x18, 0x1F, 0x1F,
  0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0xFC,
  0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x18, 0x18, 0xF0, 0xE0, 0x18, 0x71, 0x8E, 0x18, 0xC1, 0x98,
  0x33, 0x03, 0x60, 0x3C, 0x03, 0xE0, 0x36, 0x06, 0x60, 0x63, 0x06, 0x30,
  0x63, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0xC1,
  0x83, 0x07, 0xFF, 0xC0, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x78, 0xA0, 0xA3,
  0x43, 0xC6, 0x85, 0x8D, 0x1B, 0x1A, 0x26, 0x26, 0xC8, 0xCD, 0x31, 0x9E,
  0x63, 0x38, 0xC6, 0x71, 0x98, 0xC6, 0x00, 0x18, 0x18, 0xE0, 0x87, 0x0C,
  0x28, 0x63, 0x63, 0x1B, 0x18, 0xD9, 0x86, 0x6C, 0x23, 0x63, 0x1B, 0x18,
  0x50, 0xC3, 0x86, 0x1C, 0x60, 0xE0, 0x07, 0x03, 0xF8, 0xE3, 0x18, 0x36,
  0x06, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xD8, 0x1B, 0x07, 0x70, 0xC7, 0xF0,
  0x7C, 0x00, 0x1E, 0x07, 0xE1, 0x9C, 0x63, 0x30, 0xCC, 0x33, 0x18, 0xFE,
  0x3E, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x00, 0x07, 0x03, 0xF8, 0xE3,
  0x18, 0x36, 0x06, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xD8, 0x1B, 0x07, 0x70,
  0xC7, 0xF0, 0x7C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x1E, 0x07, 0xE1, 0x9C,
  0x63, 0x30, 0xCC, 0x33, 0x18, 0xFC, 0x36, 0x19, 0x86, 0x31, 0x8C, 0x63,
  0x30, 0x60, 0x0F, 0x0F, 0xCE, 0x26, 0x03, 0x01, 0x80, 0x70, 0x1C, 0x06,
  0x01, 0x80, 0xC0, 0xEF, 0xE7, 0xE0, 0xFF, 0xFF, 0x18, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0, 0x30, 0x66, 0x0C, 0xC1,
  0x10, 0x66, 0x0C, 0xC1, 0x98, 0x33, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0x61,
  0x87, 0xF0, 0xFC, 0x00, 0xC1, 0xE0, 0xF0, 0xD8, 0x6C, 0x66, 0x33, 0x31,
  0x98, 0xC8, 0x6C, 0x34, 0x1E, 0x06, 0x03, 0x00, 0xC3, 0x07, 0x86, 0x1B,
  0x1C, 0x36, 0x38, 0xCC, 0x51, 0x99, 0xA3, 0x32, 0x4C, 0x6C, 0x98, 0xD9,
  0x61, 0xE2, 0xC3, 0xC5, 0x07, 0x0E, 0x0E, 0x1C, 0x18, 0x30, 0x00, 0x18,
  0x31, 0x86, 0x0C, 0xC0, 0xCC, 0x0D, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0F,
  0x01, 0xB0, 0x33, 0x03, 0x10, 0x61, 0x8C, 0x18, 0xC3, 0xE1, 0xB1, 0x98,
  0xC4, 0xC3, 0xC1, 0xE0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x00,
  0x1F, 0xCF, 0xF0, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C,
  0x06, 0x01, 0x80, 0xFF, 0x3F, 0x80, 0x1E, 0x3C, 0x40, 0x83, 0x06, 0x0C,
  0x10, 0x60, 0xC1, 0x83, 0x04, 0x18, 0x30, 0x60, 0xF0, 0xCC, 0xCC, 0x44,
  0x66, 0x66, 0x62, 0x23, 0x1E, 0x3C, 0x18, 0x20, 0xC1, 0x83, 0x04, 0x08,
  0x30, 0x60, 0xC1, 0x06, 0x0C, 0x18, 0xF0, 0x04, 0x06, 0x03, 0x83, 0x41,
  0x31, 0x98, 0x84, 0xC3, 0xC0, 0x80, 0xFE, 0xD9, 0x80, 0x3D, 0xBB, 0x98,
  0xD8, 0x6C, 0x36, 0x1B, 0x19, 0x8C, 0xDE, 0x3B, 0x00, 0x18, 0x0C, 0x06,
  0x02, 0x03, 0x79, 0xCC, 0xC6, 0x63, 0x61, 0xB0, 0xD8, 0x6C, 0x67, 0x76,
  0xF0, 0x3E, 0xE5, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xEC, 0xF8, 0x00, 0xC0,
  0x60, 0x18, 0x06, 0x3D, 0x9C, 0xC6, 0x33, 0x0C, 0xC3, 0x30, 0xCC, 0x63,
  0x18, 0xDE, 0x1D, 0x80, 0x3E, 0x62, 0x63, 0xC6, 0xFC, 0xF0, 0xC0, 0xC0,
  0xE4, 0x7C, 0x00, 0x80, 0xF0, 0x60, 0x18, 0x06, 0x87, 0xC0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C,
  0x0E, 0x03, 0x00, 0x1E, 0xCE, 0x63, 0x19, 0x86, 0x61, 0x98, 0x66, 0x31,
  0x8C, 0x6F, 0x0E, 0xC0, 0x20, 0x18, 0x86, 0x3F, 0x03, 0x00, 0x18, 0x0C,
  0x06, 0x02, 0x03, 0x79, 0xCC, 0xC6, 0x63, 0x61, 0xB0, 0xD8, 0xCC, 0x66,
  0x36, 0x18, 0x18, 0xC0, 0x03, 0x18, 0xC6, 0x63, 0x18, 0xC6, 0x60, 0x06,
  0x0C, 0x00, 0x00, 0xC1, 0x83, 0x06, 0x18, 0x30, 0x60, 0xC1, 0x86, 0x0C,
  0x18, 0x31, 0xC3, 0x00, 0x18, 0x06, 0x01, 0x80, 0x41, 0x31, 0x8C, 0xC3,
  0x60, 0xB0, 0x7C, 0x1F, 0x06, 0xC1, 0x98, 0x46, 0x30, 0xC0, 0x18, 0xC6,
  0x23, 0x18, 0xC6, 0x63, 0x18, 0xC6, 0x60, 0x37, 0xBC, 0xE7, 0x33, 0x18,
  0xCC, 0x63, 0x61, 0x8D, 0x8C, 0x36, 0x31, 0x98, 0xC6, 0x63, 0x1B, 0x0C,
  0x60, 0x37, 0x9C, 0xCC, 0x66, 0x36, 0x1B, 0x0D, 0x8C, 0xC6, 0x63, 0x61,
  0x80, 0x3E, 0x73, 0x63, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xEC, 0x78, 0x1B,
  0xC7, 0x31, 0x8C, 0x63, 0x30, 0xCC, 0x33, 0x0C, 0xC6, 0x3B, 0x9B, 0xC6,
  0x01, 0x80, 0x60, 0x10, 0x0C, 0x00, 0x3D, 0xB9, 0x98, 0xD8, 0x6C, 0x36,
  0x1B, 0x19, 0x8C, 0xDE, 0x3B, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x37,
  0x3D, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0, 0x3E, 0xE5, 0x83,
  0x83, 0x83, 0x83, 0x06, 0xDD, 0xF0, 0x10, 0xC2, 0x7E, 0x61, 0x86, 0x10,
  0xC3, 0x0C, 0x34, 0xF0, 0x61, 0xB1, 0x98, 0xC8, 0x6C, 0x36, 0x13, 0x19,
  0x8C, 0xDE, 0x7B, 0x00, 0xC3, 0xC6, 0xC6, 0xCC, 0xCC, 0xD8, 0x58, 0x50,
  0x70, 0x60, 0xC6, 0x3E, 0x31, 0xB3, 0x89, 0x94, 0xCD, 0xA6, 0x69, 0x63,
  0xCB, 0x1E, 0x50, 0xE3, 0x87, 0x18, 0x00, 0x38, 0xC6, 0x61, 0xB0, 0x38,
  0x0E, 0x03, 0x81, 0xE0, 0xD8, 0x63, 0x38, 0xC0, 0x18, 0x63, 0x18, 0x63,
  0x0C, 0xC0, 0x98, 0x16, 0x02, 0xC0, 0x50, 0x0E, 0x01, 0x80, 0x30, 0x0C,
  0x01, 0x81, 0xE0, 0x10, 0x00, 0x3F, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x70,
  0x60, 0xFC, 0xFC, 0x03, 0x0E, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x30, 0xE0,
  0x60, 0x30, 0x30, 0x20, 0x60, 0x60, 0x70, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x10, 0x38, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x06, 0x1C, 0x60, 0xC1,
  0x06, 0x0C, 0x78, 0xE0, 0x71, 0xFF, 0x86,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 14, 5, 0, -14 },
  { 10, 6, 5, 7, 2, -14 },
  { 14, 11, 14, 11, 0, -14 },
  { 34, 9, 15, 9, 0, -14 },
  { 51, 13, 14, 14, 1, -14 },
  { 74, 11, 14, 11, 0, -14 },
  { 94, 3, 5, 4, 2, -14 },
  { 96, 6, 17, 5, 1, -14 },
  { 109, 6, 17, 5, -1, -14 },
  { 122, 8, 9, 9, 2, -15 },
  { 131, 8, 9, 10, 1, -11 },
  { 140, 4, 4, 5, -1, -2 },
  { 142, 5, 2, 6, 0, -6 },
  { 144, 3, 2, 5, 0, -2 },
  { 145, 9, 14, 7, -1, -14 },
  { 161, 8, 14, 9, 1, -14 },
  { 175, 6, 14, 9, 2, -14 },
  { 186, 9, 14, 9, 0, -14 },
  { 202, 9, 14, 9, 0, -14 },
  { 218, 9, 14, 9, 0, -14 },
  { 234, 9, 14, 9, 0, -14 },
  { 250, 9, 14, 9, 1, -14 },
  { 266, 9, 14, 9, 1, -14 },
  { 282, 9, 14, 9, 0, -14 },
  { 298, 8, 14, 9, 1, -14 },
  { 312, 4, 10, 5, 0, -10 },
  { 317, 5, 12, 5, -1, -10 },
  { 325, 8, 9, 10, 1, -11 },
  { 334, 8, 5, 10, 1, -9 },
  { 339, 8, 9, 10, 1, -11 },
  { 348, 7, 14, 7, 1, -14 },
  { 361, 13, 16, 14, 1, -14 },
  { 387, 10, 14, 10, -1, -14 },
  { 405, 10, 14, 10, 0, -14 },
  { 423, 10, 14, 10, 1, -14 },
  { 441, 11, 14, 11, 0, -14 },
  { 461, 10, 14, 9, 0, -14 },
  { 479, 10, 14, 8, 0, -14 },
  { 497, 11, 14, 12, 1, -14 },
  { 517, 12, 14, 12, 0, -14 },
  { 538, 8, 14, 6, -1, -14 },
  { 552, 8, 18, 5, -3, -14 },
  { 570, 12, 14, 10, 0, -14 },
  { 591, 7, 14, 8, 0, -14 },
  { 604, 15, 14, 15, 0, -14 },
  { 631, 13, 14, 12, 0, -14 },
  { 654, 11, 14, 12, 1, -14 },
  { 674, 10, 14, 10, 0, -14 },
  { 692, 11, 17, 12, 1, -14 },
  { 716, 10, 14, 10, 0, -14 },
  { 734, 9, 14, 9, 0, -14 },
  { 750, 8, 14, 9, 2, -14 },
  { 764, 11, 14, 12, 1, -14 },
  { 784, 9, 14, 10, 2, -14 },
  { 800, 15, 14, 15, 2, -14 },
  { 827, 12, 14, 9, -1, -14 },
  { 848, 9, 14, 9, 2, -14 },
  { 864, 10, 14, 9, 0, -14 },
  { 882, 7, 17, 6, 0, -14 },
  { 897, 4, 14, 7, 2, -14 },
  { 904, 7, 17, 6, -1, -14 },
  { 919, 9, 9, 10, 0, -14 },
  { 930, 7, 1, 7, -2, 2 },
  { 931, 3, 3, 5, 3, -15 },
  { 933, 9, 10, 10, 1, -10 },
  { 945, 9, 14, 10, 0, -14 },
  { 961, 7, 10, 8, 1, -10 },
  { 970, 10, 14, 10, 1, -14 },
  { 988, 8, 10, 9, 1, -10 },
  { 998, 10, 20, 6, -2, -15 },
  { 1023, 10, 15, 10, 0, -10 },
  { 1042, 9, 14, 10, 0, -14 },
  { 1058, 5, 14, 5, 0, -14 },
  { 1067, 7, 19, 5, -2, -14 },
  { 1084, 10, 14, 9, 0, -14 },
  { 1102, 5, 14, 5, 0, -14 },
  { 1111, 14, 10, 15, 0, -10 },
  { 1129, 9, 10, 10, 0, -10 },
  { 1141, 8, 10, 10, 1, -10 },
  { 1151, 10, 15, 10, -1, -10 },
  { 1170, 9, 15, 10, 1, -10 },
  { 1187, 8, 10, 7, 0, -10 },
  { 1197, 7, 10, 8, 0, -10 },
  { 1206, 6, 13, 6, 1, -13 },
  { 1216, 9, 10, 10, 1, -10 },
  { 1228, 8, 10, 8, 1, -10 },
  { 1238, 13, 10, 13, 1, -10 },
  { 1255, 10, 10, 9, -1, -10 },
  { 1268, 11, 15, 8, -2, -10 },
  { 1289, 8, 10, 8, 0, -10 },
  { 1299, 8, 17, 7, 0, -14 },
  { 1316, 2, 18, 9, 4, -14 },
  { 1321, 7, 17, 7, -1, -14 },
  { 1336, 8, 3, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC19PT7B_H_
