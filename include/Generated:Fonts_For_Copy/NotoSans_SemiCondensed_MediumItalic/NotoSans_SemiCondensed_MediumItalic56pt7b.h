#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC56PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7E, 0x00, 0x30, 0x00, 0x3F, 0x1F, 0x9F, 0x0F, 0xDF, 0x87,
  0xEF, 0xC3, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x7C, 0x78,
  0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE0,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x78, 0x1F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0xF0, 0x3E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xE7, 0x1E, 0x03, 0xF0, 0xE0, 0x40, 0x7E, 0x3C, 0x00,
  0x0F, 0x87, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x3E, 0x1C, 0x00, 0x07, 0xC3,
  0x80, 0x00, 0xFC, 0xF0, 0x00, 0x1F, 0xDC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7B, 0xF8, 0x00,
  0x0E, 0x3F, 0x00, 0x01, 0xC7, 0xE0, 0x00, 0x38, 0x7C, 0x00, 0x07, 0x0F,
  0x80, 0x01, 0xC3, 0xF0, 0x00, 0x38, 0x7E, 0x10, 0x07, 0x0F, 0x83, 0xC0,
  0xE3, 0xF0, 0x7F, 0xBF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0xF8, 0x07, 0xFE, 0x00, 0x0F, 0x00, 0xFF, 0xE0, 0x01, 0xF0, 0x1F, 0xFF,
  0x00, 0x3E, 0x01, 0xF1, 0xF0, 0x03, 0xC0, 0x3E, 0x0F, 0x00, 0x7C, 0x03,
  0xC0, 0xF0, 0x0F, 0x80, 0x7C, 0x0F, 0x00, 0xF0, 0x07, 0xC0, 0xF0, 0x1F,
  0x00, 0x78, 0x0F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0xF8, 0x1F,
  0x07, 0xC0, 0x0F, 0x81, 0xF0, 0xF8, 0x00, 0xF0, 0x1E, 0x0F, 0x00, 0x0F,
  0x01, 0xE1, 0xF0, 0x00, 0xF0, 0x3E, 0x3E, 0x04, 0x0F, 0x03, 0xC3, 0xC3,
  0xF8, 0xF0, 0x7C, 0x7C, 0xFF, 0xCF, 0x07, 0xCF, 0x8F, 0xFE, 0xF8, 0xF8,
  0xF1, 0xFF, 0xEF, 0xFF, 0x9F, 0x3E, 0x1F, 0xFF, 0xF3, 0xE3, 0xC1, 0xF7,
  0xFE, 0x3C, 0x7C, 0x1F, 0x3F, 0x87, 0xC7, 0xC1, 0xF0, 0x40, 0xF8, 0xF8,
  0x1F, 0x00, 0x0F, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x3E,
  0x0F, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x1E, 0x00, 0x7C, 0x1F, 0x03, 0xE0,
  0x0F, 0x81, 0xF0, 0x3E, 0x00, 0xF0, 0x1F, 0x03, 0xC0, 0x1F, 0x01, 0xF0,
  0x3C, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x3C, 0x01, 0xF0, 0x78, 0x07, 0xC0,
  0x1F, 0x0F, 0x80, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0x00, 0x0F, 0xFE, 0x01,
  0xF0, 0x00, 0x7F, 0xC0, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7E, 0x1F,
  0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xF8, 0x0F,
  0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x3F, 0x07, 0xFF, 0xC0, 0x3E, 0x0F, 0xCF, 0xC0,
  0x7E, 0x1F, 0x87, 0xE0, 0x7C, 0x3F, 0x07, 0xF0, 0xFC, 0x7E, 0x03, 0xF0,
  0xF8, 0x7E, 0x01, 0xF9, 0xF8, 0x7C, 0x01, 0xFB, 0xF0, 0xFC, 0x00, 0xFF,
  0xE0, 0xFC, 0x00, 0xFF, 0xE0, 0xFC, 0x00, 0x7F, 0xC0, 0xFC, 0x00, 0x7F,
  0x80, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0xFE, 0x01, 0xFF,
  0xC0, 0x7F, 0x8F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE7,
  0xE0, 0x1F, 0xFF, 0x83, 0xF0, 0x0F, 0xFE, 0x03, 0xF8, 0x00, 0x40, 0x00,
  0x00, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8,
  0xF8, 0xF0, 0xF0, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x04,
  0x03, 0xC0, 0x0C, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x7F, 0x1C, 0x00, 0xFF,
  0xB8, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xCF, 0x00, 0x1F, 0x1E,
  0x00, 0x7E, 0x3E, 0x01, 0xF8, 0x3C, 0x01, 0xE0, 0x7C, 0x01, 0xC0, 0xF8,
  0x01, 0x01, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x7F, 0x07, 0xE0,
  0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x03,
  0xC0, 0x7C, 0x0F, 0x80, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xE0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xF3,
  0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0,
  0x0F, 0xC3, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF1, 0xF8, 0x00, 0xF8, 0xFC,
  0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F,
  0x80, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB,
  0xF0, 0x00, 0xF9, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07,
  0xE7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF0, 0xFC, 0x01,
  0xF8, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xFB,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0x7C, 0xFF,
  0x3E, 0x7F, 0x3F, 0x1E, 0x1F, 0x8E, 0x0F, 0x82, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFB, 0xFE, 0x00, 0xF8, 0x07, 0xF0, 0x07, 0x00, 0x3F, 0x00,
  0x40, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x03, 0xF8, 0x7F, 0xC0, 0x3C, 0x03, 0xF8, 0x06, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC2, 0x00, 0x03, 0xF8, 0x70, 0x00, 0xFE, 0x0F, 0xE0, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF9,
  0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF8, 0x00,
  0xFC, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x1F,
  0x00, 0x7C, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0x20, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x10,
  0x00, 0x3F, 0x83, 0x80, 0x1F, 0xE0, 0x7E, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFE, 0x18, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x1F, 0xE0, 0x3F, 0x3F, 0xF8, 0x1F,
  0xBF, 0xFE, 0x0F, 0xBF, 0xFF, 0x07, 0xFE, 0x3F, 0xC7, 0xFC, 0x07, 0xE3,
  0xFC, 0x03, 0xF1, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F,
  0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x07,
  0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF9, 0xFE, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03,
  0xF8, 0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07,
  0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x03, 0xF0, 0x3E,
  0x00, 0x7C, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x0F, 0xC1, 0xFC,
  0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0x0F, 0xE0, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x01,
  0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F,
  0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x0F,
  0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x07, 0xF8, 0x3F, 0xC0, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xC7, 0xF8, 0x1F,
  0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x07, 0xE3, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC,
  0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x1F,
  0xCF, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF8, 0x0F, 0xF0, 0xFF, 0x1F,
  0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0x7C, 0x07, 0xFF, 0x3E, 0x01, 0xFE,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x0E, 0x1F, 0xF8, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x3E, 0x07, 0xF0, 0x7F, 0x0F, 0xF0,
  0xFE, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xC0, 0xFC, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFF, 0x0F, 0xC7, 0xF8, 0x70, 0x0F, 0xC2, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x07, 0xC0,
  0x1F, 0xF0, 0x1E, 0x0F, 0x80, 0x7F, 0xFC, 0x1E, 0x0F, 0x00, 0xFF, 0xFC,
  0x1F, 0x1F, 0x01, 0xFD, 0xFC, 0x1F, 0x1E, 0x03, 0xE0, 0x78, 0x1F, 0x3E,
  0x07, 0xC0, 0x78, 0x1F, 0x3C, 0x0F, 0x80, 0xF8, 0x1F, 0x3C, 0x0F, 0x80,
  0xF8, 0x1E, 0x7C, 0x1F, 0x00, 0xF0, 0x1E, 0x7C, 0x1F, 0x01, 0xF0, 0x1E,
  0x78, 0x1E, 0x01, 0xF0, 0x1E, 0x78, 0x3E, 0x01, 0xE0, 0x3E, 0x78, 0x3E,
  0x01, 0xE0, 0x3C, 0xF8, 0x3E, 0x03, 0xE0, 0x3C, 0xF8, 0x3E, 0x03, 0xE0,
  0x7C, 0xF8, 0x3C, 0x07, 0xC0, 0x78, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0xF8,
  0x3E, 0x0F, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0xE3, 0xF0, 0xF8, 0x1F, 0xFD,
  0xFF, 0xE0, 0x78, 0x1F, 0xF9, 0xFF, 0xC0, 0x78, 0x0F, 0xF0, 0xFF, 0x80,
  0x7C, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x20, 0x00, 0x07,
  0xF8, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7E, 0x3E, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x07,
  0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0xF8, 0x3F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8,
  0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7C, 0x03, 0xFC, 0x07,
  0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0x80,
  0x0F, 0xC0, 0x7C, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F,
  0x81, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x07,
  0xE0, 0x3F, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07,
  0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F,
  0x81, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0xC0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x07, 0xFC, 0x01, 0x80, 0x7F, 0x80, 0x04, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x18,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0x01, 0xFF, 0x00, 0x7E,
  0x00, 0xFF, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0,
  0x01, 0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01,
  0xF8, 0x3E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xFC,
  0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x1F,
  0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0xC0, 0x7C, 0x01, 0xFF, 0x01, 0xF8,
  0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x3C, 0x03, 0xFC, 0x00, 0x08, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF8, 0x7E, 0x00,
  0x7F, 0xF8, 0x7E, 0x00, 0xFF, 0xF8, 0xFC, 0x00, 0xFF, 0xF0, 0xFC, 0x00,
  0xFF, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x07, 0xC0, 0x7F, 0x00, 0x0F, 0xC0, 0x7F, 0x80, 0x0F, 0xC0, 0x3F, 0xC0,
  0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07,
  0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x02, 0x0F, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0x80,
  0x07, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0,
  0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xF8, 0x1F, 0xC0, 0x00, 0x7C, 0x1F, 0xC0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0x0F, 0x8F, 0xE0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xDF,
  0x80, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF0,
  0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00,
  0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xBE, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7D, 0xF0, 0x07, 0xDE,
  0x00, 0x0F, 0xBE, 0x01, 0xF3, 0xC0, 0x03, 0xE7, 0xC0, 0x3E, 0x78, 0x00,
  0x7D, 0xF8, 0x07, 0xCF, 0x80, 0x1F, 0x3F, 0x00, 0xF9, 0xF0, 0x03, 0xE7,
  0xC0, 0x3F, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xE7, 0xC0, 0x1F, 0x3F, 0x00,
  0xF8, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xFC, 0x03, 0xE3,
  0xE0, 0x3E, 0x1F, 0x00, 0xFC, 0x7C, 0x07, 0xC3, 0xE0, 0x1F, 0x8F, 0x81,
  0xF0, 0xFC, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x80, 0x7C, 0x1E, 0x0F, 0x83,
  0xF0, 0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x7C, 0x0F, 0x80,
  0x7C, 0x0F, 0x8F, 0x83, 0xF0, 0x0F, 0x81, 0xF3, 0xE0, 0x7E, 0x01, 0xF0,
  0x3E, 0x7C, 0x0F, 0x80, 0x7E, 0x07, 0xDF, 0x01, 0xF0, 0x0F, 0xC0, 0xFB,
  0xE0, 0x7E, 0x01, 0xF0, 0x1F, 0xF8, 0x0F, 0xC0, 0x3E, 0x03, 0xFF, 0x01,
  0xF8, 0x07, 0xC0, 0x7F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xF8, 0x07, 0xC0,
  0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x07, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x00, 0x3F,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0x00,
  0x03, 0xE0, 0x0F, 0xF8, 0x00, 0x3E, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x1F,
  0xF8, 0x00, 0x7E, 0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x1F, 0xFC, 0x00, 0x7C,
  0x03, 0xF7, 0xC0, 0x0F, 0xC0, 0x3E, 0x7C, 0x00, 0xFC, 0x03, 0xE7, 0xE0,
  0x0F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x80, 0x7E,
  0x3F, 0x01, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x80, 0x7C, 0x1F, 0x01, 0xF0,
  0x07, 0xC1, 0xF0, 0x1F, 0x00, 0x7C, 0x1F, 0x81, 0xF0, 0x0F, 0xC0, 0xF8,
  0x3F, 0x00, 0xFC, 0x0F, 0x83, 0xF0, 0x0F, 0x80, 0xFC, 0x3E, 0x00, 0xF8,
  0x07, 0xC3, 0xE0, 0x1F, 0x80, 0x7C, 0x3E, 0x01, 0xF8, 0x07, 0xE7, 0xE0,
  0x1F, 0x00, 0x7E, 0x7E, 0x01, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x00, 0x3E,
  0x7C, 0x03, 0xF0, 0x03, 0xF7, 0xC0, 0x3F, 0x00, 0x1F, 0x7C, 0x03, 0xE0,
  0x01, 0xFF, 0x80, 0x3E, 0x00, 0x1F, 0xF8, 0x03, 0xE0, 0x01, 0xFF, 0x80,
  0x7E, 0x00, 0x0F, 0xF8, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0x0F,
  0xF0, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x3F,
  0xC0, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7C, 0x07,
  0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8,
  0x0F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F,
  0x00, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xFC, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0x81, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F,
  0x7F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0x80,
  0xFF, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0,
  0x1F, 0x00, 0x3F, 0x01, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0,
  0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7E,
  0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x7F, 0xC0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0x83, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x1F,
  0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x03,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF8,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xF0,
  0x1F, 0xC0, 0x04, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x81, 0x00, 0x07, 0xF0, 0x78, 0x01,
  0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F,
  0x00, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7E,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x50, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E,
  0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF8, 0x1F,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00,
  0x7E, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07,
  0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x7C, 0x00,
  0x3F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7F,
  0x80, 0x0F, 0xC7, 0xC0, 0x0F, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xFF, 0x80,
  0x1F, 0x87, 0xC0, 0x0F, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xFF, 0x80, 0x3F,
  0x07, 0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0x7C, 0x03, 0xEF, 0x80, 0x7E, 0x07,
  0xC0, 0x3E, 0xF8, 0x07, 0xE0, 0x7C, 0x07, 0xCF, 0x80, 0xFC, 0x07, 0xC0,
  0x7C, 0xF8, 0x0F, 0xC0, 0x7C, 0x0F, 0x8F, 0x80, 0xF8, 0x07, 0xC0, 0xF8,
  0x78, 0x1F, 0x80, 0x7C, 0x0F, 0x87, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x78,
  0x3F, 0x00, 0x7C, 0x1F, 0x07, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x78, 0x7E,
  0x00, 0x7C, 0x3E, 0x07, 0x87, 0xE0, 0x07, 0xC7, 0xC0, 0x78, 0x7C, 0x00,
  0x7C, 0x7C, 0x07, 0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x78, 0xF8, 0x00, 0x7C,
  0xF8, 0x07, 0x9F, 0x80, 0x07, 0xCF, 0x80, 0x79, 0xF0, 0x00, 0x7D, 0xF0,
  0x07, 0x9F, 0x00, 0x07, 0xDF, 0x00, 0x7B, 0xF0, 0x00, 0x7D, 0xE0, 0x07,
  0xBE, 0x00, 0x07, 0xFE, 0x00, 0x7B, 0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x7C, 0xFC,
  0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xF8,
  0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xE7, 0xC0, 0x01, 0xF9, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xC0, 0xF8, 0x03,
  0xF0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC,
  0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x07, 0xC3, 0xF0, 0x01, 0xF1, 0xF8, 0x00,
  0x7E, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3F, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0xF8,
  0x1F, 0x00, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03,
  0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x0F,
  0x8F, 0x80, 0x03, 0xE7, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x1F, 0x87,
  0xE0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xF8, 0x7C, 0x03, 0xFF, 0x8F, 0x00, 0xFF, 0xFB, 0xE0, 0x3F,
  0xFF, 0x7C, 0x0F, 0xF1, 0xFF, 0x83, 0xF8, 0x0F, 0xF0, 0x7E, 0x01, 0xFC,
  0x1F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0x83, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3,
  0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x01,
  0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0xFF,
  0x81, 0xFC, 0x7F, 0xE0, 0x3F, 0xFF, 0x7C, 0x03, 0xFF, 0xCF, 0x80, 0x7F,
  0xF1, 0xF0, 0x03, 0xFC, 0x3C, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x78, 0x00, 0xFC, 0x7F, 0x80, 0x3E, 0x7F, 0xF0, 0x0F, 0xBF,
  0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0x87, 0xF0, 0x7F, 0x80, 0xFC, 0x1F,
  0xC0, 0x3F, 0x07, 0xF0, 0x07, 0xC3, 0xF8, 0x01, 0xF0, 0xFE, 0x00, 0x7C,
  0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xF3, 0xF0,
  0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x03, 0xF1, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xE0, 0x7F,
  0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0xFF, 0xE0, 0xF9, 0xFF, 0xF0, 0x3E, 0x3F,
  0xF8, 0x0F, 0x07, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x80, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xE0,
  0xE0, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x02, 0x07, 0xF8, 0x78, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x7E, 0x00,
  0x3F, 0xE3, 0xF0, 0x03, 0xFF, 0x9F, 0x00, 0x3F, 0xFE, 0xF8, 0x03, 0xFF,
  0xF7, 0xC0, 0x3F, 0x83, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7F,
  0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07,
  0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80,
  0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x3F,
  0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x07,
  0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7F, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x03, 0xFC, 0x01, 0xFC, 0x7F, 0xE0, 0x0F, 0xFF, 0xDF,
  0x00, 0x3F, 0xFC, 0xF8, 0x00, 0xFF, 0xC7, 0xC0, 0x03, 0xFC, 0x3C, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFE, 0x0F, 0xC3, 0xF8, 0x0F,
  0x87, 0xE0, 0x1F, 0x1F, 0x80, 0x3E, 0x3E, 0x00, 0xFC, 0xFC, 0x01, 0xF9,
  0xF0, 0x07, 0xE7, 0xE0, 0x3F, 0xCF, 0xC3, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x41, 0xFE, 0x07, 0x81, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF0, 0x40, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x27,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF,
  0x87, 0xC0, 0x0F, 0xFE, 0x3C, 0x01, 0xFF, 0xFB, 0xE0, 0x0F, 0xFF, 0xDF,
  0x00, 0xFF, 0x0F, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7E, 0x01, 0xFC, 0x07,
  0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80,
  0x0F, 0x81, 0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F,
  0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0xFC, 0x0F,
  0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80,
  0x1F, 0x80, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0x00, 0xFF,
  0x01, 0xFC, 0x0F, 0xF8, 0x07, 0xF1, 0xFF, 0x80, 0x3F, 0xFF, 0x7C, 0x00,
  0xFF, 0xF7, 0xE0, 0x07, 0xFF, 0x3F, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x08,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x40, 0x01, 0xF8, 0x03,
  0x00, 0x1F, 0xC0, 0x1F, 0x83, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x78, 0x00, 0xFC, 0x7F, 0x80, 0x3E, 0x7F, 0xF8, 0x0F,
  0xBF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0x87, 0xF0, 0x7F, 0xC0, 0xFC,
  0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFE, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x07, 0xC3,
  0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F,
  0x83, 0xE0, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x87, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x30, 0x01, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x08, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x1F, 0xC0, 0xF8, 0x07, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xE0, 0xFC, 0x00,
  0x7C, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7C, 0xFE,
  0x00, 0x0F, 0x9F, 0x80, 0x01, 0xF7, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xF7, 0xE0,
  0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8,
  0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80,
  0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0xFF, 0x01,
  0xFE, 0x00, 0xF9, 0xFF, 0xC3, 0xFF, 0x80, 0x79, 0xFF, 0xF3, 0xFF, 0xE0,
  0x7D, 0xFF, 0xFB, 0xFF, 0xF0, 0x3E, 0xF0, 0xFD, 0xE1, 0xFC, 0x1F, 0xE0,
  0x7F, 0xE0, 0x7E, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0x87, 0xF0, 0x07, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0x07, 0xE1,
  0xF8, 0x03, 0xF0, 0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x7C, 0x00,
  0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x3F,
  0x00, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x1F,
  0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xC0, 0x0F,
  0xC3, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x7F,
  0xC0, 0x3E, 0x7F, 0xF8, 0x0F, 0x3F, 0xFE, 0x07, 0xDF, 0xFF, 0xC1, 0xF7,
  0x87, 0xF0, 0x7F, 0xC0, 0xFC, 0x1F, 0xE0, 0x3F, 0x07, 0xF0, 0x0F, 0xC3,
  0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F,
  0xC7, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x87, 0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xE1, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x07, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x3F, 0x87, 0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0x7E,
  0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03,
  0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x3E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80,
  0x07, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x03, 0xF1, 0xF8,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0xE3, 0xFC, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xE1, 0xFE, 0x00, 0x1F,
  0x3F, 0xF8, 0x00, 0xF3, 0xFF, 0xE0, 0x0F, 0xBF, 0xFF, 0x00, 0x7D, 0xE1,
  0xFC, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0x00, 0xFE, 0x00, 0xF8,
  0x0F, 0xE0, 0x07, 0xC0, 0x7F, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF0, 0x1F,
  0x80, 0x0F, 0x80, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00,
  0x3F, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0xFC,
  0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x1F,
  0x80, 0x1F, 0x81, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x81,
  0xFC, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFB, 0xFF, 0xE0,
  0x0F, 0xCF, 0xFE, 0x00, 0x7E, 0x3F, 0xC0, 0x03, 0xE0, 0x20, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0xF8, 0x7C, 0x03, 0xFF, 0x8F, 0x00, 0xFF, 0xFB, 0xE0, 0x3F, 0xFF, 0x7C,
  0x0F, 0xE0, 0xFF, 0x83, 0xF8, 0x0F, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0x80,
  0x1F, 0x83, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x83,
  0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01,
  0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7F,
  0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0x01, 0xFC,
  0x7F, 0xE0, 0x3F, 0xFF, 0x7C, 0x03, 0xFF, 0xDF, 0x80, 0x7F, 0xF3, 0xF0,
  0x03, 0xF8, 0x7C, 0x00, 0x0C, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x1F, 0x1F, 0xC0, 0xF9, 0xFE, 0x07, 0x9F, 0xF0, 0x7D,
  0xFF, 0x03, 0xEF, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0x81, 0xE0, 0xFC, 0x01, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE3, 0x00, 0x3F, 0x0F, 0x03, 0xFC,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x20, 0xFF, 0xE0, 0xFF, 0xE0,
  0x7F, 0xE0, 0x3F, 0xE0, 0x06, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x00,
  0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F,
  0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0,
  0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3E, 0x00,
  0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x07,
  0xE0, 0x1F, 0xE0, 0xFE, 0x07, 0xF8, 0x0F, 0xE3, 0xFF, 0x01, 0xFF, 0xFB,
  0xE0, 0x3F, 0xFE, 0x7C, 0x03, 0xFF, 0x8F, 0x80, 0x3F, 0xC1, 0xE0, 0x00,
  0x40, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0x7C, 0x01, 0xF8,
  0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x80,
  0x7C, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x7E, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x01, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x7D, 0xF8,
  0x07, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0xC0, 0x3E, 0x7E, 0x03, 0xFE, 0x03,
  0xF3, 0xF0, 0x1E, 0xF0, 0x1F, 0x0F, 0x81, 0xF7, 0x81, 0xF8, 0x7C, 0x0F,
  0x7C, 0x0F, 0xC3, 0xE0, 0xFB, 0xE0, 0x7C, 0x1F, 0x07, 0xDF, 0x07, 0xE0,
  0xF8, 0x3C, 0xF8, 0x3E, 0x07, 0xC3, 0xE7, 0xC3, 0xF0, 0x3E, 0x1E, 0x3E,
  0x1F, 0x01, 0xF1, 0xF1, 0xF1, 0xF8, 0x0F, 0x8F, 0x8F, 0x8F, 0x80, 0x7C,
  0xF8, 0x7C, 0x7C, 0x03, 0xE7, 0xC3, 0xE7, 0xE0, 0x1F, 0x3C, 0x1F, 0x3E,
  0x00, 0xFB, 0xE0, 0xFB, 0xF0, 0x07, 0xDE, 0x07, 0xDF, 0x00, 0x3F, 0xF0,
  0x3E, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0x78, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x80,
  0x7E, 0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7C,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF8, 0xF8, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0xFC,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x00, 0xF8, 0x07, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F,
  0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x3F,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x87, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x80, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x9F, 0xF8, 0x00, 0x5F, 0xFF, 0x00, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00, 0x3F, 0xFD, 0x00,
  0x07, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 15, 41, 14, 1, -40 },
  { 78, 17, 14, 22, 6, -40 },
  { 108, 32, 40, 32, 1, -40 },
  { 268, 27, 46, 28, 1, -43 },
  { 424, 36, 42, 42, 4, -41 },
  { 613, 32, 42, 34, 1, -41 },
  { 781, 8, 14, 12, 6, -40 },
  { 795, 18, 49, 16, 2, -40 },
  { 906, 18, 49, 16, -4, -40 },
  { 1017, 23, 24, 27, 5, -43 },
  { 1086, 25, 27, 29, 3, -33 },
  { 1171, 12, 14, 14, -3, -7 },
  { 1192, 14, 6, 17, 1, -18 },
  { 1203, 7, 8, 14, 1, -7 },
  { 1210, 28, 40, 20, -3, -40 },
  { 1350, 25, 42, 28, 2, -41 },
  { 1482, 17, 40, 28, 7, -40 },
  { 1567, 28, 41, 28, -1, -41 },
  { 1711, 27, 42, 28, 0, -41 },
  { 1853, 27, 40, 28, 0, -40 },
  { 1988, 27, 41, 28, 1, -40 },
  { 2127, 25, 42, 28, 3, -41 },
  { 2259, 27, 40, 28, 3, -40 },
  { 2394, 27, 42, 28, 1, -41 },
  { 2536, 25, 42, 28, 2, -41 },
  { 2668, 12, 32, 14, 1, -31 },
  { 2716, 16, 38, 14, -3, -31 },
  { 2792, 25, 27, 29, 3, -34 },
  { 2877, 25, 16, 29, 3, -28 },
  { 2927, 25, 27, 29, 3, -34 },
  { 3012, 21, 42, 22, 3, -41 },
  { 3123, 40, 45, 43, 2, -40 },
  { 3348, 29, 40, 29, -3, -40 },
  { 3493, 29, 40, 31, 1, -40 },
  { 3638, 29, 42, 29, 3, -41 },
  { 3791, 31, 40, 34, 1, -40 },
  { 3946, 28, 40, 26, 1, -40 },
  { 4086, 28, 40, 25, 1, -40 },
  { 4226, 32, 42, 35, 3, -41 },
  { 4394, 34, 40, 35, 1, -40 },
  { 4564, 23, 40, 18, -2, -40 },
  { 4679, 25, 51, 15, -9, -40 },
  { 4839, 33, 40, 29, 1, -40 },
  { 5004, 20, 40, 25, 1, -40 },
  { 5104, 43, 40, 44, 1, -40 },
  { 5319, 36, 40, 36, 1, -40 },
  { 5499, 32, 42, 36, 3, -41 },
  { 5667, 29, 40, 29, 1, -40 },
  { 5812, 32, 51, 36, 3, -41 },
  { 6016, 28, 40, 30, 1, -40 },
  { 6156, 27, 42, 26, 0, -41 },
  { 6298, 25, 40, 25, 5, -40 },
  { 6423, 32, 41, 34, 3, -40 },
  { 6587, 29, 40, 29, 5, -40 },
  { 6732, 44, 40, 44, 5, -40 },
  { 6952, 35, 40, 28, -3, -40 },
  { 7127, 26, 40, 26, 5, -40 },
  { 7257, 30, 40, 26, -1, -40 },
  { 7407, 22, 49, 17, -1, -40 },
  { 7542, 11, 40, 21, 6, -40 },
  { 7597, 22, 49, 17, -4, -40 },
  { 7732, 26, 24, 28, 1, -40 },
  { 7810, 21, 4, 20, -5, 5 },
  { 7821, 10, 9, 16, 8, -43 },
  { 7833, 27, 32, 29, 2, -31 },
  { 7941, 26, 44, 30, 1, -43 },
  { 8084, 22, 32, 23, 2, -31 },
  { 8172, 29, 44, 30, 2, -43 },
  { 8332, 23, 32, 26, 2, -31 },
  { 8424, 30, 56, 17, -6, -43 },
  { 8634, 29, 44, 30, 0, -31 },
  { 8794, 26, 43, 30, 1, -43 },
  { 8934, 14, 42, 14, 1, -42 },
  { 9008, 22, 55, 14, -7, -42 },
  { 9160, 27, 43, 26, 1, -43 },
  { 9306, 15, 43, 14, 1, -43 },
  { 9387, 41, 31, 44, 1, -31 },
  { 9546, 26, 31, 30, 1, -31 },
  { 9647, 25, 32, 29, 2, -31 },
  { 9747, 29, 44, 30, -2, -31 },
  { 9907, 27, 44, 30, 2, -31 },
  { 10056, 21, 31, 20, 1, -31 },
  { 10138, 22, 32, 23, 0, -31 },
  { 10226, 16, 38, 18, 3, -37 },
  { 10302, 27, 31, 30, 2, -30 },
  { 10407, 24, 30, 24, 3, -30 },
  { 10497, 37, 30, 38, 3, -30 },
  { 10636, 29, 30, 25, -2, -30 },
  { 10745, 32, 43, 24, -5, -30 },
  { 10917, 24, 30, 22, -1, -30 },
  { 11007, 22, 49, 19, 1, -40 },
  { 11142, 4, 56, 27, 12, -43 },
  { 11170, 22, 49, 19, -3, -40 },
  { 11305, 25, 8, 29, 3, -24 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC56PT7B_H_
