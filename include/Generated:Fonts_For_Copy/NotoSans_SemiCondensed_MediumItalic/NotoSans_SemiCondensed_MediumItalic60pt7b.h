#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC60PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x30, 0x00, 0x3F, 0x87, 0xE7, 0xE0, 0xFC, 0xFC, 0x3F,
  0x1F, 0x87, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x9F, 0x83, 0xE3, 0xF0, 0x7C,
  0x7C, 0x0F, 0x8F, 0x83, 0xE1, 0xF0, 0x7C, 0x3C, 0x0F, 0x87, 0x81, 0xF1,
  0xF0, 0x3C, 0x3E, 0x07, 0x87, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07,
  0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xE0,
  0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0xF0, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3C,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03,
  0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xEF,
  0xE0, 0x3F, 0x8E, 0x0E, 0x03, 0xF0, 0xE0, 0x40, 0x3E, 0x1E, 0x00, 0x07,
  0xE1, 0xE0, 0x00, 0x7E, 0x1C, 0x00, 0x07, 0xE1, 0xC0, 0x00, 0x7E, 0x1C,
  0x00, 0x07, 0xF3, 0xC0, 0x00, 0x3F, 0xBC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0x7F, 0x00, 0x00, 0xE3, 0xF8, 0x00, 0x0E, 0x1F, 0x80, 0x00,
  0xE1, 0xF8, 0x00, 0x1E, 0x1F, 0x80, 0x01, 0xE1, 0xF8, 0x00, 0x1C, 0x1F,
  0x08, 0x01, 0xC3, 0xF0, 0xE0, 0x1C, 0x7F, 0x0F, 0xC3, 0xCF, 0xE0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xC0,
  0x1F, 0xFE, 0x00, 0x1F, 0x00, 0x7F, 0xFC, 0x00, 0x3E, 0x01, 0xF8, 0xF8,
  0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0,
  0x1F, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F,
  0x80, 0xF8, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x0F, 0x80,
  0x0F, 0x80, 0xF8, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x03,
  0xE1, 0xF0, 0x00, 0x7C, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x1F, 0x0F, 0x80,
  0x01, 0xF0, 0x3E, 0x3E, 0x0F, 0xC3, 0xE0, 0x7C, 0x7C, 0x7F, 0xE7, 0xC1,
  0xF1, 0xF1, 0xFF, 0xEF, 0x87, 0xE7, 0xC7, 0xFF, 0xDF, 0x1F, 0x8F, 0x9F,
  0x8F, 0x9F, 0xFE, 0x3E, 0x3E, 0x0F, 0xBF, 0xFC, 0xF8, 0xF8, 0x1F, 0x3F,
  0xF1, 0xF1, 0xF0, 0x3E, 0x3F, 0x87, 0xC3, 0xE0, 0x7C, 0x00, 0x1F, 0x0F,
  0x80, 0xF8, 0x00, 0x3E, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x3E, 0x03, 0xC0,
  0x03, 0xE0, 0xF8, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x1F, 0x00, 0x1F, 0x03,
  0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x81, 0xF0,
  0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0xF8,
  0x03, 0xE0, 0x03, 0xFF, 0xF0, 0x0F, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0x00,
  0x03, 0xFF, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x03, 0xF0, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x7E, 0x7F,
  0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0x07, 0xF7, 0xE0, 0x1F, 0x83,
  0xF9, 0xFC, 0x07, 0xE1, 0xFC, 0x3F, 0x83, 0xF0, 0xFE, 0x07, 0xE0, 0xFC,
  0x3F, 0x01, 0xFC, 0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0x87, 0xE0, 0x0F, 0xEF,
  0xC3, 0xF0, 0x01, 0xFF, 0xF0, 0xFC, 0x00, 0x7F, 0xF8, 0x3F, 0x00, 0x0F,
  0xFC, 0x0F, 0xC0, 0x03, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x3F, 0xE0, 0x3F, 0x80, 0x1F, 0xF8, 0x07, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0xFC, 0x7F, 0x01,
  0xFF, 0xFC, 0x1F, 0xC0, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0xFC, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0x83, 0xC3, 0xE1, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x60, 0x1F, 0x00,
  0x78, 0x1E, 0x00, 0x7E, 0x1E, 0x00, 0xFF, 0x9E, 0x00, 0xFF, 0xFC, 0x3F,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x01, 0xFE, 0x00, 0x03, 0xEF, 0x00, 0x0F, 0xCF, 0x00, 0x1F, 0xCF, 0x80,
  0x3F, 0x8F, 0x80, 0x7F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x1E, 0x07, 0xE0,
  0x0C, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F,
  0x83, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x00, 0x7F, 0xFE,
  0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0x80, 0x1C, 0x7E,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFE, 0xFC, 0x30, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x87,
  0xF0, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F,
  0xC7, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE7, 0xF0,
  0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E,
  0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00,
  0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xCF,
  0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01,
  0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F,
  0x00, 0x7E, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x1F, 0xC1, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xDF, 0x9F, 0xF3, 0xF1, 0xF8, 0xFC, 0x3E,
  0x1F, 0x83, 0x83, 0xF0, 0x40, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xF8, 0x1F, 0xE0, 0x07, 0x80, 0x1F, 0xC0, 0x0C, 0x00, 0x7F, 0x00, 0x20,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7E, 0x03, 0xFC, 0x01, 0xC0, 0x0F, 0xE0,
  0x08, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x0C, 0x00, 0x07, 0xF0,
  0x78, 0x00, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xD0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x0F, 0xDF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7E,
  0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x01,
  0xF0, 0x3F, 0x00, 0x1F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80,
  0x7C, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8,
  0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFB, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x0C, 0x00, 0x1F, 0xE0, 0x78, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x0F, 0xF0, 0x07, 0xE7, 0xFF, 0x00, 0xF9, 0xFF, 0xF0, 0x3F, 0x7F,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xC1, 0xFE, 0x1F, 0xE0, 0x1F, 0xC7,
  0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0x00,
  0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F,
  0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F,
  0xC3, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xF8, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0,
  0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xFC, 0x0F,
  0xE0, 0x07, 0xF1, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFD, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC1,
  0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF8, 0x3F, 0x80, 0x1F, 0x81, 0xFE, 0x01, 0xFC, 0x07, 0xFC, 0x7F, 0xC0,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xE3, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1,
  0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF9, 0xF8, 0x00,
  0x7F, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0x1F,
  0xC0, 0x1F, 0xE1, 0xF8, 0x07, 0xFC, 0x3F, 0x81, 0xFF, 0x87, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xDF, 0x80, 0xFF, 0xF3, 0xF0, 0x07,
  0xF8, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x01,
  0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x1F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0,
  0xFC, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xF8, 0x1F, 0xC0, 0xFC, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x1F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x7C, 0x07, 0xF0, 0xC0, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0xFF, 0xC0,
  0x7C, 0x0F, 0x80, 0x7F, 0xFE, 0x07, 0x83, 0xE0, 0x1F, 0xFF, 0xC0, 0xF0,
  0x7C, 0x07, 0xFF, 0xF8, 0x1F, 0x1F, 0x01, 0xF8, 0x1F, 0x03, 0xE3, 0xE0,
  0x7E, 0x07, 0xC0, 0x7C, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x9F, 0x03, 0xE0,
  0x1F, 0x01, 0xE3, 0xE0, 0x7C, 0x03, 0xE0, 0x3C, 0x78, 0x1F, 0x00, 0xF8,
  0x07, 0x9F, 0x03, 0xE0, 0x1F, 0x01, 0xF3, 0xE0, 0x78, 0x03, 0xE0, 0x3E,
  0x7C, 0x1F, 0x00, 0x7C, 0x07, 0x8F, 0x03, 0xE0, 0x1F, 0x00, 0xF1, 0xE0,
  0x7C, 0x03, 0xE0, 0x3E, 0x3C, 0x0F, 0x80, 0x7C, 0x07, 0xCF, 0x81, 0xF0,
  0x1F, 0x81, 0xF1, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x3E, 0x07, 0xC0, 0xFC,
  0x0F, 0x87, 0xC0, 0xF8, 0x3F, 0xC3, 0xE0, 0x78, 0x1F, 0xFF, 0x7F, 0xFC,
  0x0F, 0x01, 0xFF, 0xCF, 0xFF, 0x01, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3E,
  0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xC0, 0x0C, 0x00, 0x60, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x60, 0x00, 0x03, 0xFE, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFC, 0x0F,
  0xFE, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0xFE, 0x03, 0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF0, 0x0F,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x3F,
  0xE0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x03,
  0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03,
  0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x3F, 0xE0, 0x3F, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xC0, 0x7C, 0x00, 0xFF, 0x00, 0x08, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0x00, 0x3F, 0xE0, 0x0E,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x1F, 0xF0, 0x03, 0xF0, 0x03, 0xFC, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x03, 0xF8,
  0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07,
  0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0xC0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x01,
  0xFE, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0x00,
  0xFF, 0xC0, 0x0F, 0xC3, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x20, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xC0, 0x0F, 0xF8, 0x00, 0x70, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFE, 0x1F, 0x80, 0x0F,
  0xFF, 0x87, 0xE0, 0x03, 0xFF, 0xE1, 0xF8, 0x01, 0xFF, 0xF8, 0x7E, 0x00,
  0x7F, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8,
  0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x3F, 0xC0, 0x03, 0xF0, 0x07, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x3F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xF0, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0x1F, 0x8F, 0xF0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFB, 0xF8, 0x00, 0x01, 0xFC, 0x3F,
  0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xFC,
  0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xF0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x17, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x00, 0xFB, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xF7, 0xC0, 0x0F, 0xBF, 0x00,
  0x07, 0xDF, 0x80, 0x1F, 0x3E, 0x00, 0x1F, 0xBF, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7E, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF0, 0x01,
  0xF1, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x8F, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x7C,
  0x3F, 0x00, 0x7E, 0x3E, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7C, 0x03, 0xE1,
  0xF8, 0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x1F, 0x07,
  0xE0, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0xF8, 0x3F,
  0x00, 0x3F, 0x07, 0xC3, 0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0x87, 0xC0, 0xFC,
  0x01, 0xF8, 0x1F, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3E, 0x3E, 0x03, 0xE0,
  0x07, 0xE0, 0x7C, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0xF9, 0xF0, 0x1F, 0x80,
  0x1F, 0x01, 0xF7, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xEF, 0x80, 0x7E, 0x00,
  0xFC, 0x07, 0xFF, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xFC, 0x03, 0xF0, 0x03,
  0xE0, 0x0F, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0xFF,
  0x00, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xF0, 0x03, 0xFC, 0x00, 0x07,
  0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0x80, 0x3F,
  0xF0, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x01,
  0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xE0, 0x0F,
  0x9F, 0x80, 0x0F, 0x80, 0x1F, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x03,
  0xF1, 0xF8, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x0F, 0xC0, 0x1F, 0x83, 0xF0,
  0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x7C, 0x00,
  0xFC, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x3F,
  0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x1F, 0x00,
  0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x01,
  0xF9, 0xF8, 0x03, 0xF0, 0x03, 0xF3, 0xF0, 0x07, 0xE0, 0x07, 0xE7, 0xC0,
  0x0F, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x00, 0x0F, 0xFF, 0x00, 0x7E, 0x00,
  0x1F, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0xF0,
  0x03, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0x80,
  0x00, 0xFF, 0x80, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0xFC,
  0x00, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF1, 0xFC,
  0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x0F, 0xCF,
  0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F,
  0x7F, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x01,
  0xFD, 0xF8, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF8,
  0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0x00, 0xFF, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x03, 0xF8,
  0x01, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80,
  0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0x7E, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x00, 0x3F, 0xC0, 0x7E, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF1, 0xFC, 0x00,
  0x00, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x3F, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x03, 0xF8, 0x7E, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x0F,
  0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0x83, 0xFF, 0x80,
  0x3F, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x03,
  0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x1F,
  0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0xFE, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0xE0, 0x3F, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0,
  0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x1F, 0x80,
  0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF8, 0x07,
  0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x81, 0xF8, 0x07, 0xF8, 0x01,
  0x80, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC1, 0x00, 0x00, 0xFE, 0x06, 0x00, 0x0F,
  0xE0, 0x7C, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0xC0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x7E, 0x1F,
  0x80, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0,
  0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x01, 0xFC, 0x00, 0xF8, 0x03,
  0xF0, 0x01, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x7F,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x0F, 0x9F, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFB, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xCF, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x3F, 0x00,
  0x0F, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0xE0, 0x03, 0xF8, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xC3, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x1F,
  0x7C, 0x01, 0xFC, 0x1F, 0x80, 0x3E, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xF9,
  0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xF3, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE7,
  0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0x8F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x1F,
  0x01, 0xF8, 0x07, 0xE0, 0x7C, 0x3E, 0x07, 0xF0, 0x0F, 0xC0, 0xF8, 0x7C,
  0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xC1, 0xF0,
  0x7E, 0x00, 0x7E, 0x1F, 0x83, 0xE0, 0xFC, 0x00, 0xFC, 0x3E, 0x07, 0xC3,
  0xF0, 0x01, 0xF8, 0xFC, 0x0F, 0x87, 0xE0, 0x03, 0xF1, 0xF0, 0x1F, 0x0F,
  0x80, 0x07, 0xE7, 0xE0, 0x3E, 0x3F, 0x00, 0x0F, 0xCF, 0x80, 0x7C, 0x7E,
  0x00, 0x1F, 0x9F, 0x00, 0xF9, 0xF8, 0x00, 0x3F, 0x7E, 0x01, 0xF3, 0xF0,
  0x00, 0x7E, 0xF8, 0x03, 0xE7, 0xC0, 0x00, 0xFD, 0xF0, 0x03, 0xDF, 0x80,
  0x01, 0xFF, 0xC0, 0x07, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x0F, 0x7C, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x7F, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x7E, 0x3F, 0x80,
  0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xFB, 0xF0,
  0x00, 0x3F, 0x9F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x3F,
  0x03, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x1F,
  0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x00, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E,
  0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x1F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF8,
  0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x01, 0xF0,
  0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0xF8,
  0x00, 0x7C, 0x1F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0x87, 0xE1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x07, 0xC0, 0x3F, 0xFC, 0x7C, 0x03, 0xFF,
  0xF3, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFE, 0x3F, 0xF8, 0x1F, 0xC0, 0x7F,
  0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x0F,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0x80, 0x7F,
  0x80, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0xFB, 0xE0, 0x1F, 0xFF, 0xBF, 0x00,
  0xFF, 0xF9, 0xF0, 0x03, 0xFF, 0x8F, 0x80, 0x0F, 0xF0, 0x7C, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF0, 0xFF, 0x80, 0x3F, 0x3F, 0xFC, 0x03,
  0xF7, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xEF, 0x0F, 0xF0, 0x3F, 0xE0,
  0x7F, 0x07, 0xFC, 0x03, 0xF0, 0x7F, 0x80, 0x3F, 0x07, 0xF0, 0x03, 0xF0,
  0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F,
  0x1F, 0x80, 0x07, 0xF1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8,
  0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0xC3, 0xF8, 0x01, 0xF8, 0x7F, 0x80, 0x3F, 0x87, 0xF8, 0x07, 0xF0, 0x7F,
  0xC0, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7D, 0xFF, 0xFC, 0x0F, 0xCF, 0xFF,
  0x80, 0xF8, 0xFF, 0xF0, 0x0F, 0x83, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x03, 0xFC, 0x1C, 0x07, 0xF0, 0x04, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x60,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x3F, 0xE1, 0xF8, 0x00, 0xFF, 0xF3, 0xF0, 0x01, 0xFF,
  0xFB, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x07, 0xF0,
  0x1F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x1F, 0x80, 0xFE, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0x7F, 0x07,
  0xFE, 0x00, 0x7F, 0xDF, 0xBE, 0x00, 0x3F, 0xFF, 0x7E, 0x00, 0x3F, 0xFE,
  0x7C, 0x00, 0x1F, 0xFC, 0x7C, 0x00, 0x0F, 0xF8, 0x7C, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0x7E,
  0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F,
  0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xF1, 0xF8, 0x0F, 0xF1, 0xF9, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x02, 0x0F, 0xE0, 0x06, 0x03, 0xFE, 0x1F, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0x86, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x10, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x7C, 0x00, 0xFF, 0xF9,
  0xF0, 0x03, 0xFF, 0xF3, 0xE0, 0x0F, 0xFF, 0xF7, 0xC0, 0x3F, 0xE3, 0xFF,
  0x80, 0x7F, 0x01, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8,
  0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x0F,
  0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xE0,
  0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0x80,
  0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0x80, 0x7E, 0x03, 0xFE, 0x00, 0xFE, 0x0F,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFB, 0xF0, 0x03, 0xFF, 0xE7,
  0xC0, 0x03, 0xFF, 0x9F, 0x80, 0x03, 0xFC, 0x3F, 0x00, 0x00, 0x40, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x80, 0x01, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF0, 0xFF, 0x80, 0x3F, 0x3F, 0xFC,
  0x03, 0xF7, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xEF, 0x8F, 0xF0, 0x3F,
  0xE0, 0x7F, 0x07, 0xFC, 0x03, 0xF0, 0x7F, 0x80, 0x3F, 0x07, 0xF0, 0x03,
  0xF0, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x00,
  0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x18, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0xFE,
  0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0x7F, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8,
  0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x01, 0xFC, 0x0F, 0xC0,
  0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x10, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x0F, 0xF8, 0x0F,
  0xF8, 0x03, 0xE3, 0xFF, 0xC3, 0xFF, 0xC0, 0x3E, 0x7F, 0xFC, 0x7F, 0xFE,
  0x03, 0xEF, 0xFF, 0xEF, 0xFF, 0xE0, 0x3F, 0xF0, 0xFE, 0xF8, 0xFF, 0x07,
  0xFE, 0x07, 0xFE, 0x07, 0xF0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0x07, 0xF8,
  0x07, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC1,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0,
  0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0x03,
  0xF8, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0xFC,
  0x00, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x0F, 0xFC, 0x03,
  0xE3, 0xFF, 0xE0, 0x3E, 0x7F, 0xFE, 0x03, 0xEF, 0xFF, 0xF0, 0x3F, 0xF8,
  0xFF, 0x07, 0xFE, 0x07, 0xF0, 0x7F, 0xC0, 0x3F, 0x07, 0xF8, 0x03, 0xF0,
  0x7F, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x7E,
  0x1F, 0xC0, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8,
  0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x1F,
  0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xF8, 0xFF, 0x01, 0xFC, 0x07, 0xF0,
  0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00,
  0x3F, 0x9F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF,
  0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01,
  0xFB, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xF9, 0xF8,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x7F,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x3F, 0xE0, 0x01, 0xF1, 0xFF, 0xE0, 0x03, 0xE7, 0xFF, 0xE0, 0x07,
  0xDF, 0xFF, 0xC0, 0x0F, 0xBC, 0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0x80, 0x7F,
  0xC0, 0x3F, 0x00, 0xFF, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8,
  0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x7E, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07,
  0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7E,
  0x03, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xF7, 0xFF, 0xF0, 0x07, 0xE7, 0xFF, 0xC0, 0x0F, 0xC7, 0xFF, 0x00, 0x1F,
  0x87, 0xF8, 0x00, 0x3F, 0x01, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFF, 0x87, 0xC0, 0x3F, 0xFE, 0x7C, 0x03, 0xFF, 0xF3,
  0xE0, 0x3F, 0xFF, 0xDF, 0x03, 0xFE, 0x3F, 0xF8, 0x1F, 0xC0, 0x7F, 0xC1,
  0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xE0,
  0x03, 0xF8, 0x7F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07,
  0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0,
  0x03, 0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F,
  0xE0, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0x80, 0x7F, 0x80,
  0xFE, 0x0F, 0xFC, 0x07, 0xFD, 0xFF, 0xE0, 0x3F, 0xFF, 0xBF, 0x00, 0xFF,
  0xF9, 0xF0, 0x03, 0xFF, 0x9F, 0x80, 0x0F, 0xF0, 0xFC, 0x00, 0x0E, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x03, 0xE3, 0xFC, 0x0F, 0x8F, 0xF8, 0x1F, 0x3F,
  0xE0, 0x3E, 0xFF, 0xC0, 0x7D, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0xF0, 0x3C, 0x0F, 0xE0, 0x04, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x80, 0x07, 0xF0, 0xE0, 0x0F, 0xF0,
  0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xFD, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x02, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0xFC,
  0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC3, 0xF0,
  0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F,
  0x83, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0, 0x7E,
  0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x07,
  0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F,
  0xC0, 0x1F, 0xE0, 0xFC, 0x03, 0xFC, 0x0F, 0xC0, 0x7F, 0xC0, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0xFC, 0x07, 0xFF, 0xCF, 0x80,
  0x7F, 0xF8, 0xF8, 0x01, 0xFE, 0x0F, 0x80, 0x03, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0xFC,
  0x7C, 0x00, 0x7F, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x0F, 0xE1, 0xF8, 0x03,
  0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01,
  0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF8,
  0x00, 0xF8, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xE7,
  0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFC, 0x01, 0xFB, 0xE0, 0x07, 0xF8, 0x03, 0xF7, 0xC0, 0x1F,
  0xF0, 0x0F, 0xEF, 0x80, 0x3F, 0xE0, 0x1F, 0x9F, 0x00, 0xFF, 0xC0, 0x3F,
  0x3E, 0x01, 0xFF, 0x80, 0xFC, 0x7C, 0x03, 0xDF, 0x01, 0xF8, 0xF8, 0x0F,
  0xBE, 0x07, 0xE1, 0xF0, 0x1F, 0x7C, 0x0F, 0xC3, 0xE0, 0x7C, 0xF8, 0x1F,
  0x07, 0xC0, 0xF9, 0xF0, 0x7E, 0x0F, 0x83, 0xE3, 0xE0, 0xFC, 0x1F, 0x07,
  0xC7, 0xC3, 0xF0, 0x3E, 0x0F, 0x8F, 0x87, 0xE0, 0x7C, 0x3E, 0x1F, 0x1F,
  0x80, 0xF8, 0x7C, 0x3E, 0x3F, 0x01, 0xF1, 0xF0, 0x7C, 0x7C, 0x03, 0xE3,
  0xE0, 0xF9, 0xF8, 0x07, 0xCF, 0x81, 0xF3, 0xF0, 0x0F, 0x9F, 0x03, 0xEF,
  0xC0, 0x1F, 0x3E, 0x07, 0xDF, 0x80, 0x3E, 0xF8, 0x0F, 0xBE, 0x00, 0x7D,
  0xF0, 0x1F, 0xFC, 0x00, 0xFB, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F, 0xBF, 0x80, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F,
  0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0xFF,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x07, 0xE0,
  0x07, 0xC0, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x0F,
  0x81, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x27, 0xFF, 0x80, 0x0D,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xB0, 0x01, 0xFF, 0xE4, 0x00, 0x07, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 16, 44, 15, 1, -43 },
  { 89, 19, 16, 23, 6, -43 },
  { 127, 34, 43, 34, 1, -43 },
  { 310, 28, 49, 30, 1, -46 },
  { 482, 39, 44, 45, 4, -43 },
  { 697, 34, 45, 36, 1, -44 },
  { 889, 9, 16, 13, 6, -43 },
  { 907, 20, 52, 17, 2, -43 },
  { 1037, 20, 52, 17, -5, -43 },
  { 1167, 24, 26, 29, 6, -46 },
  { 1245, 27, 29, 31, 3, -36 },
  { 1343, 12, 15, 15, -3, -7 },
  { 1366, 15, 6, 18, 1, -19 },
  { 1378, 8, 9, 15, 1, -8 },
  { 1387, 30, 43, 22, -3, -43 },
  { 1549, 27, 45, 30, 2, -44 },
  { 1701, 19, 43, 30, 7, -43 },
  { 1804, 30, 43, 30, -1, -43 },
  { 1966, 29, 44, 30, 0, -43 },
  { 2126, 29, 43, 30, 0, -43 },
  { 2282, 29, 44, 30, 1, -43 },
  { 2442, 27, 44, 30, 3, -43 },
  { 2591, 29, 43, 30, 3, -43 },
  { 2747, 29, 45, 30, 1, -44 },
  { 2911, 27, 44, 30, 2, -43 },
  { 3060, 13, 34, 15, 1, -33 },
  { 3116, 17, 41, 15, -3, -33 },
  { 3204, 27, 29, 31, 3, -36 },
  { 3302, 27, 17, 31, 3, -30 },
  { 3360, 27, 29, 31, 3, -36 },
  { 3458, 22, 44, 23, 3, -43 },
  { 3579, 43, 48, 46, 2, -43 },
  { 3837, 32, 43, 31, -4, -43 },
  { 4009, 32, 43, 33, 1, -43 },
  { 4181, 32, 44, 31, 3, -43 },
  { 4357, 34, 43, 36, 1, -43 },
  { 4540, 30, 43, 28, 1, -43 },
  { 4702, 30, 43, 27, 1, -43 },
  { 4864, 34, 44, 37, 3, -43 },
  { 5051, 37, 43, 37, 1, -43 },
  { 5250, 25, 43, 19, -2, -43 },
  { 5385, 26, 55, 16, -9, -43 },
  { 5564, 35, 43, 31, 1, -43 },
  { 5753, 22, 43, 26, 1, -43 },
  { 5872, 47, 43, 47, 1, -43 },
  { 6125, 39, 43, 39, 1, -43 },
  { 6335, 34, 45, 39, 3, -44 },
  { 6527, 31, 43, 31, 1, -43 },
  { 6694, 34, 54, 39, 3, -44 },
  { 6924, 31, 43, 32, 1, -43 },
  { 7091, 29, 44, 28, 0, -43 },
  { 7251, 27, 43, 27, 5, -43 },
  { 7397, 34, 44, 37, 4, -43 },
  { 7584, 31, 43, 31, 5, -43 },
  { 7751, 47, 43, 48, 6, -43 },
  { 8004, 37, 43, 30, -3, -43 },
  { 8203, 29, 43, 28, 5, -43 },
  { 8359, 33, 43, 28, -2, -43 },
  { 8537, 23, 53, 18, -1, -43 },
  { 8690, 12, 43, 22, 6, -43 },
  { 8755, 23, 53, 18, -4, -43 },
  { 8908, 28, 26, 30, 1, -43 },
  { 8999, 22, 4, 22, -5, 5 },
  { 9010, 10, 10, 17, 9, -46 },
  { 9023, 29, 34, 31, 2, -33 },
  { 9147, 28, 47, 32, 1, -46 },
  { 9312, 24, 34, 25, 2, -33 },
  { 9414, 32, 47, 32, 2, -46 },
  { 9602, 25, 34, 28, 2, -33 },
  { 9709, 32, 60, 18, -7, -46 },
  { 9949, 31, 47, 32, 0, -33 },
  { 10132, 28, 46, 32, 1, -46 },
  { 10293, 15, 45, 15, 1, -45 },
  { 10378, 24, 59, 15, -8, -45 },
  { 10555, 29, 46, 28, 1, -46 },
  { 10722, 16, 46, 15, 1, -46 },
  { 10814, 44, 33, 47, 1, -33 },
  { 10996, 28, 33, 32, 1, -33 },
  { 11112, 27, 34, 31, 2, -33 },
  { 11227, 31, 47, 32, -2, -33 },
  { 11410, 29, 47, 32, 2, -33 },
  { 11581, 23, 33, 22, 1, -33 },
  { 11676, 24, 34, 24, 0, -33 },
  { 11778, 18, 41, 19, 3, -40 },
  { 11871, 28, 33, 32, 3, -32 },
  { 11987, 26, 32, 26, 3, -32 },
  { 12091, 39, 32, 41, 4, -32 },
  { 12247, 32, 32, 27, -3, -32 },
  { 12375, 34, 46, 26, -5, -32 },
  { 12571, 25, 32, 24, -1, -32 },
  { 12671, 23, 52, 21, 1, -43 },
  { 12821, 4, 60, 29, 13, -46 },
  { 12851, 23, 52, 21, -3, -43 },
  { 13001, 27, 8, 31, 3, -25 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic60pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC60PT7B_H_
