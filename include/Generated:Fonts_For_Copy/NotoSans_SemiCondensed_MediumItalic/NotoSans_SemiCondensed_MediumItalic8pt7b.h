#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC8PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x20, 0xF0, 0x31, 0x9E, 0xAE, 0x50, 0x27, 0x42, 0x6C, 0xD6,
  0xBD, 0xD6, 0xD8, 0x32, 0x98, 0xDB, 0x78, 0xC0, 0x29, 0x49, 0x20, 0x24,
  0x92, 0xB0, 0x5F, 0x00, 0x22, 0xF2, 0xC0, 0xC0, 0x80, 0x12, 0x44, 0x88,
  0x25, 0x99, 0xA6, 0x75, 0x60, 0x61, 0x12, 0x4E, 0x61, 0x16, 0x2E, 0x13,
  0x5A, 0xF2, 0x74, 0x61, 0x1E, 0x34, 0x69, 0x96, 0x71, 0x22, 0x4C, 0x35,
  0x56, 0x9E, 0x65, 0x97, 0x2E, 0x42, 0x42, 0x80, 0x16, 0xC3, 0xFF, 0x86,
  0x3C, 0x64, 0xA1, 0x80, 0x39, 0x1B, 0xED, 0xBA, 0x07, 0x00, 0x22, 0x57,
  0x99, 0x75, 0x57, 0x9E, 0x3A, 0x11, 0x08, 0x38, 0x72, 0x52, 0x99, 0x70,
  0x74, 0x46, 0x8E, 0x74, 0x46, 0x88, 0x3A, 0x11, 0x39, 0x38, 0x4A, 0x52,
  0xE9, 0x48, 0x69, 0x25, 0x80, 0x24, 0x94, 0x94, 0x4A, 0x98, 0xCA, 0x48,
  0x49, 0x29, 0xC0, 0x65, 0x96, 0xDD, 0xB6, 0xA0, 0x4B, 0x5A, 0xD9, 0x48,
  0x32, 0x53, 0x18, 0xB8, 0x75, 0x56, 0x88, 0x32, 0x53, 0x18, 0xB8, 0x40,
  0x75, 0x56, 0xA9, 0x74, 0x42, 0x2E, 0xE9, 0x49, 0x00, 0x4A, 0x52, 0xA9,
  0x38, 0x9A, 0xAC, 0xC8, 0xA6, 0x9E, 0xBA, 0x92, 0x40, 0x5A, 0x88, 0xC6,
  0x50, 0xB7, 0x49, 0x00, 0x71, 0x24, 0x4E, 0x69, 0x29, 0x30, 0xFC, 0x32,
  0x22, 0x22, 0xC0, 0x26, 0x59, 0xE0, 0xC0, 0x79, 0x9E, 0x46, 0x55, 0x9E,
  0x72, 0x30, 0x13, 0x59, 0x9E, 0x7E, 0x86, 0x12, 0x72, 0x44, 0x4C, 0x79,
  0x9E, 0x2E, 0x46, 0x55, 0x9A, 0x45, 0xA0, 0x20, 0x94, 0x94, 0x45, 0x64,
  0xAA, 0x55, 0xA0, 0x7D, 0x59, 0x69, 0x75, 0x9A, 0x79, 0x96, 0x75, 0x9E,
  0x88, 0x79, 0x9E, 0x22, 0x6A, 0x40, 0xE8, 0xE0, 0x5D, 0x4C, 0x55, 0x9E,
  0x9A, 0x44, 0xB6, 0xE5, 0x94, 0x74, 0x4A, 0x4A, 0x88, 0x42, 0x60, 0x69,
  0x70, 0x29, 0x64, 0xB0, 0xFF, 0x49, 0x35, 0x20, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 3, 1, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 6, 4, 0, -6 },
  { 11, 5, 6, 6, 1, -6 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 1, 2, 2, 1, -6 },
  { 20, 3, 7, 2, 0, -6 },
  { 23, 3, 7, 2, -1, -6 },
  { 26, 3, 3, 4, 1, -6 },
  { 28, 4, 4, 4, 0, -5 },
  { 30, 1, 2, 2, 0, -1 },
  { 31, 2, 1, 2, 0, -3 },
  { 32, 1, 1, 2, 0, -1 },
  { 33, 4, 6, 3, 0, -6 },
  { 36, 4, 6, 4, 0, -6 },
  { 39, 2, 6, 4, 1, -6 },
  { 41, 4, 6, 4, 0, -6 },
  { 44, 4, 6, 4, 0, -6 },
  { 47, 4, 6, 4, 0, -6 },
  { 50, 4, 6, 4, 0, -6 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 4, 6, 4, 0, -6 },
  { 62, 4, 6, 4, 0, -6 },
  { 65, 2, 4, 2, 0, -4 },
  { 66, 2, 5, 2, 0, -4 },
  { 68, 4, 4, 4, 0, -5 },
  { 70, 4, 2, 4, 0, -4 },
  { 71, 4, 4, 4, 0, -5 },
  { 73, 3, 6, 3, 0, -6 },
  { 76, 6, 7, 6, 0, -6 },
  { 82, 4, 6, 4, 0, -6 },
  { 85, 4, 6, 4, 0, -6 },
  { 88, 5, 6, 4, 0, -6 },
  { 92, 5, 6, 5, 0, -6 },
  { 96, 4, 6, 4, 0, -6 },
  { 99, 4, 6, 4, 0, -6 },
  { 102, 5, 6, 5, 0, -6 },
  { 106, 5, 6, 5, 0, -6 },
  { 110, 3, 6, 3, 0, -6 },
  { 113, 3, 8, 2, -1, -6 },
  { 116, 5, 6, 4, 0, -6 },
  { 120, 3, 6, 4, 0, -6 },
  { 123, 6, 6, 6, 0, -6 },
  { 128, 5, 6, 5, 0, -6 },
  { 132, 5, 6, 5, 0, -6 },
  { 136, 4, 6, 4, 0, -6 },
  { 139, 5, 7, 5, 0, -6 },
  { 144, 4, 6, 4, 0, -6 },
  { 147, 4, 6, 4, 0, -6 },
  { 150, 3, 6, 4, 1, -6 },
  { 153, 5, 6, 5, 0, -6 },
  { 157, 4, 6, 4, 1, -6 },
  { 160, 6, 6, 6, 1, -6 },
  { 165, 5, 6, 4, 0, -6 },
  { 169, 3, 6, 4, 1, -6 },
  { 172, 4, 6, 4, 0, -6 },
  { 175, 3, 7, 2, 0, -6 },
  { 178, 1, 6, 3, 1, -6 },
  { 179, 4, 7, 2, -1, -6 },
  { 183, 4, 4, 4, 0, -6 },
  { 185, 3, 1, 3, -1, 0 },
  { 186, 2, 1, 2, 1, -6 },
  { 187, 4, 4, 4, 0, -4 },
  { 189, 4, 6, 4, 0, -6 },
  { 192, 3, 4, 3, 0, -4 },
  { 194, 4, 6, 4, 0, -6 },
  { 197, 4, 4, 4, 0, -4 },
  { 199, 4, 8, 2, -1, -6 },
  { 203, 4, 6, 4, 0, -4 },
  { 206, 4, 6, 4, 0, -6 },
  { 209, 2, 6, 2, 0, -6 },
  { 211, 3, 8, 2, -1, -6 },
  { 214, 4, 6, 4, 0, -6 },
  { 217, 2, 6, 2, 0, -6 },
  { 219, 6, 4, 6, 0, -4 },
  { 222, 4, 4, 4, 0, -4 },
  { 224, 4, 4, 4, 0, -4 },
  { 226, 4, 6, 4, 0, -4 },
  { 229, 4, 6, 4, 0, -4 },
  { 232, 3, 4, 3, 0, -4 },
  { 234, 3, 4, 3, 0, -4 },
  { 236, 3, 5, 3, 0, -5 },
  { 238, 4, 4, 4, 0, -4 },
  { 240, 4, 4, 3, 0, -4 },
  { 242, 6, 4, 5, 0, -4 },
  { 245, 4, 4, 4, 0, -4 },
  { 247, 5, 6, 4, -1, -4 },
  { 251, 3, 4, 3, 0, -4 },
  { 253, 3, 7, 3, 0, -6 },
  { 256, 1, 8, 4, 2, -6 },
  { 257, 3, 7, 3, 0, -6 },
  { 260, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC8PT7B_H_
