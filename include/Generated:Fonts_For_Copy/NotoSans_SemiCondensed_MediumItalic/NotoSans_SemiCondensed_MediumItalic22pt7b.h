#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC22PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC6, 0x18, 0x63, 0x8C, 0x30, 0xC3, 0x00, 0x01, 0x8E,
  0x38, 0x66, 0xCD, 0x9A, 0x6C, 0xD9, 0x80, 0x03, 0x30, 0x11, 0x01, 0x88,
  0x0C, 0xC0, 0x46, 0x1F, 0xFC, 0x33, 0x01, 0x98, 0x08, 0x80, 0xCC, 0xBF,
  0xF8, 0x23, 0x03, 0x10, 0x19, 0x80, 0x8C, 0x0C, 0xC0, 0x01, 0x00, 0x20,
  0x1F, 0x0F, 0xF1, 0xA4, 0x64, 0x0C, 0x80, 0xD0, 0x1E, 0x00, 0xF0, 0x16,
  0x02, 0xC0, 0xD9, 0x13, 0x3F, 0xC3, 0xF0, 0x08, 0x03, 0x00, 0x1C, 0x0C,
  0x7C, 0x31, 0x98, 0xC3, 0x31, 0x84, 0x66, 0x08, 0xD8, 0x31, 0x36, 0x66,
  0xDE, 0x7B, 0x66, 0xE6, 0xCC, 0x1B, 0x18, 0x66, 0x20, 0xCC, 0xC3, 0x19,
  0x8C, 0x36, 0x38, 0x38, 0x07, 0x80, 0x7E, 0x03, 0x38, 0x39, 0x81, 0x8C,
  0x06, 0xE0, 0x3E, 0x01, 0xC0, 0x3E, 0x1B, 0xB9, 0x98, 0xCC, 0xC3, 0xCE,
  0x1C, 0x70, 0xE1, 0xFF, 0x87, 0xCE, 0x6D, 0xBD, 0x80, 0x06, 0x18, 0x61,
  0xC3, 0x0E, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x81, 0x80, 0x0C, 0x06, 0x06, 0x06, 0x06, 0x03, 0x03, 0x03, 0x06, 0x06,
  0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0xE0, 0x0C, 0x06, 0x23,
  0x1D, 0x87, 0xF8, 0xFC, 0xD0, 0xCC, 0x26, 0x02, 0x00, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x33,
  0x76, 0x6C, 0x7F, 0xF0, 0x7F, 0x80, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0,
  0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00,
  0xE0, 0x18, 0x06, 0x00, 0x0F, 0x07, 0xE3, 0x98, 0xC7, 0x70, 0xD8, 0x76,
  0x1F, 0x87, 0xC1, 0xB0, 0x6C, 0x1B, 0x0E, 0xC3, 0x31, 0xCF, 0xE1, 0xF0,
  0x0C, 0x77, 0xFB, 0xD8, 0x61, 0x86, 0x38, 0xC3, 0x0C, 0x31, 0xC6, 0x18,
  0x07, 0x83, 0xF8, 0x63, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xE7, 0xFC, 0x0F, 0x83,
  0xF8, 0x43, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x60, 0xF8, 0x1F, 0x00, 0x30,
  0x06, 0x00, 0xC0, 0x19, 0x07, 0x3F, 0xC7, 0xF0, 0x00, 0xE0, 0x38, 0x07,
  0x01, 0xE0, 0x6C, 0x1B, 0x87, 0x60, 0xCC, 0x31, 0x8C, 0x33, 0x0E, 0x7F,
  0xEF, 0xFC, 0x06, 0x00, 0xC0, 0x30, 0x0F, 0xE1, 0xFC, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x0F, 0x81, 0xFC, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x19,
  0x07, 0x3F, 0xC7, 0xF0, 0x03, 0xC3, 0xF1, 0xC0, 0xE0, 0x30, 0x18, 0x06,
  0xF1, 0xFE, 0xE3, 0xB8, 0x6C, 0x1B, 0x06, 0xC3, 0xB8, 0xC7, 0xE1, 0xF0,
  0x3F, 0xEF, 0xF8, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0E,
  0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x07, 0x00, 0x07, 0x81,
  0xF8, 0x63, 0x8C, 0x31, 0x86, 0x31, 0x87, 0x70, 0x78, 0x1F, 0x06, 0x31,
  0x87, 0x30, 0xEE, 0x1C, 0xC3, 0x1F, 0xE1, 0xF8, 0x0F, 0x0F, 0xE3, 0x19,
  0x86, 0x61, 0xD8, 0x76, 0x19, 0x8E, 0x7F, 0x8F, 0x60, 0x38, 0x0C, 0x07,
  0x03, 0x8F, 0xC3, 0xE0, 0x19, 0xCE, 0x00, 0x00, 0x00, 0x03, 0x39, 0xC0,
  0x0C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x18, 0x63, 0x0C, 0x00,
  0x00, 0xC0, 0xF0, 0xF0, 0xF0, 0x70, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x30, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x70, 0x78, 0xF0, 0xF0, 0x30, 0x00, 0x3E, 0x7F,
  0x43, 0x03, 0x03, 0x07, 0x0E, 0x1C, 0x38, 0x30, 0x60, 0x00, 0x00, 0x60,
  0xE0, 0xE0, 0x01, 0xE0, 0x0F, 0xF0, 0x30, 0x30, 0xC0, 0x33, 0x08, 0x6C,
  0x7E, 0x59, 0x98, 0xE2, 0x31, 0xCC, 0x67, 0x98, 0x8F, 0x23, 0x1E, 0x66,
  0x6C, 0xF7, 0x98, 0xC6, 0x10, 0x00, 0x30, 0x00, 0x3F, 0xC0, 0x1F, 0x00,
  0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x6C, 0x0D, 0x83, 0x98, 0x63, 0x1C,
  0x63, 0xFC, 0xFF, 0x98, 0x37, 0x06, 0xC0, 0xF8, 0x1E, 0x03, 0x0F, 0x80,
  0xFE, 0x1C, 0x71, 0x83, 0x18, 0x31, 0x87, 0x18, 0xE3, 0xFC, 0x3F, 0xC3,
  0x0E, 0x30, 0xE7, 0x0E, 0x60, 0xE6, 0x1C, 0x7F, 0x8F, 0xF0, 0x03, 0xE0,
  0xFF, 0x1C, 0x23, 0x80, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x7F, 0x83, 0xF8, 0x0F, 0x80,
  0x7F, 0x07, 0x3C, 0x30, 0x61, 0x83, 0x8C, 0x1C, 0x60, 0xE7, 0x07, 0x30,
  0x31, 0x81, 0x8C, 0x1C, 0xE0, 0xC7, 0x0E, 0x30, 0xE1, 0xFE, 0x1F, 0xC0,
  0x0F, 0xE1, 0xFC, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xFC, 0x3F,
  0x86, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x1F, 0xC7, 0xF8, 0x0F, 0xE1,
  0xFC, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xFC, 0x3F, 0x86, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0x03, 0xE0, 0x7F, 0xC7,
  0x04, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x02, 0xE1, 0xE7, 0x13,
  0x38, 0x19, 0xC1, 0xCE, 0x0E, 0x38, 0x61, 0xFF, 0x03, 0xF8, 0x0C, 0x0C,
  0x30, 0x71, 0xC1, 0x86, 0x06, 0x18, 0x18, 0x60, 0xE1, 0x83, 0x8F, 0xFC,
  0x3F, 0xF0, 0xC0, 0xC3, 0x07, 0x1C, 0x18, 0x70, 0x61, 0x81, 0x86, 0x06,
  0x38, 0x38, 0x0F, 0x8F, 0xC1, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C,
  0x0E, 0x06, 0x03, 0x01, 0x80, 0xC1, 0xE1, 0xF8, 0x01, 0x80, 0xC0, 0xE0,
  0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60,
  0x30, 0x18, 0x1C, 0x0C, 0x3E, 0x1E, 0x00, 0x0C, 0x18, 0x61, 0x87, 0x1C,
  0x31, 0xC1, 0x9C, 0x0D, 0xC0, 0x6C, 0x07, 0xC0, 0x3F, 0x01, 0xD8, 0x0C,
  0xC0, 0xE7, 0x06, 0x18, 0x30, 0xC1, 0x87, 0x1C, 0x18, 0x0C, 0x0C, 0x1C,
  0x18, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x7F,
  0xFF, 0x0E, 0x03, 0x87, 0x01, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF8,
  0xF0, 0x78, 0x78, 0x6C, 0x64, 0x36, 0x33, 0x33, 0x19, 0x9B, 0x8C, 0xD9,
  0x8E, 0x6C, 0xC6, 0x3C, 0x63, 0x1E, 0x31, 0x8E, 0x31, 0xC6, 0x18, 0x0C,
  0x0E, 0x1C, 0x18, 0x78, 0x30, 0xF0, 0x61, 0xF0, 0xC3, 0x63, 0x0E, 0xC6,
  0x19, 0x8C, 0x31, 0x98, 0x63, 0x30, 0xC6, 0xC3, 0x8F, 0x86, 0x0F, 0x0C,
  0x1E, 0x18, 0x3C, 0x70, 0x30, 0x07, 0xC0, 0x7F, 0x07, 0x1C, 0x70, 0x63,
  0x03, 0xB8, 0x1D, 0x80, 0xEC, 0x07, 0xE0, 0x37, 0x01, 0xB8, 0x1D, 0xC0,
  0xEE, 0x0E, 0x38, 0xE1, 0xFE, 0x07, 0xE0, 0x0F, 0x80, 0xFE, 0x1C, 0xE1,
  0x87, 0x18, 0x71, 0x87, 0x18, 0x63, 0x8E, 0x3F, 0xC3, 0xF0, 0x30, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x07, 0xC0, 0x7F, 0x07, 0x1C,
  0x70, 0x63, 0x03, 0xB8, 0x1D, 0x80, 0xEC, 0x07, 0xE0, 0x37, 0x01, 0xB8,
  0x1D, 0xC0, 0xCE, 0x0E, 0x38, 0xE1, 0xFE, 0x07, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x0F, 0x80, 0xFE, 0x1C, 0xE1, 0x87, 0x18, 0x71,
  0x86, 0x18, 0x63, 0x9E, 0x3F, 0x83, 0xF0, 0x33, 0x07, 0x38, 0x61, 0x86,
  0x18, 0x61, 0xCE, 0x0C, 0x07, 0xC3, 0xFC, 0x61, 0x1C, 0x03, 0x00, 0x70,
  0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x19, 0x07, 0x3F,
  0xC7, 0xF0, 0xFF, 0xFF, 0xF1, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x18, 0x39,
  0xC1, 0xCC, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x39, 0xC1, 0x8C, 0x0C, 0x60,
  0x63, 0x03, 0x18, 0x39, 0xC1, 0x8E, 0x0C, 0x70, 0xE1, 0xFE, 0x07, 0xE0,
  0xC0, 0x78, 0x1F, 0x03, 0x60, 0xEC, 0x19, 0x87, 0x38, 0xC7, 0x38, 0x66,
  0x0D, 0xC1, 0xB0, 0x36, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xC0, 0xC1,
  0xE0, 0xE0, 0xF0, 0x70, 0xD8, 0x78, 0x6C, 0x3C, 0x76, 0x36, 0x33, 0x1B,
  0x39, 0x8D, 0x98, 0xCC, 0xCC, 0x66, 0x6C, 0x36, 0x36, 0x1B, 0x1F, 0x0F,
  0x0F, 0x07, 0x87, 0x83, 0x83, 0x81, 0xC1, 0xC0, 0x1C, 0x1C, 0x30, 0xE0,
  0xC3, 0x03, 0x98, 0x06, 0xE0, 0x1B, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x3E, 0x00, 0xD8, 0x06, 0x60, 0x39, 0xC0, 0xC7, 0x06, 0x0C, 0x38, 0x38,
  0xC0, 0xF0, 0x7E, 0x19, 0x8C, 0x67, 0x19, 0x86, 0xC1, 0xF0, 0x38, 0x0E,
  0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x0F, 0xF0, 0xFF, 0x00,
  0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1C,
  0x01, 0x80, 0x38, 0x07, 0x00, 0x7F, 0xCF, 0xF8, 0x0F, 0x1F, 0x18, 0x18,
  0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0xC0,
  0xC0, 0xC0, 0xF0, 0xF0, 0xC6, 0x18, 0xC6, 0x31, 0x8C, 0x61, 0x8C, 0x63,
  0x18, 0xC7, 0x0F, 0x87, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x1E, 0x1F,
  0x00, 0x02, 0x00, 0xE0, 0x1C, 0x07, 0x81, 0x98, 0x33, 0x0C, 0x21, 0x86,
  0x60, 0xDC, 0x0C, 0xFF, 0xE6, 0x23, 0x1E, 0xCF, 0xF7, 0x1D, 0x87, 0xE1,
  0xB8, 0x6C, 0x1B, 0x0E, 0xC3, 0xB1, 0xCF, 0xF1, 0xEC, 0x0C, 0x01, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x37, 0x87, 0xF1, 0xE7, 0x38, 0x66, 0x1C, 0xC3,
  0xB8, 0x66, 0x0C, 0xC3, 0x9C, 0x63, 0xFC, 0xDF, 0x00, 0x1F, 0x3F, 0x70,
  0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0x7E, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x70, 0x0C, 0x3D, 0x8F, 0xF3, 0x8E, 0x61, 0xDC, 0x33, 0x06,
  0x60, 0xCC, 0x39, 0x86, 0x31, 0xC7, 0xF8, 0x7B, 0x00, 0x1F, 0x1F, 0xDC,
  0x6C, 0x3E, 0x37, 0xFB, 0xF1, 0x80, 0xC0, 0x60, 0x3F, 0x8F, 0xC0, 0x00,
  0x70, 0x1F, 0x01, 0x80, 0x18, 0x03, 0x80, 0x7E, 0x0F, 0xC0, 0x30, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0xF8, 0x0F, 0x00, 0x0F, 0x63, 0xFC, 0xE3,
  0x98, 0x77, 0x0C, 0xC1, 0x98, 0x33, 0x0E, 0x61, 0xCC, 0x71, 0xFE, 0x1E,
  0xC0, 0x38, 0x06, 0x00, 0xC7, 0xF0, 0xFC, 0x00, 0x0C, 0x01, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x37, 0x87, 0xF1, 0xE7, 0x38, 0xE6, 0x18, 0xC3, 0x38,
  0x66, 0x0C, 0xC3, 0x98, 0x63, 0x0C, 0xE1, 0x80, 0x0C, 0x70, 0x00, 0x18,
  0x63, 0x8C, 0x30, 0xC7, 0x1C, 0x61, 0x86, 0x38, 0x01, 0x81, 0xC0, 0x00,
  0x00, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60,
  0x30, 0x38, 0x18, 0x0C, 0x06, 0x1F, 0x0F, 0x00, 0x0C, 0x01, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x31, 0xC6, 0x71, 0xCC, 0x33, 0x06, 0xC0, 0xF8, 0x3F,
  0x07, 0x60, 0xCE, 0x18, 0xC3, 0x18, 0xE3, 0x80, 0x0C, 0x31, 0xC6, 0x18,
  0x61, 0x8E, 0x30, 0xC3, 0x1C, 0x61, 0x86, 0x18, 0xE0, 0x1B, 0xCF, 0x17,
  0xDF, 0x3C, 0xF3, 0x38, 0xE3, 0x30, 0xC3, 0x30, 0xC3, 0x70, 0xC3, 0x61,
  0xC7, 0x61, 0x86, 0x61, 0x86, 0x61, 0x86, 0xE3, 0x8E, 0x1B, 0xC2, 0xF8,
  0xF3, 0x9C, 0x73, 0x0C, 0x61, 0x9C, 0x33, 0x86, 0x61, 0xCC, 0x31, 0x86,
  0x70, 0xC0, 0x1F, 0x1F, 0xDC, 0x6C, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC3,
  0xE1, 0xBF, 0x8F, 0x80, 0x0D, 0xE0, 0xBE, 0x1E, 0x71, 0xC3, 0x18, 0x31,
  0x87, 0x18, 0x63, 0x06, 0x30, 0xE3, 0x8C, 0x3F, 0xC7, 0x78, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x00, 0x1E, 0xCF, 0xF7, 0x1D, 0x87, 0xE1,
  0xB0, 0x6C, 0x1B, 0x0E, 0xC3, 0xB1, 0xCF, 0xF1, 0xEC, 0x07, 0x01, 0x80,
  0x60, 0x18, 0x0E, 0x00, 0x1B, 0x8B, 0x8F, 0x07, 0x03, 0x01, 0x81, 0xC0,
  0xC0, 0x60, 0x30, 0x18, 0x1C, 0x00, 0x1F, 0x9F, 0x9C, 0x0E, 0x03, 0x01,
  0xE0, 0x78, 0x0C, 0x06, 0x43, 0x3F, 0x9F, 0x80, 0x18, 0x20, 0xC3, 0xFF,
  0xCE, 0x18, 0x30, 0x60, 0xC3, 0x86, 0x0C, 0x1F, 0x1E, 0x00, 0x30, 0xDC,
  0x36, 0x0D, 0x87, 0x61, 0x98, 0x6E, 0x1B, 0x0E, 0xC3, 0x31, 0xCF, 0xF1,
  0xEC, 0xC1, 0xF0, 0x6C, 0x33, 0x8C, 0x66, 0x19, 0x86, 0xC1, 0xB0, 0x78,
  0x1E, 0x07, 0x01, 0xC0, 0xC3, 0x8F, 0x87, 0x1B, 0x1E, 0x36, 0x3C, 0xCC,
  0xD9, 0x99, 0xB6, 0x32, 0x6C, 0x6C, 0xD8, 0xD9, 0xE0, 0xE3, 0xC1, 0xC7,
  0x03, 0x0E, 0x00, 0x18, 0x71, 0x8E, 0x0D, 0xC0, 0xD8, 0x0F, 0x00, 0x70,
  0x0E, 0x01, 0xF0, 0x1B, 0x03, 0x30, 0x71, 0x8E, 0x18, 0x18, 0x38, 0xC1,
  0x87, 0x1C, 0x18, 0xC0, 0xCE, 0x06, 0x60, 0x37, 0x01, 0xB0, 0x0F, 0x80,
  0x78, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x1F, 0x00, 0xF0,
  0x00, 0x1F, 0xC7, 0xF0, 0x18, 0x0C, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x38,
  0x0C, 0x07, 0xF3, 0xFC, 0x01, 0x83, 0xC3, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x30, 0x38, 0x38, 0x3C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x18,
  0x0E, 0x00, 0xFF, 0xFF, 0xFC, 0x0C, 0x1E, 0x06, 0x06, 0x06, 0x06, 0x0C,
  0x0C, 0x0E, 0x07, 0x0F, 0x0C, 0x18, 0x18, 0x18, 0x38, 0x30, 0x70, 0xE0,
  0x7C, 0x7F, 0xF8, 0x38,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 16, 6, 0, -16 },
  { 13, 7, 6, 9, 2, -16 },
  { 19, 13, 16, 13, 0, -16 },
  { 45, 11, 18, 11, 0, -17 },
  { 70, 15, 16, 17, 1, -16 },
  { 100, 13, 16, 13, 0, -16 },
  { 126, 3, 6, 5, 2, -16 },
  { 129, 7, 19, 6, 1, -16 },
  { 146, 8, 19, 6, -2, -16 },
  { 165, 9, 10, 11, 2, -17 },
  { 177, 10, 11, 12, 1, -13 },
  { 191, 4, 6, 5, -1, -3 },
  { 194, 6, 2, 7, 0, -7 },
  { 196, 3, 3, 5, 0, -3 },
  { 198, 11, 16, 8, -1, -16 },
  { 220, 10, 16, 11, 1, -16 },
  { 240, 6, 16, 11, 3, -16 },
  { 252, 11, 16, 11, 0, -16 },
  { 274, 11, 16, 11, 0, -16 },
  { 296, 11, 16, 11, 0, -16 },
  { 318, 11, 16, 11, 0, -16 },
  { 340, 10, 16, 11, 1, -16 },
  { 360, 11, 16, 11, 1, -16 },
  { 382, 11, 16, 11, 0, -16 },
  { 404, 10, 16, 11, 1, -16 },
  { 424, 5, 12, 5, 0, -12 },
  { 432, 6, 15, 5, -1, -12 },
  { 444, 10, 10, 12, 1, -13 },
  { 457, 10, 6, 12, 1, -11 },
  { 465, 10, 10, 12, 1, -13 },
  { 478, 8, 16, 9, 1, -16 },
  { 494, 15, 18, 17, 1, -16 },
  { 528, 11, 16, 12, -1, -16 },
  { 550, 12, 16, 12, 0, -16 },
  { 574, 12, 16, 12, 1, -16 },
  { 598, 13, 16, 13, 0, -16 },
  { 624, 11, 16, 10, 0, -16 },
  { 646, 11, 16, 10, 0, -16 },
  { 668, 13, 16, 14, 1, -16 },
  { 694, 14, 16, 14, 0, -16 },
  { 722, 9, 16, 7, -1, -16 },
  { 740, 9, 20, 6, -3, -16 },
  { 763, 13, 16, 11, 0, -16 },
  { 789, 8, 16, 10, 0, -16 },
  { 805, 17, 16, 17, 0, -16 },
  { 839, 15, 16, 14, 0, -16 },
  { 869, 13, 16, 14, 1, -16 },
  { 895, 12, 16, 11, 0, -16 },
  { 919, 13, 20, 14, 1, -16 },
  { 952, 12, 16, 12, 0, -16 },
  { 976, 11, 16, 10, 0, -16 },
  { 998, 10, 16, 10, 2, -16 },
  { 1018, 13, 16, 13, 1, -16 },
  { 1044, 11, 16, 11, 2, -16 },
  { 1066, 17, 16, 17, 2, -16 },
  { 1100, 14, 16, 11, -1, -16 },
  { 1128, 10, 16, 10, 2, -16 },
  { 1148, 12, 16, 10, -1, -16 },
  { 1172, 8, 20, 6, 0, -16 },
  { 1192, 5, 16, 8, 2, -16 },
  { 1202, 9, 20, 6, -2, -16 },
  { 1225, 11, 10, 11, 0, -16 },
  { 1239, 8, 1, 8, -2, 2 },
  { 1240, 4, 4, 6, 3, -17 },
  { 1242, 10, 12, 12, 1, -12 },
  { 1257, 11, 17, 12, 0, -17 },
  { 1281, 8, 12, 9, 1, -12 },
  { 1293, 11, 17, 12, 1, -17 },
  { 1317, 9, 12, 10, 1, -12 },
  { 1331, 12, 22, 7, -3, -17 },
  { 1364, 11, 17, 12, 0, -12 },
  { 1388, 11, 17, 12, 0, -17 },
  { 1412, 6, 16, 5, 0, -16 },
  { 1424, 9, 21, 5, -3, -16 },
  { 1448, 11, 17, 10, 0, -17 },
  { 1472, 6, 17, 5, 0, -17 },
  { 1485, 16, 12, 17, 0, -12 },
  { 1509, 11, 12, 12, 0, -12 },
  { 1526, 9, 12, 11, 1, -12 },
  { 1540, 12, 17, 12, -1, -12 },
  { 1566, 10, 17, 12, 1, -12 },
  { 1588, 9, 12, 8, 0, -12 },
  { 1602, 9, 12, 9, 0, -12 },
  { 1616, 7, 15, 7, 1, -15 },
  { 1630, 10, 12, 12, 1, -12 },
  { 1645, 10, 12, 10, 1, -12 },
  { 1660, 15, 12, 15, 1, -12 },
  { 1683, 12, 12, 10, -1, -12 },
  { 1701, 13, 17, 10, -2, -12 },
  { 1729, 10, 12, 9, -1, -12 },
  { 1744, 9, 19, 8, 0, -16 },
  { 1766, 1, 22, 11, 5, -17 },
  { 1769, 8, 19, 8, -1, -16 },
  { 1788, 10, 3, 12, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC22PT7B_H_
