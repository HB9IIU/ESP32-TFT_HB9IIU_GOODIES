#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC54PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x08, 0x00, 0x3E,
  0x1F, 0xBF, 0x0F, 0x9F, 0x87, 0xCF, 0x87, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1,
  0xE0, 0xF8, 0xF0, 0x7C, 0xF8, 0x3C, 0x7C, 0x1E, 0x3C, 0x1F, 0x1E, 0x0F,
  0x0F, 0x07, 0x87, 0x83, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF8, 0x1E,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x01, 0xF0, 0x3C, 0x10, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3E, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFE, 0xE3, 0xC0, 0x7E, 0x38,
  0x30, 0x1F, 0x0E, 0x00, 0x07, 0xC3, 0x80, 0x01, 0xF1, 0xC0, 0x00, 0x7C,
  0x70, 0x00, 0x1F, 0x1C, 0x00, 0x07, 0xE7, 0x00, 0x01, 0xFD, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0x3F, 0x00, 0x01, 0xCF, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x38, 0x7C, 0x00,
  0x0E, 0x1F, 0x00, 0x03, 0x87, 0xC2, 0x00, 0xE3, 0xF0, 0xE0, 0x71, 0xF8,
  0x3F, 0x1C, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7F, 0xC0, 0x01, 0xE0, 0x1F, 0xF8, 0x00,
  0x7C, 0x07, 0xFF, 0x80, 0x1F, 0x01, 0xF0, 0xF0, 0x03, 0xC0, 0x3E, 0x1E,
  0x00, 0xF8, 0x0F, 0x83, 0xC0, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0x80, 0x3C,
  0x0F, 0x01, 0xF0, 0x0F, 0x81, 0xE0, 0x7C, 0x01, 0xF0, 0x3C, 0x0F, 0x00,
  0x3C, 0x07, 0x83, 0xE0, 0x07, 0x81, 0xF0, 0xF8, 0x00, 0xF0, 0x3E, 0x1E,
  0x00, 0x1E, 0x07, 0x87, 0xC0, 0x07, 0xC0, 0xF1, 0xF0, 0x60, 0xF8, 0x3E,
  0x3C, 0x7F, 0x9F, 0x07, 0x8F, 0x9F, 0xF9, 0xE1, 0xF3, 0xE7, 0xFF, 0xBC,
  0x7C, 0x78, 0xF9, 0xF7, 0xFF, 0x9F, 0x3E, 0x1E, 0xFF, 0xE7, 0xC7, 0x83,
  0xCF, 0xF8, 0xF1, 0xF0, 0x78, 0x7C, 0x3E, 0x3C, 0x0F, 0x00, 0x0F, 0x8F,
  0x81, 0xE0, 0x01, 0xE1, 0xF0, 0x3C, 0x00, 0x7C, 0x3C, 0x07, 0x80, 0x1F,
  0x07, 0x80, 0xF0, 0x03, 0xC0, 0xF0, 0x3E, 0x00, 0xF8, 0x1E, 0x07, 0x80,
  0x3E, 0x07, 0xC0, 0xF0, 0x07, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0x1F, 0x07,
  0x80, 0x3C, 0x03, 0xE1, 0xF0, 0x0F, 0x00, 0x3C, 0x3E, 0x03, 0xE0, 0x07,
  0xDF, 0x80, 0x78, 0x00, 0xFF, 0xE0, 0x1E, 0x00, 0x0F, 0xF8, 0x07, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7E,
  0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x03,
  0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xE3, 0xF0, 0x00,
  0x0F, 0x9F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x7C, 0x3F, 0xBE, 0x03, 0xF1, 0xFC, 0xFC, 0x0F, 0x8F, 0xC1, 0xF8,
  0x3E, 0x3E, 0x07, 0xE1, 0xF1, 0xF8, 0x0F, 0xC7, 0xC7, 0xC0, 0x3F, 0x3E,
  0x3F, 0x00, 0x7F, 0xF8, 0xFC, 0x01, 0xFF, 0xC3, 0xE0, 0x03, 0xFE, 0x0F,
  0x80, 0x07, 0xF8, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0xFF, 0x03, 0xF8,
  0x07, 0xFE, 0x07, 0xF0, 0xFF, 0xF8, 0x1F, 0xFF, 0xFB, 0xF0, 0x3F, 0xFF,
  0xCF, 0xC0, 0x7F, 0xFC, 0x1F, 0x80, 0xFF, 0xE0, 0x7F, 0x00, 0x38, 0x00,
  0x00, 0x3E, 0xFD, 0xFB, 0xE7, 0xCF, 0x9F, 0x3C, 0xF9, 0xF3, 0xC7, 0x8F,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x80, 0xF0, 0x07, 0x83, 0xC0, 0x1F, 0x8F, 0x00,
  0xFF, 0xB8, 0x05, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0xFF, 0xFC, 0x0F, 0xF0, 0x00, 0x7D, 0xE0, 0x03, 0xF7, 0x80, 0x1F, 0x9F,
  0x00, 0xFC, 0x3C, 0x07, 0xE0, 0xF8, 0x07, 0x83, 0xE0, 0x0C, 0x07, 0xC0,
  0x10, 0x1E, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xC3, 0xF0, 0xF8, 0x7C, 0x1F,
  0x07, 0x83, 0xE0, 0xF0, 0x00, 0x7F, 0xFD, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE,
  0xFF, 0xF8, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x30, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x03, 0xF8, 0x7F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x1F,
  0x0F, 0xC0, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F,
  0x3F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0x7C, 0x07, 0xE0,
  0x7E, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC,
  0x7F, 0xFE, 0xFF, 0xBE, 0x3F, 0x1F, 0x1F, 0x1F, 0x87, 0x0F, 0xC2, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x01, 0xF0, 0x1F, 0xC0, 0x1C, 0x01, 0xF8, 0x02, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x3C, 0x07, 0xF0, 0x0C, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x80, 0x00, 0xFC, 0x30, 0x00, 0xFE, 0x0F, 0xC0,
  0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xEF, 0x80,
  0x01, 0xF7, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x1F,
  0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0x3E, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x04, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x80, 0x01, 0xF8,
  0x30, 0x01, 0xFC, 0x0F, 0x81, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x0C, 0x00, 0x3E, 0x3F,
  0xC0, 0x3F, 0x7F, 0xF0, 0x1F, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0x0F, 0xFC,
  0x3F, 0x87, 0xF8, 0x0F, 0xC3, 0xF8, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0xFC,
  0x00, 0xFC, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x1F,
  0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xE0,
  0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0xE3, 0xF8,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x7E,
  0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0xC0,
  0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x1F,
  0x80, 0xFC, 0x07, 0xC0, 0x3F, 0x07, 0xF0, 0x07, 0xE3, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x03, 0xFD, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x03, 0xF0,
  0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0xE1, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0,
  0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x3F, 0x80,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0x3E, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x3F, 0x00,
  0x3F, 0x3F, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x3E, 0x00,
  0x3F, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x7F, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0xFE, 0x3F, 0x81, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0x7C, 0x07, 0xFE, 0x7C, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xC0, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0x04, 0x00, 0x00, 0x01, 0xC0, 0x7C, 0x1F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x7C, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xF0, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE1, 0xC0, 0x7E, 0x10, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x07, 0xC1,
  0xE0, 0x0F, 0xF8, 0x0F, 0x0F, 0x80, 0xFF, 0xF8, 0x3C, 0x7C, 0x07, 0xFF,
  0xE0, 0xF1, 0xE0, 0x3F, 0x9F, 0x03, 0xC7, 0x81, 0xF0, 0x3C, 0x0F, 0x3E,
  0x0F, 0x80, 0xF0, 0x3C, 0xF0, 0x3C, 0x07, 0xC0, 0xF7, 0xC1, 0xF0, 0x1E,
  0x03, 0xDE, 0x07, 0x80, 0x78, 0x0F, 0x78, 0x3E, 0x03, 0xE0, 0x7D, 0xE0,
  0xF8, 0x0F, 0x81, 0xE7, 0x83, 0xC0, 0x3C, 0x07, 0xBE, 0x0F, 0x00, 0xF0,
  0x1E, 0xF8, 0x3C, 0x07, 0xC0, 0xF3, 0xC0, 0xF0, 0x1F, 0x03, 0xCF, 0x03,
  0xC0, 0xF8, 0x1F, 0x3C, 0x0F, 0x03, 0xE0, 0x78, 0xF0, 0x3C, 0x1F, 0xC3,
  0xC3, 0xE0, 0xFD, 0xEF, 0xBF, 0x0F, 0x83, 0xFF, 0xBF, 0xF8, 0x1E, 0x07,
  0xFC, 0x7F, 0xC0, 0x78, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x04, 0x00,
  0x03, 0xFC, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xFC,
  0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xE0,
  0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0x80, 0xFF, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x00, 0x3F, 0x01, 0xF0, 0x03,
  0xF0, 0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03,
  0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x01,
  0xFC, 0x07, 0xC0, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xF8, 0x0F, 0xF0, 0x0F, 0x80,
  0x3F, 0x80, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x81, 0xF8, 0x00, 0xFC,
  0x1F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x83, 0xF0,
  0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF8, 0x3E, 0x00, 0x7F,
  0x07, 0xE0, 0x0F, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x1C, 0x03, 0xFC, 0x00, 0x40, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x01, 0x80, 0x3F, 0xE1, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xE0, 0xFF, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0xFE,
  0x01, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x7E,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7E,
  0x1F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7F, 0x07,
  0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x03, 0xF0,
  0x01, 0xFC, 0x0F, 0x80, 0x1F, 0xE0, 0x3E, 0x00, 0xFF, 0x01, 0xF8, 0x0F,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x03, 0xE0, 0x3F, 0xC0,
  0x01, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0x1F, 0x00,
  0x3F, 0xFC, 0xFC, 0x00, 0xFF, 0xE3, 0xF0, 0x07, 0xFF, 0x8F, 0xC0, 0x1F,
  0xFE, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x7F,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x7E, 0x03, 0xFF, 0x9F, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x05, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xE0,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x03, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x0F, 0xC0,
  0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x03, 0xF0,
  0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C,
  0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x08, 0x7F, 0x80,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x01,
  0xF8, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x01, 0xF0, 0x1F, 0xC0, 0x01,
  0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x03, 0xE1, 0xFC, 0x00, 0x03, 0xE3, 0xF8, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xEF, 0x80, 0x03, 0xFF, 0x00,
  0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x0F, 0xBE,
  0x00, 0x3E, 0xFC, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0xFB, 0xE0, 0x07,
  0xCF, 0x80, 0x7E, 0xF8, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x00, 0xF9, 0xF8,
  0x07, 0xC7, 0x80, 0x3E, 0x7E, 0x01, 0xF1, 0xE0, 0x1F, 0x1F, 0x00, 0x7C,
  0x78, 0x07, 0xC7, 0xC0, 0x3E, 0x1E, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0x80,
  0xF8, 0xFC, 0x03, 0xE1, 0xF0, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x1F, 0x0F,
  0x80, 0x3E, 0x1F, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC3, 0xE1, 0xF8, 0x07,
  0xC1, 0xF1, 0xF0, 0x7E, 0x01, 0xF0, 0x7C, 0x7C, 0x1F, 0x00, 0x7C, 0x1F,
  0x3E, 0x07, 0xC0, 0x3F, 0x07, 0xCF, 0x81, 0xF0, 0x0F, 0x80, 0xF7, 0xC0,
  0xFC, 0x03, 0xE0, 0x3D, 0xF0, 0x3F, 0x00, 0xF8, 0x0F, 0xF8, 0x0F, 0x80,
  0x3E, 0x03, 0xFE, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0x00, 0xF8, 0x07, 0xC0,
  0x3F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0x00, 0xFC, 0x03, 0xF8,
  0x00, 0x1F, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x00, 0x7C, 0x03,
  0xFE, 0x00, 0x0F, 0x80, 0x7F, 0xC0, 0x03, 0xF0, 0x0F, 0xFC, 0x00, 0x7C,
  0x01, 0xEF, 0x80, 0x0F, 0x80, 0x7D, 0xF0, 0x01, 0xF0, 0x0F, 0xBE, 0x00,
  0x7E, 0x01, 0xF3, 0xE0, 0x0F, 0x80, 0x3E, 0x7C, 0x01, 0xF0, 0x07, 0xCF,
  0x80, 0x3E, 0x01, 0xF1, 0xF8, 0x07, 0xC0, 0x3E, 0x1F, 0x01, 0xF8, 0x07,
  0xC3, 0xE0, 0x3E, 0x00, 0xF8, 0x7E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0xF8,
  0x07, 0xC0, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x07, 0xE0, 0x1F, 0x03, 0xF0,
  0xF8, 0x03, 0xE0, 0x3E, 0x1F, 0x00, 0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0x00,
  0xFC, 0x7C, 0x03, 0xE0, 0x0F, 0x9F, 0x80, 0x7C, 0x01, 0xF3, 0xE0, 0x0F,
  0x80, 0x3E, 0x7C, 0x03, 0xF0, 0x07, 0xEF, 0x80, 0x7C, 0x00, 0x7D, 0xF0,
  0x0F, 0x80, 0x0F, 0xBC, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0x1F,
  0xF0, 0x0F, 0xC0, 0x03, 0xFE, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x3E, 0x00,
  0x0F, 0xF0, 0x07, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x3E,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7C, 0xFC, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC,
  0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0x83, 0xFE,
  0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xE0, 0x03,
  0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07,
  0xE0, 0x0F, 0xC0, 0x7C, 0x01, 0xFC, 0x07, 0xC0, 0x3F, 0x80, 0xFC, 0x3F,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x7F,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x3E, 0x7E, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x3E, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xF0, 0x7F, 0xC0, 0x7E,
  0x03, 0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7C,
  0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0,
  0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0xC0,
  0xF8, 0x07, 0xF0, 0x1F, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F,
  0x83, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x80, 0xF8,
  0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0,
  0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x01, 0xF8,
  0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x01, 0xE0, 0x3F, 0x80,
  0x10, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x80, 0x01,
  0xF8, 0x38, 0x01, 0xFE, 0x0F, 0xE3, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xF0,
  0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF8, 0x1F,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x80,
  0x01, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01,
  0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0x9F, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x01, 0xF8, 0xFC,
  0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7E,
  0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x03, 0xE0,
  0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x1F, 0x80,
  0x3E, 0x07, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x07,
  0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0xF9, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7D, 0xF0,
  0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x80, 0x07, 0xCF, 0xC0, 0x07, 0xF0, 0x01, 0xF9, 0xF8,
  0x00, 0xFE, 0x00, 0x3E, 0x3F, 0x00, 0x3F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07,
  0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xFF, 0x00, 0x7E, 0x1F, 0x80, 0x3D, 0xE0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xBC, 0x01, 0xF0, 0x7E, 0x01, 0xF7, 0x80, 0x7E,
  0x0F, 0xC0, 0x7C, 0xF0, 0x0F, 0x81, 0xF8, 0x0F, 0x9E, 0x03, 0xF0, 0x3F,
  0x01, 0xE3, 0xC0, 0x7C, 0x07, 0xE0, 0x7C, 0x78, 0x0F, 0x80, 0xFC, 0x0F,
  0x8F, 0x03, 0xF0, 0x0F, 0x83, 0xE1, 0xE0, 0x7C, 0x01, 0xF0, 0x7C, 0x3C,
  0x1F, 0x80, 0x3E, 0x1F, 0x07, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0xF0, 0xFC,
  0x00, 0xF8, 0x78, 0x1E, 0x1F, 0x00, 0x1F, 0x1F, 0x03, 0xC3, 0xE0, 0x03,
  0xE3, 0xE0, 0x78, 0xFC, 0x00, 0x7C, 0xF8, 0x0F, 0x1F, 0x00, 0x0F, 0x9F,
  0x01, 0xE7, 0xE0, 0x01, 0xF7, 0xC0, 0x3C, 0xF8, 0x00, 0x3E, 0xF8, 0x07,
  0x9F, 0x00, 0x07, 0xDE, 0x00, 0xF7, 0xC0, 0x00, 0xF7, 0xC0, 0x1E, 0xF8,
  0x00, 0x1E, 0xF8, 0x03, 0xDF, 0x00, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0x7C, 0x00,
  0x00, 0x1F, 0x9F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x0F,
  0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xE0, 0xFC, 0x03,
  0xF0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x81, 0xF8, 0x07, 0xC0,
  0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x7C, 0x00, 0x3E,
  0x7E, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x03,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0x3C, 0x00,
  0x3C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1E, 0x03, 0xC0, 0x1F, 0x01, 0xF0,
  0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x3C, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x07,
  0x83, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0x79, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC,
  0xFC, 0x3E, 0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0x3C, 0x0F, 0x00, 0x0E, 0x00,
  0x00, 0x1F, 0xE1, 0xF0, 0x1F, 0xFC, 0x78, 0x0F, 0xFF, 0xBE, 0x07, 0xFF,
  0xEF, 0x81, 0xFC, 0x3F, 0xE0, 0xFE, 0x07, 0xF8, 0x7F, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xF8,
  0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x07, 0xE1, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x03, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x83,
  0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xF8, 0x1F, 0x87, 0xBE, 0x07, 0xFF, 0xEF,
  0x00, 0xFF, 0xF7, 0xC0, 0x3F, 0xF9, 0xF0, 0x07, 0xF8, 0x7C, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x0C, 0x00, 0x3E, 0x3F, 0xC0, 0x1F, 0x3F, 0xF0, 0x1F, 0xBF,
  0xFC, 0x0F, 0xBF, 0xFF, 0x07, 0xFC, 0x3F, 0x83, 0xFC, 0x0F, 0xC1, 0xFC,
  0x03, 0xE1, 0xFC, 0x01, 0xF0, 0xFE, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x3F,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x0F, 0xC7,
  0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF1, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3F, 0x80, 0x3F,
  0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x3F, 0x87, 0xFC, 0x3F, 0x83, 0xDF, 0xFF,
  0x83, 0xEF, 0xFF, 0x81, 0xF3, 0xFF, 0x80, 0xF0, 0xFF, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x03, 0xF8, 0x18, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x83, 0xF8, 0x3C, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0xE0, 0xFC, 0x00, 0x7F, 0x8F, 0xC0, 0x1F, 0xFC,
  0xF8, 0x03, 0xFF, 0xEF, 0x80, 0x7F, 0xFE, 0xF8, 0x07, 0xF0, 0xFF, 0x80,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x00,
  0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0,
  0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0xFC,
  0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x80, 0x7E, 0x1F, 0xF0, 0x07, 0xFF, 0xEF,
  0x00, 0x3F, 0xFD, 0xF0, 0x03, 0xFF, 0x9F, 0x00, 0x1F, 0xE1, 0xF0, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x07, 0xC7, 0xE0,
  0x1F, 0x1F, 0x00, 0x7C, 0xFC, 0x01, 0xF3, 0xE0, 0x0F, 0xDF, 0x80, 0x7E,
  0x7E, 0x07, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x41,
  0xFC, 0x07, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xC2, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC1,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xFE, 0x1F, 0x00, 0x7F, 0xF1, 0xE0, 0x0F, 0xFF, 0xBE, 0x01,
  0xFF, 0xFB, 0xE0, 0x1F, 0xC3, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x00,
  0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0,
  0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x1F, 0x00,
  0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF0,
  0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x7F, 0x03, 0xF0,
  0x07, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xE0, 0x3F, 0x03, 0xFE,
  0x01, 0xF8, 0x7F, 0xC0, 0x1F, 0xFF, 0x7C, 0x01, 0xFF, 0xF7, 0xC0, 0x0F,
  0xFC, 0xFC, 0x00, 0x7F, 0x8F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x80, 0x07, 0xF0, 0x0E, 0x00, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x0E, 0x00, 0x3E, 0x3F, 0xE0, 0x1F, 0x3F, 0xF8,
  0x1F, 0xBF, 0xFC, 0x0F, 0xBF, 0xFF, 0x07, 0xFC, 0x3F, 0x83, 0xFC, 0x0F,
  0xC1, 0xFC, 0x03, 0xE1, 0xFC, 0x01, 0xF0, 0xFE, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0xC0,
  0x1F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xE1, 0xF8,
  0x01, 0xF0, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x3F,
  0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xC3,
  0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF8,
  0x00, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x7E,
  0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x7E, 0x00,
  0x7C, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE3, 0xF0,
  0x00, 0xF9, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xDF, 0x80, 0x0F,
  0xE7, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0xC0,
  0x1F, 0x81, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xF8,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x01, 0xE0, 0x07, 0x87, 0xF8, 0x0F,
  0xF0, 0x0F, 0x1F, 0xF8, 0x7F, 0xF0, 0x3E, 0x7F, 0xF9, 0xFF, 0xF0, 0x7D,
  0xFF, 0xF7, 0xFF, 0xE0, 0xFF, 0x87, 0xEF, 0x0F, 0xC1, 0xFE, 0x07, 0xFC,
  0x0F, 0x83, 0xF8, 0x0F, 0xF0, 0x1F, 0x0F, 0xE0, 0x1F, 0xC0, 0x3E, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x7E, 0x00, 0xF8,
  0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xE0, 0x0F, 0x87,
  0xE0, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x03, 0xE1,
  0xF0, 0x03, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x0F,
  0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x00, 0xF8,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x07, 0xE1, 0xF0, 0x07,
  0xE0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x70, 0x01, 0xE1, 0xFF,
  0x00, 0xF1, 0xFF, 0xC0, 0xF9, 0xFF, 0xE0, 0x7D, 0xFF, 0xF8, 0x3F, 0xF1,
  0xFC, 0x1F, 0xE0, 0x7E, 0x1F, 0xE0, 0x3F, 0x0F, 0xE0, 0x1F, 0x87, 0xF0,
  0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF1, 0xF8, 0x01, 0xF0, 0xFC,
  0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xE0, 0x07, 0xE3,
  0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x7C, 0x00, 0xFC,
  0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x1F,
  0x87, 0xC0, 0x0F, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xF0, 0xFE, 0x0F, 0xC0,
  0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00,
  0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7F, 0x0F, 0xE0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x07, 0x87, 0xF8, 0x00, 0x78, 0xFF, 0xC0, 0x0F, 0x9F, 0xFE,
  0x00, 0xFB, 0xFF, 0xF0, 0x0F, 0xF8, 0x7F, 0x00, 0xFF, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0x01, 0xFC, 0x01, 0xF0, 0x1F, 0xC0, 0x1F, 0x01, 0xF8, 0x01,
  0xF0, 0x1F, 0x80, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x03,
  0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x7E, 0x00,
  0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0,
  0x7C, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFF, 0x87, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFB, 0xFF, 0xC0,
  0x1F, 0x3F, 0xF8, 0x01, 0xF0, 0xFF, 0x00, 0x1F, 0x01, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xE1, 0xF0,
  0x1F, 0xFC, 0x78, 0x0F, 0xFF, 0xBE, 0x07, 0xFF, 0xFF, 0x81, 0xFC, 0x3F,
  0xE0, 0xFC, 0x07, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F,
  0x80, 0x0F, 0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7C,
  0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x01,
  0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC,
  0x07, 0xF8, 0x1F, 0x87, 0xFC, 0x07, 0xFF, 0xDF, 0x00, 0xFF, 0xE7, 0xC0,
  0x3F, 0xF1, 0xF0, 0x07, 0xF8, 0xFC, 0x00, 0x10, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x1E, 0x1F, 0x80, 0xF1, 0xFC, 0x0F, 0x9F, 0xE0,
  0x7D, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x07,
  0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xE0, 0x38,
  0x3E, 0x00, 0x43, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x80,
  0x0F, 0xC7, 0x81, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0x7F,
  0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xC1, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x20, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x60,
  0x00, 0x07, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x3E,
  0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF0,
  0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xE0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x83, 0xE0,
  0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x07,
  0xC0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFE,
  0x0F, 0xC0, 0x7F, 0x83, 0xF0, 0x3F, 0xE0, 0xFE, 0x1E, 0xF0, 0x1F, 0xFF,
  0x7C, 0x07, 0xFF, 0x9F, 0x00, 0xFF, 0xC7, 0xC0, 0x1F, 0xE1, 0xF0, 0x00,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7,
  0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x9F, 0x80, 0x3E, 0x3F, 0x00, 0xFC, 0x7E,
  0x01, 0xF0, 0x7C, 0x07, 0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x3F, 0x03, 0xE0,
  0x7C, 0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F,
  0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xC0,
  0x03, 0xCF, 0x80, 0x07, 0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x3E,
  0xF8, 0x03, 0xF8, 0x07, 0xEF, 0x80, 0x7F, 0x80, 0x7C, 0xF8, 0x07, 0xF8,
  0x0F, 0xCF, 0x80, 0xFF, 0x80, 0xF8, 0xF8, 0x0F, 0x78, 0x0F, 0x8F, 0x80,
  0xF7, 0x81, 0xF8, 0xF8, 0x1F, 0x78, 0x1F, 0x0F, 0x81, 0xE7, 0x83, 0xF0,
  0xF8, 0x3E, 0x78, 0x3E, 0x0F, 0x83, 0xC7, 0x83, 0xE0, 0xF8, 0x7C, 0x78,
  0x7C, 0x07, 0x87, 0xC7, 0x87, 0xC0, 0x78, 0x78, 0x78, 0xFC, 0x07, 0x8F,
  0x87, 0x8F, 0x80, 0x78, 0xF0, 0x79, 0xF8, 0x07, 0x9F, 0x07, 0x9F, 0x00,
  0x79, 0xE0, 0x79, 0xF0, 0x07, 0x9E, 0x07, 0xBE, 0x00, 0x7B, 0xE0, 0x7B,
  0xE0, 0x07, 0xBC, 0x07, 0xBC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xF8,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF0, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x0F,
  0xC0, 0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x00,
  0xFC, 0x7E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xBE, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xFC,
  0x1F, 0x00, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0xFC, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x01,
  0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x20, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x10, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0x3F, 0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x80, 0x0F, 0xFC, 0x80, 0x00,
  0xF0,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 14, 40, 14, 1, -39 },
  { 71, 17, 14, 21, 6, -39 },
  { 101, 31, 39, 31, 1, -39 },
  { 253, 26, 44, 27, 1, -41 },
  { 396, 35, 40, 41, 3, -39 },
  { 571, 30, 40, 32, 1, -39 },
  { 721, 7, 14, 12, 6, -39 },
  { 734, 18, 48, 16, 2, -39 },
  { 842, 18, 48, 16, -4, -39 },
  { 950, 22, 23, 26, 5, -41 },
  { 1014, 24, 26, 28, 3, -32 },
  { 1092, 10, 13, 13, -2, -6 },
  { 1109, 14, 5, 16, 1, -17 },
  { 1118, 7, 8, 13, 1, -7 },
  { 1125, 27, 39, 20, -3, -39 },
  { 1257, 24, 40, 27, 2, -39 },
  { 1377, 17, 39, 27, 6, -39 },
  { 1460, 27, 39, 27, -1, -39 },
  { 1592, 26, 40, 27, 0, -39 },
  { 1722, 26, 39, 27, 0, -39 },
  { 1849, 26, 40, 27, 1, -39 },
  { 1979, 25, 40, 27, 2, -39 },
  { 2104, 25, 39, 27, 3, -39 },
  { 2226, 26, 40, 27, 1, -39 },
  { 2356, 24, 40, 27, 2, -39 },
  { 2476, 11, 31, 13, 1, -30 },
  { 2519, 15, 37, 13, -3, -30 },
  { 2589, 24, 27, 28, 3, -33 },
  { 2670, 24, 16, 28, 3, -27 },
  { 2718, 24, 27, 28, 3, -33 },
  { 2799, 20, 40, 21, 3, -39 },
  { 2899, 38, 44, 41, 2, -39 },
  { 3108, 28, 39, 28, -3, -39 },
  { 3245, 28, 39, 29, 1, -39 },
  { 3382, 28, 40, 28, 3, -39 },
  { 3522, 30, 39, 32, 1, -39 },
  { 3669, 26, 39, 25, 1, -39 },
  { 3796, 26, 39, 24, 1, -39 },
  { 3923, 30, 40, 33, 3, -39 },
  { 4073, 33, 39, 33, 1, -39 },
  { 4234, 23, 39, 17, -2, -39 },
  { 4347, 23, 50, 14, -8, -39 },
  { 4491, 32, 39, 28, 1, -39 },
  { 4647, 19, 39, 24, 1, -39 },
  { 4740, 42, 39, 42, 1, -39 },
  { 4945, 35, 39, 35, 1, -39 },
  { 5116, 31, 40, 35, 3, -39 },
  { 5271, 28, 39, 28, 1, -39 },
  { 5408, 31, 48, 35, 3, -39 },
  { 5594, 27, 39, 29, 1, -39 },
  { 5726, 26, 40, 25, 0, -39 },
  { 5856, 24, 39, 25, 5, -39 },
  { 5973, 31, 40, 33, 3, -39 },
  { 6128, 27, 39, 28, 5, -39 },
  { 6260, 43, 39, 43, 5, -39 },
  { 6470, 34, 39, 27, -3, -39 },
  { 6636, 25, 39, 25, 5, -39 },
  { 6758, 29, 39, 25, -1, -39 },
  { 6900, 21, 48, 16, -1, -39 },
  { 7026, 10, 39, 20, 6, -39 },
  { 7075, 21, 48, 16, -4, -39 },
  { 7201, 25, 24, 27, 1, -39 },
  { 7276, 21, 3, 20, -5, 5 },
  { 7284, 9, 8, 15, 8, -41 },
  { 7293, 26, 31, 28, 2, -30 },
  { 7394, 25, 42, 28, 1, -41 },
  { 7526, 21, 31, 22, 2, -30 },
  { 7608, 28, 42, 29, 2, -41 },
  { 7755, 22, 31, 25, 2, -30 },
  { 7841, 29, 54, 16, -6, -41 },
  { 8037, 28, 43, 29, 0, -30 },
  { 8188, 25, 41, 28, 1, -41 },
  { 8317, 14, 40, 13, 1, -40 },
  { 8387, 22, 53, 13, -7, -40 },
  { 8533, 26, 41, 25, 1, -41 },
  { 8667, 14, 41, 13, 1, -41 },
  { 8739, 39, 30, 43, 1, -30 },
  { 8886, 25, 30, 28, 1, -30 },
  { 8980, 24, 30, 28, 2, -30 },
  { 9070, 28, 43, 28, -2, -30 },
  { 9221, 26, 43, 29, 2, -30 },
  { 9361, 21, 30, 20, 1, -30 },
  { 9440, 21, 31, 22, 0, -30 },
  { 9522, 17, 37, 17, 2, -36 },
  { 9601, 26, 30, 28, 2, -29 },
  { 9699, 23, 29, 23, 3, -29 },
  { 9783, 36, 29, 37, 3, -29 },
  { 9914, 28, 29, 24, -2, -29 },
  { 10016, 31, 42, 24, -5, -29 },
  { 10179, 23, 29, 21, -1, -29 },
  { 10263, 21, 48, 19, 1, -39 },
  { 10389, 5, 54, 26, 11, -41 },
  { 10423, 21, 48, 19, -3, -39 },
  { 10549, 24, 8, 28, 3, -23 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic54pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC54PT7B_H_
