#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC10PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x24, 0x20, 0xB4, 0x28, 0xA7, 0xCC, 0xF9, 0x47, 0x00, 0x11,
  0xD4, 0xC3, 0x1A, 0xC8, 0x40, 0xEE, 0xAD, 0x3B, 0x35, 0x59, 0x80, 0x38,
  0xA3, 0x19, 0x9A, 0x6F, 0x80, 0xC0, 0x34, 0x44, 0x88, 0x88, 0x40, 0x22,
  0x11, 0x22, 0x24, 0x80, 0x2A, 0x7E, 0x20, 0x44, 0xF4, 0x40, 0xE0, 0xE0,
  0x80, 0x11, 0x24, 0x48, 0x80, 0x3A, 0x52, 0x99, 0x49, 0x80, 0x7C, 0xA4,
  0x90, 0x78, 0x42, 0x22, 0x23, 0xC0, 0x78, 0x44, 0xE1, 0x0B, 0xC0, 0x19,
  0x4C, 0xA9, 0x3C, 0x80, 0x3A, 0x10, 0xE1, 0x0B, 0xC0, 0x3A, 0x1C, 0xA8,
  0xC9, 0xC0, 0xF1, 0x26, 0x48, 0x80, 0x3A, 0x5E, 0xE9, 0x49, 0xC0, 0x7A,
  0x52, 0xF1, 0x0B, 0x80, 0x40, 0x80, 0x20, 0x15, 0x80, 0x16, 0x86, 0x10,
  0xF0, 0xF0, 0x86, 0x16, 0x80, 0xE4, 0xA8, 0x20, 0x3E, 0x85, 0x7D, 0x5A,
  0xB6, 0x90, 0x1C, 0x08, 0x61, 0x8A, 0x39, 0x1C, 0x40, 0x3A, 0x52, 0xE4,
  0xA7, 0xC0, 0x7E, 0x21, 0x08, 0x43, 0x80, 0x39, 0x14, 0x51, 0x49, 0x2F,
  0x00, 0x3A, 0x10, 0xE4, 0x23, 0xC0, 0x3A, 0x10, 0xE4, 0x22, 0x00, 0x7E,
  0x21, 0x79, 0x4B, 0xC0, 0x25, 0x14, 0x5F, 0x49, 0x28, 0x80, 0x72, 0x44,
  0x44, 0xC0, 0x08, 0x84, 0x21, 0x08, 0x84, 0xE0, 0x2D, 0x65, 0x18, 0x51,
  0x49, 0x80, 0x24, 0x44, 0x44, 0xF0, 0x23, 0x63, 0x66, 0x66, 0x5A, 0x52,
  0x96, 0x22, 0xC9, 0x52, 0xA5, 0x49, 0x22, 0x00, 0x7C, 0x63, 0x18, 0xCB,
  0xC0, 0x3A, 0x52, 0xF4, 0x22, 0x00, 0x7C, 0x63, 0x18, 0xCB, 0xC4, 0x10,
  0x3A, 0x52, 0xE5, 0x2A, 0x60, 0x7A, 0x10, 0x61, 0x0B, 0x80, 0xF4, 0x44,
  0x4C, 0x80, 0x4C, 0x63, 0x29, 0x4B, 0x80, 0x8C, 0xA5, 0x4A, 0x63, 0x00,
  0x93, 0x92, 0xB2, 0xB4, 0xD4, 0xC8, 0x88, 0x26, 0x38, 0x60, 0x82, 0x8D,
  0x32, 0x00, 0x9C, 0xA8, 0x84, 0x22, 0x00, 0x78, 0x84, 0x44, 0x63, 0xC0,
  0x34, 0x44, 0x48, 0x88, 0xC0, 0xA9, 0x54, 0x31, 0x12, 0x22, 0x22, 0xC0,
  0x21, 0x95, 0x90, 0xF0, 0xD0, 0x7A, 0x63, 0x27, 0x00, 0x21, 0x14, 0xD4,
  0xA7, 0x5E, 0x74, 0x88, 0x60, 0x04, 0x20, 0x9E, 0x4A, 0x29, 0x1C, 0x75,
  0xE8, 0x70, 0x08, 0x88, 0xE2, 0x10, 0x88, 0x46, 0x00, 0x7A, 0x63, 0x27,
  0x0B, 0x80, 0x21, 0x14, 0xD4, 0xA6, 0x52, 0x21, 0x25, 0x20, 0x10, 0x22,
  0x24, 0x44, 0xC0, 0x21, 0x12, 0xA6, 0x32, 0xD2, 0x25, 0x24, 0xA4, 0x7E,
  0x95, 0x4C, 0x99, 0x20, 0x13, 0x52, 0x99, 0x48, 0x7A, 0x63, 0x27, 0x00,
  0x7A, 0x53, 0xAF, 0x42, 0x00, 0x7A, 0x63, 0x27, 0x08, 0xC0, 0x74, 0x48,
  0x80, 0x74, 0x22, 0xE0, 0x2B, 0xA5, 0x98, 0x4A, 0x55, 0x27, 0x00, 0xBA,
  0xCC, 0x80, 0xA7, 0x6D, 0xA4, 0x90, 0x5B, 0x18, 0xC9, 0x00, 0x2C, 0xA3,
  0x0C, 0x20, 0x8C, 0x00, 0x72, 0x44, 0xE0, 0x32, 0x24, 0xC4, 0x44, 0x40,
  0xFF, 0xC0, 0x64, 0xA2, 0x94, 0x80, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 7, 3, 0, -7 },
  { 4, 3, 2, 4, 1, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 5, 9, 5, 0, -8 },
  { 17, 6, 7, 8, 1, -7 },
  { 23, 6, 7, 6, 0, -7 },
  { 29, 1, 2, 2, 1, -7 },
  { 30, 4, 9, 3, 0, -7 },
  { 35, 4, 9, 3, -1, -7 },
  { 40, 4, 5, 5, 1, -8 },
  { 43, 4, 5, 5, 1, -6 },
  { 46, 2, 2, 2, 0, -1 },
  { 47, 3, 1, 3, 0, -3 },
  { 48, 1, 1, 2, 0, -1 },
  { 49, 4, 7, 4, 0, -7 },
  { 53, 5, 7, 5, 0, -7 },
  { 58, 3, 7, 5, 1, -7 },
  { 61, 5, 7, 5, 0, -7 },
  { 66, 5, 7, 5, 0, -7 },
  { 71, 5, 7, 5, 0, -7 },
  { 76, 5, 7, 5, 0, -7 },
  { 81, 5, 7, 5, 0, -7 },
  { 86, 4, 7, 5, 1, -7 },
  { 90, 5, 7, 5, 0, -7 },
  { 95, 5, 7, 5, 0, -7 },
  { 100, 2, 5, 2, 0, -5 },
  { 102, 3, 6, 2, -1, -5 },
  { 105, 4, 5, 5, 1, -6 },
  { 108, 4, 3, 5, 1, -5 },
  { 110, 4, 5, 5, 1, -6 },
  { 113, 3, 7, 4, 1, -7 },
  { 116, 7, 8, 8, 0, -7 },
  { 123, 6, 7, 5, -1, -7 },
  { 129, 5, 7, 5, 0, -7 },
  { 134, 5, 7, 5, 1, -7 },
  { 139, 6, 7, 6, 0, -7 },
  { 145, 5, 7, 5, 0, -7 },
  { 150, 5, 7, 4, 0, -7 },
  { 155, 5, 7, 6, 1, -7 },
  { 160, 6, 7, 6, 0, -7 },
  { 166, 4, 7, 3, 0, -7 },
  { 170, 5, 9, 3, -2, -7 },
  { 176, 6, 7, 5, 0, -7 },
  { 182, 4, 7, 4, 0, -7 },
  { 186, 8, 7, 8, 0, -7 },
  { 193, 7, 7, 7, 0, -7 },
  { 200, 5, 7, 6, 1, -7 },
  { 205, 5, 7, 5, 0, -7 },
  { 210, 5, 9, 6, 1, -7 },
  { 216, 5, 7, 5, 0, -7 },
  { 221, 5, 7, 5, 0, -7 },
  { 226, 4, 7, 5, 1, -7 },
  { 230, 5, 7, 6, 1, -7 },
  { 235, 5, 7, 5, 1, -7 },
  { 240, 8, 7, 8, 1, -7 },
  { 247, 7, 7, 5, -1, -7 },
  { 254, 5, 7, 5, 1, -7 },
  { 259, 5, 7, 5, 0, -7 },
  { 264, 4, 9, 3, 0, -7 },
  { 269, 2, 7, 4, 1, -7 },
  { 271, 4, 9, 3, -1, -7 },
  { 276, 5, 4, 5, 0, -7 },
  { 279, 4, 1, 4, -1, 1 },
  { 280, 2, 2, 3, 1, -8 },
  { 281, 5, 5, 5, 0, -5 },
  { 285, 5, 8, 5, 0, -8 },
  { 290, 4, 5, 4, 0, -5 },
  { 293, 6, 8, 5, 0, -8 },
  { 299, 4, 5, 5, 0, -5 },
  { 302, 5, 10, 3, -1, -8 },
  { 309, 5, 7, 5, 0, -5 },
  { 314, 5, 8, 5, 0, -8 },
  { 319, 3, 7, 2, 0, -7 },
  { 322, 4, 9, 2, -1, -7 },
  { 327, 5, 8, 5, 0, -8 },
  { 332, 3, 8, 2, 0, -8 },
  { 335, 7, 5, 8, 0, -5 },
  { 340, 5, 6, 5, 0, -6 },
  { 344, 5, 5, 5, 0, -5 },
  { 348, 5, 7, 5, 0, -5 },
  { 353, 5, 7, 5, 0, -5 },
  { 358, 4, 5, 4, 0, -5 },
  { 361, 4, 5, 4, 0, -5 },
  { 364, 3, 7, 3, 0, -7 },
  { 367, 5, 5, 5, 0, -5 },
  { 371, 4, 5, 4, 1, -5 },
  { 374, 6, 5, 7, 1, -5 },
  { 378, 5, 5, 4, 0, -5 },
  { 382, 6, 7, 4, -1, -5 },
  { 388, 4, 5, 4, 0, -5 },
  { 391, 4, 9, 3, 0, -7 },
  { 396, 1, 10, 5, 2, -8 },
  { 398, 3, 9, 3, 0, -7 },
  { 402, 4, 1, 5, 1, -4 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC10PT7B_H_
