#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC31PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0x0F,
  0x03, 0x80, 0x79, 0xDC, 0xE7, 0x39, 0xCE, 0x63, 0x98, 0xCE, 0x33, 0x0C,
  0x01, 0xC7, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x71, 0xC0, 0x30, 0xC0, 0x18,
  0x60, 0xFF, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0x83, 0x1C, 0x03, 0x8E, 0x01,
  0x86, 0x00, 0xC3, 0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0x38, 0xE0,
  0x1C, 0x60, 0x0C, 0x30, 0x06, 0x38, 0x07, 0x1C, 0x03, 0x0C, 0x00, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0xFE, 0x0F, 0xFC, 0x7F, 0xF1, 0xC8, 0x8E,
  0x60, 0x39, 0x80, 0xE6, 0x01, 0xD8, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x9C, 0x02, 0x70, 0x19, 0xC8, 0x67, 0x31, 0xBC, 0xFF, 0xE3,
  0xFF, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x1F, 0x00, 0xE3,
  0xF8, 0x1C, 0x31, 0x83, 0x87, 0x18, 0x30, 0x61, 0x87, 0x0E, 0x18, 0xE0,
  0xE3, 0x8C, 0x0E, 0x39, 0xC0, 0xE3, 0x38, 0x8C, 0x73, 0x3E, 0xE7, 0x77,
  0xFF, 0xEE, 0xE7, 0x7C, 0xCC, 0x30, 0x1C, 0xC7, 0x03, 0x9C, 0x70, 0x31,
  0xC7, 0x07, 0x18, 0x70, 0xE1, 0x86, 0x0C, 0x18, 0xE1, 0xC1, 0xCC, 0x38,
  0x1F, 0xC7, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xFC, 0x03, 0xCF, 0x01, 0xC3,
  0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0xE0, 0x1C, 0xE0, 0x0F, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xF0, 0x77, 0xBC, 0x73, 0x8E, 0x3B, 0x83, 0xB9,
  0xC1, 0xFC, 0xE0, 0x7C, 0x70, 0x3C, 0x38, 0x1E, 0x1F, 0x7F, 0x87, 0xFD,
  0xE1, 0xF8, 0x78, 0x7B, 0x9C, 0xE6, 0x33, 0x98, 0x01, 0xC0, 0xE0, 0x70,
  0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0x07, 0x00, 0xE0, 0x38, 0x06, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0,
  0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0,
  0x38, 0x1C, 0x0E, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xC0, 0x86, 0x0F, 0x30,
  0x7F, 0x8C, 0xFF, 0xE1, 0xFF, 0x1F, 0x01, 0xDC, 0x1E, 0x60, 0xE3, 0x82,
  0x1C, 0x00, 0x80, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x83, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0x3C, 0xF3, 0x9E, 0x71, 0x8E, 0x30, 0xFF, 0xFF,
  0xF8, 0x73, 0xFC, 0xE0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xF0,
  0x1F, 0xE0, 0xF3, 0xC7, 0x87, 0x1C, 0x1C, 0xF0, 0x73, 0x81, 0xDE, 0x07,
  0x70, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x0F, 0xF0, 0x3B, 0x80, 0xEE, 0x03,
  0xB8, 0x1C, 0xE0, 0x73, 0x83, 0xC7, 0x0E, 0x1E, 0xF0, 0x7F, 0xC0, 0xFC,
  0x00, 0x03, 0x87, 0xC7, 0xEF, 0xEF, 0x77, 0x39, 0x1C, 0x1E, 0x0E, 0x07,
  0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03,
  0x83, 0xC0, 0x01, 0xFC, 0x07, 0xFE, 0x07, 0x9F, 0x06, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF8, 0x07, 0xF8,
  0x1F, 0xF8, 0x3C, 0x78, 0x20, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x38, 0x0F, 0xE0, 0x1F, 0x00, 0x7F, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF2, 0x01, 0xE7, 0x9F, 0x8F,
  0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x3B, 0x80, 0x67, 0x01, 0xDC, 0x07, 0x38, 0x1C, 0x70, 0x70,
  0xE0, 0xE1, 0xC3, 0x87, 0x0E, 0x0E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x07, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1D, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x72, 0x01, 0xE7, 0x9F, 0x8F,
  0xFE, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0x10, 0x78, 0x01,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x3B, 0xE0, 0xEF, 0xE1, 0xFF,
  0xE3, 0xC3, 0xC7, 0x03, 0x9E, 0x07, 0x3C, 0x0E, 0x70, 0x1C, 0xE0, 0x78,
  0xE0, 0xE1, 0xC3, 0xC3, 0xEF, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0xFD,
  0xFF, 0xF7, 0xFF, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x00, 0x07, 0xF8, 0x3F, 0xF1, 0xE3, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x71,
  0xC1, 0xC7, 0x0E, 0x0E, 0x78, 0x3F, 0x80, 0xFC, 0x07, 0xF8, 0x3C, 0xF1,
  0xC1, 0xCE, 0x07, 0xB8, 0x0E, 0xE0, 0x3B, 0x81, 0xEE, 0x07, 0x3E, 0x7C,
  0x7F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xE7, 0x8F, 0x0F, 0x38,
  0x1C, 0xE0, 0x77, 0x01, 0xDC, 0x07, 0x70, 0x3D, 0xC0, 0xF7, 0x87, 0x8F,
  0xFE, 0x3F, 0xB8, 0x3C, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x33, 0xE0, 0xFF, 0x03, 0xF8, 0x00, 0x0E, 0x3C, 0x78, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x1C, 0x78, 0xF0, 0x03, 0x83,
  0xC1, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x00, 0x00, 0x08,
  0x00, 0xC0, 0x1E, 0x03, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3C, 0x00, 0x60, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x06, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x78, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0x78, 0x03, 0x00,
  0x00, 0x3F, 0xCF, 0xF9, 0xC7, 0xA0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x78, 0x0F, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0x80, 0x3C, 0x0F, 0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x18, 0x70, 0x00,
  0x71, 0x83, 0xF9, 0xCE, 0x1F, 0xE3, 0x30, 0xE3, 0x0D, 0xC7, 0x0C, 0x36,
  0x38, 0x71, 0xD8, 0xE1, 0xC7, 0xE3, 0x06, 0x1B, 0x8C, 0x38, 0x6E, 0x30,
  0xE3, 0xB8, 0xC7, 0x8C, 0xE3, 0xB7, 0xF3, 0x8F, 0xDF, 0x86, 0x0C, 0x38,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x04, 0x01, 0xFB, 0xE0, 0x03,
  0xFF, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xEE, 0x00, 0xEE, 0x01, 0xC6, 0x01, 0xC6, 0x03,
  0x87, 0x03, 0x87, 0x07, 0x07, 0x07, 0x07, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F,
  0xFF, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x78, 0x07, 0x70, 0x07, 0xF0,
  0x07, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x0E, 0x0F, 0x1E, 0x0F, 0x1C,
  0x0F, 0x1C, 0x0F, 0x1C, 0x0E, 0x1C, 0x1E, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F,
  0xF8, 0x38, 0x3C, 0x38, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70,
  0x3C, 0xF0, 0x78, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x01, 0xFE, 0x07,
  0xFF, 0x0F, 0xCE, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x7F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x81,
  0xC1, 0xE1, 0xE0, 0x70, 0xE0, 0x3C, 0x70, 0x1E, 0x38, 0x0F, 0x1C, 0x07,
  0x9E, 0x03, 0xCE, 0x01, 0xE7, 0x00, 0xF3, 0x80, 0x71, 0xC0, 0x79, 0xE0,
  0x3C, 0xE0, 0x1C, 0x70, 0x1E, 0x38, 0x1E, 0x3C, 0x3E, 0x1F, 0xFE, 0x0F,
  0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xFE,
  0x1F, 0xF8, 0x3F, 0xF0, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xF3, 0xC3, 0xE0,
  0x23, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x1F, 0xDC, 0x0F, 0xCE, 0x0F, 0xE7, 0x00, 0x73, 0x80, 0x39,
  0xC0, 0x3C, 0xE0, 0x1C, 0x78, 0x0E, 0x3E, 0x07, 0x0F, 0xFF, 0x83, 0xFF,
  0xC0, 0xFF, 0x80, 0x0F, 0x01, 0xE1, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x00,
  0xE1, 0xE0, 0x3C, 0x38, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x07,
  0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0x80, 0x70, 0x70, 0x1E,
  0x1C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x0E, 0x0E, 0x01, 0xC3, 0xC0, 0x78,
  0x70, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0x03, 0xC3,
  0x81, 0xC0, 0xE0, 0xF0, 0x38, 0x78, 0x1E, 0x3C, 0x07, 0x1E, 0x01, 0xC7,
  0x00, 0x73, 0x80, 0x1D, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3D, 0xC0, 0x0E, 0x78, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xF0, 0x1C,
  0x3C, 0x0F, 0x07, 0x03, 0x81, 0xE0, 0xE0, 0x78, 0x38, 0x0E, 0x00, 0x0F,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0xC0, 0x7F, 0xFF, 0xFD, 0xFF, 0x80, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7E, 0x1F, 0x80, 0x6E, 0x1F, 0x80, 0xFC,
  0x1D, 0x80, 0xDC, 0x1D, 0x81, 0xDC, 0x1D, 0x81, 0x9C, 0x39, 0x83, 0x9C,
  0x39, 0xC3, 0x38, 0x39, 0xC7, 0x38, 0x39, 0xC6, 0x38, 0x31, 0xCE, 0x38,
  0x71, 0xCC, 0x78, 0x71, 0xDC, 0x70, 0x71, 0xD8, 0x70, 0x71, 0xF8, 0x70,
  0xE0, 0xF0, 0x70, 0xE0, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0x0F, 0x00, 0xF0, 0xF0, 0x0E, 0x0F, 0x80, 0xE0, 0xF8, 0x0E, 0x1F, 0x80,
  0xE1, 0xDC, 0x1C, 0x1D, 0xC1, 0xC1, 0xDC, 0x1C, 0x19, 0xC1, 0xC3, 0x8E,
  0x3C, 0x38, 0xE3, 0x83, 0x8E, 0x38, 0x38, 0x73, 0x87, 0x07, 0x38, 0x70,
  0x77, 0x07, 0x07, 0x70, 0x70, 0x3F, 0x07, 0x03, 0xF0, 0xE0, 0x3F, 0x0E,
  0x01, 0xE0, 0xE0, 0x1E, 0x0E, 0x01, 0xE0, 0x03, 0xFC, 0x03, 0xFF, 0x03,
  0xE7, 0xC3, 0xC0, 0xF3, 0xC0, 0x79, 0xC0, 0x1D, 0xE0, 0x0E, 0xE0, 0x07,
  0x70, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3B, 0x80, 0x1D, 0xC0, 0x1E, 0xE0, 0x0E, 0x78, 0x0F, 0x3C, 0x0F, 0x0F,
  0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8,
  0x70, 0xF1, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x78,
  0x3C, 0xE1, 0xF1, 0xFF, 0xC3, 0xFF, 0x07, 0xC0, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xFC, 0x03, 0xFF, 0x03, 0xE7, 0xC3, 0xC0, 0xF3, 0xC0, 0x79, 0xC0,
  0x1D, 0xE0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x1E, 0xE0, 0x0E,
  0x78, 0x0F, 0x3C, 0x0F, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xF8, 0x70, 0xF1, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E,
  0x07, 0x1C, 0x1E, 0x78, 0x78, 0xFF, 0xE1, 0xFF, 0x83, 0xFC, 0x07, 0x3C,
  0x1C, 0x38, 0x38, 0x70, 0x70, 0xF0, 0xE0, 0xE3, 0xC1, 0xC7, 0x03, 0xCE,
  0x07, 0x9C, 0x07, 0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x3E, 0x70, 0xF0, 0x21,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE2, 0x03, 0xC7, 0xFF, 0x8F, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0x81, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE7, 0x80, 0xF3, 0x80, 0x71,
  0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x78, 0x0F, 0x38, 0x07, 0x1C, 0x03,
  0x8E, 0x01, 0xCF, 0x00, 0xE7, 0x00, 0xF3, 0x80, 0x71, 0xC0, 0x38, 0xE0,
  0x3C, 0x70, 0x1C, 0x3C, 0x1E, 0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x00,
  0xE0, 0x0F, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x38,
  0xE0, 0x70, 0xE0, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0x61, 0xC0, 0x71, 0xC0,
  0x73, 0x80, 0x73, 0x80, 0x77, 0x00, 0x77, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xE0, 0x3C, 0x07, 0xE0,
  0x3C, 0x0F, 0xE0, 0x7C, 0x0E, 0xE0, 0x7C, 0x1E, 0xE0, 0x7C, 0x1C, 0xE0,
  0xFC, 0x1C, 0xE0, 0xDC, 0x38, 0xE1, 0xDC, 0x38, 0xE1, 0xDC, 0x78, 0xE3,
  0x9C, 0x70, 0xE3, 0x9C, 0x70, 0xE3, 0x1C, 0xE0, 0xE7, 0x1C, 0xE0, 0xE6,
  0x1D, 0xC0, 0xEE, 0x1D, 0xC0, 0xEE, 0x1D, 0xC0, 0xFC, 0x1F, 0x80, 0xFC,
  0x1F, 0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x1E, 0x00, 0xF0,
  0x1E, 0x00, 0x07, 0x80, 0xF0, 0x38, 0x1E, 0x03, 0x83, 0xC0, 0x3C, 0x38,
  0x01, 0xC7, 0x00, 0x1C, 0xF0, 0x01, 0xCE, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xB8, 0x00, 0x73, 0xC0, 0x0E, 0x1C, 0x01, 0xE1, 0xC0, 0x1C,
  0x1C, 0x03, 0x81, 0xE0, 0x78, 0x0E, 0x0F, 0x00, 0xE0, 0xE0, 0x3F, 0x80,
  0xEE, 0x07, 0x9C, 0x1C, 0x70, 0xE1, 0xC3, 0x87, 0x1C, 0x1C, 0xF0, 0x3B,
  0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x03,
  0xF0, 0x3F, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x7E,
  0x07, 0xE0, 0xFE, 0x00, 0xE1, 0x86, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0xC3,
  0x8E, 0x38, 0xE3, 0x8E, 0x18, 0x71, 0xC7, 0x1C, 0x70, 0x07, 0xF0, 0x7E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFE, 0x0F, 0xC0,
  0xFC, 0x00, 0x01, 0x80, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x0E, 0xE0, 0x3B,
  0x81, 0xC6, 0x06, 0x1C, 0x38, 0x30, 0xC0, 0xE7, 0x03, 0x98, 0x06, 0xE0,
  0x1C, 0xFF, 0xFF, 0xFF, 0xE7, 0x1C, 0xE3, 0x80, 0x07, 0xCE, 0x1F, 0xDC,
  0x7F, 0xB1, 0xE1, 0xE3, 0x83, 0xCF, 0x07, 0x9C, 0x0F, 0x38, 0x1C, 0x70,
  0x39, 0xE0, 0x73, 0x81, 0xE7, 0x03, 0xCE, 0x0F, 0x1E, 0x1E, 0x1E, 0xFC,
  0x3F, 0xB8, 0x3E, 0x60, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x3C, 0x0E, 0xFC, 0x1B, 0xFC, 0x7C,
  0x38, 0xF0, 0x71, 0xC0, 0xE3, 0x81, 0xCF, 0x03, 0x9C, 0x07, 0x38, 0x1E,
  0x70, 0x38, 0xE0, 0x73, 0xC1, 0xE7, 0x83, 0x8F, 0x9F, 0x1B, 0xFC, 0x73,
  0xE0, 0x03, 0xF0, 0xFF, 0x1F, 0xF3, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x07,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x79, 0xC7,
  0xFC, 0x1F, 0x80, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x07, 0xCE, 0x0F, 0xEE, 0x1F, 0xFC, 0x3C,
  0x3C, 0x38, 0x3C, 0x78, 0x3C, 0x70, 0x3C, 0x70, 0x38, 0xF0, 0x38, 0xF0,
  0x38, 0xE0, 0x78, 0xE0, 0x78, 0xE0, 0xF0, 0xF0, 0xF0, 0x7B, 0xF0, 0x7F,
  0x70, 0x3E, 0x60, 0x03, 0xE0, 0x7F, 0x87, 0xFE, 0x78, 0x73, 0x83, 0xBC,
  0x1D, 0xC3, 0xCF, 0xFC, 0xFF, 0xC7, 0xF0, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xE3, 0x8F, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xFC,
  0x03, 0xFC, 0x03, 0xFE, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x09, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x00, 0x03, 0xE7, 0x07, 0xF7, 0x0F, 0xF6, 0x1E, 0x1E, 0x1C, 0x1E, 0x3C,
  0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x78, 0x1C, 0x70, 0x3C, 0x70,
  0x3C, 0x70, 0x78, 0x78, 0x78, 0x3D, 0xF8, 0x3F, 0xB8, 0x1F, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0xC1, 0xE0, 0xFF, 0xC0, 0xFF,
  0x80, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x3C, 0x0E, 0xFC, 0x1B, 0xFC, 0x7C, 0x38, 0xF0, 0x71,
  0xC0, 0xE3, 0x81, 0xCF, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0,
  0xF3, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x78, 0x3C, 0x07, 0x07,
  0x07, 0x02, 0x00, 0x00, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C,
  0x38, 0x38, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0xF0, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x02, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x09, 0xC0, 0xFC, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x0F, 0x0E, 0x1E,
  0x0E, 0x3C, 0x1C, 0x78, 0x1C, 0xF0, 0x1C, 0xE0, 0x1D, 0xC0, 0x3B, 0x80,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3D, 0xC0, 0x39, 0xE0, 0x70, 0xE0, 0x70, 0xE0,
  0x70, 0xF0, 0x70, 0x70, 0xF0, 0x78, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70,
  0x78, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70,
  0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0x0C, 0x78, 0x7C,
  0x19, 0xF9, 0xFC, 0x37, 0xF7, 0xF8, 0xF8, 0xF8, 0x71, 0xE1, 0xF0, 0xE3,
  0x83, 0xC1, 0xC7, 0x07, 0x83, 0x9E, 0x0E, 0x07, 0x38, 0x1C, 0x1C, 0x70,
  0x38, 0x38, 0xE0, 0xF0, 0x71, 0xC1, 0xC0, 0xE7, 0x83, 0x83, 0xCE, 0x07,
  0x07, 0x1C, 0x0E, 0x0E, 0x38, 0x38, 0x1C, 0xF0, 0x70, 0x38, 0x0E, 0x78,
  0x19, 0xF8, 0x77, 0xF8, 0xF8, 0x71, 0xE0, 0xE3, 0xC1, 0xC7, 0x07, 0x9E,
  0x0F, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC1, 0xE7, 0x83, 0x8E, 0x07,
  0x1C, 0x0E, 0x38, 0x1C, 0xF0, 0x78, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F,
  0x0E, 0x38, 0x3D, 0xE0, 0x77, 0x01, 0xDC, 0x07, 0xF0, 0x3F, 0x80, 0xEE,
  0x03, 0xB8, 0x0E, 0xE0, 0x73, 0xC3, 0xC7, 0xBE, 0x1F, 0xF0, 0x1F, 0x80,
  0x07, 0x3C, 0x06, 0x7E, 0x06, 0xFF, 0x0F, 0x87, 0x0F, 0x07, 0x0E, 0x07,
  0x0E, 0x07, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x0F, 0x1C, 0x0E, 0x1C, 0x0E,
  0x3C, 0x1E, 0x3C, 0x1C, 0x3E, 0x7C, 0x3F, 0xF8, 0x3B, 0xE0, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x07, 0xCE, 0x1F, 0xDC, 0x7F, 0xB1, 0xE1, 0xE3, 0x83, 0xCF, 0x07, 0x9C,
  0x0F, 0x38, 0x1C, 0x70, 0x39, 0xE0, 0x73, 0x81, 0xE7, 0x03, 0xCE, 0x0F,
  0x1E, 0x1E, 0x1E, 0xFC, 0x3F, 0xB8, 0x3E, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x70, 0xCF,
  0x0D, 0xF1, 0xF8, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x00, 0x07,
  0xE1, 0xFF, 0x3E, 0xF3, 0x81, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x1C, 0x01, 0xE8, 0x1C, 0xE3, 0xCF, 0xF8, 0xFF,
  0x00, 0x06, 0x03, 0x80, 0xC0, 0xFF, 0x7F, 0xFF, 0xE3, 0xC0, 0xE0, 0x38,
  0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x87,
  0xE1, 0xF8, 0x1C, 0x0E, 0x38, 0x3C, 0xF0, 0x71, 0xC0, 0xE3, 0x81, 0xC7,
  0x03, 0x8E, 0x0F, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC1, 0xE7, 0x83,
  0x8F, 0x0F, 0x1E, 0x1E, 0x3E, 0xFC, 0x3F, 0xB8, 0x3E, 0x60, 0xE0, 0x3F,
  0x03, 0xB8, 0x1D, 0xC1, 0xCE, 0x0E, 0x70, 0xE3, 0x87, 0x1C, 0x70, 0xE3,
  0x87, 0x38, 0x39, 0xC0, 0xDC, 0x06, 0xE0, 0x36, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x00, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE1, 0xF0, 0xEE, 0x1F, 0x0E,
  0xE3, 0xF1, 0xCE, 0x3F, 0x1C, 0xE3, 0x71, 0xCE, 0x77, 0x38, 0xE6, 0x73,
  0x8E, 0xE7, 0x70, 0xEE, 0x77, 0x0F, 0xC7, 0x60, 0xFC, 0x7E, 0x0F, 0x87,
  0xE0, 0xF8, 0x7C, 0x0F, 0x07, 0xC0, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x0E,
  0x0E, 0x0E, 0x1C, 0x0F, 0x3C, 0x07, 0x78, 0x07, 0x70, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0E, 0xE0, 0x1C, 0xE0, 0x3C,
  0xF0, 0x38, 0x70, 0x70, 0x70, 0xF0, 0x78, 0x07, 0x01, 0xC1, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x1C, 0x07, 0x07, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C,
  0x70, 0x03, 0x1C, 0x00, 0xCE, 0x00, 0x3B, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x07, 0x80, 0x0F, 0xE0, 0x03, 0xE0,
  0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xE0, 0x07, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0xF0, 0x1F, 0x01, 0xE0,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x01,
  0xE0, 0x7C, 0x07, 0x00, 0xFC, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3E, 0x01, 0xE0, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0x01, 0xF0, 0x1F, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0C, 0x01, 0xC0, 0x3E, 0x01, 0xC1, 0xF8, 0x38, 0x0E, 0x01,
  0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0xF8, 0x1E, 0x03,
  0x80, 0x00, 0x7C, 0x0F, 0xFC, 0xFB, 0xFF, 0x03, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 22, 8, 0, -22 },
  { 26, 10, 8, 12, 3, -22 },
  { 36, 17, 22, 18, 1, -22 },
  { 83, 14, 26, 15, 1, -24 },
  { 129, 20, 22, 23, 2, -22 },
  { 184, 17, 22, 19, 1, -22 },
  { 231, 5, 8, 7, 3, -22 },
  { 236, 10, 27, 9, 1, -22 },
  { 270, 10, 27, 9, -2, -22 },
  { 304, 13, 14, 15, 3, -24 },
  { 327, 13, 15, 16, 2, -18 },
  { 352, 6, 8, 8, -1, -4 },
  { 358, 7, 3, 9, 1, -10 },
  { 361, 5, 4, 8, 0, -4 },
  { 364, 15, 22, 11, -1, -22 },
  { 406, 14, 22, 15, 1, -22 },
  { 445, 9, 22, 15, 4, -22 },
  { 470, 16, 22, 15, -1, -22 },
  { 514, 15, 22, 15, 0, -22 },
  { 556, 15, 22, 15, 0, -22 },
  { 598, 15, 22, 15, 0, -22 },
  { 640, 15, 22, 15, 1, -22 },
  { 682, 14, 22, 15, 2, -22 },
  { 721, 14, 22, 15, 1, -22 },
  { 760, 14, 22, 15, 1, -22 },
  { 799, 7, 17, 8, 0, -17 },
  { 814, 9, 21, 8, -2, -17 },
  { 838, 13, 15, 16, 2, -19 },
  { 863, 13, 8, 16, 2, -15 },
  { 876, 13, 15, 16, 2, -19 },
  { 901, 11, 22, 12, 2, -22 },
  { 932, 22, 25, 24, 1, -22 },
  { 1001, 16, 22, 16, -2, -22 },
  { 1045, 16, 22, 17, 1, -22 },
  { 1089, 16, 22, 16, 2, -22 },
  { 1133, 17, 22, 19, 1, -22 },
  { 1180, 15, 22, 15, 1, -22 },
  { 1222, 15, 22, 14, 1, -22 },
  { 1264, 17, 22, 19, 2, -22 },
  { 1311, 19, 22, 19, 1, -22 },
  { 1364, 13, 22, 10, -1, -22 },
  { 1400, 14, 28, 8, -5, -22 },
  { 1449, 18, 22, 16, 1, -22 },
  { 1499, 11, 22, 14, 1, -22 },
  { 1530, 24, 22, 24, 1, -22 },
  { 1596, 20, 22, 20, 1, -22 },
  { 1651, 17, 22, 20, 2, -22 },
  { 1698, 15, 22, 16, 1, -22 },
  { 1740, 17, 27, 20, 2, -22 },
  { 1798, 15, 22, 16, 1, -22 },
  { 1840, 15, 22, 14, 0, -22 },
  { 1882, 14, 22, 14, 3, -22 },
  { 1921, 17, 22, 19, 2, -22 },
  { 1968, 16, 22, 16, 3, -22 },
  { 2012, 24, 22, 25, 3, -22 },
  { 2078, 20, 22, 15, -2, -22 },
  { 2133, 14, 22, 15, 3, -22 },
  { 2172, 17, 22, 14, -1, -22 },
  { 2219, 12, 27, 9, -1, -22 },
  { 2260, 6, 22, 11, 3, -22 },
  { 2277, 12, 27, 9, -2, -22 },
  { 2318, 14, 13, 16, 1, -22 },
  { 2341, 12, 2, 11, -3, 3 },
  { 2344, 5, 5, 9, 5, -24 },
  { 2348, 15, 17, 16, 1, -17 },
  { 2380, 15, 24, 16, 0, -24 },
  { 2425, 12, 17, 13, 1, -17 },
  { 2451, 16, 24, 16, 1, -24 },
  { 2499, 13, 17, 15, 1, -17 },
  { 2527, 17, 31, 9, -4, -24 },
  { 2593, 16, 24, 16, 0, -17 },
  { 2641, 15, 24, 16, 0, -24 },
  { 2686, 8, 23, 8, 0, -23 },
  { 2709, 12, 30, 8, -4, -23 },
  { 2754, 16, 24, 14, 0, -24 },
  { 2802, 9, 24, 8, 0, -24 },
  { 2829, 23, 17, 25, 0, -17 },
  { 2878, 15, 17, 16, 0, -17 },
  { 2910, 14, 17, 16, 1, -17 },
  { 2940, 16, 24, 16, -1, -17 },
  { 2988, 15, 24, 16, 1, -17 },
  { 3033, 12, 17, 11, 0, -17 },
  { 3059, 12, 17, 12, 0, -17 },
  { 3085, 10, 20, 10, 1, -20 },
  { 3110, 15, 17, 16, 1, -17 },
  { 3142, 13, 17, 13, 2, -17 },
  { 3170, 20, 17, 21, 2, -17 },
  { 3213, 16, 17, 14, -1, -17 },
  { 3247, 18, 24, 14, -3, -17 },
  { 3301, 14, 17, 12, -1, -17 },
  { 3331, 12, 27, 11, 0, -22 },
  { 3372, 3, 31, 15, 6, -24 },
  { 3384, 11, 27, 11, -1, -22 },
  { 3422, 13, 4, 16, 2, -13 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC31PT7B_H_
