#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC43PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C,
  0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x02, 0x00, 0x3C, 0x7C, 0xF1,
  0xF3, 0xC7, 0x8F, 0x1E, 0x78, 0x79, 0xE1, 0xC7, 0x87, 0x1C, 0x3C, 0x70,
  0xF1, 0xC3, 0x8F, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1C, 0x00,
  0x38, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x78, 0x38, 0x00, 0x70, 0x78, 0x00,
  0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0xF0, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x01, 0xC1, 0xE0, 0x01, 0xC1, 0xC0, 0x03,
  0xC1, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x83, 0x80, 0x07,
  0x87, 0x84, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x0E,
  0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0x98,
  0x60, 0xF1, 0x80, 0x0F, 0x18, 0x01, 0xF3, 0x80, 0x1F, 0x38, 0x00, 0xF3,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x6F, 0x80, 0x0E, 0x78, 0x00, 0xE7, 0x80,
  0x0C, 0x78, 0x00, 0xC7, 0x88, 0x1C, 0x78, 0xE1, 0xCF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x03, 0xC0,
  0xFE, 0x00, 0x78, 0x1F, 0xF0, 0x07, 0x03, 0xC7, 0x00, 0xE0, 0x38, 0x70,
  0x1E, 0x07, 0x87, 0x81, 0xC0, 0x70, 0x70, 0x38, 0x07, 0x07, 0x07, 0x80,
  0xF0, 0x70, 0x70, 0x0F, 0x07, 0x0F, 0x00, 0xE0, 0xF1, 0xE0, 0x0E, 0x0F,
  0x1C, 0x00, 0xE0, 0xE3, 0xC7, 0x8E, 0x1E, 0x79, 0xFC, 0xE1, 0xE7, 0x3F,
  0xEF, 0x3C, 0xF7, 0xDE, 0xFF, 0x9E, 0x78, 0xF7, 0xF1, 0xCF, 0x0F, 0x3E,
  0x3C, 0xF0, 0xF0, 0x07, 0x8E, 0x0F, 0x00, 0x71, 0xE0, 0xE0, 0x0F, 0x1E,
  0x0E, 0x01, 0xE1, 0xE0, 0xE0, 0x1C, 0x1C, 0x1E, 0x03, 0xC1, 0xC1, 0xE0,
  0x78, 0x1C, 0x1C, 0x07, 0x01, 0xC3, 0xC0, 0xF0, 0x1E, 0x78, 0x1E, 0x01,
  0xFF, 0x81, 0xC0, 0x0F, 0xF0, 0x3C, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xF3, 0xE0, 0x03, 0xE1, 0xF0,
  0x03, 0xC1, 0xF0, 0x03, 0xC1, 0xF0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0,
  0x03, 0xC3, 0xE0, 0x03, 0xC7, 0xC0, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x0F,
  0x1F, 0x7C, 0x1E, 0x3E, 0x3E, 0x1E, 0x7C, 0x3E, 0x3C, 0x78, 0x1F, 0x3C,
  0xF8, 0x1F, 0x78, 0xF0, 0x0F, 0xF8, 0xF0, 0x07, 0xF0, 0xF0, 0x07, 0xE0,
  0xF0, 0x07, 0xE0, 0xF8, 0x0F, 0xE0, 0xFE, 0x7F, 0xF0, 0x7F, 0xFE, 0xF8,
  0x3F, 0xF8, 0xF8, 0x1F, 0xF0, 0x7C, 0x3E, 0x78, 0xF1, 0xE7, 0x8F, 0x1E,
  0x3C, 0x70, 0xE3, 0xC0, 0x00, 0x3E, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00,
  0xE8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x40, 0xE0, 0x1C, 0x38,
  0x07, 0xCE, 0x03, 0xFF, 0x9F, 0x3F, 0xFF, 0xC0, 0xFF, 0xF0, 0x3E, 0xFC,
  0x1F, 0x80, 0x0F, 0x70, 0x0F, 0x9C, 0x07, 0xC7, 0x80, 0xF0, 0xE0, 0x18,
  0x3C, 0x02, 0x0E, 0x00, 0x02, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x0F, 0x87, 0x87, 0xC3,
  0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x38, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xE0, 0x33, 0xFF, 0xFF, 0xF9, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0xFC, 0x3C, 0x1F, 0x07, 0xC7, 0xC0, 0xF8, 0xF0,
  0x0F, 0x3E, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0xBE, 0x01, 0xF7, 0x80,
  0x3E, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1E, 0xF8, 0x03, 0xDE, 0x00,
  0x7B, 0xC0, 0x1F, 0x78, 0x03, 0xEF, 0x00, 0x79, 0xE0, 0x1F, 0x3C, 0x03,
  0xE7, 0x80, 0x78, 0xF0, 0x1F, 0x1E, 0x07, 0xC3, 0xE0, 0xF8, 0x3F, 0x7E,
  0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x78, 0x07, 0xC0,
  0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xF9, 0xFB, 0xDF, 0x9E, 0x71, 0xF1, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xE0,
  0xFC, 0x06, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x38, 0x1F, 0x81, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x30, 0x03, 0xE1,
  0xF0, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x7B, 0xC0, 0x03, 0xBC, 0x00, 0x3D, 0xE0, 0x03,
  0xCF, 0x00, 0x3C, 0x78, 0x01, 0xE7, 0xC0, 0x1E, 0x3C, 0x01, 0xE1, 0xE0,
  0x1E, 0x0F, 0x01, 0xE0, 0xF8, 0x0F, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x01,
  0xE0, 0xF0, 0x0F, 0x07, 0x80, 0xF8, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x80, 0x1F, 0x0F, 0x0F, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFE, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC1, 0x00, 0x3C, 0xFE, 0x07,
  0xBF, 0xF0, 0x7B, 0xFF, 0x87, 0xF0, 0xF8, 0x7C, 0x07, 0x8F, 0xC0, 0x7C,
  0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x78, 0xF0, 0x07,
  0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x07, 0xE7,
  0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFC,
  0x03, 0xFF, 0xE0, 0x7E, 0x3F, 0x07, 0xC1, 0xF0, 0x78, 0x0F, 0x0F, 0x80,
  0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF8, 0x1F, 0x07, 0x81, 0xE0, 0x7C,
  0x3E, 0x03, 0xEF, 0xC0, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F,
  0xFE, 0x01, 0xF9, 0xF0, 0x3E, 0x0F, 0x87, 0xC0, 0x78, 0x78, 0x07, 0xCF,
  0x80, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x07, 0xCF, 0x80, 0x7C,
  0xF8, 0x0F, 0x87, 0xE1, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F,
  0x83, 0xE0, 0xF0, 0x1E, 0x1F, 0x01, 0xE1, 0xE0, 0x1F, 0x3E, 0x01, 0xF3,
  0xE0, 0x1F, 0x3C, 0x01, 0xF3, 0xC0, 0x1F, 0x3C, 0x01, 0xE3, 0xE0, 0x3E,
  0x3E, 0x07, 0xE3, 0xF0, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xF3,
  0xC0, 0x3C, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x0E, 0x1F, 0x80, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x01, 0x01, 0xF0, 0xFC, 0x3F,
  0x0F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01, 0xF0, 0x7C, 0x3F, 0x0F, 0xC1,
  0xE0, 0x20, 0x00, 0x00, 0x40, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x01, 0xF0,
  0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x70,
  0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x1C, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF8, 0x1F,
  0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x18, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x20,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0x81, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xC0,
  0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x3C, 0x78,
  0x1F, 0xF8, 0xF3, 0xC0, 0xFF, 0xC1, 0xCF, 0x07, 0xCF, 0x07, 0x38, 0x3C,
  0x3C, 0x1D, 0xE1, 0xE0, 0xF0, 0x77, 0x07, 0x03, 0x81, 0xDC, 0x3C, 0x0E,
  0x0F, 0xF0, 0xE0, 0x78, 0x3B, 0x83, 0x81, 0xE0, 0xEE, 0x1E, 0x07, 0x03,
  0xB8, 0x78, 0x3C, 0x1E, 0xE1, 0xE0, 0xF0, 0x73, 0x87, 0x87, 0xC3, 0xCE,
  0x1E, 0x1F, 0x1E, 0x38, 0x3F, 0xFF, 0xF0, 0xE0, 0xFF, 0x3F, 0x83, 0xC1,
  0xF8, 0xFC, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x01, 0x00, 0x07, 0xF0, 0x7C,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC,
  0x00, 0x0F, 0x78, 0x00, 0x3C, 0x70, 0x00, 0x78, 0xF0, 0x01, 0xE1, 0xE0,
  0x03, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x78, 0x1E, 0x00,
  0xF0, 0x3C, 0x03, 0xE0, 0x78, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xE0, 0x0F, 0x07, 0xC0, 0x1F, 0x0F, 0x00,
  0x3E, 0x3E, 0x00, 0x7C, 0x78, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xC0, 0x01,
  0xEF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xC0, 0xFC, 0x1F, 0x01, 0xF0,
  0x7C, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x01, 0xF0, 0xF8,
  0x07, 0xC3, 0xC0, 0x3E, 0x0F, 0x01, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x78, 0x0F, 0x81, 0xE0, 0x1F, 0x0F,
  0x80, 0x7C, 0x3E, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x1F, 0x0F, 0x00,
  0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0x87, 0x80, 0x7E, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0x01, 0x80,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x02, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x03, 0xC1, 0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x3E,
  0x07, 0x80, 0x3E, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1F,
  0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3E,
  0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0xF8,
  0x3C, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x7C, 0x07, 0xE0, 0x78, 0x1F, 0xC0,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xF8, 0x0E, 0x07,
  0xE0, 0x02, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x07, 0xFE, 0x7C, 0x07, 0xFC, 0x78, 0x07, 0xFC, 0x78,
  0x07, 0xFC, 0xF8, 0x08, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF8,
  0x00, 0x78, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7E,
  0x00, 0xF0, 0x3F, 0x00, 0xF0, 0x3F, 0xEF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xE0, 0x03, 0xC0, 0xF8, 0x01, 0xF0,
  0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x81, 0xF0, 0x03,
  0xE0, 0x7C, 0x00, 0xF8, 0x1E, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x01, 0xE0,
  0x03, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x1E, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0xF8, 0x00, 0xF0, 0x3E, 0x00,
  0x7C, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x7C,
  0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x81, 0xE0, 0x03, 0xC0,
  0x78, 0x00, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x00, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x37, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xF0, 0x0F, 0x80, 0x78,
  0x0F, 0x80, 0x3C, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F,
  0x07, 0xC0, 0x07, 0x87, 0xC0, 0x03, 0xC7, 0xC0, 0x03, 0xE7, 0xE0, 0x01,
  0xE3, 0xE0, 0x00, 0xF3, 0xE0, 0x00, 0x7B, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xDE, 0x00, 0x07, 0xCF, 0x80,
  0x07, 0xC7, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0x7C,
  0x00, 0x78, 0x1E, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1E, 0x01,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x1E, 0x03, 0xC0,
  0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0xC0,
  0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xF8,
  0x01, 0xFE, 0x03, 0xBC, 0x01, 0xEF, 0x03, 0xCE, 0x00, 0xF7, 0x81, 0xE7,
  0x00, 0xF3, 0xC0, 0xF3, 0x80, 0x73, 0xE0, 0x79, 0xC0, 0x79, 0xE0, 0x7C,
  0xF0, 0x38, 0xF0, 0x3C, 0x78, 0x3C, 0x78, 0x1E, 0x3C, 0x1C, 0x7C, 0x0F,
  0x1E, 0x1E, 0x3E, 0x07, 0x8F, 0x0E, 0x1E, 0x07, 0x87, 0x8F, 0x0F, 0x03,
  0xC3, 0xC7, 0x07, 0x81, 0xE1, 0xE7, 0x87, 0xC0, 0xF0, 0x73, 0x83, 0xC0,
  0x78, 0x3B, 0xC1, 0xE0, 0x78, 0x1D, 0xC0, 0xF0, 0x3C, 0x0F, 0xE0, 0x78,
  0x1E, 0x07, 0xE0, 0x7C, 0x0F, 0x03, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x1E,
  0x07, 0x80, 0xF8, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x3F, 0x00, 0x1E, 0x03, 0xF0, 0x01, 0xE0, 0x3F, 0x00, 0x1E, 0x03,
  0xF8, 0x03, 0xE0, 0x7F, 0x80, 0x3C, 0x07, 0xF8, 0x03, 0xC0, 0x7F, 0x80,
  0x3C, 0x07, 0xBC, 0x03, 0xC0, 0xF3, 0xC0, 0x7C, 0x0F, 0x3C, 0x07, 0x80,
  0xF3, 0xE0, 0x78, 0x0F, 0x1E, 0x07, 0x80, 0xF1, 0xE0, 0x78, 0x1F, 0x1F,
  0x0F, 0x81, 0xE0, 0xF0, 0xF0, 0x1E, 0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0xF0,
  0x1E, 0x0F, 0x9F, 0x03, 0xE0, 0x79, 0xE0, 0x3C, 0x07, 0x9E, 0x03, 0xC0,
  0x7D, 0xE0, 0x3C, 0x03, 0xDE, 0x03, 0xC0, 0x3D, 0xE0, 0x78, 0x03, 0xFC,
  0x07, 0x80, 0x1F, 0xC0, 0x78, 0x01, 0xFC, 0x07, 0x80, 0x1F, 0xC0, 0xF8,
  0x01, 0xFC, 0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x1E, 0x1F,
  0x00, 0x0F, 0x8F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF7,
  0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x1E,
  0x78, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03,
  0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x01, 0xF0, 0xF0, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0xFC, 0x07, 0xFB,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xC1,
  0xF8, 0x1F, 0x03, 0xF0, 0x7C, 0x07, 0xC1, 0xE0, 0x1F, 0x07, 0x80, 0x7C,
  0x1E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1E, 0x0F, 0x00, 0xF8, 0x3C,
  0x07, 0xE1, 0xF0, 0x3F, 0x07, 0xCF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x01, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F,
  0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7,
  0xC0, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3C,
  0xF8, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xDF, 0x00, 0x03, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x01,
  0xF0, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x0F, 0x80,
  0xFC, 0x07, 0xFB, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03,
  0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0xC1, 0xE0, 0x1F, 0x07, 0x80,
  0x7C, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0x83, 0xE0, 0x3E, 0x0F, 0x00, 0xF8,
  0x3C, 0x07, 0xC1, 0xF0, 0x7F, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F,
  0xF8, 0x01, 0xE1, 0xE0, 0x0F, 0x87, 0x80, 0x3E, 0x1F, 0x00, 0xF0, 0x7C,
  0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x07,
  0x80, 0x7C, 0x1E, 0x01, 0xF0, 0x78, 0x07, 0xC3, 0xE0, 0x0F, 0x0F, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7E, 0x07, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x30, 0x07,
  0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x1F,
  0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x1E,
  0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3C,
  0x00, 0x7C, 0x3C, 0x00, 0x78, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0x78,
  0x00, 0xF8, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF8,
  0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0,
  0x03, 0xE0, 0xF0, 0x03, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0xC0, 0xFF,
  0x7F, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xF0,
  0x00, 0x7F, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3C, 0xF0, 0x01,
  0xF3, 0xC0, 0x07, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF0, 0xF8, 0x07, 0xC3,
  0xE0, 0x1E, 0x07, 0x80, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x01, 0xE0,
  0x78, 0x07, 0x83, 0xE0, 0x1E, 0x0F, 0x00, 0x78, 0x7C, 0x01, 0xE1, 0xE0,
  0x07, 0x8F, 0x80, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE7, 0x80, 0x07,
  0x9E, 0x00, 0x1E, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0xFC, 0x00, 0xF8, 0x01, 0xEF, 0x00, 0x3E,
  0x00, 0xFB, 0xC0, 0x0F, 0x80, 0x3C, 0xF0, 0x07, 0xE0, 0x0F, 0x3C, 0x01,
  0xF8, 0x07, 0xCF, 0x00, 0xFE, 0x01, 0xE3, 0xC0, 0x3B, 0x80, 0xF8, 0xF0,
  0x1E, 0xE0, 0x3C, 0x3C, 0x07, 0xB8, 0x1F, 0x0F, 0x03, 0xCE, 0x07, 0x83,
  0xC0, 0xF3, 0x81, 0xE0, 0xF0, 0x38, 0xE0, 0xF8, 0x3C, 0x1E, 0x38, 0x3C,
  0x0F, 0x07, 0x8E, 0x1F, 0x03, 0xC3, 0xC3, 0x87, 0x80, 0xF0, 0xF0, 0xE1,
  0xE0, 0x3C, 0x78, 0x38, 0xF0, 0x0F, 0x1E, 0x0E, 0x3C, 0x03, 0xC7, 0x03,
  0x9F, 0x00, 0xF3, 0xC0, 0xE7, 0x80, 0x1C, 0xF0, 0x39, 0xE0, 0x07, 0x78,
  0x0E, 0xF0, 0x01, 0xDE, 0x03, 0xBC, 0x00, 0x77, 0x00, 0xEE, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x0F, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00,
  0x78, 0x07, 0x80, 0x0F, 0x01, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x1F,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0x7C, 0x00,
  0x07, 0xC7, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x83,
  0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x3E, 0x00, 0xF0, 0x01,
  0xFF, 0x80, 0x1E, 0xF8, 0x03, 0xE7, 0x80, 0x7C, 0x78, 0x07, 0x87, 0x80,
  0xF8, 0x78, 0x0F, 0x07, 0xC1, 0xF0, 0x3C, 0x3E, 0x03, 0xC3, 0xC0, 0x3C,
  0x7C, 0x03, 0xC7, 0x80, 0x3C, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0x70, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x38, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E,
  0x0F, 0x0F, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xDE, 0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0x70,
  0x07, 0x07, 0x80, 0xF0, 0x78, 0x1E, 0x03, 0x81, 0xE0, 0x3C, 0x3C, 0x01,
  0xC3, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x0E, 0xF0, 0x00, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF1, 0xF1, 0xE1, 0xE3, 0xC3, 0x80,
  0x00, 0x60, 0x00, 0x3F, 0x8F, 0x07, 0xFC, 0xF0, 0xFF, 0xEF, 0x1F, 0x8F,
  0xE1, 0xF0, 0x7E, 0x3E, 0x03, 0xE3, 0xC0, 0x3E, 0x7C, 0x03, 0xC7, 0x80,
  0x3C, 0xF8, 0x03, 0xCF, 0x80, 0x3C, 0xF8, 0x07, 0xCF, 0x00, 0x78, 0xF0,
  0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x01, 0xF8, 0xF0, 0x1F, 0x0F,
  0x83, 0xF0, 0xFC, 0xFF, 0x07, 0xFE, 0xF0, 0x7F, 0xCE, 0x03, 0xF8, 0xE0,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x70, 0x0F, 0x9F, 0xC0, 0xF3, 0xFE, 0x0F, 0x7F, 0xE0, 0xFE, 0x3F, 0x0F,
  0xC1, 0xF1, 0xF8, 0x1F, 0x1F, 0x00, 0xF1, 0xF0, 0x0F, 0x1E, 0x00, 0xF3,
  0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x1F, 0x3C, 0x01, 0xE3, 0xC0, 0x1E,
  0x7C, 0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F,
  0x8F, 0xF3, 0xF0, 0xF7, 0xFF, 0x0F, 0x7F, 0xE0, 0xE3, 0xF8, 0x00, 0x00,
  0x30, 0x00, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE1, 0xF8, 0x20, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1F, 0x01, 0x0F, 0xC3, 0x83, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x01, 0x83, 0xC0, 0x3F, 0x8F, 0x01, 0xFF, 0x7C, 0x0F,
  0xFF, 0xE0, 0x7E, 0x3F, 0x81, 0xF0, 0x7E, 0x0F, 0x80, 0xF8, 0x3C, 0x03,
  0xE1, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xF8, 0x07, 0xC3,
  0xE0, 0x1F, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x83, 0xC0,
  0x3E, 0x0F, 0x01, 0xF0, 0x3C, 0x07, 0xC0, 0xF8, 0x3F, 0x03, 0xF3, 0xFC,
  0x07, 0xFE, 0xF0, 0x1F, 0xF3, 0x80, 0x3F, 0x8E, 0x00, 0x00, 0x30, 0x00,
  0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF1, 0xF8, 0x78, 0xF0, 0x3C, 0xF8, 0x1E,
  0xF8, 0x0F, 0x78, 0x0F, 0xBC, 0x0F, 0xBE, 0x3F, 0xDF, 0xFF, 0x8F, 0xFF,
  0x87, 0xFE, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x8F, 0xC1, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x4F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xF8, 0xF0, 0x1F, 0xF3,
  0xC0, 0xFF, 0xEF, 0x07, 0xE3, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x0F, 0x83,
  0xC0, 0x3E, 0x1F, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xE0, 0x0F, 0x0F, 0x80,
  0x7C, 0x3E, 0x01, 0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0xF8,
  0x3C, 0x03, 0xE0, 0xF0, 0x1F, 0x83, 0xC0, 0xFC, 0x0F, 0x83, 0xF0, 0x3F,
  0x3F, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0x78, 0x03, 0xF9, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x02,
  0x00, 0xF8, 0x0F, 0x0F, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x70, 0x0F, 0x9F, 0xC0, 0xF3, 0xFE, 0x0F, 0x7F, 0xE0, 0xFE,
  0x3F, 0x0F, 0xC1, 0xF1, 0xF8, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1E, 0x1E,
  0x01, 0xE3, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xC3,
  0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0xC0, 0x3C, 0x78, 0x07, 0xC7, 0x80, 0x78,
  0x78, 0x07, 0x8F, 0x80, 0x78, 0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0xF0, 0x0F,
  0x00, 0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F,
  0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x02, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x43, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0,
  0x7C, 0x07, 0x83, 0xC0, 0x3C, 0x3E, 0x03, 0xE3, 0xE0, 0x1E, 0x3E, 0x00,
  0xF3, 0xE0, 0x07, 0xBE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0x07, 0xCF, 0x00, 0x7C, 0x7C, 0x03, 0xC3, 0xE0, 0x1E,
  0x0F, 0x00, 0xF0, 0x7C, 0x07, 0x83, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0x7C,
  0x1E, 0x03, 0xE0, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0,
  0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78,
  0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x60, 0x1E, 0x3F, 0x87, 0xF0,
  0x3D, 0xFF, 0x1F, 0xF0, 0x7B, 0xFF, 0x7F, 0xF0, 0xFE, 0x3F, 0xE3, 0xE1,
  0xF8, 0x3F, 0x03, 0xC7, 0xE0, 0x7E, 0x07, 0x8F, 0x80, 0xF8, 0x0F, 0x1F,
  0x01, 0xE0, 0x1E, 0x3C, 0x03, 0xC0, 0x7C, 0xF8, 0x0F, 0x80, 0xF1, 0xF0,
  0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0x07, 0x8F, 0x00,
  0xF0, 0x1F, 0x3E, 0x03, 0xE0, 0x3C, 0x7C, 0x07, 0x80, 0x78, 0xF0, 0x0F,
  0x00, 0xF1, 0xE0, 0x1E, 0x03, 0xE3, 0xC0, 0x7C, 0x07, 0xCF, 0x80, 0xF8,
  0x0F, 0x1E, 0x01, 0xE0, 0x1E, 0x3C, 0x03, 0xC0, 0x3C, 0x78, 0x07, 0x80,
  0xF8, 0x00, 0x07, 0x00, 0xF1, 0xFC, 0x0F, 0x7F, 0xE0, 0xF7, 0xFE, 0x0F,
  0xE3, 0xF1, 0xFC, 0x1F, 0x1F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1,
  0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xE0, 0x3E, 0x3C, 0x03, 0xE3, 0xC0, 0x3E,
  0x3C, 0x03, 0xC7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0x80, 0x7C, 0x78, 0x07,
  0x87, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x80, 0xF8, 0xF0, 0x0F, 0x8F, 0x00,
  0xF0, 0x00, 0x20, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0x8F,
  0xCF, 0xC1, 0xF3, 0xE0, 0x3D, 0xF0, 0x0F, 0x7C, 0x03, 0xDE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x1E, 0xF0, 0x07, 0xBC, 0x03, 0xEF, 0x01, 0xF3, 0xE0, 0x7C, 0x7C, 0x7E,
  0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x00, 0xE0, 0x03, 0xC7,
  0xF0, 0x07, 0x9F, 0xF0, 0x0F, 0x7F, 0xE0, 0x1F, 0xC7, 0xE0, 0x3F, 0x07,
  0xC0, 0xFC, 0x07, 0x81, 0xF0, 0x0F, 0x03, 0xE0, 0x1E, 0x07, 0x80, 0x3C,
  0x0F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0xF0, 0x07, 0x81,
  0xE0, 0x0F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x78, 0x1F, 0x01, 0xF0, 0x3E,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xFE, 0x7E, 0x03, 0xDF, 0xFC, 0x07, 0xBF,
  0xF0, 0x0F, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x3F, 0x8F, 0x07, 0xFC, 0xF0, 0xFF, 0xEF, 0x1F, 0x8F, 0xE1, 0xF0, 0x7E,
  0x3E, 0x03, 0xE3, 0xC0, 0x3E, 0x7C, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03,
  0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00,
  0xF8, 0xF0, 0x0F, 0x8F, 0x01, 0xF8, 0xF0, 0x1F, 0x0F, 0x83, 0xF0, 0xFC,
  0xFF, 0x07, 0xFE, 0xF0, 0x7F, 0xDE, 0x03, 0xF9, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x0F, 0x1F, 0x0F, 0x3F, 0x0F, 0x7F, 0x0F, 0xFE, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x60,
  0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xE1, 0xF0, 0x30, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x10, 0x0F, 0x8E, 0x0F, 0xC7, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF,
  0xC0, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x87, 0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0x1F,
  0x00, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x3E, 0x01, 0xE3,
  0xC0, 0x3E, 0x3C, 0x03, 0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC7, 0xC0, 0x3C,
  0x78, 0x07, 0xC7, 0x80, 0x78, 0x78, 0x07, 0x8F, 0x80, 0x78, 0xF8, 0x0F,
  0x8F, 0x00, 0xF8, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x3F, 0x0F, 0x8F,
  0xF0, 0xFF, 0xEF, 0x07, 0xFC, 0xE0, 0x3F, 0x8E, 0x00, 0xF8, 0x03, 0xFF,
  0x00, 0x7B, 0xE0, 0x1F, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF0, 0x1E, 0x1E,
  0x07, 0xC3, 0xC0, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE1, 0xE0, 0x3C,
  0x3C, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x78, 0x01, 0xCF, 0x00, 0x3B,
  0xC0, 0x07, 0x78, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x01, 0xFF, 0x01, 0xF0, 0x1E, 0xF0,
  0x3F, 0x03, 0xEF, 0x03, 0xF0, 0x3C, 0xF0, 0x7F, 0x03, 0xCF, 0x07, 0x70,
  0x7C, 0xF0, 0xF7, 0x07, 0x8F, 0x0E, 0x70, 0xF8, 0xF0, 0xE7, 0x0F, 0x0F,
  0x1E, 0x70, 0xF0, 0xF1, 0xC7, 0x1E, 0x0F, 0x3C, 0x71, 0xE0, 0xF3, 0x87,
  0x3C, 0x0F, 0x78, 0x73, 0xC0, 0xF7, 0x87, 0x7C, 0x0F, 0x70, 0x77, 0x80,
  0xFF, 0x07, 0x78, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xC0,
  0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x7E, 0x07, 0x80, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x0F,
  0x80, 0x1E, 0x1E, 0x00, 0x3E, 0x78, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xEF, 0x80, 0x07,
  0xCF, 0x00, 0x1F, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x3C, 0x03, 0xE0,
  0x78, 0x0F, 0x80, 0xF8, 0x3E, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0xF0, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x03, 0xE0,
  0x0F, 0x01, 0xE0, 0x07, 0x81, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0xF8,
  0x00, 0xF0, 0x78, 0x00, 0x78, 0x7C, 0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x3E,
  0x00, 0x07, 0x9E, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x04, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x00,
  0x07, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x1F, 0x80, 0xFF, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xF8, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x2F, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFC, 0x07, 0xFD, 0x00, 0x1E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 32, 11, 1, -31 },
  { 45, 14, 11, 17, 4, -31 },
  { 65, 24, 31, 25, 1, -31 },
  { 158, 20, 36, 21, 1, -33 },
  { 248, 28, 31, 32, 3, -31 },
  { 357, 24, 31, 26, 1, -31 },
  { 450, 7, 11, 10, 4, -31 },
  { 460, 15, 38, 12, 1, -31 },
  { 532, 14, 38, 12, -3, -31 },
  { 599, 18, 19, 21, 4, -33 },
  { 642, 19, 21, 23, 2, -26 },
  { 692, 9, 11, 11, -2, -5 },
  { 705, 11, 4, 13, 1, -14 },
  { 711, 5, 7, 11, 1, -6 },
  { 716, 21, 31, 16, -2, -31 },
  { 798, 19, 31, 21, 2, -31 },
  { 872, 13, 31, 21, 5, -31 },
  { 923, 22, 31, 21, -1, -31 },
  { 1009, 21, 31, 21, 0, -31 },
  { 1091, 21, 31, 21, 0, -31 },
  { 1173, 20, 31, 21, 1, -31 },
  { 1251, 20, 31, 21, 2, -31 },
  { 1329, 21, 31, 21, 2, -31 },
  { 1411, 20, 31, 21, 1, -31 },
  { 1489, 20, 31, 21, 1, -31 },
  { 1567, 10, 25, 11, 0, -24 },
  { 1599, 12, 30, 11, -2, -24 },
  { 1644, 19, 21, 23, 2, -26 },
  { 1694, 19, 12, 23, 2, -21 },
  { 1723, 19, 21, 23, 2, -26 },
  { 1773, 16, 32, 17, 2, -31 },
  { 1837, 30, 35, 33, 2, -31 },
  { 1969, 23, 31, 23, -3, -31 },
  { 2059, 22, 31, 23, 1, -31 },
  { 2145, 23, 31, 23, 2, -31 },
  { 2235, 24, 31, 26, 1, -31 },
  { 2328, 21, 31, 20, 1, -31 },
  { 2410, 21, 31, 19, 1, -31 },
  { 2492, 24, 31, 26, 2, -31 },
  { 2585, 26, 31, 27, 1, -31 },
  { 2686, 17, 31, 14, -1, -31 },
  { 2752, 19, 39, 11, -7, -31 },
  { 2845, 25, 31, 22, 1, -31 },
  { 2942, 15, 31, 19, 1, -31 },
  { 3001, 33, 31, 34, 1, -31 },
  { 3129, 28, 31, 28, 1, -31 },
  { 3238, 25, 31, 28, 2, -31 },
  { 3335, 22, 31, 22, 1, -31 },
  { 3421, 25, 38, 28, 2, -31 },
  { 3540, 22, 31, 23, 1, -31 },
  { 3626, 21, 31, 20, 0, -31 },
  { 3708, 19, 31, 20, 4, -31 },
  { 3782, 24, 31, 26, 3, -31 },
  { 3875, 22, 31, 22, 4, -31 },
  { 3961, 34, 31, 34, 4, -31 },
  { 4093, 27, 31, 21, -2, -31 },
  { 4198, 20, 31, 20, 4, -31 },
  { 4276, 23, 31, 20, -1, -31 },
  { 4366, 17, 38, 13, -1, -31 },
  { 4447, 8, 31, 16, 5, -31 },
  { 4478, 17, 38, 13, -3, -31 },
  { 4559, 20, 19, 22, 1, -31 },
  { 4607, 16, 3, 16, -4, 4 },
  { 4613, 7, 7, 12, 6, -33 },
  { 4620, 20, 24, 23, 2, -24 },
  { 4680, 20, 33, 23, 1, -33 },
  { 4763, 17, 24, 18, 2, -24 },
  { 4814, 22, 33, 23, 2, -33 },
  { 4905, 17, 24, 20, 2, -24 },
  { 4956, 23, 43, 13, -5, -33 },
  { 5080, 22, 34, 23, 0, -24 },
  { 5174, 20, 33, 23, 1, -33 },
  { 5257, 11, 32, 11, 1, -32 },
  { 5301, 17, 42, 11, -5, -32 },
  { 5391, 21, 33, 20, 1, -33 },
  { 5478, 11, 33, 11, 1, -33 },
  { 5524, 31, 24, 34, 1, -24 },
  { 5617, 20, 24, 23, 1, -24 },
  { 5677, 18, 24, 22, 2, -24 },
  { 5731, 23, 34, 23, -2, -24 },
  { 5829, 20, 34, 23, 2, -24 },
  { 5914, 16, 24, 16, 1, -24 },
  { 5962, 17, 24, 17, 0, -24 },
  { 6013, 13, 28, 14, 2, -28 },
  { 6059, 20, 23, 23, 2, -23 },
  { 6117, 19, 23, 19, 2, -23 },
  { 6172, 28, 23, 29, 3, -23 },
  { 6253, 23, 23, 19, -2, -23 },
  { 6320, 25, 33, 19, -4, -23 },
  { 6424, 19, 23, 17, -1, -23 },
  { 6479, 16, 38, 15, 1, -31 },
  { 6555, 4, 43, 21, 9, -33 },
  { 6577, 16, 38, 15, -2, -31 },
  { 6653, 19, 6, 23, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC43PT7B_H_
