#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &NotoSans_SemiCondensed_MediumItalic6pt7b, 6, "NotoSans_SemiCondensed_MediumItalic6pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic7pt7b, 7, "NotoSans_SemiCondensed_MediumItalic7pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic8pt7b, 8, "NotoSans_SemiCondensed_MediumItalic8pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic9pt7b, 9, "NotoSans_SemiCondensed_MediumItalic9pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic10pt7b, 10, "NotoSans_SemiCondensed_MediumItalic10pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic11pt7b, 11, "NotoSans_SemiCondensed_MediumItalic11pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic12pt7b, 12, "NotoSans_SemiCondensed_MediumItalic12pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic13pt7b, 13, "NotoSans_SemiCondensed_MediumItalic13pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic14pt7b, 14, "NotoSans_SemiCondensed_MediumItalic14pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic15pt7b, 15, "NotoSans_SemiCondensed_MediumItalic15pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic16pt7b, 16, "NotoSans_SemiCondensed_MediumItalic16pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic17pt7b, 17, "NotoSans_SemiCondensed_MediumItalic17pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic18pt7b, 18, "NotoSans_SemiCondensed_MediumItalic18pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic19pt7b, 19, "NotoSans_SemiCondensed_MediumItalic19pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic20pt7b, 20, "NotoSans_SemiCondensed_MediumItalic20pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic21pt7b, 21, "NotoSans_SemiCondensed_MediumItalic21pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic22pt7b, 22, "NotoSans_SemiCondensed_MediumItalic22pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic23pt7b, 23, "NotoSans_SemiCondensed_MediumItalic23pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic24pt7b, 24, "NotoSans_SemiCondensed_MediumItalic24pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic25pt7b, 25, "NotoSans_SemiCondensed_MediumItalic25pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic26pt7b, 26, "NotoSans_SemiCondensed_MediumItalic26pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic27pt7b, 27, "NotoSans_SemiCondensed_MediumItalic27pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic28pt7b, 28, "NotoSans_SemiCondensed_MediumItalic28pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic29pt7b, 29, "NotoSans_SemiCondensed_MediumItalic29pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic30pt7b, 30, "NotoSans_SemiCondensed_MediumItalic30pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic31pt7b, 31, "NotoSans_SemiCondensed_MediumItalic31pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic32pt7b, 32, "NotoSans_SemiCondensed_MediumItalic32pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic33pt7b, 33, "NotoSans_SemiCondensed_MediumItalic33pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic34pt7b, 34, "NotoSans_SemiCondensed_MediumItalic34pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic35pt7b, 35, "NotoSans_SemiCondensed_MediumItalic35pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic36pt7b, 36, "NotoSans_SemiCondensed_MediumItalic36pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic37pt7b, 37, "NotoSans_SemiCondensed_MediumItalic37pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic38pt7b, 38, "NotoSans_SemiCondensed_MediumItalic38pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic39pt7b, 39, "NotoSans_SemiCondensed_MediumItalic39pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic40pt7b, 40, "NotoSans_SemiCondensed_MediumItalic40pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic41pt7b, 41, "NotoSans_SemiCondensed_MediumItalic41pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic42pt7b, 42, "NotoSans_SemiCondensed_MediumItalic42pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic43pt7b, 43, "NotoSans_SemiCondensed_MediumItalic43pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic44pt7b, 44, "NotoSans_SemiCondensed_MediumItalic44pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic45pt7b, 45, "NotoSans_SemiCondensed_MediumItalic45pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic46pt7b, 46, "NotoSans_SemiCondensed_MediumItalic46pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic47pt7b, 47, "NotoSans_SemiCondensed_MediumItalic47pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic48pt7b, 48, "NotoSans_SemiCondensed_MediumItalic48pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic49pt7b, 49, "NotoSans_SemiCondensed_MediumItalic49pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic50pt7b, 50, "NotoSans_SemiCondensed_MediumItalic50pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic51pt7b, 51, "NotoSans_SemiCondensed_MediumItalic51pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic52pt7b, 52, "NotoSans_SemiCondensed_MediumItalic52pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic53pt7b, 53, "NotoSans_SemiCondensed_MediumItalic53pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic54pt7b, 54, "NotoSans_SemiCondensed_MediumItalic54pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic55pt7b, 55, "NotoSans_SemiCondensed_MediumItalic55pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic56pt7b, 56, "NotoSans_SemiCondensed_MediumItalic56pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic57pt7b, 57, "NotoSans_SemiCondensed_MediumItalic57pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic58pt7b, 58, "NotoSans_SemiCondensed_MediumItalic58pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic59pt7b, 59, "NotoSans_SemiCondensed_MediumItalic59pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic60pt7b, 60, "NotoSans_SemiCondensed_MediumItalic60pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic61pt7b, 61, "NotoSans_SemiCondensed_MediumItalic61pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic62pt7b, 62, "NotoSans_SemiCondensed_MediumItalic62pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic63pt7b, 63, "NotoSans_SemiCondensed_MediumItalic63pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic64pt7b, 64, "NotoSans_SemiCondensed_MediumItalic64pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic65pt7b, 65, "NotoSans_SemiCondensed_MediumItalic65pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic66pt7b, 66, "NotoSans_SemiCondensed_MediumItalic66pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic67pt7b, 67, "NotoSans_SemiCondensed_MediumItalic67pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic68pt7b, 68, "NotoSans_SemiCondensed_MediumItalic68pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic69pt7b, 69, "NotoSans_SemiCondensed_MediumItalic69pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic70pt7b, 70, "NotoSans_SemiCondensed_MediumItalic70pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic71pt7b, 71, "NotoSans_SemiCondensed_MediumItalic71pt7b" },
  { &NotoSans_SemiCondensed_MediumItalic72pt7b, 72, "NotoSans_SemiCondensed_MediumItalic72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
