#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC21PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x61, 0x86, 0x18, 0xC3, 0x0C, 0x30, 0x86, 0x00, 0x63, 0x8E,
  0x00, 0x6E, 0xD9, 0x36, 0x6C, 0x80, 0x02, 0x20, 0x66, 0x06, 0x60, 0x44,
  0x3F, 0xF3, 0xFF, 0x08, 0x81, 0x98, 0x19, 0x8F, 0xFE, 0xFF, 0xE3, 0x30,
  0x33, 0x02, 0x20, 0x66, 0x00, 0x01, 0x00, 0xC0, 0xFC, 0x7F, 0x32, 0x0C,
  0x83, 0xE0, 0x70, 0x0F, 0x01, 0xE0, 0x58, 0x26, 0x89, 0xBF, 0xC7, 0xE0,
  0x60, 0x10, 0x00, 0x3C, 0x18, 0xD0, 0xC6, 0x62, 0x11, 0x98, 0x44, 0xC3,
  0x32, 0x0C, 0xDB, 0xB6, 0xDB, 0x72, 0xCC, 0x1B, 0x30, 0xCC, 0xC2, 0x23,
  0x18, 0x98, 0xC3, 0x66, 0x0F, 0x00, 0x07, 0x80, 0xDC, 0x18, 0xC1, 0x8C,
  0x19, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x36, 0x36, 0x36, 0x63, 0xEE, 0x1C,
  0xE1, 0xC7, 0xFC, 0x3E, 0xE0, 0x6D, 0x6C, 0x0E, 0x30, 0x61, 0x83, 0x0C,
  0x18, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0xC0, 0x0C,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x60, 0xC1, 0x86,
  0x1C, 0x31, 0xC0, 0x0C, 0x06, 0x32, 0x1F, 0x31, 0xF9, 0xE1, 0xB0, 0xCC,
  0x04, 0x00, 0x0C, 0x06, 0x03, 0x01, 0x8F, 0xF8, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x00, 0x36, 0x64, 0xC0, 0x7F, 0xE0, 0x7F, 0x80, 0x00, 0xC0, 0x60,
  0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0,
  0x60, 0x18, 0x0C, 0x00, 0x0F, 0x0F, 0xCC, 0x6E, 0x36, 0x1B, 0x0F, 0x07,
  0x83, 0xC1, 0xE1, 0xB0, 0xD8, 0x6C, 0x67, 0xF1, 0xE0, 0x0E, 0x3C, 0xF7,
  0x64, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x61, 0x83, 0x06, 0x0C, 0x00, 0x0F,
  0x8F, 0xF1, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x3F, 0xEF, 0xF0, 0x0F, 0x8F, 0xF1, 0x0C, 0x03, 0x00,
  0xC0, 0x61, 0xF0, 0x78, 0x03, 0x00, 0x60, 0x18, 0x06, 0x83, 0xBF, 0xCF,
  0xE0, 0x00, 0xC0, 0x70, 0x3C, 0x1A, 0x0D, 0x83, 0x61, 0x98, 0xC6, 0x63,
  0x18, 0xCF, 0xFF, 0xFF, 0x07, 0x01, 0x80, 0x60, 0x0F, 0xC7, 0xF1, 0x80,
  0x60, 0x18, 0x0C, 0x03, 0xF0, 0xDE, 0x01, 0x80, 0x60, 0x18, 0x06, 0x83,
  0xBF, 0xCF, 0xE0, 0x07, 0xC7, 0xE3, 0x80, 0xC0, 0x60, 0x19, 0x07, 0xF3,
  0xCC, 0xE3, 0xB0, 0xEC, 0x33, 0x0C, 0xC7, 0x3F, 0x87, 0xC0, 0x7F, 0xDF,
  0xF0, 0x18, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x01, 0x80,
  0xC0, 0x30, 0x18, 0x0E, 0x00, 0x0F, 0x87, 0xF1, 0x8C, 0x63, 0x18, 0xC6,
  0x70, 0xF0, 0x7C, 0x3B, 0x98, 0x66, 0x1B, 0x86, 0x61, 0x9F, 0xC3, 0xE0,
  0x1F, 0x1F, 0xDC, 0x6C, 0x36, 0x1F, 0x0D, 0x8E, 0xCF, 0x7F, 0x09, 0x80,
  0xC0, 0xC0, 0xE7, 0xE3, 0xE0, 0x11, 0xCE, 0x00, 0x00, 0x00, 0x03, 0x39,
  0xC0, 0x08, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x18, 0x63, 0x0C,
  0x00, 0x00, 0x80, 0xC1, 0xE3, 0xC7, 0x87, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xC0, 0x20, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x80, 0x60, 0x1C,
  0x03, 0x80, 0x70, 0x0C, 0x1E, 0x3C, 0x78, 0x60, 0x20, 0x00, 0x3E, 0x7F,
  0x03, 0x03, 0x07, 0x06, 0x1C, 0x38, 0x30, 0x60, 0x60, 0x00, 0x40, 0xE0,
  0xE0, 0x03, 0xF0, 0x1E, 0x70, 0x60, 0x31, 0x80, 0x26, 0x3E, 0x6C, 0xEC,
  0xD3, 0x19, 0xE6, 0x22, 0xC8, 0xC5, 0x91, 0x9B, 0x67, 0x26, 0x7F, 0xCC,
  0x66, 0x18, 0x00, 0x18, 0x00, 0x1F, 0xE0, 0x0F, 0x00, 0x01, 0xC0, 0x78,
  0x0F, 0x03, 0x60, 0x6C, 0x19, 0x83, 0x30, 0xE6, 0x18, 0xC7, 0xF8, 0xFF,
  0x38, 0x76, 0x07, 0xC0, 0xF0, 0x18, 0x0F, 0xC3, 0xFC, 0x61, 0x8C, 0x31,
  0x86, 0x71, 0xCF, 0xF1, 0xFC, 0x31, 0xC6, 0x19, 0xC3, 0x30, 0x66, 0x1C,
  0xFF, 0x3F, 0xC0, 0x07, 0xE3, 0xFC, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xFE, 0x0F, 0xC0,
  0x0F, 0xC1, 0xFE, 0x18, 0x71, 0x87, 0x18, 0x33, 0x83, 0x30, 0x33, 0x03,
  0x30, 0x73, 0x06, 0x70, 0x66, 0x0C, 0x61, 0xC7, 0xF8, 0xFE, 0x00, 0x0F,
  0xE3, 0xF8, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0F, 0xE1, 0xFC, 0x30, 0x06,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xE3, 0xF8, 0x60,
  0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0xFC, 0x3F, 0x86, 0x01, 0xC0, 0x30,
  0x06, 0x00, 0xC0, 0x38, 0x00, 0x07, 0xF1, 0xFF, 0x38, 0x23, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x0E, 0x3E, 0xC3, 0xEC, 0x0C, 0xC0, 0xCE, 0x0C, 0x60,
  0xC7, 0xFC, 0x3F, 0x80, 0x0C, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x61, 0x83,
  0x1C, 0x18, 0xFF, 0xC7, 0xFE, 0x30, 0x61, 0x83, 0x1C, 0x18, 0xC0, 0xC6,
  0x0E, 0x30, 0x63, 0x83, 0x00, 0x1F, 0x87, 0x81, 0x81, 0xC0, 0xC0, 0x60,
  0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC3, 0xF0, 0x01, 0x81,
  0xC0, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80,
  0xC0, 0x60, 0x30, 0x38, 0x18, 0x7C, 0x3C, 0x00, 0x0C, 0x38, 0xC3, 0x06,
  0x38, 0x33, 0x81, 0xB8, 0x1D, 0x80, 0xD8, 0x07, 0xC0, 0x3F, 0x01, 0x98,
  0x1C, 0xC0, 0xC7, 0x06, 0x18, 0x30, 0xC3, 0x87, 0x00, 0x0C, 0x18, 0x18,
  0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x7F, 0xFF,
  0x0E, 0x07, 0x8F, 0x03, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xE1, 0xB1, 0xB0,
  0xF8, 0xD8, 0xD8, 0x6C, 0x6C, 0x36, 0x66, 0x19, 0x33, 0x18, 0xB3, 0x0C,
  0x59, 0x86, 0x38, 0xC3, 0x1C, 0x63, 0x8C, 0x70, 0x0C, 0x0C, 0x70, 0x31,
  0xE1, 0x87, 0x86, 0x1E, 0x18, 0xCC, 0x63, 0x31, 0x8C, 0xCC, 0x33, 0xB0,
  0xC6, 0xC6, 0x1B, 0x18, 0x68, 0x60, 0xE1, 0x83, 0x8E, 0x0E, 0x00, 0x07,
  0xC1, 0xFE, 0x38, 0x73, 0x03, 0x70, 0x36, 0x03, 0x60, 0x3E, 0x03, 0xE0,
  0x7C, 0x06, 0xC0, 0x6E, 0x0E, 0x61, 0xC7, 0xF8, 0x3F, 0x00, 0x0F, 0x83,
  0xFC, 0x61, 0x8C, 0x31, 0x86, 0x70, 0xCC, 0x39, 0xFE, 0x3F, 0x86, 0x01,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x00, 0x07, 0xC1, 0xFE, 0x38, 0x73,
  0x03, 0x70, 0x36, 0x03, 0x60, 0x3E, 0x03, 0xE0, 0x7C, 0x06, 0xC0, 0x6E,
  0x0E, 0x61, 0xC7, 0xF8, 0x3F, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80,
  0x0F, 0x83, 0xF8, 0x63, 0x8C, 0x31, 0x86, 0x71, 0xCC, 0x31, 0xFC, 0x3F,
  0x06, 0x61, 0xCC, 0x31, 0xC6, 0x18, 0xC3, 0x38, 0x70, 0x0F, 0xC7, 0xF3,
  0x84, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x0E,
  0x83, 0x3F, 0xCF, 0xC0, 0xFF, 0xFF, 0xC6, 0x03, 0x01, 0x81, 0xC0, 0xC0,
  0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x80, 0x38, 0x33, 0x03,
  0x30, 0x73, 0x06, 0x30, 0x67, 0x06, 0x60, 0x66, 0x0E, 0x60, 0xCE, 0x0C,
  0xC0, 0xCC, 0x1C, 0xE1, 0x87, 0xF8, 0x3E, 0x00, 0xC0, 0xF8, 0x1B, 0x06,
  0x60, 0xCC, 0x31, 0x86, 0x31, 0x86, 0x30, 0xCC, 0x0D, 0x81, 0xE0, 0x3C,
  0x07, 0x00, 0xE0, 0x18, 0x00, 0xC1, 0x83, 0xC1, 0x83, 0xC3, 0x86, 0xC2,
  0x86, 0xC6, 0x8E, 0xC6, 0x8C, 0xCC, 0x8C, 0xCC, 0x98, 0xC8, 0x98, 0xD8,
  0xB0, 0xD8, 0xB0, 0xF0, 0xB0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xC0, 0x1C,
  0x38, 0x61, 0x83, 0x18, 0x19, 0xC0, 0x6C, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x7C, 0x06, 0x60, 0x73, 0x03, 0x18, 0x30, 0xE3, 0x83, 0x00,
  0xC1, 0xF0, 0x6C, 0x31, 0x9C, 0x66, 0x1B, 0x06, 0xC1, 0xE0, 0x30, 0x0C,
  0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03,
  0x80, 0x70, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0x1E, 0x18, 0x18, 0x10, 0x30,
  0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xF0,
  0xCC, 0x46, 0x66, 0x66, 0x62, 0x33, 0x33, 0x30, 0x1F, 0x1E, 0x06, 0x06,
  0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30,
  0x30, 0xF0, 0x06, 0x01, 0x80, 0xF0, 0x2C, 0x19, 0x0C, 0x63, 0x19, 0x83,
  0xE0, 0xC0, 0xFF, 0xE6, 0x30, 0x08, 0x0F, 0xB3, 0x39, 0x86, 0x61, 0xB0,
  0x6C, 0x3B, 0x0C, 0xC3, 0x31, 0xCF, 0xF1, 0xE8, 0x0C, 0x06, 0x01, 0x80,
  0x60, 0x19, 0x07, 0xF3, 0xCC, 0xE3, 0x30, 0xCC, 0x37, 0x0D, 0x83, 0x61,
  0x98, 0x67, 0xF3, 0x78, 0x04, 0x1F, 0x31, 0x60, 0xE0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xFC, 0x7C, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x8C, 0x7D,
  0x8C, 0xE3, 0x0C, 0x61, 0x98, 0x33, 0x0E, 0x61, 0x8C, 0x31, 0x8E, 0x3F,
  0xC3, 0xD0, 0x04, 0x1F, 0x33, 0x63, 0xE3, 0xDE, 0xFC, 0xC0, 0xC0, 0xC0,
  0xFE, 0x7E, 0x01, 0xE0, 0x78, 0x0C, 0x03, 0x00, 0x60, 0x3F, 0x01, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x78, 0x0E, 0x00, 0x04, 0x03, 0xEC, 0x67, 0x18,
  0x63, 0x0C, 0xC1, 0x98, 0x73, 0x0C, 0x61, 0x8C, 0x71, 0xF6, 0x1F, 0x80,
  0x30, 0x06, 0x21, 0xC7, 0xF0, 0xFC, 0x00, 0x0C, 0x06, 0x01, 0x80, 0x60,
  0x19, 0x07, 0xF3, 0xCC, 0xE3, 0x30, 0xCC, 0x37, 0x1D, 0x86, 0x61, 0x98,
  0x66, 0x1B, 0x8E, 0x08, 0x71, 0x80, 0x00, 0x63, 0x0C, 0x30, 0xC7, 0x18,
  0x61, 0x86, 0x38, 0x01, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06,
  0x1E, 0x0F, 0x00, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x82, 0x31, 0x8C,
  0x61, 0x98, 0x36, 0x07, 0x81, 0xF8, 0x3B, 0x06, 0x60, 0xCE, 0x18, 0xC7,
  0x1C, 0x0C, 0x71, 0x86, 0x18, 0x63, 0x0C, 0x30, 0xC7, 0x18, 0x61, 0x86,
  0x38, 0x01, 0x04, 0x17, 0x9E, 0x3D, 0xF7, 0x38, 0xE3, 0x30, 0xC7, 0x31,
  0xC6, 0x71, 0x86, 0x61, 0x86, 0x61, 0x86, 0x61, 0x8C, 0x63, 0x8C, 0xE3,
  0x0C, 0x01, 0x05, 0xF3, 0xCC, 0xE3, 0x30, 0xCC, 0x37, 0x1D, 0x86, 0x61,
  0x98, 0x66, 0x1B, 0x8E, 0x04, 0x1F, 0x8C, 0xEC, 0x3E, 0x1E, 0x0F, 0x07,
  0x87, 0xC3, 0x63, 0xBF, 0x8F, 0x80, 0x00, 0x81, 0x7C, 0x79, 0x8E, 0x31,
  0x86, 0x30, 0xCE, 0x19, 0x83, 0x30, 0xC6, 0x18, 0xFE, 0x37, 0x86, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xC0, 0x00, 0x08, 0x0F, 0xB3, 0x39, 0x86, 0x61,
  0xB0, 0x6C, 0x3B, 0x0C, 0xC3, 0x31, 0xCF, 0xF1, 0xF8, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x0C, 0x00, 0x01, 0x17, 0x3F, 0x38, 0x30, 0x30, 0x70, 0x60,
  0x60, 0x60, 0x60, 0xE0, 0x0C, 0x3F, 0x31, 0x60, 0x70, 0x38, 0x1C, 0x0E,
  0x06, 0x06, 0xFE, 0xFC, 0x10, 0xC3, 0x3F, 0x61, 0x86, 0x18, 0x63, 0x0C,
  0x30, 0xF3, 0xC0, 0x71, 0xD8, 0x66, 0x19, 0x86, 0x61, 0xB0, 0xCC, 0x33,
  0x0C, 0xC7, 0x3E, 0xC7, 0x20, 0xC1, 0xE1, 0xB0, 0xD8, 0xC4, 0x63, 0x61,
  0xB0, 0xF0, 0x78, 0x38, 0x1C, 0x00, 0xC3, 0x0F, 0x1C, 0x6C, 0x51, 0xB3,
  0x4C, 0xCD, 0x33, 0x64, 0xCD, 0x96, 0x34, 0x58, 0xF1, 0xC3, 0x87, 0x0E,
  0x18, 0x00, 0x18, 0xE3, 0x38, 0x36, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0xD8, 0x33, 0x0E, 0x63, 0x86, 0x00, 0x18, 0x31, 0x86, 0x18, 0x60, 0xCC,
  0x0C, 0xC0, 0xD8, 0x0D, 0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0xF8, 0x0F, 0x00, 0x1F, 0xC0, 0x60, 0x30, 0x1C, 0x06,
  0x03, 0x01, 0x80, 0xE0, 0x30, 0x1F, 0xCF, 0xE0, 0x03, 0x07, 0x0C, 0x0C,
  0x0C, 0x08, 0x18, 0x18, 0x70, 0xE0, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60,
  0x70, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x1E, 0x06, 0x06,
  0x06, 0x0C, 0x0C, 0x0C, 0x07, 0x07, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x30,
  0x70, 0xE0, 0x70, 0xFF, 0xE1, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 15, 5, 0, -15 },
  { 13, 7, 5, 8, 2, -15 },
  { 18, 12, 15, 12, 0, -15 },
  { 41, 10, 17, 10, 0, -16 },
  { 63, 14, 15, 16, 1, -15 },
  { 90, 12, 15, 13, 0, -15 },
  { 113, 3, 5, 5, 2, -15 },
  { 115, 7, 18, 6, 1, -15 },
  { 131, 7, 18, 6, -2, -15 },
  { 147, 9, 9, 10, 2, -16 },
  { 158, 9, 10, 11, 1, -12 },
  { 170, 4, 5, 5, -1, -2 },
  { 173, 6, 2, 6, 0, -7 },
  { 175, 3, 3, 5, 0, -3 },
  { 177, 10, 15, 8, -1, -15 },
  { 196, 9, 15, 10, 1, -15 },
  { 213, 7, 15, 10, 2, -15 },
  { 227, 10, 15, 10, 0, -15 },
  { 246, 10, 15, 10, 0, -15 },
  { 265, 10, 15, 10, 0, -15 },
  { 284, 10, 15, 10, 0, -15 },
  { 303, 10, 15, 10, 1, -15 },
  { 322, 10, 15, 10, 1, -15 },
  { 341, 10, 15, 10, 0, -15 },
  { 360, 9, 15, 10, 1, -15 },
  { 377, 5, 12, 5, 0, -12 },
  { 385, 6, 15, 5, -1, -12 },
  { 397, 9, 11, 11, 1, -13 },
  { 410, 9, 6, 11, 1, -10 },
  { 417, 9, 11, 11, 1, -13 },
  { 430, 8, 15, 8, 1, -15 },
  { 445, 15, 17, 16, 1, -15 },
  { 477, 11, 15, 11, -1, -15 },
  { 498, 11, 15, 11, 0, -15 },
  { 519, 11, 15, 11, 1, -15 },
  { 540, 12, 15, 13, 0, -15 },
  { 563, 11, 15, 10, 0, -15 },
  { 584, 11, 15, 9, 0, -15 },
  { 605, 12, 15, 13, 1, -15 },
  { 628, 13, 15, 13, 0, -15 },
  { 653, 9, 15, 7, -1, -15 },
  { 670, 9, 19, 6, -3, -15 },
  { 692, 13, 15, 11, 0, -15 },
  { 717, 8, 15, 9, 0, -15 },
  { 732, 17, 15, 16, 0, -15 },
  { 764, 14, 15, 14, 0, -15 },
  { 791, 12, 15, 14, 1, -15 },
  { 814, 11, 15, 11, 0, -15 },
  { 835, 12, 19, 14, 1, -15 },
  { 864, 11, 15, 11, 0, -15 },
  { 885, 10, 15, 10, 0, -15 },
  { 904, 9, 15, 10, 2, -15 },
  { 921, 12, 15, 13, 1, -15 },
  { 944, 11, 15, 11, 2, -15 },
  { 965, 16, 15, 17, 2, -15 },
  { 995, 13, 15, 10, -1, -15 },
  { 1020, 10, 15, 10, 2, -15 },
  { 1039, 12, 15, 10, -1, -15 },
  { 1062, 8, 18, 6, 0, -15 },
  { 1080, 4, 15, 8, 2, -15 },
  { 1088, 8, 18, 6, -1, -15 },
  { 1106, 10, 9, 11, 0, -15 },
  { 1118, 8, 1, 8, -2, 2 },
  { 1119, 4, 3, 6, 3, -16 },
  { 1121, 10, 12, 11, 1, -12 },
  { 1136, 10, 16, 11, 0, -16 },
  { 1156, 8, 12, 9, 1, -12 },
  { 1168, 11, 16, 11, 1, -16 },
  { 1190, 8, 12, 10, 1, -12 },
  { 1202, 11, 21, 6, -2, -16 },
  { 1231, 11, 17, 11, 0, -12 },
  { 1255, 10, 16, 11, 0, -16 },
  { 1275, 6, 16, 5, 0, -16 },
  { 1287, 9, 21, 5, -3, -16 },
  { 1311, 11, 16, 10, 0, -16 },
  { 1333, 6, 16, 5, 0, -16 },
  { 1345, 16, 12, 17, 0, -12 },
  { 1369, 10, 12, 11, 0, -12 },
  { 1384, 9, 12, 11, 1, -12 },
  { 1398, 11, 17, 11, -1, -12 },
  { 1422, 10, 17, 11, 1, -12 },
  { 1444, 8, 12, 8, 0, -12 },
  { 1456, 8, 12, 8, 0, -12 },
  { 1468, 6, 14, 7, 1, -14 },
  { 1479, 10, 11, 11, 1, -11 },
  { 1493, 9, 11, 9, 1, -11 },
  { 1506, 14, 11, 14, 1, -11 },
  { 1526, 11, 11, 9, -1, -11 },
  { 1542, 12, 16, 9, -2, -11 },
  { 1566, 10, 11, 8, -1, -11 },
  { 1580, 8, 18, 7, 0, -15 },
  { 1598, 2, 21, 10, 4, -16 },
  { 1604, 8, 18, 7, -1, -15 },
  { 1622, 9, 3, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC21PT7B_H_
