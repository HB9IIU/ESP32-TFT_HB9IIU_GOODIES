#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC58PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0x70, 0x00, 0x3F, 0x0F, 0xCF, 0xC3,
  0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xC1, 0xF1,
  0xF0, 0x7C, 0x7C, 0x1F, 0x1E, 0x07, 0x87, 0x81, 0xE3, 0xE0, 0xF8, 0xF8,
  0x3E, 0x3C, 0x0F, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x03, 0xC0, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xE7, 0x87, 0x01, 0xF8, 0xE0,
  0x40, 0x7E, 0x1C, 0x00, 0x0F, 0xC3, 0x80, 0x01, 0xF8, 0xF0, 0x00, 0x3F,
  0x1E, 0x00, 0x07, 0xE3, 0x80, 0x00, 0xFC, 0x70, 0x00, 0x1F, 0xCE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3B, 0xF8, 0x00, 0x07, 0x3F, 0x80, 0x00, 0xE3, 0xF0, 0x00, 0x3C,
  0x7E, 0x00, 0x07, 0x0F, 0xC0, 0x00, 0xE1, 0xF8, 0x00, 0x1C, 0x3F, 0x00,
  0x07, 0x87, 0xC3, 0x00, 0xE1, 0xF8, 0x7C, 0x1C, 0x7F, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x20, 0x1F, 0xF0, 0x00, 0x3E, 0x01, 0xFF, 0xC0, 0x03,
  0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0x01, 0xF9, 0xF8, 0x01, 0xF0, 0x0F, 0x87,
  0xC0, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x80,
  0x7C, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x1E, 0x03, 0xE0,
  0x7C, 0x01, 0xF0, 0x1F, 0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x3E, 0x00, 0x7C,
  0x07, 0x83, 0xE0, 0x03, 0xE0, 0x7C, 0x1E, 0x00, 0x1F, 0x03, 0xE1, 0xF0,
  0x00, 0xF0, 0x1F, 0x1F, 0x00, 0x07, 0x81, 0xF0, 0xF0, 0xFE, 0x3C, 0x0F,
  0x8F, 0x8F, 0xFD, 0xE0, 0xF8, 0xF8, 0xFF, 0xEF, 0x87, 0xC7, 0x8F, 0xFF,
  0xFE, 0x7C, 0x7C, 0xFC, 0x7F, 0xFF, 0xE7, 0xC7, 0xC3, 0xEF, 0xFE, 0x3C,
  0x7C, 0x0F, 0x3F, 0xE3, 0xE3, 0xE0, 0x78, 0xFC, 0x3E, 0x1E, 0x03, 0xC0,
  0x01, 0xE1, 0xF0, 0x3E, 0x00, 0x1F, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x7C,
  0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0x0F,
  0x81, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x78, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x3C, 0x03, 0xE0, 0x07, 0xC3, 0xE0, 0x1E, 0x00, 0x1F, 0xFE, 0x01,
  0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xFF, 0x01, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xF9, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x04, 0x1F, 0xFF, 0x00, 0x7C, 0x1F, 0xCF, 0xC0, 0x7E, 0x1F, 0xC7, 0xF0,
  0x3F, 0x1F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC0, 0xFE, 0x1F, 0x8F, 0xC0, 0x3F,
  0x1F, 0x87, 0xE0, 0x1F, 0xCF, 0x83, 0xE0, 0x07, 0xEF, 0xC3, 0xF0, 0x01,
  0xFF, 0xC1, 0xF8, 0x00, 0xFF, 0xE0, 0xFC, 0x00, 0x3F, 0xE0, 0x7E, 0x00,
  0x1F, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xF0,
  0x1F, 0xFE, 0x03, 0xFE, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC7, 0xF0, 0x1F, 0xFF, 0xC3, 0xF8, 0x03, 0xFF, 0x80, 0xFE, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C,
  0x7C, 0x78, 0x78, 0xF8, 0xF8, 0xF0, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x08, 0x07, 0xC0, 0x1C, 0x0F, 0x80, 0x7E, 0x1E, 0x00, 0xFF, 0x3C,
  0x01, 0xFF, 0xF8, 0x3D, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xDF, 0x00,
  0x3F, 0x1E, 0x00, 0xFC, 0x3E, 0x03, 0xF8, 0x7C, 0x03, 0xE0, 0xFC, 0x03,
  0x80, 0xF8, 0x02, 0x01, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC,
  0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0xF8, 0x00, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC0,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0x8F, 0xE0,
  0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x0F, 0xC1, 0xF8, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0,
  0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF,
  0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7C, 0x00,
  0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC,
  0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF8,
  0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x0F,
  0xE0, 0x7F, 0x07, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0x3F, 0x3F, 0x8F, 0xC7, 0xC3,
  0xE0, 0xC1, 0xF8, 0x20, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xE0, 0x0F, 0xE0, 0x0E,
  0x00, 0x7F, 0x00, 0x20, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xC0, 0xFF, 0x00, 0xF0, 0x07, 0xF0, 0x04, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x08, 0x00, 0x0F, 0xE0,
  0xF0, 0x01, 0xFE, 0x0F, 0xF9, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x7C,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3E, 0x1F,
  0x80, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x81, 0xF0, 0x03,
  0xF0, 0x3F, 0x00, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x60, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0x83, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x80, 0x01, 0xFC, 0x0E, 0x00, 0x3F, 0xC0, 0xFF, 0x7F,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xE0, 0x20, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x1F, 0xE0, 0x0F, 0x8F, 0xFC, 0x07, 0xEF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x1F, 0xF0, 0x3F, 0x8F, 0xF0, 0x07, 0xE3, 0xF8, 0x01,
  0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE3, 0xF0,
  0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xE3,
  0xE0, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F,
  0x83, 0xF0, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0xFE,
  0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x07,
  0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x81, 0xFC, 0x01,
  0xFC, 0x3F, 0x80, 0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0x9F, 0xC0, 0x1F, 0xE0, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8,
  0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0xFE,
  0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0x01, 0xF8, 0x3F, 0x80, 0x7E,
  0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0x1F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC,
  0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF8,
  0xFC, 0x01, 0xFE, 0x3F, 0x80, 0xFF, 0x87, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0x7C, 0x07, 0xFF, 0xBF, 0x00, 0xFF, 0x8F, 0xC0, 0x0F,
  0x83, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x80, 0x1F, 0xC0, 0x3E, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x8F, 0x81, 0xFC, 0x30, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x03, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0xFF,
  0x80, 0xF8, 0x7C, 0x01, 0xFF, 0xF0, 0x7C, 0x3E, 0x03, 0xFF, 0xF8, 0x1E,
  0x3E, 0x03, 0xFF, 0xFC, 0x0F, 0x1F, 0x01, 0xF0, 0x3C, 0x07, 0x8F, 0x01,
  0xF0, 0x3E, 0x03, 0xCF, 0x81, 0xF0, 0x1F, 0x01, 0xE7, 0xC0, 0xF0, 0x0F,
  0x81, 0xF3, 0xC0, 0xF8, 0x07, 0x80, 0xFB, 0xE0, 0x78, 0x07, 0xC0, 0x7D,
  0xF0, 0x7C, 0x03, 0xE0, 0x3C, 0xF0, 0x3E, 0x01, 0xF0, 0x1E, 0x78, 0x1E,
  0x00, 0xF0, 0x1F, 0x3C, 0x0F, 0x00, 0xF8, 0x0F, 0xBE, 0x0F, 0x80, 0x7C,
  0x07, 0x9F, 0x07, 0xC0, 0x7E, 0x07, 0xCF, 0x83, 0xE0, 0x3E, 0x03, 0xC7,
  0xC1, 0xF0, 0x3F, 0x03, 0xE3, 0xE0, 0x7C, 0x1F, 0xC3, 0xE1, 0xF0, 0x3E,
  0x3D, 0xE3, 0xF0, 0x78, 0x1F, 0xFE, 0xFF, 0xF0, 0x3C, 0x07, 0xFE, 0x3F,
  0xF0, 0x1F, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0x80, 0x38, 0x03, 0xC0, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x08, 0x00, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x07,
  0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xF8,
  0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0xFD, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03,
  0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xE0, 0x1F, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFF, 0x03, 0xF0, 0x07,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0x00, 0x7F, 0xC0, 0x0C,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x07, 0xFC, 0x00, 0xFC, 0x01, 0xFE,
  0x01, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC,
  0x1F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xF0,
  0x3F, 0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x3F, 0xC0,
  0x3F, 0x00, 0xFF, 0x80, 0x7E, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0x87, 0xF0, 0x07, 0xFC, 0x00, 0x38, 0x03, 0xFC, 0x00, 0x04, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x07, 0xFF, 0xC3, 0xF0, 0x03, 0xFF, 0xE1, 0xF8, 0x01, 0xFF,
  0xF1, 0xFC, 0x00, 0xFF, 0xF0, 0xFE, 0x00, 0xFF, 0xF8, 0x7F, 0x00, 0x00,
  0xFC, 0x3F, 0x80, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x3F, 0x80, 0x03, 0xF0, 0x1F, 0xC0,
  0x01, 0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x03,
  0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xC1, 0xFC,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x1F,
  0xC0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03, 0xE7, 0xF0, 0x00, 0x01, 0xFB,
  0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xBF, 0x00, 0x00,
  0x3F, 0xCF, 0xC0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x0F, 0xBE, 0x00, 0x0F,
  0xFF, 0x00, 0x7D, 0xF0, 0x00, 0x7D, 0xF8, 0x03, 0xEF, 0x80, 0x07, 0xEF,
  0xC0, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xE0,
  0x0F, 0x9F, 0x00, 0x1F, 0x3F, 0x00, 0x7C, 0xF8, 0x01, 0xF9, 0xF8, 0x03,
  0xE7, 0xC0, 0x0F, 0x8F, 0xC0, 0x3F, 0x1F, 0x00, 0xFC, 0x7C, 0x01, 0xF8,
  0xF8, 0x07, 0xC7, 0xE0, 0x0F, 0x87, 0xC0, 0x7E, 0x3F, 0x00, 0x7C, 0x3E,
  0x03, 0xE1, 0xF8, 0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x81,
  0xF0, 0xFC, 0x01, 0xF8, 0x7C, 0x1F, 0x87, 0xE0, 0x0F, 0x83, 0xE0, 0xF8,
  0x3F, 0x00, 0x7C, 0x1F, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xF8, 0x7C, 0x0F,
  0x80, 0x3F, 0x07, 0xC7, 0xE0, 0xFC, 0x01, 0xF0, 0x3E, 0x3E, 0x07, 0xE0,
  0x0F, 0x80, 0xF3, 0xF0, 0x3F, 0x00, 0x7C, 0x07, 0xDF, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x01, 0xF0,
  0x0F, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x7F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFE,
  0x00, 0xFC, 0x01, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0x00, 0x7E, 0x01, 0xFF,
  0x00, 0x03, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0x00, 0x7F, 0xC0, 0x00, 0xF8,
  0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x3F, 0xF8, 0x00, 0x7E, 0x01, 0xF7, 0xC0,
  0x03, 0xF0, 0x0F, 0xBF, 0x00, 0x1F, 0x00, 0x7D, 0xF8, 0x00, 0xF8, 0x03,
  0xE7, 0xC0, 0x0F, 0xC0, 0x3F, 0x3E, 0x00, 0x7E, 0x01, 0xF9, 0xF8, 0x03,
  0xF0, 0x0F, 0x8F, 0xC0, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x07, 0xE1,
  0xF8, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x3E, 0x03, 0xE0,
  0x0F, 0x81, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x7E,
  0x0F, 0xC0, 0x3F, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x0F, 0xC3, 0xE0, 0x0F,
  0x80, 0x7E, 0x1F, 0x00, 0x7C, 0x01, 0xF1, 0xF8, 0x07, 0xE0, 0x0F, 0xCF,
  0xC0, 0x3F, 0x00, 0x7E, 0x7E, 0x01, 0xF0, 0x03, 0xF3, 0xE0, 0x0F, 0x80,
  0x0F, 0x9F, 0x00, 0xFC, 0x00, 0x7E, 0xF8, 0x07, 0xE0, 0x03, 0xFF, 0xC0,
  0x3F, 0x00, 0x0F, 0xFE, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x03,
  0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x3F,
  0x00, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0x80, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x07,
  0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x01, 0xF8,
  0xFE, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xE3, 0xF8, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x03, 0xFC,
  0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x7F, 0x01, 0xF8,
  0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xC0,
  0x7E, 0x00, 0xFF, 0x01, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00,
  0xFD, 0xFC, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0,
  0x03, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x1F, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07,
  0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x03, 0xF0,
  0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0xFE, 0x03, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0xC0, 0x7E, 0x03, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F,
  0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF0,
  0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFE, 0x07,
  0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0xFE, 0x01, 0xFC, 0x00, 0xC0,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x04, 0x00, 0x1F, 0xE0, 0xF8, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07,
  0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E,
  0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x3F,
  0x80, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x80,
  0x03, 0xE0, 0x7E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0xF8, 0x7E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xBE,
  0x00, 0x0F, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xCF, 0x80,
  0x07, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0xC0, 0x07, 0xF3, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xFF,
  0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x7F, 0xE0,
  0x0F, 0xC1, 0xF0, 0x07, 0xDF, 0x00, 0x7E, 0x0F, 0x80, 0x3E, 0xF8, 0x03,
  0xF0, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x03, 0xE0, 0x1F, 0x3E, 0x01, 0xF8,
  0x1F, 0x00, 0xF9, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x8F, 0x80, 0xFC, 0x07,
  0xC0, 0x7C, 0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xC3, 0xE0, 0x7E, 0x01, 0xF0,
  0x3E, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x00, 0x7C, 0x1F,
  0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0x81,
  0xF0, 0xFC, 0x00, 0xF8, 0x7C, 0x07, 0x87, 0xC0, 0x07, 0xC7, 0xC0, 0x3C,
  0x7E, 0x00, 0x3E, 0x3E, 0x01, 0xE3, 0xE0, 0x01, 0xF3, 0xF0, 0x0F, 0x3F,
  0x00, 0x0F, 0x9F, 0x00, 0x79, 0xF8, 0x00, 0x7C, 0xF8, 0x03, 0xCF, 0x80,
  0x03, 0xEF, 0x80, 0x1E, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0xF7, 0xC0, 0x00,
  0xFF, 0xC0, 0x07, 0xBE, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x3F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFE, 0x1F,
  0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xF7,
  0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xF8, 0x7E, 0x00,
  0x3F, 0x07, 0xE0, 0x07, 0xF0, 0x3E, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x03, 0xF8, 0x01, 0xF0,
  0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x8F, 0xC0,
  0x01, 0xF9, 0xFC, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0xF8, 0x1F, 0x03, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x9F,
  0x00, 0x01, 0xE3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0xC1, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF3, 0xF0, 0x00, 0x3E,
  0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFE, 0x1F, 0x83, 0xF0, 0xFC, 0x1F,
  0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFE,
  0x1F, 0x00, 0xFF, 0xF3, 0xE0, 0x1F, 0xFF, 0x3E, 0x03, 0xFF, 0xFB, 0xE0,
  0x7F, 0x87, 0xFE, 0x07, 0xF0, 0x3F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0,
  0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x01, 0xF8,
  0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0,
  0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC,
  0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x3F,
  0xE0, 0x7E, 0x07, 0xFC, 0x07, 0xF9, 0xF7, 0xC0, 0x7F, 0xFF, 0x7C, 0x03,
  0xFF, 0xE7, 0xC0, 0x1F, 0xFC, 0x78, 0x00, 0xFF, 0x0F, 0x80, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xE3,
  0xFE, 0x00, 0xFC, 0xFF, 0xE0, 0x1F, 0xBF, 0xFE, 0x03, 0xEF, 0xFF, 0xC0,
  0xFF, 0xE3, 0xFC, 0x1F, 0xF0, 0x1F, 0x83, 0xFC, 0x03, 0xF0, 0x7F, 0x00,
  0x7E, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x03,
  0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xF0, 0xF8,
  0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E,
  0x1F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xE0,
  0x3F, 0x83, 0xFF, 0x9F, 0xE0, 0x7D, 0xFF, 0xF8, 0x1F, 0x3F, 0xFF, 0x03,
  0xE3, 0xFF, 0x80, 0x7C, 0x3F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0xFF, 0x87, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x03, 0x03, 0xFE, 0x3E, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0x03, 0xF0, 0x01, 0xFF,
  0x8F, 0xC0, 0x0F, 0xFF, 0x3E, 0x00, 0x7F, 0xFC, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xE1, 0xFF, 0x80, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F,
  0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x7E, 0x07, 0xE0,
  0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7F,
  0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x80,
  0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0x7F, 0xC0, 0x1F,
  0xE7, 0xDF, 0x00, 0x7F, 0xFF, 0x7C, 0x00, 0xFF, 0xF9, 0xF0, 0x01, 0xFF,
  0xC7, 0x80, 0x03, 0xFC, 0x1E, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xF8, 0x7F, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80,
  0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x7E, 0x3E, 0x00,
  0xFE, 0x7E, 0x07, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x30, 0x7F, 0xC1, 0xF0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFD, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x08, 0x7F,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0xE1, 0xF0, 0x03, 0xFF, 0xCF, 0x80, 0x1F, 0xFF,
  0x3E, 0x00, 0xFF, 0xFE, 0xF8, 0x07, 0xF8, 0x7F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xC0,
  0xFE, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x7F,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x07, 0xC0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03,
  0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF8,
  0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0x80, 0xFE, 0x03, 0xFE, 0x01,
  0xF8, 0x1F, 0xF0, 0x07, 0xF9, 0xF7, 0xC0, 0x1F, 0xFF, 0xBF, 0x00, 0x3F,
  0xFE, 0xFC, 0x00, 0x7F, 0xE3, 0xE0, 0x00, 0xFF, 0x1F, 0x80, 0x00, 0x40,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x30, 0x00, 0xFE, 0x00, 0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x07,
  0xE3, 0xFE, 0x00, 0xFC, 0xFF, 0xE0, 0x1F, 0x3F, 0xFE, 0x03, 0xEF, 0xFF,
  0xE0, 0xFF, 0xE1, 0xFC, 0x1F, 0xF0, 0x1F, 0x83, 0xFC, 0x03, 0xF0, 0x7F,
  0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0x83, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x0F,
  0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0xF8,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x04, 0x7F, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x03, 0xE0, 0x3F,
  0x80, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xE1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0xFE,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFB, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xEF,
  0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF0, 0x7E, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xE0, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF8,
  0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x7F, 0xC0, 0x7F, 0xC0, 0x3E, 0x3F, 0xF8,
  0x7F, 0xF8, 0x0F, 0x9F, 0xFE, 0x3F, 0xFF, 0x03, 0xEF, 0xFF, 0xDF, 0xFF,
  0xC1, 0xFF, 0xC7, 0xF7, 0xC7, 0xF0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFC, 0x1F,
  0xE0, 0x3F, 0xE0, 0x3F, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xC1, 0xFC, 0x03,
  0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x00,
  0x3F, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x7C, 0x3F, 0xF0, 0x0F, 0x8F, 0xFF, 0x01, 0xF3, 0xFF, 0xE0,
  0x3E, 0xFF, 0xFE, 0x0F, 0xFE, 0x3F, 0xC1, 0xFF, 0x01, 0xF8, 0x3F, 0xC0,
  0x3F, 0x07, 0xF8, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x87,
  0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x01, 0xFE, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0x7E,
  0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0x03, 0xE3, 0xF0, 0x00, 0xFC, 0xFC, 0x00,
  0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xF9, 0xF8,
  0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x07,
  0xF3, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x7F, 0x07, 0xF0,
  0x3F, 0x80, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0xFF, 0x80, 0x07, 0xC7, 0xFF, 0x00, 0x1F, 0x3F,
  0xFE, 0x00, 0x7D, 0xFF, 0xF8, 0x01, 0xFF, 0x8F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF0,
  0x1F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07,
  0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F,
  0x01, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0xC0, 0x3F, 0x80,
  0xFF, 0x01, 0xFC, 0x03, 0xFF, 0x1F, 0xE0, 0x0F, 0xBF, 0xFF, 0x00, 0x7E,
  0xFF, 0xFC, 0x01, 0xF9, 0xFF, 0xC0, 0x07, 0xE3, 0xFE, 0x00, 0x1F, 0x81,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFE, 0x1F, 0x00, 0xFF,
  0xF3, 0xE0, 0x1F, 0xFF, 0xBE, 0x03, 0xFF, 0xFB, 0xE0, 0x7F, 0x87, 0xFE,
  0x0F, 0xF0, 0x3F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xF8,
  0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F,
  0x87, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E,
  0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x0F,
  0xC0, 0x0F, 0xE0, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0x7E, 0x07,
  0xFC, 0x07, 0xF9, 0xF7, 0xC0, 0x7F, 0xFE, 0xFC, 0x03, 0xFF, 0xCF, 0xC0,
  0x1F, 0xF8, 0xF8, 0x00, 0xFF, 0x1F, 0x80, 0x03, 0x81, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x0F,
  0x87, 0xF0, 0x3E, 0x3F, 0xC0, 0xF9, 0xFF, 0x03, 0xEF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC1, 0xFC, 0x07, 0x03, 0xF0, 0x02, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF1,
  0x00, 0x0F, 0xC3, 0x00, 0x3F, 0x87, 0xC1, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x18, 0x3F,
  0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x08, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0xC0, 0xF8,
  0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F,
  0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F,
  0x00, 0x1F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07,
  0xE0, 0x0F, 0xE0, 0x7C, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xE0, 0xFE, 0x03,
  0xFC, 0x07, 0xE0, 0x7F, 0xC0, 0x7F, 0xBF, 0x7C, 0x07, 0xFF, 0xE7, 0xC0,
  0x3F, 0xFC, 0x7C, 0x03, 0xFF, 0x87, 0x80, 0x1F, 0xF0, 0xF8, 0x00, 0x10,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF,
  0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE3, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xF0,
  0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0xFC,
  0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x0F, 0x8F,
  0xC0, 0x07, 0xCF, 0xC0, 0x03, 0xE7, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xFB,
  0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0xF8, 0x03, 0xFC, 0x01,
  0xF9, 0xF0, 0x07, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0xF0, 0x0F, 0xC7, 0xC0,
  0x3F, 0xE0, 0x1F, 0x8F, 0x80, 0x7F, 0xC0, 0x7E, 0x1F, 0x01, 0xFF, 0x80,
  0xFC, 0x3E, 0x03, 0xFF, 0x01, 0xF0, 0x7C, 0x0F, 0xBE, 0x07, 0xE0, 0xF8,
  0x1F, 0x7C, 0x0F, 0xC1, 0xF0, 0x3C, 0xF8, 0x3F, 0x03, 0xE0, 0xF9, 0xF0,
  0x7E, 0x07, 0xC1, 0xF3, 0xE0, 0xF8, 0x0F, 0x87, 0xC7, 0xC3, 0xF0, 0x1F,
  0x0F, 0x8F, 0x87, 0xC0, 0x3E, 0x3E, 0x1F, 0x1F, 0x80, 0x7C, 0x7C, 0x3E,
  0x3E, 0x00, 0xF8, 0xF0, 0x7C, 0xFC, 0x01, 0xF3, 0xE0, 0xF9, 0xF8, 0x03,
  0xE7, 0xC1, 0xF3, 0xE0, 0x07, 0xDF, 0x03, 0xEF, 0xC0, 0x0F, 0xBE, 0x07,
  0xDF, 0x00, 0x1F, 0x78, 0x0F, 0xBE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x03,
  0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xEF, 0x80, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x7B, 0xF0, 0x00, 0x00,
  0x3D, 0xF0, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x47,
  0xFC, 0x00, 0x17, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFA, 0x00, 0x0F, 0xFC, 0x80, 0x00,
  0x50, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 15, 42, 15, 1, -41 },
  { 80, 18, 15, 23, 6, -41 },
  { 114, 33, 41, 33, 1, -41 },
  { 284, 27, 47, 29, 1, -44 },
  { 443, 37, 43, 44, 4, -42 },
  { 642, 33, 43, 35, 1, -42 },
  { 820, 8, 15, 13, 6, -41 },
  { 835, 19, 51, 17, 2, -42 },
  { 957, 19, 51, 17, -4, -42 },
  { 1079, 23, 25, 28, 6, -44 },
  { 1151, 26, 27, 30, 3, -34 },
  { 1239, 12, 15, 14, -3, -7 },
  { 1262, 15, 5, 17, 1, -18 },
  { 1272, 7, 8, 14, 1, -7 },
  { 1279, 29, 42, 21, -3, -42 },
  { 1432, 26, 43, 29, 2, -42 },
  { 1572, 18, 41, 29, 7, -41 },
  { 1665, 29, 42, 29, -1, -42 },
  { 1818, 28, 43, 29, 0, -42 },
  { 1969, 28, 42, 29, 0, -42 },
  { 2116, 28, 42, 29, 1, -41 },
  { 2263, 26, 43, 29, 3, -42 },
  { 2403, 28, 41, 29, 3, -41 },
  { 2547, 28, 43, 29, 1, -42 },
  { 2698, 26, 43, 29, 2, -42 },
  { 2838, 12, 33, 14, 1, -32 },
  { 2888, 16, 40, 14, -3, -32 },
  { 2968, 26, 28, 30, 3, -35 },
  { 3059, 26, 17, 30, 3, -29 },
  { 3115, 26, 28, 30, 3, -35 },
  { 3206, 21, 43, 23, 3, -42 },
  { 3319, 41, 47, 44, 2, -42 },
  { 3560, 30, 41, 30, -3, -41 },
  { 3714, 31, 41, 32, 1, -41 },
  { 3873, 31, 43, 30, 3, -42 },
  { 4040, 32, 41, 35, 1, -41 },
  { 4204, 29, 41, 27, 1, -41 },
  { 4353, 29, 41, 26, 1, -41 },
  { 4502, 33, 43, 36, 3, -42 },
  { 4680, 35, 41, 36, 1, -41 },
  { 4860, 24, 41, 18, -2, -41 },
  { 4983, 25, 52, 15, -9, -41 },
  { 5146, 34, 41, 30, 1, -41 },
  { 5321, 21, 41, 25, 1, -41 },
  { 5429, 45, 41, 45, 1, -41 },
  { 5660, 37, 41, 38, 1, -41 },
  { 5850, 33, 43, 37, 3, -42 },
  { 6028, 30, 41, 30, 1, -41 },
  { 6182, 33, 52, 37, 3, -42 },
  { 6397, 30, 41, 31, 1, -41 },
  { 6551, 28, 43, 27, 0, -42 },
  { 6702, 26, 41, 26, 5, -41 },
  { 6836, 33, 42, 35, 3, -41 },
  { 7010, 30, 41, 30, 5, -41 },
  { 7164, 45, 41, 46, 6, -41 },
  { 7395, 36, 41, 29, -3, -41 },
  { 7580, 28, 41, 27, 5, -41 },
  { 7724, 31, 41, 27, -1, -41 },
  { 7883, 22, 51, 17, -1, -42 },
  { 8024, 11, 42, 21, 6, -42 },
  { 8082, 22, 51, 17, -4, -42 },
  { 8223, 27, 26, 29, 1, -42 },
  { 8311, 22, 4, 21, -5, 5 },
  { 8322, 10, 9, 16, 8, -44 },
  { 8334, 28, 33, 30, 2, -32 },
  { 8450, 27, 45, 31, 1, -44 },
  { 8602, 23, 33, 24, 2, -32 },
  { 8697, 30, 45, 31, 2, -44 },
  { 8866, 24, 33, 27, 2, -32 },
  { 8965, 31, 58, 17, -7, -44 },
  { 9190, 30, 46, 31, 0, -32 },
  { 9363, 27, 44, 31, 1, -44 },
  { 9512, 15, 43, 14, 1, -43 },
  { 9593, 23, 57, 14, -7, -43 },
  { 9757, 28, 44, 27, 1, -44 },
  { 9911, 15, 44, 14, 1, -44 },
  { 9994, 42, 32, 46, 1, -32 },
  { 10162, 27, 32, 31, 1, -32 },
  { 10270, 26, 33, 30, 2, -32 },
  { 10378, 30, 46, 31, -2, -32 },
  { 10551, 28, 46, 31, 2, -32 },
  { 10712, 22, 32, 21, 1, -32 },
  { 10800, 23, 33, 23, 0, -32 },
  { 10895, 17, 39, 18, 3, -38 },
  { 10978, 28, 32, 31, 2, -31 },
  { 11090, 25, 31, 25, 3, -31 },
  { 11187, 39, 31, 39, 3, -31 },
  { 11339, 31, 31, 26, -3, -31 },
  { 11460, 33, 45, 25, -5, -31 },
  { 11646, 25, 31, 23, -1, -31 },
  { 11743, 22, 50, 20, 1, -41 },
  { 11881, 5, 58, 28, 12, -44 },
  { 11918, 22, 50, 20, -3, -41 },
  { 12056, 26, 9, 30, 3, -25 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC58PT7B_H_
