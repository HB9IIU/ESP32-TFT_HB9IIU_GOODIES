#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC47PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xF8, 0x0F, 0x80, 0x20, 0x00, 0x3C, 0x3E, 0xF8, 0xF9, 0xF1, 0xF3,
  0xE3, 0xE7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0xF0, 0xF1, 0xE1,
  0xE3, 0xC3, 0xC7, 0x07, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x07,
  0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x78, 0x3C,
  0x00, 0x1E, 0x0F, 0x01, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0x0E, 0x07, 0x00, 0x07, 0x83, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80,
  0x03, 0x81, 0xC0, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF8, 0x07, 0x03, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x38,
  0x1C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xC0, 0xE0, 0x00,
  0x70, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xC0,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xEE, 0x78, 0x3E,
  0x38, 0x40, 0xF8, 0xE0, 0x03, 0xC3, 0x00, 0x0F, 0x1C, 0x00, 0x3C, 0x70,
  0x00, 0xF9, 0xC0, 0x03, 0xF6, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x07,
  0x7E, 0x00, 0x1C, 0xF8, 0x00, 0x71, 0xE0, 0x01, 0x87, 0x80, 0x0E, 0x3E,
  0x00, 0x38, 0xF8, 0xC0, 0xE7, 0xC3, 0xE3, 0x3F, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0xF0, 0x1F, 0xE0, 0x03, 0xC0, 0xFF, 0x80, 0x1E, 0x07, 0xDF, 0x00,
  0xF0, 0x3C, 0x3C, 0x03, 0xC0, 0xF0, 0xF0, 0x1E, 0x07, 0x83, 0xC0, 0xF0,
  0x1E, 0x0F, 0x03, 0xC0, 0x78, 0x3C, 0x1E, 0x01, 0xC0, 0xF0, 0xF0, 0x0F,
  0x03, 0xC3, 0xC0, 0x3C, 0x1E, 0x1E, 0x00, 0xF0, 0x78, 0xF0, 0x03, 0xC1,
  0xE3, 0xC1, 0x0F, 0x07, 0x1E, 0x3F, 0xBC, 0x3C, 0xF1, 0xFE, 0xF1, 0xE3,
  0xCF, 0xFF, 0xEF, 0x9E, 0x78, 0xF7, 0xFC, 0xF1, 0xE1, 0xDF, 0xE3, 0xCF,
  0x07, 0x1F, 0x1E, 0x3C, 0x1C, 0x00, 0xF1, 0xE0, 0x70, 0x03, 0xC7, 0x83,
  0xC0, 0x1E, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x3C, 0x03, 0xC1, 0xC0, 0xF0,
  0x1E, 0x07, 0x03, 0x80, 0xF0, 0x3C, 0x1E, 0x03, 0xC0, 0x70, 0x78, 0x1E,
  0x01, 0xC3, 0xC0, 0xF0, 0x07, 0x9F, 0x03, 0xC0, 0x1F, 0xF8, 0x1E, 0x00,
  0x3F, 0xC0, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x78,
  0x1E, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x03, 0xE0, 0x78, 0x00,
  0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xE7, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x7C, 0x7C, 0xF8, 0x1F, 0x3E,
  0x1F, 0x0F, 0x9F, 0x07, 0xE3, 0xE7, 0xC0, 0xF9, 0xF3, 0xE0, 0x1F, 0x78,
  0xF8, 0x07, 0xFE, 0x3E, 0x00, 0xFF, 0x0F, 0x80, 0x3F, 0x83, 0xE0, 0x07,
  0xE0, 0xF8, 0x03, 0xF8, 0x3F, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFD, 0xF8, 0x3F, 0xFE, 0x3E, 0x07, 0xFE, 0x0F, 0xC0, 0x3E, 0xF9, 0xF3,
  0xE7, 0x8F, 0x1E, 0x3C, 0xF1, 0xE3, 0xC7, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x08, 0x0F, 0x00, 0xC1, 0xE0, 0x3E, 0x38, 0x07, 0xF7, 0x00,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFC, 0x0F, 0xFF, 0x81, 0xF3, 0xF0, 0xFF, 0x00,
  0x3E, 0xE0, 0x0F, 0x9E, 0x03, 0xF1, 0xC0, 0x7C, 0x3C, 0x07, 0x07, 0x80,
  0x40, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x87, 0xC3, 0xE3, 0xE1, 0xF0, 0xF0, 0xF8, 0x78,
  0x7C, 0x3C, 0x1E, 0x1E, 0x00, 0x7F, 0xF7, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF,
  0xE0, 0x7B, 0xFF, 0xFF, 0xFB, 0xE2, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7E, 0x3F, 0x03, 0xE0,
  0xF8, 0x3E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF,
  0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03,
  0xEF, 0x80, 0x1F, 0x78, 0x00, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0,
  0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C,
  0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x81,
  0xF0, 0x3E, 0x1F, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xF8,
  0x7F, 0xE7, 0xFF, 0xBF, 0xBE, 0xF8, 0xF1, 0xC7, 0xC6, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x01, 0xF8, 0x7E, 0x01, 0xE0, 0x3F, 0x00, 0x80, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3E, 0x0F, 0xC0,
  0x30, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x08, 0x00, 0x7E, 0x1C, 0x01, 0xFC, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xBC, 0x00, 0x1F,
  0x78, 0x00, 0x3D, 0xF0, 0x00, 0xF3, 0xE0, 0x03, 0xC7, 0xC0, 0x0F, 0x8F,
  0x00, 0x1E, 0x3E, 0x00, 0x78, 0x7C, 0x01, 0xE0, 0xF8, 0x07, 0xC1, 0xE0,
  0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x0F,
  0x80, 0x78, 0x1E, 0x00, 0xF0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3D, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x38, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x80, 0x0F, 0xC3, 0x00, 0x7F, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFC,
  0x08, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF9,
  0xFC, 0x03, 0xCF, 0xF8, 0x1F, 0x7F, 0xF0, 0x7F, 0xFF, 0xE1, 0xFC, 0x0F,
  0x87, 0xE0, 0x3E, 0x1F, 0x00, 0x78, 0xFC, 0x01, 0xE3, 0xE0, 0x07, 0x8F,
  0x80, 0x1E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80,
  0x3C, 0x3E, 0x01, 0xF0, 0x78, 0x0F, 0xC1, 0xF0, 0x7E, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xE0, 0xFC, 0x1F, 0x01, 0xF0,
  0x7C, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x01, 0xF0, 0x7C,
  0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xE1, 0xF8, 0x0F, 0x8F, 0xC0, 0x1F, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x07,
  0xE3, 0xF0, 0x3F, 0x07, 0xE1, 0xF8, 0x0F, 0x87, 0xC0, 0x1F, 0x3E, 0x00,
  0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0xF8,
  0xF8, 0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xFB, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xE1, 0xF8, 0x3F, 0x03, 0xE0, 0xF8, 0x0F,
  0x87, 0xC0, 0x1E, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xE0, 0x07, 0xCF,
  0x80, 0x1F, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80,
  0x7E, 0x1F, 0x03, 0xF8, 0x7E, 0x3F, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xBC,
  0x07, 0xF9, 0xF0, 0x07, 0x87, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x02,
  0x00, 0x00, 0x70, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01,
  0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F,
  0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x0F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xE3, 0xC1, 0xF9, 0x80, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x0F, 0x07, 0x80, 0x18, 0x03, 0x87, 0x80, 0x7F, 0xE1, 0xE3, 0xC0,
  0xFF, 0xF0, 0xF3, 0xC0, 0xFF, 0xF0, 0x79, 0xE0, 0xF8, 0x78, 0x3C, 0xE0,
  0x78, 0x3C, 0x1E, 0xF0, 0x78, 0x1E, 0x0F, 0x78, 0x78, 0x0E, 0x07, 0xB8,
  0x3C, 0x0F, 0x03, 0xFC, 0x1C, 0x07, 0x81, 0xDE, 0x1E, 0x03, 0xC1, 0xEF,
  0x0F, 0x01, 0xC0, 0xF7, 0x87, 0x81, 0xE0, 0x73, 0xC3, 0xC0, 0xF0, 0x79,
  0xE1, 0xE0, 0xF8, 0x3C, 0xF0, 0xF0, 0x7C, 0x3C, 0x78, 0x7C, 0xEF, 0x3C,
  0x3C, 0x1F, 0xF7, 0xFC, 0x1E, 0x0F, 0xF1, 0xFC, 0x0F, 0x01, 0xE0, 0x78,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x03, 0x00, 0x03, 0xF8, 0x0F,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0xBC, 0x00, 0x07, 0x9E, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xC7,
  0x80, 0x03, 0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF0,
  0x78, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xC0, 0x0F, 0x07, 0xC0, 0x07, 0x83,
  0xE0, 0x03, 0xC3, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x7C,
  0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07,
  0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0,
  0xF8, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x1F, 0xF0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xC3, 0xFC,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x01,
  0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x00,
  0x3F, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x3F, 0x81, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFC, 0x3E, 0x07, 0xF0, 0x04, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xF8,
  0x0F, 0xE0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0xC1,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0x80, 0x07,
  0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xC3, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F,
  0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xFC,
  0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07,
  0xF0, 0x7C, 0x07, 0xF8, 0x1F, 0x07, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x03, 0xFE, 0x0F, 0x81, 0xFC, 0x00, 0x40, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0x3E, 0x01, 0xFF, 0xCF,
  0x80, 0x7F, 0xE3, 0xE0, 0x1F, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xF0, 0x01, 0xE0, 0x7E, 0x00, 0xF8, 0x1F,
  0xC0, 0x3E, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80,
  0x7C, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x03,
  0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x0F, 0x80,
  0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80,
  0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1E, 0x01, 0xF0,
  0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03,
  0xE0, 0x3E, 0x00, 0x1E, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x03,
  0xF0, 0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x1E, 0x01, 0xF8, 0x03,
  0xE0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3C, 0x0F,
  0xC0, 0x07, 0xC1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFD, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xE0,
  0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xE0, 0x7C, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x7C,
  0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0x80, 0x1F,
  0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x1F,
  0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x7F, 0xC0, 0x07, 0xBC, 0x07, 0xBE, 0x00, 0xFB, 0xC0, 0x79,
  0xE0, 0x0F, 0x7C, 0x07, 0x9E, 0x01, 0xF7, 0xC0, 0xF9, 0xE0, 0x1E, 0x7C,
  0x0F, 0x9E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x07,
  0x8F, 0x80, 0xF1, 0xE0, 0x78, 0xF8, 0x1F, 0x1E, 0x0F, 0x0F, 0x81, 0xF1,
  0xE0, 0xF0, 0xF0, 0x1E, 0x1E, 0x1E, 0x1F, 0x01, 0xE1, 0xE1, 0xE1, 0xF0,
  0x3E, 0x1E, 0x3C, 0x1F, 0x03, 0xE1, 0xF3, 0xC1, 0xE0, 0x3E, 0x0F, 0x78,
  0x1E, 0x03, 0xC0, 0xF7, 0x83, 0xE0, 0x3C, 0x0F, 0xF0, 0x3E, 0x07, 0xC0,
  0xFF, 0x03, 0xE0, 0x7C, 0x0F, 0xE0, 0x3C, 0x07, 0x80, 0xFE, 0x03, 0xC0,
  0x78, 0x0F, 0xC0, 0x7C, 0x07, 0x80, 0xFC, 0x07, 0xC0, 0xF8, 0x0F, 0x80,
  0x7C, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x3C, 0x07, 0xE0,
  0x01, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0xFE, 0x00, 0x1F, 0x03, 0xFC, 0x00,
  0x78, 0x0F, 0xF0, 0x01, 0xE0, 0x3F, 0xC0, 0x0F, 0x80, 0xFF, 0x80, 0x3E,
  0x07, 0xFE, 0x00, 0xF0, 0x1F, 0x78, 0x03, 0xC0, 0x79, 0xE0, 0x1F, 0x01,
  0xE7, 0xC0, 0x7C, 0x07, 0x9F, 0x01, 0xF0, 0x3E, 0x3C, 0x07, 0x80, 0xF8,
  0xF8, 0x1E, 0x03, 0xC3, 0xE0, 0xF8, 0x0F, 0x07, 0x83, 0xE0, 0x3C, 0x1E,
  0x0F, 0x81, 0xF0, 0x7C, 0x3C, 0x07, 0xC0, 0xF0, 0xF0, 0x1E, 0x03, 0xC7,
  0xC0, 0x78, 0x0F, 0x9F, 0x03, 0xE0, 0x3E, 0x7C, 0x0F, 0x80, 0x79, 0xE0,
  0x3E, 0x01, 0xF7, 0x80, 0xF0, 0x07, 0xDE, 0x03, 0xC0, 0x0F, 0xF8, 0x1F,
  0x00, 0x3F, 0xC0, 0x7C, 0x00, 0xFF, 0x01, 0xF0, 0x03, 0xFC, 0x07, 0x80,
  0x07, 0xF0, 0x1E, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x7F, 0x81, 0xF8, 0x07, 0xE0, 0xFC, 0x00,
  0xF8, 0x3E, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xE0,
  0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00,
  0x07, 0xEF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x3E,
  0x00, 0x0F, 0x8F, 0x80, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0x7C, 0x01, 0xF8,
  0x1F, 0xC0, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xE0, 0x7E, 0x03,
  0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07,
  0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x7E, 0x0F, 0x80, 0xFC, 0x0F, 0x81, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x03, 0xF8, 0x7F, 0x81, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x3E, 0x00,
  0x3F, 0x1F, 0x80, 0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8,
  0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80,
  0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0x8F,
  0x80, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x1F, 0xC0, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xE0, 0x7E, 0x03, 0xE0,
  0x3F, 0x03, 0xE0, 0x3F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x3E, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x7C, 0x0F, 0x81, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x3E, 0x07, 0x80, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3C, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x01,
  0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xC7,
  0xC0, 0xFC, 0x01, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x08, 0x00, 0x7C, 0x1E, 0x03, 0xF8,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xC1, 0xF0, 0x01,
  0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0,
  0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87,
  0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0x78,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07,
  0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x7C,
  0x78, 0x00, 0x7C, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x78, 0x01, 0xF0,
  0x78, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x7C, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF0, 0x00,
  0x3D, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0x1F,
  0xF0, 0x01, 0xF0, 0x01, 0xEF, 0x00, 0x3F, 0x00, 0x3E, 0xF0, 0x03, 0xF0,
  0x03, 0xEF, 0x00, 0x7F, 0x00, 0x7C, 0xF0, 0x07, 0xF0, 0x07, 0xCF, 0x00,
  0x7F, 0x00, 0xF8, 0xF0, 0x0F, 0xF0, 0x0F, 0x8F, 0x00, 0xFF, 0x00, 0xF0,
  0xF0, 0x1E, 0xF0, 0x1F, 0x0F, 0x01, 0xEF, 0x01, 0xF0, 0xF0, 0x3E, 0xF0,
  0x3E, 0x0F, 0x03, 0xCF, 0x03, 0xE0, 0xF0, 0x3C, 0xF0, 0x3C, 0x0F, 0x07,
  0x8F, 0x07, 0xC0, 0xF0, 0x78, 0xF0, 0x78, 0x0F, 0x0F, 0x0F, 0x0F, 0x80,
  0xF0, 0xF0, 0xF0, 0xF8, 0x0F, 0x1F, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0xF1,
  0xF0, 0x0F, 0x3E, 0x07, 0x1E, 0x00, 0xF3, 0xC0, 0x73, 0xE0, 0x0F, 0x3C,
  0x07, 0x3C, 0x00, 0xF7, 0x80, 0x73, 0xC0, 0x0F, 0x78, 0x07, 0x7C, 0x00,
  0xF7, 0x80, 0x77, 0x80, 0x0F, 0xF0, 0x07, 0x78, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF0, 0x1F, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x78,
  0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x7E, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xF7, 0x80, 0x0F, 0x9F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x0F,
  0x87, 0xC0, 0x7E, 0x0F, 0x01, 0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03,
  0xE1, 0xF0, 0x07, 0x8F, 0x80, 0x1E, 0x3E, 0x00, 0x79, 0xF0, 0x01, 0xF7,
  0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0xF0, 0x78, 0x3C, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1F, 0x0F, 0x83, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x79, 0xE0,
  0x01, 0xE7, 0x80, 0x0F, 0x1F, 0x00, 0x3C, 0x3C, 0x01, 0xE0, 0xF0, 0x07,
  0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x1E, 0x07, 0x80, 0x3C, 0x3C, 0x00,
  0xF0, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0xF0, 0x00, 0x3C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0xF8, 0xF8, 0x7C, 0x3C, 0x3E,
  0x1E, 0x0E, 0x07, 0x00, 0x78, 0x00, 0x07, 0xF8, 0xF0, 0x3F, 0xF3, 0xC1,
  0xFF, 0xDF, 0x0F, 0xE7, 0xF8, 0x7E, 0x07, 0xE1, 0xF0, 0x1F, 0x8F, 0x80,
  0x7E, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C,
  0xF8, 0x01, 0xF3, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8,
  0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7C, 0x3E, 0x03, 0xF0, 0xF8, 0x1F,
  0xC3, 0xF0, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFD, 0xE0, 0x3F, 0xE7, 0x80,
  0x7F, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x3C, 0x01, 0xF3, 0xFC,
  0x07, 0x9F, 0xF0, 0x3E, 0xFF, 0xE0, 0xFF, 0x9F, 0x83, 0xF8, 0x1F, 0x0F,
  0xC0, 0x7C, 0x3E, 0x01, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00,
  0x7C, 0x7C, 0x01, 0xF1, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0xF8,
  0xF8, 0x03, 0xE3, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0,
  0x0F, 0xC7, 0xE0, 0x3E, 0x1F, 0x81, 0xF0, 0xFF, 0xFF, 0xC3, 0xDF, 0xFE,
  0x0F, 0x3F, 0xF0, 0x3C, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xE3, 0x87, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x01, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x78, 0x7C, 0x01, 0xFE, 0x7C, 0x03, 0xFF, 0x7C, 0x07, 0xFF, 0x78, 0x0F,
  0xC7, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x3E,
  0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xF8,
  0x01, 0xF0, 0xF8, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8,
  0x03, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8,
  0x1F, 0xC0, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xF7, 0x80, 0x3F,
  0xE7, 0x80, 0x1F, 0xC7, 0x80, 0x00, 0x3C, 0x00, 0x3F, 0xF0, 0x0F, 0xFF,
  0x03, 0xFF, 0xF0, 0xFC, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0x79, 0xF0, 0x1F,
  0x3C, 0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x3F, 0x3C, 0xFF, 0xCF, 0xFF, 0xF1,
  0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x06, 0x1F, 0xCF, 0xC3,
  0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7E, 0x10, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7F, 0x8F, 0x00, 0xFF, 0xCF, 0x01, 0xFF, 0xFF, 0x03, 0xF1,
  0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0x7E, 0x0F, 0x80,
  0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00,
  0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x3E, 0x07,
  0xF0, 0x3F, 0x0F, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFD, 0xE0, 0x0F, 0xFB,
  0xE0, 0x07, 0xE3, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x80, 0x0F, 0x80, 0xE0, 0x1F,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x3C, 0x01, 0xF3, 0xFC, 0x07, 0x9F,
  0xF8, 0x3E, 0xFF, 0xE0, 0xFF, 0x8F, 0xC3, 0xF8, 0x1F, 0x0F, 0xC0, 0x7C,
  0x3E, 0x01, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1E, 0x1F, 0x00, 0xF8, 0x7C,
  0x03, 0xE1, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF0, 0xF8, 0x07,
  0xC3, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xE1, 0xF0, 0x0F, 0x87,
  0xC0, 0x3E, 0x1E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x0F, 0x80,
  0x7C, 0x3E, 0x01, 0xF0, 0x00, 0xE0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x78, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x08, 0x3E, 0x03, 0xE0, 0x78, 0x0F,
  0x81, 0xF0, 0x3E, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x8F, 0xC0,
  0x1E, 0x3F, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF0, 0x01, 0xE7, 0xC0, 0x03,
  0xDF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7E,
  0xF8, 0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x83,
  0xE0, 0x1F, 0x07, 0xC0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F,
  0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x1C, 0x01, 0xE3, 0xF8, 0x3F, 0xC0, 0x7B, 0xFF,
  0x1F, 0xF8, 0x3E, 0xFF, 0xEF, 0xFF, 0x0F, 0x79, 0xFF, 0x8F, 0xC3, 0xF8,
  0x3F, 0xC1, 0xF0, 0xFC, 0x0F, 0xE0, 0x7C, 0x3E, 0x03, 0xF0, 0x1F, 0x1F,
  0x80, 0xFC, 0x07, 0xC7, 0xC0, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x80, 0x7C,
  0x7C, 0x03, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x03,
  0xE3, 0xE0, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC0, 0x3C, 0x3C, 0x01, 0xE0,
  0x0F, 0x1F, 0x00, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x01, 0xF1, 0xF0, 0x0F,
  0x80, 0x7C, 0x7C, 0x03, 0xE0, 0x1E, 0x1E, 0x00, 0xF0, 0x07, 0x8F, 0x80,
  0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC0, 0x3E, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x3F, 0xC0, 0x7B, 0xFF,
  0x83, 0xEF, 0xFE, 0x0F, 0x79, 0xFC, 0x3F, 0x81, 0xF0, 0xFC, 0x07, 0xC3,
  0xF0, 0x1F, 0x1F, 0x80, 0x7C, 0x7C, 0x01, 0xE1, 0xF0, 0x0F, 0x87, 0xC0,
  0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C,
  0x3C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0xF8, 0x7C,
  0x03, 0xE1, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF0, 0xF8, 0x07,
  0xC3, 0xE0, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0,
  0x7F, 0xFE, 0x0F, 0xC7, 0xE1, 0xF8, 0x1F, 0x3F, 0x01, 0xF3, 0xE0, 0x1F,
  0x7E, 0x00, 0xF7, 0xC0, 0x0F, 0x7C, 0x00, 0xF7, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF, 0x80,
  0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0xC1, 0xF8, 0x7F,
  0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x78, 0xFF, 0x00, 0x3C, 0xFF, 0x80, 0x3E, 0xFF, 0xE0, 0x1E, 0xF1,
  0xF0, 0x0F, 0xE0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x03, 0xF0,
  0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3C,
  0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07,
  0x80, 0x1F, 0x03, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0xC0,
  0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x7F, 0xFF, 0xE0, 0x3E, 0xFF, 0xE0,
  0x1F, 0x7F, 0xE0, 0x0F, 0x1F, 0xC0, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xF8, 0xF0, 0x3F,
  0xF3, 0xC1, 0xFF, 0xFF, 0x0F, 0xC7, 0xF8, 0x7E, 0x07, 0xE1, 0xF0, 0x1F,
  0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F,
  0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E, 0x00,
  0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7C, 0x3E, 0x03, 0xF0,
  0xF8, 0x1F, 0xC3, 0xE0, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFD, 0xE0, 0x3F,
  0xEF, 0x80, 0x7E, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC1, 0xE3, 0xF0, 0x79, 0xF8, 0x3E, 0xFE, 0x0F, 0x7F, 0x83, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xF8, 0x38, 0x3E, 0x01,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF1,
  0x80, 0x7C, 0x3F, 0x7F, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x03, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFC, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0xF0, 0xFF, 0xC1, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x7C, 0x7C, 0x01,
  0xF1, 0xF0, 0x07, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x78, 0x03, 0xE3,
  0xE0, 0x0F, 0x8F, 0x80, 0x3C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xC0,
  0x1F, 0x1F, 0x00, 0x78, 0x7C, 0x01, 0xE1, 0xF0, 0x0F, 0x87, 0x80, 0x3E,
  0x1E, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0xFC, 0x3E,
  0x07, 0xF0, 0xF8, 0x3F, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0x78, 0x1F, 0xF9,
  0xE0, 0x3F, 0x87, 0x80, 0xF8, 0x01, 0xFB, 0xC0, 0x0F, 0x9E, 0x00, 0xF8,
  0xF0, 0x07, 0xC7, 0x80, 0x3C, 0x3C, 0x03, 0xE1, 0xF0, 0x1E, 0x0F, 0x81,
  0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0x80, 0xF8, 0x7C, 0x03,
  0xC3, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xE0, 0x07, 0x9F, 0x00, 0x3C, 0xF0,
  0x01, 0xEF, 0x80, 0x0F, 0x78, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x0F,
  0xC0, 0x3F, 0xE0, 0x1F, 0x80, 0xFB, 0xC0, 0x7F, 0x01, 0xF7, 0x80, 0xFE,
  0x07, 0xCF, 0x01, 0xFC, 0x0F, 0x9E, 0x07, 0xF8, 0x1E, 0x3C, 0x0E, 0xF0,
  0x7C, 0x78, 0x3D, 0xE0, 0xF0, 0xF0, 0x7B, 0xC3, 0xE1, 0xE1, 0xE7, 0x87,
  0xC3, 0xC3, 0xCF, 0x0F, 0x07, 0x87, 0x1E, 0x3E, 0x0F, 0x1E, 0x3C, 0x78,
  0x1E, 0x3C, 0x79, 0xF0, 0x3C, 0xF0, 0xF3, 0xC0, 0x79, 0xE1, 0xEF, 0x80,
  0xF7, 0x83, 0xDE, 0x01, 0xEF, 0x07, 0xBC, 0x03, 0xDC, 0x0F, 0xF8, 0x07,
  0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x1F, 0x81, 0xF0, 0x1F, 0x00, 0x78, 0x1F, 0x80, 0x3E, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x07, 0x8F, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x01, 0xF1, 0xE0, 0x01, 0xF0,
  0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0xE0, 0x3C, 0x00,
  0xF8, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF0, 0x03,
  0xE0, 0x3E, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3C,
  0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x0F,
  0x0F, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x9F, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x3E,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xF8,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x17, 0xFC, 0x01, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xF8, 0x03, 0xFE, 0x80, 0x07, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 35, 12, 1, -34 },
  { 54, 15, 13, 18, 5, -34 },
  { 79, 26, 34, 27, 1, -34 },
  { 190, 22, 39, 23, 1, -36 },
  { 298, 30, 34, 35, 3, -34 },
  { 426, 26, 34, 28, 1, -34 },
  { 537, 7, 13, 10, 5, -34 },
  { 549, 16, 41, 14, 1, -34 },
  { 631, 16, 41, 14, -4, -34 },
  { 713, 19, 20, 23, 5, -36 },
  { 761, 20, 23, 25, 3, -28 },
  { 819, 9, 12, 12, -2, -6 },
  { 833, 12, 5, 14, 1, -15 },
  { 841, 6, 7, 12, 1, -6 },
  { 847, 23, 34, 17, -2, -34 },
  { 945, 21, 34, 23, 2, -34 },
  { 1035, 14, 34, 23, 6, -34 },
  { 1095, 24, 34, 23, -1, -34 },
  { 1197, 23, 34, 23, 0, -34 },
  { 1295, 23, 34, 23, 0, -34 },
  { 1393, 22, 34, 23, 1, -34 },
  { 1487, 22, 34, 23, 2, -34 },
  { 1581, 22, 34, 23, 3, -34 },
  { 1675, 22, 34, 23, 1, -34 },
  { 1769, 22, 34, 23, 1, -34 },
  { 1863, 10, 27, 12, 1, -26 },
  { 1897, 13, 32, 12, -2, -26 },
  { 1949, 20, 23, 25, 3, -28 },
  { 2007, 20, 13, 25, 3, -23 },
  { 2040, 20, 23, 25, 3, -28 },
  { 2098, 17, 35, 18, 3, -34 },
  { 2173, 33, 38, 36, 2, -34 },
  { 2330, 25, 34, 25, -3, -34 },
  { 2437, 25, 34, 26, 1, -34 },
  { 2544, 24, 34, 25, 3, -34 },
  { 2646, 26, 34, 28, 1, -34 },
  { 2757, 23, 34, 22, 1, -34 },
  { 2855, 23, 34, 21, 1, -34 },
  { 2953, 26, 34, 29, 3, -34 },
  { 3064, 29, 34, 29, 1, -34 },
  { 3188, 20, 34, 15, -2, -34 },
  { 3273, 20, 43, 12, -7, -34 },
  { 3381, 28, 34, 24, 1, -34 },
  { 3500, 17, 34, 21, 1, -34 },
  { 3573, 36, 34, 37, 1, -34 },
  { 3726, 30, 34, 31, 1, -34 },
  { 3854, 26, 34, 30, 3, -34 },
  { 3965, 24, 34, 24, 1, -34 },
  { 4067, 26, 42, 30, 3, -34 },
  { 4204, 24, 34, 25, 1, -34 },
  { 4306, 23, 34, 22, 0, -34 },
  { 4404, 21, 34, 21, 4, -34 },
  { 4494, 26, 34, 29, 3, -34 },
  { 4605, 24, 34, 24, 4, -34 },
  { 4707, 36, 34, 37, 5, -34 },
  { 4860, 30, 34, 23, -3, -34 },
  { 4988, 22, 34, 22, 4, -34 },
  { 5082, 25, 34, 22, -1, -34 },
  { 5189, 18, 41, 14, -1, -34 },
  { 5282, 9, 34, 17, 5, -34 },
  { 5321, 18, 41, 14, -3, -34 },
  { 5414, 22, 21, 24, 1, -34 },
  { 5472, 18, 3, 17, -4, 4 },
  { 5479, 8, 8, 13, 7, -36 },
  { 5487, 22, 26, 25, 2, -26 },
  { 5559, 22, 36, 25, 1, -36 },
  { 5658, 18, 26, 19, 2, -26 },
  { 5717, 24, 36, 25, 2, -36 },
  { 5825, 19, 26, 22, 2, -26 },
  { 5887, 25, 47, 14, -5, -36 },
  { 6034, 24, 37, 25, 0, -26 },
  { 6145, 22, 36, 25, 1, -36 },
  { 6244, 12, 35, 12, 1, -35 },
  { 6297, 19, 46, 12, -6, -35 },
  { 6407, 23, 36, 22, 1, -36 },
  { 6511, 12, 36, 12, 1, -36 },
  { 6565, 34, 26, 37, 1, -26 },
  { 6676, 22, 26, 25, 1, -26 },
  { 6748, 20, 26, 24, 2, -26 },
  { 6813, 25, 37, 25, -2, -26 },
  { 6929, 22, 37, 25, 2, -26 },
  { 7031, 18, 26, 17, 1, -26 },
  { 7090, 19, 26, 19, 0, -26 },
  { 7152, 14, 31, 15, 2, -31 },
  { 7207, 22, 25, 25, 2, -25 },
  { 7276, 21, 25, 20, 2, -25 },
  { 7342, 31, 25, 32, 3, -25 },
  { 7439, 25, 25, 21, -2, -25 },
  { 7518, 27, 36, 21, -4, -25 },
  { 7640, 20, 25, 19, -1, -25 },
  { 7703, 18, 41, 16, 1, -34 },
  { 7796, 4, 47, 23, 10, -36 },
  { 7820, 18, 41, 16, -2, -34 },
  { 7913, 20, 7, 25, 3, -20 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC47PT7B_H_
