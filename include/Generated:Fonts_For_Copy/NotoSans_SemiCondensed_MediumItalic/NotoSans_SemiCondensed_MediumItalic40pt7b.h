#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC40PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03,
  0xC0, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x3E, 0x0F, 0x83, 0xE0,
  0xF0, 0x00, 0x3C, 0xFB, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F, 0x38, 0x71,
  0xC3, 0x8E, 0x3C, 0xF1, 0xC7, 0x0E, 0x38, 0x70, 0x00, 0x38, 0x78, 0x00,
  0xE1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x83,
  0x80, 0x0E, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xE1, 0xC0, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38,
  0x70, 0x01, 0xE1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x38, 0x0F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x38, 0x70, 0x01, 0xC1, 0xC0, 0x07,
  0x07, 0x00, 0x1C, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x1E,
  0x00, 0x78, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x7F, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xEE, 0xF0, 0x79, 0x84, 0x1E,
  0x30, 0x03, 0xC6, 0x00, 0x79, 0xC0, 0x0F, 0x38, 0x01, 0xF6, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0x7C, 0x00, 0x67, 0x80, 0x1C, 0xF0, 0x03, 0x1E, 0x00, 0x63, 0xC4, 0x0C,
  0xF8, 0xF3, 0xBE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x07, 0x80, 0x0F, 0x0F,
  0xE0, 0x07, 0x0F, 0xF8, 0x07, 0x07, 0x1C, 0x07, 0x87, 0x8E, 0x03, 0x83,
  0x87, 0x03, 0x83, 0xC3, 0x83, 0xC1, 0xC1, 0xC1, 0xC0, 0xE0, 0xE1, 0xC0,
  0x70, 0x71, 0xE0, 0x38, 0x78, 0xE0, 0x1C, 0x38, 0xE0, 0x8E, 0x1C, 0xF3,
  0xF7, 0x1E, 0x73, 0xFF, 0x8E, 0x73, 0xDF, 0xFE, 0x7B, 0xC7, 0x7F, 0x39,
  0xC3, 0x9E, 0x38, 0xE1, 0xC0, 0x3C, 0xF0, 0xE0, 0x1C, 0x70, 0x70, 0x1C,
  0x38, 0x38, 0x1E, 0x1C, 0x1C, 0x0E, 0x0E, 0x1E, 0x0E, 0x07, 0x0E, 0x0F,
  0x03, 0x87, 0x07, 0x01, 0xC7, 0x07, 0x00, 0xFF, 0x87, 0x80, 0x7F, 0x87,
  0x80, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0xF9, 0xF0, 0x03, 0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0,
  0xF0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x3D, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x0F, 0x3E,
  0x78, 0x3D, 0xF1, 0xE1, 0xE7, 0x83, 0xC7, 0xBC, 0x0F, 0xBC, 0xF0, 0x1F,
  0xF3, 0xC0, 0x7F, 0x8F, 0x00, 0xFC, 0x3C, 0x03, 0xE0, 0xF0, 0x1F, 0xC3,
  0xE0, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFE, 0x7C, 0x1F, 0xE1, 0xF0, 0x3D,
  0xF7, 0x9E, 0x79, 0xC7, 0x1C, 0xF3, 0x8E, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00,
  0x38, 0x01, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x00, 0x01, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x41, 0xC0,
  0x71, 0xC0, 0xFD, 0xC0, 0xFF, 0xFF, 0x1F, 0xFF, 0x03, 0xFF, 0x07, 0xC1,
  0x0E, 0xE0, 0x3E, 0xE0, 0x7C, 0xF0, 0x78, 0x70, 0x30, 0x78, 0x10, 0x70,
  0x00, 0x40, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x0F, 0x1F,
  0x1E, 0x3E, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0x7F, 0xFF, 0xFF, 0xFB, 0xFE,
  0x77, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0xF8, 0x78, 0xF8, 0x3C, 0x78, 0x1E, 0x78, 0x0F, 0x3C, 0x07,
  0xBE, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEF,
  0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF9, 0xE0, 0x78, 0xF0, 0x7C, 0x7C, 0x7C,
  0x1F, 0xFC, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0xF0,
  0xFE, 0x1F, 0xE7, 0xFE, 0xFD, 0xEF, 0x1E, 0x63, 0xC4, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F,
  0xFF, 0x03, 0xC1, 0xF0, 0x10, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF,
  0xF8, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF0, 0x30, 0x3E, 0x04, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x07,
  0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x80, 0x1F, 0x1E, 0x0F, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xDE, 0x00, 0x73, 0xC0, 0x1E,
  0x78, 0x07, 0x9E, 0x00, 0xE3, 0xC0, 0x38, 0x78, 0x0F, 0x0F, 0x03, 0xC1,
  0xC0, 0xF0, 0x78, 0x1C, 0x0F, 0x07, 0x81, 0xE1, 0xE0, 0x3C, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x70, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x80, 0x3E, 0x1C, 0x1F, 0xC3,
  0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xF0,
  0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE3, 0xE0, 0x7B, 0xFE,
  0x1F, 0xFF, 0x87, 0xE1, 0xF3, 0xF0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xCF,
  0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xE3, 0xC0,
  0x78, 0xF0, 0x3E, 0x1E, 0x1F, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0,
  0x00, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xE3, 0xE0, 0xF8, 0x3E, 0x1E, 0x03,
  0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x78, 0x3E, 0x1E,
  0x03, 0xE7, 0xC0, 0x3F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xE0,
  0x1F, 0x3E, 0x07, 0x83, 0xE1, 0xE0, 0x3C, 0x7C, 0x07, 0xCF, 0x00, 0x79,
  0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x78, 0xF8, 0x0F, 0x1F, 0x87, 0xE1,
  0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0x07, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF0,
  0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07,
  0xCF, 0x03, 0xF3, 0xE1, 0xFC, 0x7F, 0xFE, 0x1F, 0xF7, 0x83, 0xF9, 0xE0,
  0x10, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x20, 0x7E, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x80,
  0x00, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x1F, 0x1F, 0x8F,
  0xC3, 0xC0, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78,
  0x0E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xE0, 0x3F,
  0xF0, 0xFF, 0xF1, 0xFF, 0xE3, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x78, 0x00,
  0x1C, 0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0E, 0x1C, 0x07, 0xE0, 0xE3,
  0xC1, 0xFF, 0x87, 0x38, 0x3F, 0xF8, 0x77, 0x87, 0x87, 0x07, 0x70, 0x70,
  0x70, 0x77, 0x0E, 0x07, 0x07, 0xF0, 0xE0, 0xF0, 0xEE, 0x1C, 0x0E, 0x0E,
  0xE1, 0xC0, 0xE0, 0xEE, 0x1C, 0x1E, 0x0E, 0xE1, 0xC1, 0xE1, 0xCE, 0x1C,
  0x1C, 0x1C, 0xE1, 0xC3, 0xC3, 0x8E, 0x1C, 0x7E, 0x78, 0xE1, 0xFE, 0xFF,
  0x0E, 0x0F, 0xC7, 0xE0, 0xE0, 0x30, 0x38, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x20, 0x01, 0xF8, 0x3E,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x77, 0x80, 0x07, 0xBC, 0x00, 0x39, 0xE0,
  0x03, 0xC7, 0x00, 0x1E, 0x38, 0x01, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0xF0,
  0x78, 0x07, 0x83, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0x80, 0x78, 0x78, 0x03,
  0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xF3, 0xE0, 0x07, 0x9E, 0x00, 0x3D, 0xF0,
  0x01, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x7C, 0x1E, 0x03, 0xE1,
  0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0x83, 0xC0, 0x7C, 0x1E, 0x07,
  0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1E,
  0x07, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0xC3, 0xC0, 0x3E,
  0x3E, 0x01, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x78, 0x0F, 0x83, 0xC3,
  0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0x03, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x78, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xFC, 0x07, 0x83, 0xF8, 0x1E, 0x03, 0xE0, 0x78, 0x07, 0x83, 0xE0,
  0x1F, 0x0F, 0x00, 0x7C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F,
  0x1F, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x1F, 0x1E,
  0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x3C, 0x3C, 0x01,
  0xF1, 0xF0, 0x07, 0x87, 0x80, 0x3E, 0x1E, 0x01, 0xF0, 0x78, 0x1F, 0x81,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7E, 0x01, 0x81, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xFE,
  0x7C, 0x07, 0xFC, 0xF8, 0x1F, 0xF1, 0xF0, 0x01, 0xE3, 0xE0, 0x03, 0xC7,
  0xC0, 0x07, 0x8F, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3E,
  0x00, 0xF0, 0x7E, 0x03, 0xE0, 0x7E, 0x0F, 0x80, 0x7F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x03,
  0xC0, 0x0F, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07,
  0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0F,
  0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF8, 0x3C,
  0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x78,
  0x01, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF8,
  0x01, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x03, 0xFF, 0x03, 0xFF,
  0x07, 0xFF, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0,
  0x00, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xF0, 0x3C, 0x07,
  0xC0, 0x78, 0x1F, 0x00, 0xF0, 0x7C, 0x01, 0xE1, 0xF0, 0x07, 0xC3, 0xC0,
  0x0F, 0x0F, 0x80, 0x1E, 0x3E, 0x00, 0x3C, 0xF8, 0x00, 0x7B, 0xE0, 0x01,
  0xEF, 0x80, 0x03, 0xDE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0x78, 0x00, 0x7C, 0xF8, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3,
  0xE0, 0x0F, 0x83, 0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x80, 0x78, 0x0F,
  0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xFC,
  0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x7F, 0x81, 0xDC, 0x00, 0xEF, 0x07, 0xB8, 0x03, 0xFC, 0x0F,
  0x70, 0x07, 0x78, 0x1E, 0xE0, 0x1E, 0xF0, 0x3D, 0xC0, 0x39, 0xE0, 0x73,
  0x80, 0xF7, 0x81, 0xE7, 0x01, 0xCF, 0x03, 0xCF, 0x07, 0x9E, 0x07, 0x9E,
  0x0E, 0x3C, 0x0F, 0x3C, 0x3C, 0x78, 0x1C, 0x78, 0x71, 0xE0, 0x78, 0xF1,
  0xE3, 0xC0, 0xF0, 0xE3, 0x87, 0x81, 0xE1, 0xCF, 0x0F, 0x03, 0xC3, 0x9C,
  0x1E, 0x0F, 0x07, 0x78, 0x78, 0x1E, 0x0E, 0xE0, 0xF0, 0x3C, 0x1F, 0xC1,
  0xE0, 0x78, 0x3F, 0x03, 0xC0, 0xE0, 0x7E, 0x0F, 0x83, 0xC0, 0xF8, 0x1E,
  0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x03,
  0xC0, 0xF8, 0x01, 0xE0, 0x7E, 0x00, 0x78, 0x1F, 0x80, 0x1E, 0x07, 0xF0,
  0x07, 0x81, 0xFC, 0x01, 0xC0, 0x7F, 0x00, 0xF0, 0x3D, 0xE0, 0x3C, 0x0F,
  0x78, 0x0F, 0x03, 0xDE, 0x03, 0xC0, 0xF3, 0x80, 0xE0, 0x38, 0xF0, 0x78,
  0x1E, 0x3C, 0x1E, 0x07, 0x8F, 0x07, 0x81, 0xE1, 0xE1, 0xE0, 0x78, 0x78,
  0xF0, 0x1C, 0x1E, 0x3C, 0x0F, 0x03, 0x8F, 0x03, 0xC0, 0xF3, 0xC0, 0xF0,
  0x3C, 0xF0, 0x3C, 0x0F, 0x38, 0x1E, 0x01, 0xFE, 0x07, 0x80, 0x7F, 0x81,
  0xE0, 0x1F, 0xE0, 0x78, 0x03, 0xF0, 0x1C, 0x00, 0xFC, 0x0F, 0x00, 0x3F,
  0x03, 0xC0, 0x0F, 0xC0, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7E, 0x0F, 0xC1, 0xF0,
  0x0F, 0x87, 0xC0, 0x0F, 0x0F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00,
  0x3C, 0xF0, 0x00, 0x7B, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x00, 0x07,
  0xDE, 0x00, 0x0F, 0xFC, 0x00, 0x1E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0xFB,
  0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1E, 0x1E,
  0x00, 0x7C, 0x3C, 0x01, 0xF0, 0x7C, 0x07, 0xE0, 0x7E, 0x3F, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0x83, 0xF0, 0x78, 0x1F, 0x07,
  0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0x1F, 0x1F, 0x01, 0xE1, 0xE0, 0x7E, 0x1E, 0x1F, 0xC1, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7E, 0x0F, 0xC1,
  0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x0F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x7C,
  0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xE0, 0x01, 0xF7, 0x80, 0x03, 0xEF, 0x00,
  0x07, 0xDE, 0x00, 0x0F, 0xFC, 0x00, 0x1E, 0xF8, 0x00, 0x3D, 0xF0, 0x00,
  0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1E,
  0x1E, 0x00, 0x7C, 0x3C, 0x01, 0xF0, 0x7C, 0x07, 0xE0, 0x7E, 0x3F, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0x83, 0xF0, 0x78, 0x1F, 0x07, 0x80, 0xF0, 0xF8,
  0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x1E, 0x1E,
  0x03, 0xE1, 0xE0, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFC, 0x03,
  0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xE0, 0x3C, 0x1E, 0x07, 0xC1, 0xE0,
  0x78, 0x1E, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0xF8, 0x0F,
  0x8F, 0x00, 0x78, 0xF0, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xC0, 0xC0, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x80, 0x1F, 0x0F, 0x07, 0xE0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x3C, 0x00, 0xF8, 0x78, 0x01,
  0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x87, 0xC0, 0x0F, 0x0F, 0x00, 0x3E,
  0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE1, 0xE0, 0x03, 0xC3,
  0xC0, 0x0F, 0x87, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x78,
  0x01, 0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x80,
  0x1E, 0x1F, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0x78, 0x0F,
  0x80, 0xFC, 0x3F, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x80,
  0x00, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0xF0,
  0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x0F,
  0x01, 0xF0, 0xF0, 0x1E, 0x0F, 0x03, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0xC0,
  0x70, 0x78, 0x07, 0x0F, 0x80, 0x70, 0xF0, 0x07, 0x8F, 0x00, 0x79, 0xE0,
  0x07, 0x9E, 0x00, 0x7B, 0xC0, 0x07, 0xBC, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x03, 0x80, 0x1F, 0xE0, 0x0F, 0x00, 0x3F, 0xC0, 0x1E,
  0x00, 0xF7, 0x80, 0x7C, 0x01, 0xEF, 0x00, 0xF8, 0x07, 0x9E, 0x03, 0xF0,
  0x0F, 0x3C, 0x07, 0xF0, 0x3E, 0x78, 0x1F, 0xE0, 0x78, 0xF0, 0x3F, 0xC0,
  0xF1, 0xE0, 0x77, 0x83, 0xC3, 0xC1, 0xEF, 0x07, 0x87, 0x83, 0x9E, 0x1E,
  0x0F, 0x0F, 0x3C, 0x3C, 0x1E, 0x1C, 0x78, 0x78, 0x3C, 0x78, 0xF1, 0xE0,
  0x78, 0xF1, 0xE3, 0xC0, 0xF1, 0xC3, 0xCF, 0x01, 0xE7, 0x87, 0x9E, 0x03,
  0xCE, 0x0F, 0x38, 0x07, 0xBC, 0x1E, 0xF0, 0x0F, 0x70, 0x3D, 0xE0, 0x1E,
  0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE,
  0x03, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xC0,
  0x1F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0xF0,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x07, 0xC0, 0x0F, 0x03, 0xC0, 0x07,
  0x83, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0x79, 0xE0, 0x00,
  0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x3C, 0x78,
  0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x1E, 0x03,
  0xC0, 0x1F, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x0F, 0x00, 0x3C, 0x0F, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7B, 0xC0, 0x3E, 0xF0,
  0x1F, 0x1E, 0x07, 0x87, 0x83, 0xE1, 0xE0, 0xF0, 0x78, 0x78, 0x1E, 0x1E,
  0x03, 0xCF, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0xFF, 0x00, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x38, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x00, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x39, 0xC0, 0x1E, 0x78, 0x07,
  0x1E, 0x03, 0xC3, 0x80, 0xE0, 0xF0, 0x78, 0x1C, 0x1C, 0x07, 0x0F, 0x01,
  0xE3, 0x80, 0x39, 0xE0, 0x0F, 0x70, 0x01, 0xFC, 0x00, 0x70, 0x7F, 0xFF,
  0xFF, 0xFE, 0xF1, 0xF1, 0xE3, 0xC3, 0xC3, 0x83, 0x80, 0x01, 0xE1, 0xE0,
  0xFF, 0x38, 0x3F, 0xF7, 0x0F, 0xFF, 0xE3, 0xE0, 0xFC, 0x7C, 0x0F, 0x1F,
  0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x9F, 0x00, 0xF3, 0xC0, 0x3C, 0x78,
  0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0xC7, 0x80, 0xF0, 0xF0,
  0x3E, 0x1E, 0x0F, 0xC3, 0xE3, 0xF8, 0x7F, 0xEE, 0x07, 0xF9, 0xC0, 0x7E,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x1E, 0x01,
  0xEF, 0xF0, 0x3F, 0xFF, 0x07, 0x77, 0xE1, 0xF8, 0x3C, 0x3E, 0x07, 0xC7,
  0xC0, 0xF8, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1E,
  0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x0F, 0x9E, 0x01, 0xE3, 0xC0, 0x3C, 0x78,
  0x0F, 0x8F, 0x83, 0xE3, 0xF8, 0xF8, 0x7F, 0xFF, 0x0E, 0x7F, 0xC1, 0xC7,
  0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0xFE, 0xE3, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0xC3, 0xFF, 0x87, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE1, 0xC0, 0x7F, 0xBC, 0x0F, 0xFF, 0xC1,
  0xFB, 0xFC, 0x3E, 0x0F, 0xC3, 0xC0, 0x78, 0x7C, 0x07, 0x87, 0x80, 0x78,
  0x78, 0x07, 0x8F, 0x80, 0x78, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F,
  0x0F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xE0, 0xF0, 0x3E, 0x0F, 0x07,
  0xE0, 0xF8, 0xFE, 0x0F, 0xFD, 0xC0, 0x7F, 0x9C, 0x03, 0xF1, 0xC0, 0x01,
  0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0x9F, 0x3E, 0x0F, 0x3C, 0x0F, 0x78,
  0x0F, 0x78, 0x1F, 0xF8, 0x3E, 0xF1, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x18, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x7C, 0x78, 0x0F, 0xF3, 0x80, 0xFF, 0xDC, 0x0F, 0xFF, 0xE0, 0xF8,
  0x3F, 0x07, 0xC0, 0xF0, 0x7C, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE1,
  0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x03,
  0xE0, 0xF0, 0x1F, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0xFC, 0x0F,
  0x8F, 0xE0, 0x7F, 0xEE, 0x01, 0xFE, 0xF0, 0x07, 0xE7, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x81, 0x80,
  0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x1F, 0x03, 0xDF, 0xE0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x1F, 0x83, 0xC7, 0xC0, 0xF1, 0xF0, 0x3C, 0x78, 0x0F,
  0x3E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x7C, 0xF0, 0x1E, 0x3C, 0x07, 0x9E,
  0x01, 0xE7, 0x80, 0x79, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xCF, 0x00,
  0xF3, 0xC0, 0x3C, 0xF0, 0x1E, 0x3C, 0x07, 0x80, 0x01, 0x80, 0xF0, 0x7C,
  0x1F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x00, 0x06,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x01, 0xE1, 0xE0, 0x78, 0x3C, 0x1E, 0x07, 0x87, 0x81, 0xE1,
  0xF0, 0x3C, 0x7C, 0x07, 0x9F, 0x00, 0xF7, 0xC0, 0x3C, 0xF0, 0x07, 0xBC,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xF9, 0xE0, 0x1E, 0x3E,
  0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x83, 0xC0, 0xF0, 0x78, 0x1E,
  0x0F, 0x03, 0xE1, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x0E, 0x1E, 0x03, 0xC0,
  0x73, 0xFC, 0x7F, 0x83, 0xBF, 0xE7, 0xFC, 0x3F, 0xDF, 0xFB, 0xF1, 0xF8,
  0x3F, 0x07, 0x8F, 0x81, 0xF0, 0x3C, 0x7C, 0x0F, 0x81, 0xE3, 0xC0, 0x78,
  0x0F, 0x3E, 0x07, 0xC0, 0xF1, 0xE0, 0x3C, 0x07, 0x8F, 0x01, 0xE0, 0x3C,
  0x78, 0x0F, 0x01, 0xE3, 0xC0, 0x78, 0x0F, 0x3C, 0x07, 0x80, 0xF1, 0xE0,
  0x3C, 0x07, 0x8F, 0x01, 0xE0, 0x3C, 0x78, 0x0F, 0x01, 0xE3, 0xC0, 0x78,
  0x0F, 0x3C, 0x07, 0x80, 0xF1, 0xE0, 0x3C, 0x07, 0x8F, 0x01, 0xE0, 0x3C,
  0x78, 0x0F, 0x01, 0xE0, 0x0E, 0x1F, 0x03, 0x9F, 0xE0, 0xEF, 0xFC, 0x7F,
  0xFF, 0x1F, 0xC3, 0xC7, 0xE0, 0xF1, 0xF0, 0x3C, 0x78, 0x0F, 0x3E, 0x03,
  0xCF, 0x00, 0xF3, 0xC0, 0x7C, 0xF0, 0x1E, 0x3C, 0x07, 0x9E, 0x01, 0xE7,
  0x80, 0x79, 0xE0, 0x3C, 0x78, 0x0F, 0x3E, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x7C, 0xF0, 0x1E, 0x3C, 0x07, 0x80, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF,
  0x83, 0xFF, 0xE3, 0xE0, 0xF9, 0xE0, 0x3D, 0xF0, 0x1E, 0xF0, 0x0F, 0xF8,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7B,
  0xC0, 0x3D, 0xE0, 0x3E, 0xF0, 0x1E, 0x78, 0x1F, 0x3E, 0x1F, 0x0F, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0x87, 0x80, 0x1C, 0xFF, 0x00, 0xEF,
  0xFC, 0x07, 0xF7, 0xE0, 0x7E, 0x0F, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0,
  0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01,
  0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E,
  0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0xE3, 0xE0, 0x7F, 0xFF, 0x03, 0xDF, 0xF0,
  0x1E, 0x7E, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF1, 0xE0, 0xFF, 0x38, 0x3F, 0xF7,
  0x0F, 0xDF, 0xE3, 0xE0, 0xFC, 0x78, 0x0F, 0x1F, 0x01, 0xE3, 0xC0, 0x3C,
  0x78, 0x07, 0x9F, 0x00, 0xF3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1,
  0xE0, 0x1E, 0x3C, 0x07, 0xC7, 0x80, 0xF0, 0xF0, 0x3E, 0x1E, 0x0F, 0xC3,
  0xE3, 0xF8, 0x7F, 0xEE, 0x07, 0xFB, 0xC0, 0x7E, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0E, 0x1E, 0x1C,
  0xFC, 0x3B, 0xF0, 0xF7, 0xE1, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0x1E, 0x1E,
  0x02, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x7C, 0x80, 0x78, 0xC0, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xC0, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xF0, 0xFF,
  0x07, 0xF0, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C,
  0x03, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x78, 0x07, 0x9E, 0x01,
  0xE7, 0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x01, 0xE3,
  0xC0, 0x78, 0xF0, 0x3E, 0x3C, 0x1F, 0x8F, 0x0F, 0xE3, 0xFF, 0x70, 0x7F,
  0x9C, 0x1F, 0xC7, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xDE, 0x01,
  0xEF, 0x01, 0xE3, 0x80, 0xF1, 0xC0, 0xF0, 0xE0, 0x78, 0x78, 0x78, 0x3C,
  0x3C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xEF, 0x00,
  0xF7, 0x80, 0x7B, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x1F, 0x01, 0xFE, 0x03, 0xE0, 0x7B, 0xC0, 0xFC,
  0x0F, 0x78, 0x1F, 0x83, 0xEF, 0x03, 0xF0, 0x78, 0xE0, 0xEE, 0x0F, 0x1C,
  0x1D, 0xC3, 0xC3, 0x87, 0xB8, 0x78, 0x70, 0xE7, 0x1E, 0x0E, 0x3C, 0xE3,
  0xC1, 0xC7, 0x1C, 0xF0, 0x38, 0xE3, 0x9E, 0x07, 0x38, 0x73, 0xC0, 0xE7,
  0x0E, 0xF0, 0x1D, 0xE1, 0xDE, 0x03, 0xB8, 0x3B, 0x80, 0x77, 0x07, 0xF0,
  0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0,
  0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x78, 0x3E, 0x07, 0xC0,
  0xF0, 0x7C, 0x07, 0x83, 0xC0, 0x3E, 0x3C, 0x00, 0xF3, 0xE0, 0x07, 0x9E,
  0x00, 0x1D, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0x70, 0x00, 0xF3, 0xC0,
  0x0F, 0x9E, 0x00, 0x78, 0x78, 0x07, 0x83, 0xC0, 0x7C, 0x1E, 0x07, 0xC0,
  0xF8, 0x7C, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x07,
  0x81, 0xE0, 0x1E, 0x03, 0x80, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x1E, 0x00,
  0xF0, 0x78, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x78, 0x00, 0xF1,
  0xE0, 0x03, 0xCF, 0x00, 0x07, 0x3C, 0x00, 0x1C, 0xE0, 0x00, 0x77, 0x80,
  0x01, 0xDC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xBE, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0x80, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x7C, 0x01,
  0xF8, 0x07, 0xF0, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x5F, 0xF0, 0x3F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xC0, 0x7F, 0xA0, 0x07, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 29, 10, 1, -29 },
  { 38, 13, 11, 16, 4, -29 },
  { 56, 22, 29, 23, 1, -29 },
  { 136, 19, 32, 20, 1, -30 },
  { 212, 25, 29, 30, 3, -29 },
  { 303, 22, 29, 24, 1, -29 },
  { 383, 6, 11, 9, 4, -29 },
  { 392, 13, 35, 12, 1, -29 },
  { 449, 13, 35, 12, -3, -29 },
  { 506, 16, 18, 19, 4, -31 },
  { 542, 18, 19, 21, 2, -24 },
  { 585, 8, 10, 10, -2, -5 },
  { 595, 10, 4, 12, 1, -13 },
  { 600, 5, 5, 10, 1, -5 },
  { 604, 20, 29, 15, -2, -29 },
  { 677, 17, 29, 20, 2, -29 },
  { 739, 12, 29, 20, 5, -29 },
  { 783, 20, 29, 20, -1, -29 },
  { 856, 19, 29, 20, 0, -29 },
  { 925, 19, 29, 20, 0, -29 },
  { 994, 19, 29, 20, 1, -29 },
  { 1063, 18, 29, 20, 2, -29 },
  { 1129, 19, 29, 20, 2, -29 },
  { 1198, 19, 29, 20, 1, -29 },
  { 1267, 18, 29, 20, 1, -29 },
  { 1333, 9, 22, 10, 0, -22 },
  { 1358, 11, 27, 10, -2, -22 },
  { 1396, 18, 19, 21, 2, -24 },
  { 1439, 18, 12, 21, 2, -20 },
  { 1466, 18, 19, 21, 2, -24 },
  { 1509, 15, 29, 16, 2, -29 },
  { 1564, 28, 33, 30, 2, -29 },
  { 1680, 21, 29, 21, -2, -29 },
  { 1757, 21, 29, 22, 1, -29 },
  { 1834, 21, 29, 21, 2, -29 },
  { 1911, 22, 29, 24, 1, -29 },
  { 1991, 19, 29, 19, 1, -29 },
  { 2060, 19, 29, 18, 1, -29 },
  { 2129, 23, 29, 25, 2, -29 },
  { 2213, 24, 29, 25, 1, -29 },
  { 2300, 16, 29, 13, -1, -29 },
  { 2358, 17, 37, 11, -6, -29 },
  { 2437, 23, 29, 21, 1, -29 },
  { 2521, 14, 29, 18, 1, -29 },
  { 2572, 31, 29, 31, 1, -29 },
  { 2685, 26, 29, 26, 1, -29 },
  { 2780, 23, 29, 26, 2, -29 },
  { 2864, 20, 29, 21, 1, -29 },
  { 2937, 23, 36, 26, 2, -29 },
  { 3041, 20, 29, 21, 1, -29 },
  { 3114, 20, 29, 19, 0, -29 },
  { 3187, 18, 29, 18, 3, -29 },
  { 3253, 23, 29, 24, 2, -29 },
  { 3337, 20, 29, 20, 4, -29 },
  { 3410, 31, 29, 32, 4, -29 },
  { 3523, 25, 29, 20, -2, -29 },
  { 3614, 18, 29, 19, 4, -29 },
  { 3680, 22, 29, 19, -1, -29 },
  { 3760, 16, 35, 12, -1, -29 },
  { 3830, 8, 29, 15, 4, -29 },
  { 3859, 16, 35, 12, -3, -29 },
  { 3929, 18, 18, 20, 1, -29 },
  { 3970, 16, 2, 15, -4, 4 },
  { 3974, 7, 7, 11, 6, -31 },
  { 3981, 19, 22, 21, 2, -22 },
  { 4034, 19, 30, 21, 1, -30 },
  { 4106, 15, 22, 17, 2, -22 },
  { 4148, 20, 30, 21, 2, -30 },
  { 4223, 16, 22, 19, 2, -22 },
  { 4267, 22, 41, 12, -5, -31 },
  { 4380, 21, 32, 21, 0, -22 },
  { 4464, 18, 30, 21, 1, -30 },
  { 4532, 10, 30, 10, 1, -30 },
  { 4570, 16, 40, 10, -5, -30 },
  { 4650, 19, 30, 19, 1, -30 },
  { 4722, 10, 30, 10, 1, -30 },
  { 4760, 29, 22, 32, 1, -22 },
  { 4840, 18, 22, 21, 1, -22 },
  { 4890, 17, 22, 21, 2, -22 },
  { 4937, 21, 32, 21, -1, -22 },
  { 5021, 19, 32, 21, 2, -22 },
  { 5097, 15, 22, 15, 1, -22 },
  { 5139, 16, 22, 16, 0, -22 },
  { 5183, 12, 26, 13, 2, -26 },
  { 5222, 18, 22, 21, 2, -22 },
  { 5272, 17, 22, 17, 2, -22 },
  { 5319, 27, 22, 27, 2, -22 },
  { 5394, 21, 22, 18, -2, -22 },
  { 5452, 22, 32, 17, -3, -22 },
  { 5540, 17, 22, 16, -1, -22 },
  { 5587, 16, 35, 14, 0, -29 },
  { 5657, 4, 39, 19, 8, -30 },
  { 5677, 15, 35, 14, -2, -29 },
  { 5743, 18, 6, 21, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC40PT7B_H_
