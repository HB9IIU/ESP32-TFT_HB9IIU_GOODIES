#ifndef _JETBRAINSMONO_SEMIBOLDITALIC45PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F,
  0xE0, 0x7C, 0x00, 0x7E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3C, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0x7C, 0x00, 0x1E, 0x03, 0xC0, 0x03,
  0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0xF0,
  0x00, 0x78, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x78,
  0x1E, 0x23, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0,
  0x1E, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x03,
  0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03,
  0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x01, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0xF0, 0x00, 0x78,
  0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00,
  0x1E, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF6, 0xFE, 0x0F, 0xC6, 0x3F, 0x0F,
  0x8E, 0x3F, 0x0F, 0x8E, 0x3F, 0x1F, 0x8E, 0x3F, 0x1F, 0x8E, 0x00, 0x1F,
  0x8E, 0x00, 0x1F, 0x8C, 0x00, 0x1F, 0xDC, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x39, 0xFC, 0x00, 0x38, 0xFC, 0x00,
  0x38, 0xFC, 0x00, 0x30, 0xFC, 0xF8, 0x70, 0xFC, 0xF8, 0x70, 0xF8, 0xFC,
  0x70, 0xF8, 0xFC, 0x71, 0xF8, 0xFF, 0x77, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0x01, 0xFF, 0x80, 0x1E, 0x03, 0xFF,
  0x80, 0x3C, 0x03, 0xE7, 0xC0, 0x78, 0x07, 0x83, 0xC0, 0xF0, 0x07, 0x83,
  0xC0, 0xF0, 0x07, 0x83, 0xC1, 0xE0, 0x07, 0x03, 0xC3, 0xC0, 0x0F, 0x03,
  0x87, 0x80, 0x0F, 0x07, 0x8F, 0x00, 0x0F, 0x07, 0x9E, 0x00, 0x0F, 0xDF,
  0xBC, 0x00, 0x07, 0xFF, 0x3C, 0x00, 0x03, 0xFE, 0x78, 0x00, 0x01, 0xF8,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x3F, 0xC0, 0x00, 0x1E,
  0x7F, 0xE0, 0x00, 0x3C, 0xFF, 0xF0, 0x00, 0x79, 0xE0, 0xF0, 0x00, 0xF1,
  0xE0, 0xF0, 0x01, 0xE1, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0xF0, 0x03, 0xC1,
  0xC0, 0xE0, 0x07, 0x83, 0xC1, 0xE0, 0x0F, 0x03, 0xC1, 0xE0, 0x1E, 0x03,
  0xE3, 0xE0, 0x3C, 0x01, 0xFF, 0xC0, 0x78, 0x01, 0xFF, 0x80, 0xF8, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0x0F, 0xE0, 0x1F, 0x03, 0xF0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xBE, 0x0F, 0xCF, 0x9F,
  0x87, 0xCF, 0x87, 0xC7, 0xC7, 0xC3, 0xF7, 0xE3, 0xE0, 0xFB, 0xE1, 0xF0,
  0x3F, 0xE0, 0xF8, 0x1F, 0xE0, 0xF8, 0x07, 0xF0, 0x7C, 0x03, 0xF0, 0x3E,
  0x01, 0xF8, 0x1F, 0x81, 0xFE, 0x0F, 0xC1, 0xFF, 0x03, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFB, 0xE0, 0x7F, 0xF8, 0xF8, 0x1F, 0xF0, 0x7E, 0x00, 0x3E, 0x7C,
  0xFB, 0xF7, 0xEF, 0x9F, 0x3E, 0x7C, 0xF9, 0xE7, 0xCF, 0x9F, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF0,
  0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x3C,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x20, 0x1E, 0x01, 0x38,
  0x1E, 0x0F, 0x7E, 0x1C, 0x3F, 0x7F, 0x9C, 0xFF, 0xFF, 0xD9, 0xFF, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xEF, 0x00, 0x03, 0xEF, 0x80, 0x07, 0xCF, 0x80, 0x0F, 0x87, 0xC0, 0x1F,
  0x87, 0xE0, 0x3F, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1C, 0x03, 0xC0, 0x0C,
  0x01, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80,
  0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x1C, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07,
  0xF0, 0xFE, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x1F,
  0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x3C, 0x3E, 0x3E, 0x7E, 0x3E, 0x3E,
  0x7E, 0x7C, 0x3E, 0x7E, 0x7C, 0x3C, 0x3C, 0x7C, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7F,
  0x07, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xFC, 0x07, 0xFB, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x0E,
  0x0F, 0xC0, 0x60, 0x7C, 0x04, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xF9, 0xFE, 0x0F, 0xC0, 0x7E, 0x1F,
  0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xF8,
  0x01, 0xF8, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x07, 0xE0, 0x3E, 0x1F, 0x80, 0xFC,
  0x7E, 0x01, 0xF9, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F,
  0x80, 0x1F, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0x00, 0x1F, 0x3F,
  0xE0, 0x1F, 0x7F, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0x81,
  0xFC, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7F, 0x0F,
  0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFB, 0xF8, 0x03, 0xEF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x7F, 0x03, 0xF9, 0xFC, 0x03, 0xF3, 0xF0, 0x03, 0xE7, 0xC0,
  0x07, 0xDF, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00,
  0xFD, 0xF0, 0x01, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x87, 0xF0, 0x7F,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xDF, 0x80, 0x1F, 0xBE, 0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xF8,
  0x03, 0xF1, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07,
  0xF0, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x7C, 0x0F,
  0xC1, 0xF8, 0x07, 0xE3, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xE7, 0xF0, 0x1F, 0x83, 0xF8, 0x3F,
  0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xFC,
  0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x07, 0xFF,
  0xFE, 0x1F, 0xC3, 0xF8, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x00, 0x1F,
  0x7C, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xC0, 0x1F, 0xBF, 0x81, 0xFC, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFB, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC1, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x3F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x30, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0x08, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03,
  0xFF, 0x00, 0x7F, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x3E, 0x00, 0x3E, 0x07,
  0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0, 0xF0, 0x00,
  0x1E, 0x1F, 0x00, 0x01, 0xE1, 0xF0, 0x1F, 0x1E, 0x1E, 0x03, 0xFD, 0xE1,
  0xE0, 0x7F, 0xDE, 0x1E, 0x0F, 0xCF, 0xE3, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F,
  0x03, 0xC3, 0xE1, 0xE0, 0x3C, 0x3C, 0x1E, 0x07, 0xC3, 0xC1, 0xE0, 0x7C,
  0x3C, 0x3E, 0x07, 0xC7, 0xC3, 0xE0, 0x78, 0x7C, 0x3E, 0x07, 0x87, 0xC3,
  0xC0, 0x78, 0x78, 0x3C, 0x0F, 0x87, 0x83, 0xC0, 0xF8, 0x78, 0x3E, 0x1F,
  0x87, 0x83, 0xFF, 0xF0, 0xF8, 0x1F, 0xEF, 0x0F, 0x81, 0xFC, 0xF0, 0xF8,
  0x03, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xBE, 0x00, 0x1F,
  0x7C, 0x00, 0x3E, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE3,
  0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x3E,
  0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x3F, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x3E, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0,
  0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x3E, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0x80, 0x7F, 0x0F, 0x80, 0x3F, 0x0F, 0x80,
  0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x7E, 0x1F, 0x00, 0xFC, 0x1F, 0x03, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3E, 0x03, 0xF8, 0x3E, 0x00,
  0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0x7C, 0x03,
  0xF8, 0xF8, 0x1F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF9, 0xFE, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01,
  0xF8, 0x7E, 0x03, 0xF0, 0x7F, 0x0F, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0x80,
  0xFE, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80,
  0x3F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01,
  0xF8, 0x7C, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x07, 0xF9, 0xFE, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F,
  0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x1F, 0xFE, 0x3E, 0x1F, 0xFC, 0x3E, 0x1F, 0xFC, 0x3E,
  0x1F, 0xFC, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7C,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7E,
  0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0x81,
  0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF8,
  0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F,
  0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03,
  0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0x83, 0xF0,
  0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x3E,
  0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x07,
  0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0x7C, 0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x07, 0xE0, 0x7F,
  0x87, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x0F, 0x81, 0xF8, 0x07, 0xE0, 0x7C,
  0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x07, 0xC3,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0xC0,
  0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x07,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0xFC,
  0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0xE0,
  0xF8, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x1F, 0xC0,
  0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x77, 0x83,
  0xDC, 0x1F, 0xF0, 0x7B, 0x83, 0xBC, 0x0F, 0x70, 0xF7, 0x83, 0xEF, 0x1C,
  0xF0, 0x7D, 0xE7, 0xBE, 0x0F, 0xBC, 0xF7, 0xC1, 0xF7, 0xBC, 0xF8, 0x3C,
  0x77, 0x9E, 0x07, 0x8E, 0xE3, 0xC0, 0xF1, 0xFC, 0xF8, 0x3E, 0x3F, 0x1F,
  0x07, 0xC7, 0xE3, 0xE0, 0xF8, 0xF8, 0x7C, 0x1F, 0x00, 0x1F, 0x03, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0,
  0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07,
  0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xC1, 0xFC,
  0x01, 0xF0, 0x7F, 0x80, 0x78, 0x1F, 0xE0, 0x3E, 0x07, 0xF8, 0x0F, 0x81,
  0xFE, 0x03, 0xE0, 0x7F, 0x80, 0xF8, 0x1F, 0xF0, 0x3E, 0x0F, 0xFC, 0x0F,
  0x03, 0xEF, 0x07, 0xC0, 0xFB, 0xC1, 0xF0, 0x3E, 0xF0, 0x7C, 0x0F, 0x3C,
  0x1F, 0x03, 0xCF, 0x87, 0xC1, 0xF1, 0xE1, 0xF0, 0x7C, 0x78, 0x78, 0x1F,
  0x1E, 0x3E, 0x07, 0xC7, 0x8F, 0x81, 0xF1, 0xF3, 0xE0, 0x78, 0x3C, 0xF8,
  0x3E, 0x0F, 0x3E, 0x0F, 0x83, 0xCF, 0x03, 0xE0, 0xF3, 0xC0, 0xF8, 0x3E,
  0xF0, 0x3E, 0x07, 0xFC, 0x0F, 0x01, 0xFF, 0x03, 0xC0, 0x7F, 0xC1, 0xF0,
  0x1F, 0xE0, 0x7C, 0x07, 0xF8, 0x1F, 0x01, 0xFE, 0x07, 0xC0, 0x3F, 0x81,
  0xF0, 0x0F, 0xE0, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF9, 0xFE, 0x0F, 0xC0,
  0x7E, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3E, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x3F, 0x00,
  0x7E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01,
  0xF8, 0x7C, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x7F, 0x0F, 0xE0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7C, 0x01, 0xFC, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F,
  0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xF1,
  0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF9, 0xFE, 0x0F, 0xC0, 0x7E,
  0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E,
  0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC,
  0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8,
  0x7C, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x7C, 0x03, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xE1, 0xF0,
  0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03,
  0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x1F, 0x80, 0x7C,
  0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03,
  0xE0, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xC7, 0xF0, 0x3F, 0x00, 0xFC,
  0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x7E, 0x3E,
  0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x1F, 0x87, 0xF8, 0x3F, 0x81,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xC1, 0xF0, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00,
  0x7E, 0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E,
  0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07,
  0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE0,
  0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x7C,
  0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xEF, 0xC0, 0x0F, 0xCF, 0x80,
  0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07,
  0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8,
  0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x3E, 0x00,
  0xF8, 0x7C, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x78, 0x00, 0x7D, 0xF0, 0x00, 0xFB,
  0xE0, 0x00, 0xF7, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x0F, 0x81, 0xE7, 0x81,
  0xF0, 0x3C, 0xF0, 0x3E, 0x0F, 0x9E, 0x0F, 0xC1, 0xF3, 0xC1, 0xF8, 0x3C,
  0x78, 0x3F, 0x07, 0x8F, 0x07, 0xE1, 0xF1, 0xE1, 0xDC, 0x3C, 0x3C, 0x3B,
  0x87, 0x87, 0x87, 0x70, 0xF1, 0xF0, 0xCE, 0x3E, 0x3E, 0x39, 0xC7, 0x87,
  0xC7, 0x38, 0xF0, 0xF8, 0xE6, 0x1E, 0x1F, 0x38, 0xC7, 0xC3, 0xE7, 0x38,
  0xF0, 0x78, 0xE7, 0x1E, 0x0F, 0x1C, 0xE3, 0xC1, 0xE7, 0x1C, 0xF0, 0x3C,
  0xE3, 0x9E, 0x07, 0x9C, 0x73, 0xC0, 0xF7, 0x0E, 0x78, 0x1E, 0xE1, 0xDE,
  0x03, 0xDC, 0x3B, 0xC0, 0x7B, 0x87, 0x78, 0x0F, 0xE0, 0xEF, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0,
  0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF0, 0x7E,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3F,
  0x3F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF8, 0x1F,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0xCF, 0xC0, 0x0F, 0xC3,
  0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x1F, 0x03, 0xF0, 0x0F, 0xC1, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x04, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x1F, 0x78, 0x03, 0xE7, 0x80, 0x3E, 0x78, 0x07,
  0xC7, 0xC0, 0x78, 0x7C, 0x0F, 0x83, 0xC1, 0xF0, 0x3E, 0x1F, 0x03, 0xE3,
  0xE0, 0x3E, 0x3E, 0x01, 0xE7, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFC, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x00, 0xFE,
  0x3E, 0x07, 0xFE, 0x7C, 0x1F, 0xFE, 0xF8, 0x7F, 0xFD, 0xF0, 0xFF, 0x3B,
  0xE3, 0xF0, 0x1F, 0xC7, 0xC0, 0x3F, 0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0x8F,
  0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF8, 0xF8,
  0x03, 0xF1, 0xF0, 0x07, 0xC3, 0xF0, 0x1F, 0x87, 0xF0, 0xFF, 0x0F, 0xFF,
  0xBE, 0x0F, 0xFF, 0x7C, 0x1F, 0xFC, 0xF8, 0x0F, 0xF3, 0xF0, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x8F, 0xE0,
  0x3F, 0x7F, 0xE0, 0x7D, 0xFF, 0xE0, 0xFB, 0xFF, 0xE1, 0xFF, 0x3F, 0xC3,
  0xF0, 0x1F, 0x87, 0xE0, 0x1F, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x7C,
  0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0xCF, 0xC0,
  0x1F, 0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03,
  0xF1, 0xF0, 0x07, 0xC7, 0xF0, 0x1F, 0x8F, 0xF0, 0xFF, 0x1F, 0x7F, 0xFC,
  0x3E, 0xFF, 0xF0, 0x7C, 0xFF, 0xC0, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0x3F, 0xC3,
  0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3E, 0x00, 0x7E, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x01,
  0xF1, 0xF0, 0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xF0, 0x7F, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0xFE,
  0x3E, 0x01, 0xFF, 0x9F, 0x01, 0xFF, 0xEF, 0x81, 0xFF, 0xF7, 0xC0, 0xFF,
  0x3B, 0xE0, 0xFC, 0x07, 0xF0, 0x7C, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x87,
  0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0,
  0x7C, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x7E,
  0x07, 0xF0, 0xFF, 0x03, 0xFF, 0xEF, 0x80, 0xFF, 0xF7, 0xC0, 0x7F, 0xF3,
  0xE0, 0x0F, 0xF3, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFC, 0x1F, 0xC3, 0xF0, 0x0F, 0x87, 0xC0,
  0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x23,
  0xE0, 0x0F, 0x87, 0xE0, 0x3F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x7C, 0x1F, 0xF9, 0xF0, 0xFF, 0xF7, 0xC7,
  0xFF, 0xDF, 0x1F, 0xE7, 0xFC, 0xFC, 0x07, 0xF3, 0xE0, 0x1F, 0x9F, 0x80,
  0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x9F, 0x00, 0x7E,
  0xFC, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xFC,
  0x03, 0xF3, 0xF0, 0x1F, 0xCF, 0xE0, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFB,
  0xE0, 0xFF, 0xCF, 0x81, 0xFE, 0x3E, 0x00, 0xC1, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x81, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x8F, 0xE0,
  0x3F, 0x7F, 0xE0, 0x7D, 0xFF, 0xE0, 0xFB, 0xFF, 0xE1, 0xFF, 0x3F, 0xC3,
  0xF0, 0x1F, 0x87, 0xE0, 0x1F, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x7C,
  0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0x8F, 0xC0,
  0x1F, 0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03,
  0xF1, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF8, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0x83, 0xE0, 0x1F,
  0x81, 0xF0, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x3E, 0x0F,
  0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0x07, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFC,
  0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x0F,
  0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x0F, 0xC1,
  0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0x9E, 0x1F, 0x03, 0xEF, 0xCF,
  0xE0, 0xF7, 0xF7, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0x8F, 0x87, 0xC3, 0xC1,
  0xE1, 0xF1, 0xF0, 0x70, 0x7C, 0x7C, 0x3C, 0x1E, 0x1F, 0x0F, 0x0F, 0x87,
  0xC3, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x3E, 0x3E, 0x0E, 0x0F,
  0x8F, 0x87, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x1E,
  0x1F, 0x0F, 0x07, 0x87, 0xC3, 0xC1, 0xE1, 0xF1, 0xF0, 0xF0, 0x78, 0x7C,
  0x3C, 0x1E, 0x1F, 0x0F, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8,
  0xF8, 0x3C, 0x3E, 0x00, 0x1F, 0x8F, 0xE0, 0x3F, 0x7F, 0xE0, 0x7D, 0xFF,
  0xE0, 0xFB, 0xFF, 0xE1, 0xFF, 0x3F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x1F,
  0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1,
  0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xE7, 0xE0,
  0x0F, 0x8F, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01,
  0xF8, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0x7F, 0xC3, 0xF0, 0x1F, 0x87, 0xC0, 0x1F,
  0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1,
  0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC3, 0xF0,
  0x1F, 0x87, 0xF0, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x07, 0xE3, 0xF8, 0x03, 0xF7, 0xFE, 0x01, 0xF7,
  0xFF, 0x80, 0xFB, 0xFF, 0xE0, 0x7F, 0xCF, 0xF0, 0x3F, 0x81, 0xF8, 0x1F,
  0x80, 0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x83,
  0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF0,
  0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x3F,
  0x07, 0xC0, 0x1F, 0x07, 0xF0, 0x1F, 0x83, 0xEC, 0x1F, 0xC1, 0xF7, 0xFF,
  0xC0, 0xFB, 0xFF, 0xC0, 0x7C, 0xFF, 0xC0, 0x3E, 0x3F, 0xC0, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x3E, 0x07, 0xFE, 0x7C, 0x1F, 0xFE, 0xF8, 0x7F, 0xFD, 0xF0,
  0xFF, 0x3F, 0xE3, 0xF0, 0x1F, 0xC7, 0xC0, 0x3F, 0x1F, 0x80, 0x3E, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xE7, 0xE0,
  0x0F, 0x8F, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01,
  0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC3, 0xF0, 0x1F, 0x87, 0xF0, 0xFF,
  0x0F, 0xFF, 0xBE, 0x0F, 0xFF, 0x7C, 0x1F, 0xFD, 0xF8, 0x0F, 0xF3, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x0F,
  0x87, 0xF0, 0x0F, 0x9F, 0xF8, 0x0F, 0xBF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F,
  0xF0, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE1, 0xFC, 0x0F, 0xC3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xE0, 0x0F, 0xCF,
  0xE0, 0x3F, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0x80,
  0x3E, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x07,
  0xE3, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0x8F,
  0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8,
  0x03, 0xF1, 0xF0, 0x07, 0xC3, 0xF0, 0x1F, 0x87, 0xF0, 0xFE, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xC7, 0xC0, 0x1F,
  0x8F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07,
  0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x9F, 0x80, 0x1F, 0x3E, 0x00, 0x3E,
  0xFC, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x3E,
  0x07, 0xF8, 0x1F, 0x07, 0xBC, 0x0F, 0x83, 0xDE, 0x0F, 0xC1, 0xEF, 0x07,
  0xE1, 0xF7, 0x83, 0x70, 0xF3, 0xC3, 0xB8, 0x79, 0xE1, 0xDC, 0x7C, 0xF0,
  0xCE, 0x3C, 0x78, 0xE7, 0x1E, 0x3C, 0x73, 0x8F, 0x1E, 0x39, 0xCF, 0x0F,
  0x38, 0xE7, 0x87, 0x9C, 0x73, 0xC3, 0xCE, 0x3B, 0xC1, 0xEE, 0x1D, 0xE0,
  0xF7, 0x0C, 0xF0, 0x7B, 0x86, 0xF0, 0x3D, 0x83, 0x78, 0x1F, 0xC1, 0xBC,
  0x0F, 0xE0, 0xDC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F,
  0x80, 0xFC, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8,
  0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x03, 0xF1,
  0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE0, 0xF8,
  0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x03, 0xF0,
  0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0x8F,
  0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF8, 0xF8,
  0x03, 0xF1, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x1F, 0x00,
  0x3E, 0x3E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xF1, 0xFE, 0x3F,
  0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xDF, 0x03, 0xFF, 0x3E, 0x03, 0xF8, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0x03, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xF0, 0x1F, 0x3F, 0xF8, 0x1F, 0x3F, 0xFC, 0x1E, 0x7C, 0xFC,
  0x1E, 0x7C, 0x7E, 0x3E, 0x78, 0x3F, 0xFE, 0x78, 0x1F, 0xFC, 0xF8, 0x0F,
  0xF8, 0xF8, 0x07, 0xF0,
};

const GFXglyph JetBrainsMono_SemiBoldItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 12, 33, 27, 8, -33 },
  { 51, 16, 14, 27, 8, -33 },
  { 79, 27, 33, 27, 1, -33 },
  { 191, 24, 45, 27, 2, -39 },
  { 326, 32, 33, 27, -2, -33 },
  { 458, 25, 33, 27, 1, -33 },
  { 562, 7, 14, 27, 12, -33 },
  { 575, 19, 44, 27, 7, -38 },
  { 680, 19, 44, 27, 2, -38 },
  { 785, 24, 23, 27, 2, -27 },
  { 854, 22, 22, 27, 3, -26 },
  { 915, 13, 14, 27, 4, -7 },
  { 938, 16, 5, 27, 6, -17 },
  { 948, 8, 8, 27, 8, -8 },
  { 956, 28, 42, 27, 0, -37 },
  { 1103, 24, 33, 27, 2, -33 },
  { 1202, 21, 33, 27, 2, -33 },
  { 1289, 24, 33, 27, 2, -33 },
  { 1388, 24, 33, 27, 2, -33 },
  { 1487, 23, 33, 27, 2, -33 },
  { 1582, 24, 33, 27, 2, -33 },
  { 1681, 23, 33, 27, 2, -33 },
  { 1776, 23, 33, 27, 5, -33 },
  { 1871, 24, 33, 27, 2, -33 },
  { 1970, 22, 33, 27, 4, -33 },
  { 2061, 11, 25, 27, 8, -25 },
  { 2096, 15, 32, 27, 4, -25 },
  { 2156, 23, 24, 27, 3, -27 },
  { 2225, 22, 16, 27, 3, -23 },
  { 2269, 22, 24, 27, 2, -27 },
  { 2335, 19, 33, 27, 6, -33 },
  { 2414, 28, 41, 27, 0, -33 },
  { 2558, 23, 33, 27, 0, -33 },
  { 2653, 24, 33, 27, 2, -33 },
  { 2752, 24, 33, 27, 2, -33 },
  { 2851, 24, 33, 27, 2, -33 },
  { 2950, 25, 33, 27, 2, -33 },
  { 3054, 25, 33, 27, 2, -33 },
  { 3158, 24, 33, 27, 2, -33 },
  { 3257, 25, 33, 27, 2, -33 },
  { 3361, 24, 33, 27, 2, -33 },
  { 3460, 26, 33, 27, 0, -33 },
  { 3568, 26, 33, 27, 2, -33 },
  { 3676, 20, 33, 27, 3, -33 },
  { 3759, 27, 33, 27, 1, -33 },
  { 3871, 26, 33, 27, 1, -33 },
  { 3979, 24, 33, 27, 2, -33 },
  { 4078, 25, 33, 27, 2, -33 },
  { 4182, 24, 41, 27, 2, -33 },
  { 4305, 25, 33, 27, 2, -33 },
  { 4409, 25, 33, 27, 1, -33 },
  { 4513, 23, 33, 27, 5, -33 },
  { 4608, 25, 33, 27, 2, -33 },
  { 4712, 23, 33, 27, 5, -33 },
  { 4807, 27, 33, 27, 2, -33 },
  { 4919, 29, 33, 27, -1, -33 },
  { 5039, 25, 33, 27, 4, -33 },
  { 5143, 24, 33, 27, 2, -33 },
  { 5242, 19, 42, 27, 6, -37 },
  { 5342, 14, 42, 27, 7, -37 },
  { 5416, 18, 42, 27, 4, -37 },
  { 5511, 20, 18, 27, 4, -33 },
  { 5556, 22, 5, 27, 0, 1 },
  { 5570, 10, 6, 27, 11, -35 },
  { 5578, 23, 25, 27, 2, -25 },
  { 5650, 23, 33, 27, 2, -33 },
  { 5745, 23, 25, 27, 2, -25 },
  { 5817, 25, 33, 27, 2, -33 },
  { 5921, 23, 25, 27, 2, -25 },
  { 5993, 30, 41, 27, -2, -33 },
  { 6147, 22, 33, 27, 3, -25 },
  { 6238, 23, 33, 27, 2, -33 },
  { 6333, 23, 35, 27, 1, -35 },
  { 6434, 24, 43, 27, 0, -35 },
  { 6563, 25, 33, 27, 2, -33 },
  { 6667, 20, 33, 27, 4, -33 },
  { 6750, 26, 25, 27, 0, -25 },
  { 6832, 23, 25, 27, 2, -25 },
  { 6904, 23, 25, 27, 2, -25 },
  { 6976, 25, 33, 27, 0, -25 },
  { 7080, 23, 33, 27, 2, -25 },
  { 7175, 24, 25, 27, 2, -25 },
  { 7250, 23, 25, 27, 2, -25 },
  { 7322, 23, 32, 27, 3, -32 },
  { 7414, 23, 25, 27, 2, -25 },
  { 7486, 23, 25, 27, 4, -25 },
  { 7558, 25, 25, 27, 3, -25 },
  { 7637, 27, 25, 27, 0, -25 },
  { 7722, 23, 33, 27, 2, -25 },
  { 7817, 23, 25, 27, 2, -25 },
  { 7889, 23, 42, 27, 4, -37 },
  { 8010, 12, 42, 27, 8, -37 },
  { 8073, 23, 42, 27, 1, -37 },
  { 8194, 24, 10, 27, 2, -21 },
};

const GFXfont JetBrainsMono_SemiBoldItalic45pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic45pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC45PT7B_H_
