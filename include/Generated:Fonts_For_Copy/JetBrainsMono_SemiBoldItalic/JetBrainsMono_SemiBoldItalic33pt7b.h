#ifndef _JETBRAINSMONO_SEMIBOLDITALIC33PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C,
  0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8,
  0xF8, 0x78, 0xFF, 0x0F, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xE1, 0xEE,
  0x1C, 0xE1, 0xCE, 0x1C, 0x00, 0x70, 0x70, 0x07, 0x0E, 0x00, 0xE0, 0xE0,
  0x0E, 0x0C, 0x00, 0xE1, 0xC0, 0x1C, 0x1C, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0x38, 0x30, 0x03, 0x87, 0x00, 0x70, 0x70, 0x07, 0x06,
  0x00, 0x70, 0xE0, 0x0E, 0x0E, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF8, 0x1C, 0x38, 0x01, 0x83, 0x80, 0x38, 0x38, 0x03, 0x87, 0x00, 0x30,
  0x70, 0x07, 0x07, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xB7,
  0xC7, 0x8C, 0xF1, 0xE6, 0x3C, 0x79, 0x80, 0x1E, 0x60, 0x07, 0x98, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x03,
  0x7C, 0x00, 0xCF, 0x00, 0x33, 0xC0, 0x1C, 0xF3, 0xC6, 0x3C, 0x79, 0x8F,
  0x1F, 0x6F, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x0E,
  0x1F, 0xE0, 0x38, 0x39, 0xE0, 0xE0, 0xE1, 0xC3, 0x81, 0xC3, 0x8E, 0x03,
  0x86, 0x38, 0x07, 0x1C, 0x70, 0x0E, 0x39, 0xC0, 0x1F, 0xE7, 0x00, 0x3F,
  0xDC, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x78, 0x00, 0x3B, 0xF8, 0x00, 0xEF, 0xF8, 0x03, 0x9C, 0x70, 0x0E, 0x70,
  0xE0, 0x38, 0xE1, 0xC0, 0xE1, 0xC3, 0x81, 0xC3, 0x86, 0x07, 0x07, 0xBC,
  0x1C, 0x07, 0xF0, 0x70, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x0F,
  0xFE, 0x03, 0xC3, 0xC0, 0x70, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFE,
  0x1E, 0x79, 0xE7, 0x8E, 0x3C, 0xF3, 0xC3, 0xFC, 0x78, 0x7F, 0x0F, 0x07,
  0xC1, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0x87, 0xE0, 0xFF, 0xFE, 0x0F, 0xF9,
  0xE0, 0xFE, 0x3C, 0x7B, 0xDE, 0xFF, 0x7B, 0xDE, 0xF7, 0x00, 0x00, 0x04,
  0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x78, 0x00, 0x60, 0x04, 0x00, 0x1C, 0x00, 0xFC, 0x03,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x04, 0x1C,
  0x0B, 0x8E, 0x3F, 0xF3, 0x7F, 0xFD, 0x7F, 0x3F, 0xFC, 0x00, 0xE0, 0x01,
  0xF8, 0x01, 0xDE, 0x01, 0xE7, 0x01, 0xE3, 0xC1, 0xE1, 0xF0, 0xF0, 0x70,
  0x10, 0x30, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x8F, 0x87, 0xC3, 0xC3, 0xE1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x00, 0x7F,
  0xF7, 0xFF, 0x7F, 0xFF, 0xFE, 0x31, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF,
  0x07, 0xFF, 0xC3, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xE0, 0x1E, 0xF0,
  0x0F, 0x78, 0x07, 0x3C, 0x03, 0x9E, 0x73, 0xCF, 0x79, 0xE7, 0x3C, 0xF3,
  0x8E, 0x7B, 0xC0, 0x39, 0xE0, 0x1C, 0xF0, 0x0E, 0x78, 0x0F, 0x3C, 0x07,
  0x9E, 0x07, 0x8F, 0x87, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x00,
  0x7C, 0x01, 0xFC, 0x03, 0xFC, 0x0F, 0xFC, 0x1F, 0x3C, 0x1E, 0x3C, 0x18,
  0x78, 0x10, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3E, 0x1E, 0x1E, 0x07, 0xC7, 0x80,
  0xF3, 0xC0, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x1F, 0xFF,
  0xCF, 0xFF, 0xE3, 0xFF, 0xF8, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x1E, 0x03, 0xC7, 0x00, 0xF1,
  0xE0, 0x78, 0x7C, 0x3E, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x0F, 0x3E, 0x0E, 0x7C,
  0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF,
  0xFC, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x1F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0xF0, 0x1F, 0xFE, 0x0E, 0xFF, 0x87, 0xCF,
  0xC7, 0xC1, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x3C, 0x07, 0x9E, 0x07, 0x8F, 0x87, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0,
  0x7F, 0xC0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xBE, 0x07,
  0xBF, 0x87, 0xFF, 0xE3, 0xE1, 0xF3, 0xE0, 0x7D, 0xE0, 0x1E, 0xF0, 0x0F,
  0x70, 0x07, 0xB8, 0x03, 0x9C, 0x03, 0xCF, 0x03, 0xE7, 0xC3, 0xE3, 0xFF,
  0xE0, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF,
  0x00, 0xF7, 0x80, 0xF3, 0x80, 0x7B, 0xC0, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x01, 0xFF,
  0xE0, 0xFF, 0xF8, 0x3C, 0x1E, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x38,
  0x78, 0x1E, 0x1E, 0x0F, 0x83, 0xC7, 0xC0, 0x7F, 0xC0, 0x0F, 0xE0, 0x07,
  0xFC, 0x07, 0xCF, 0x83, 0xC1, 0xF0, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03,
  0xC7, 0x80, 0xF1, 0xE0, 0x7C, 0x7C, 0x3E, 0x1F, 0xFF, 0x03, 0xFF, 0x80,
  0x7F, 0xC0, 0x07, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x3C, 0x1F, 0x78, 0x0F,
  0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E,
  0xFC, 0x7E, 0x7F, 0xFC, 0x3F, 0xBC, 0x1E, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x1F, 0x3F, 0x3F, 0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0xFC, 0xFC, 0xFC, 0xF8, 0x03, 0xE0, 0xFC, 0x1F,
  0x83, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07,
  0x80, 0xE0, 0x3C, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0xFE,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF8,
  0x00, 0x38, 0x00, 0x08, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0x10, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x00,
  0xF8, 0x00, 0x70, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xC3, 0xFF,
  0x8F, 0xFF, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01,
  0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xC0, 0x7C, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0xC0, 0x1E,
  0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xF7, 0xE0, 0xF8, 0x0F, 0x0E,
  0x00, 0xF1, 0xE0, 0x07, 0x1C, 0x00, 0x73, 0xC0, 0x07, 0x38, 0x1E, 0x73,
  0x87, 0xF7, 0x38, 0x79, 0xE3, 0x8F, 0x0E, 0x38, 0xE0, 0xE7, 0x8E, 0x0E,
  0x70, 0xE0, 0xE7, 0x1E, 0x1E, 0x71, 0xE1, 0xE7, 0x1C, 0x1C, 0x71, 0xE1,
  0xCF, 0x1E, 0x3C, 0xF0, 0xFD, 0xCE, 0x0F, 0x9C, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0E, 0xE0, 0x0F, 0x70, 0x07, 0xB8, 0x03, 0x9E, 0x03, 0xCF, 0x01,
  0xE7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x70, 0xF0, 0x78, 0x38, 0x3C, 0x1C,
  0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x8F, 0x01, 0xE7, 0x80, 0xF7, 0x80,
  0x7B, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0xFF, 0xF8, 0x78, 0x3F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78,
  0x0E, 0x1C, 0x07, 0x87, 0x03, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFE,
  0x0F, 0x07, 0xC3, 0x80, 0xF0, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7,
  0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x3E, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF,
  0x80, 0x03, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC3, 0xE1, 0xF3, 0xE0, 0x79,
  0xE0, 0x3C, 0xF0, 0x1E, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0xCF, 0x87, 0xC3, 0xFF, 0xC1,
  0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x78,
  0x7E, 0x1E, 0x07, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1C, 0x03,
  0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3,
  0xC0, 0x79, 0xE0, 0x1C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0,
  0x78, 0x7F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xFF,
  0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xE0, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC3, 0xE1, 0xF3, 0xE0, 0x79,
  0xE0, 0x3C, 0xF0, 0x1E, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x1F, 0xE7, 0x8F, 0xF3, 0xC7, 0xF9, 0xC7, 0xFD, 0xE0, 0x1C, 0xF0,
  0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0xCF, 0x87, 0xC3, 0xFF, 0xC1,
  0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0x01, 0xE1, 0xE0, 0x78, 0x3C, 0x0F, 0x0F,
  0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xE0, 0xF0, 0x3C, 0x1E,
  0x07, 0x83, 0x80, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x78,
  0x1E, 0x0F, 0x03, 0xC1, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0,
  0x3C, 0x3C, 0x07, 0x07, 0x81, 0xE0, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80,
  0xF0, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x07, 0xFF, 0xE3,
  0xFF, 0xF1, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x0F, 0x01, 0xE1, 0xE0,
  0x3C, 0x3C, 0x0F, 0x87, 0xC3, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF,
  0x80, 0x0F, 0x01, 0xF0, 0xF0, 0x1E, 0x0E, 0x03, 0xC1, 0xE0, 0x7C, 0x1E,
  0x07, 0x81, 0xE0, 0xF0, 0x1E, 0x1F, 0x01, 0xE1, 0xE0, 0x1E, 0x3C, 0x03,
  0xC7, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xC7, 0x80,
  0x3C, 0x78, 0x03, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x3E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x03,
  0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x8F, 0x83, 0x71, 0xF8, 0xFC, 0x7F, 0x1F,
  0x8E, 0xE7, 0x71, 0xDC, 0xEE, 0x39, 0xB9, 0xC7, 0x37, 0x78, 0xE6, 0xCE,
  0x1C, 0xF9, 0xC7, 0x9E, 0x38, 0xF3, 0xCF, 0x1E, 0x01, 0xE3, 0xC0, 0x3C,
  0x70, 0x07, 0x8E, 0x00, 0xE3, 0xC0, 0x1C, 0x78, 0x07, 0x8F, 0x00, 0xF1,
  0xE0, 0x1E, 0x38, 0x03, 0xC7, 0x00, 0x70, 0x0F, 0x81, 0xE1, 0xF0, 0x38,
  0x7E, 0x07, 0x0F, 0xC0, 0xE1, 0xFC, 0x3C, 0x3B, 0x87, 0x87, 0x70, 0xF0,
  0xEE, 0x1C, 0x1D, 0xC3, 0x87, 0xB8, 0x70, 0xF3, 0x9E, 0x1E, 0x73, 0xC3,
  0x8E, 0x78, 0x71, 0xCE, 0x0E, 0x39, 0xC3, 0xC7, 0xB8, 0x78, 0x77, 0x0F,
  0x0E, 0xE1, 0xE1, 0xFC, 0x38, 0x3F, 0x87, 0x07, 0xE1, 0xE0, 0x7C, 0x3C,
  0x0F, 0x87, 0x81, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE1,
  0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x70, 0x0E, 0x78, 0x0F, 0x3C,
  0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xC0, 0x79,
  0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0x8F, 0x87,
  0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0x0F, 0x07, 0xE1, 0xE0, 0x3E, 0x3C, 0x03, 0xC7, 0x80, 0x78,
  0xF0, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1F, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE1,
  0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0x3C,
  0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0x80, 0x7B, 0xC0, 0x39,
  0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0x8F, 0x87,
  0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0xFE, 0x01, 0xFF,
  0xF0, 0x3F, 0xFE, 0x0F, 0x07, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80,
  0xF0, 0xF0, 0x1E, 0x1C, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x3E, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0x1E, 0x01, 0xC3, 0xC0, 0x78, 0x78,
  0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0xE0, 0x3C,
  0x3C, 0x07, 0x87, 0x80, 0x78, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF8,
  0x3C, 0x1F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x03, 0xCF, 0x00, 0xF3,
  0xE0, 0x3C, 0x7C, 0x3E, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xFA, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x03, 0xC7, 0x80, 0xE3, 0xC0, 0x78,
  0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1C, 0x38,
  0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03,
  0x87, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3,
  0xC0, 0xF0, 0xF8, 0x7C, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0xF0,
  0x07, 0xF8, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3,
  0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x38, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x1E,
  0x07, 0x8F, 0x03, 0xC7, 0x01, 0xE7, 0x80, 0xF3, 0x80, 0x7B, 0xC0, 0x3D,
  0xE0, 0x1E, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x70, 0xF0, 0xF7, 0x0F, 0x0E, 0x70, 0xF0, 0xE7, 0x0F, 0x1E,
  0x71, 0xB1, 0xC7, 0x1B, 0x1C, 0x71, 0xB1, 0xC7, 0x3B, 0x3C, 0x73, 0x73,
  0x8F, 0x37, 0x38, 0xF3, 0x73, 0x8E, 0x76, 0x70, 0xE6, 0x67, 0x0E, 0x66,
  0x70, 0xEE, 0x67, 0x0E, 0xC6, 0xE0, 0xEC, 0x6E, 0x0E, 0xC6, 0xE0, 0xFC,
  0x6E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F,
  0x07, 0x80, 0x0F, 0x00, 0xF8, 0x7C, 0x0F, 0x81, 0xE0, 0x78, 0x0F, 0x07,
  0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x3C, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x78,
  0xF0, 0x07, 0xC7, 0x80, 0x3C, 0x1E, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x81,
  0xE0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x03, 0xDE, 0x01, 0xE7, 0x80, 0x79,
  0xE0, 0x3C, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xC0, 0x70, 0xF0, 0x1E,
  0x78, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xFE, 0x1F, 0xFF,
  0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x00,
  0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x00, 0x01, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x77, 0x01, 0xE7, 0x07, 0x8E, 0x0E,
  0x1C, 0x3C, 0x3C, 0x70, 0x39, 0xE0, 0x77, 0x80, 0xEF, 0x01, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0xF0, 0xE1, 0xE0, 0x0F, 0xE7,
  0x8F, 0xFB, 0x8F, 0xFF, 0xC7, 0xC3, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0,
  0x3C, 0xF0, 0x1C, 0x70, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF,
  0x01, 0xE7, 0x81, 0xE3, 0xE1, 0xF1, 0xFF, 0xF8, 0x7F, 0xBC, 0x1F, 0x9E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x7B, 0xF8, 0x3F, 0xFE, 0x1D, 0xFF, 0x1F, 0x87, 0xCF, 0x81,
  0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x3C, 0x70, 0x1E, 0x78,
  0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xC7, 0xC3, 0xE3, 0xBF, 0xE3,
  0xDF, 0xE1, 0xE7, 0xE0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x3E, 0x1F,
  0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0xF0, 0x3E, 0xF8, 0x7C, 0x7F, 0xF8,
  0x7F, 0xF0, 0x1F, 0xE0, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0xFE, 0x70, 0x7F, 0xDC, 0x3F, 0xFF,
  0x0F, 0x87, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0x87,
  0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0,
  0xF0, 0xF8, 0x7C, 0x3F, 0xFF, 0x07, 0xFB, 0xC0, 0xFC, 0xF0, 0x07, 0xF8,
  0x0F, 0xFE, 0x1F, 0xFE, 0x3C, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x1E, 0xF8, 0x3C, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE7, 0x8F, 0xFF, 0x8F, 0xFF, 0xC7, 0xC3, 0xE7, 0xC0, 0xF3,
  0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1C, 0x70, 0x1E, 0x78, 0x0F, 0x3C, 0x07,
  0x9E, 0x03, 0xCF, 0x83, 0xE7, 0xF7, 0xE1, 0xFF, 0xF0, 0x7F, 0x78, 0x1F,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x83, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7B, 0xF8, 0x3F, 0xFE, 0x1D, 0xFF, 0x1F,
  0x87, 0xCF, 0x81, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x38, 0xF0, 0x3C,
  0x70, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xC7, 0x81,
  0xE3, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0x00, 0x1C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0xF8, 0xF0, 0x3E, 0x1E, 0x0F, 0x83, 0x83, 0xE0, 0xF0,
  0x78, 0x1E, 0x1E, 0x03, 0xC7, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x78, 0xF8, 0x0F, 0x0F, 0x01, 0xE1, 0xF0, 0x3C, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0x3C, 0x1C, 0x07, 0x87, 0x80, 0x78, 0xFF, 0xC3, 0xFF, 0x0F,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x7F, 0xF0, 0xFF,
  0xC1, 0xFF, 0x1D, 0xF7, 0xC3, 0xBE, 0xFC, 0x79, 0xE7, 0x8E, 0x38, 0xF3,
  0xC7, 0x1E, 0x78, 0xE3, 0xCF, 0x1C, 0x71, 0xC3, 0x8E, 0x38, 0x61, 0xC7,
  0x1C, 0x78, 0xE3, 0x8F, 0x3C, 0x71, 0xE7, 0x8E, 0x38, 0xF1, 0xC7, 0x1C,
  0x30, 0xE3, 0x8E, 0x1C, 0x71, 0xC7, 0x9E, 0x38, 0xF0, 0x1E, 0xFE, 0x0F,
  0xFF, 0x87, 0x7F, 0xC7, 0xE1, 0xF3, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E,
  0x78, 0x0E, 0x3C, 0x0F, 0x1C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80,
  0xF3, 0xC0, 0x71, 0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x00,
  0x07, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x3E, 0x1F, 0x7C, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0x78, 0x0F, 0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x3C, 0xF8, 0x7C, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xC0,
  0x0F, 0x7F, 0x03, 0xFF, 0xE0, 0xEF, 0xF8, 0x7E, 0x1F, 0x1F, 0x03, 0xC7,
  0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0x87, 0x01, 0xE3, 0xC0,
  0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x03, 0xC3, 0xE1, 0xF0, 0xEF, 0xF8,
  0x7B, 0xFC, 0x1E, 0x7E, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE7, 0x8F, 0xFF, 0x8F, 0xFF,
  0xC7, 0x83, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x3C, 0x70,
  0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xE3,
  0xE1, 0xF1, 0xFF, 0xF8, 0x7F, 0xBC, 0x1F, 0x9E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x1C, 0xFE, 0x1E,
  0xFF, 0x8F, 0xFF, 0xC7, 0xC1, 0xF3, 0xC0, 0xF9, 0xE0, 0x3C, 0xE0, 0x1E,
  0xF0, 0x1E, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xC0, 0xF3, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xC0,
  0x01, 0xE0, 0x00, 0xF3, 0x80, 0x79, 0xE0, 0x78, 0xFF, 0xFC, 0x3F, 0xFC,
  0x0F, 0xF8, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x87, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x3C, 0x07, 0x9E, 0x03, 0x8E, 0x03, 0xCF, 0x01,
  0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1C, 0x78, 0x1E, 0x78,
  0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xE3, 0xE1, 0xF0,
  0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0x00, 0xF0, 0x0F, 0xF8, 0x07, 0xBC,
  0x07, 0x8E, 0x03, 0xC7, 0x01, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0xF0,
  0x78, 0x78, 0x1C, 0x78, 0x0E, 0x3C, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0xE1, 0xE1,
  0xF8, 0x78, 0x7E, 0x1E, 0x1F, 0x87, 0x8E, 0xE3, 0x63, 0xB8, 0xD8, 0xEE,
  0x36, 0x73, 0x99, 0x9C, 0xE6, 0x67, 0x39, 0x9B, 0x8E, 0xC6, 0xE3, 0xB1,
  0xB8, 0xEC, 0x7C, 0x3F, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF8, 0x78,
  0x3C, 0x1E, 0x00, 0x1F, 0x03, 0xE1, 0xE0, 0x78, 0x1E, 0x1E, 0x03, 0xC7,
  0x80, 0x3D, 0xF0, 0x07, 0xBC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xF0,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xDE, 0x00, 0xFB, 0xC0, 0x1E, 0x3C,
  0x07, 0x87, 0x81, 0xE0, 0x78, 0x7C, 0x0F, 0x1F, 0x01, 0xF0, 0x3C, 0x07,
  0x9E, 0x07, 0x8E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0,
  0x38, 0xF0, 0x3C, 0x70, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0xCF,
  0x83, 0xE7, 0xFE, 0xE1, 0xFF, 0xF0, 0x7F, 0x78, 0x1C, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x83, 0xFF, 0x81, 0xFF, 0x80, 0xFF,
  0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xFF, 0xFC, 0xFF,
  0xFE, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x07, 0xFE, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x07, 0x83,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x0F, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0x80, 0x00, 0x3F, 0x03, 0xBF, 0xC3, 0xDF, 0xF1, 0xFE, 0x78, 0xEE,
  0x1F, 0xF7, 0x07, 0xF3, 0x81, 0xF0,
};

const GFXglyph JetBrainsMono_SemiBoldItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 8, 24, 20, 6, -24 },
  { 25, 12, 10, 20, 6, -24 },
  { 40, 20, 24, 20, 0, -24 },
  { 100, 18, 34, 20, 1, -29 },
  { 177, 23, 24, 20, -1, -24 },
  { 246, 19, 24, 20, 0, -24 },
  { 303, 5, 10, 20, 9, -24 },
  { 310, 14, 32, 20, 5, -28 },
  { 366, 14, 32, 20, 2, -28 },
  { 422, 17, 17, 20, 2, -20 },
  { 459, 16, 16, 20, 2, -19 },
  { 491, 9, 10, 20, 3, -5 },
  { 503, 12, 4, 20, 4, -13 },
  { 509, 6, 6, 20, 6, -6 },
  { 514, 21, 31, 20, 0, -27 },
  { 596, 17, 24, 20, 2, -24 },
  { 647, 16, 24, 20, 1, -24 },
  { 695, 18, 24, 20, 1, -24 },
  { 749, 18, 24, 20, 1, -24 },
  { 803, 16, 24, 20, 2, -24 },
  { 851, 17, 24, 20, 2, -24 },
  { 902, 17, 24, 20, 1, -24 },
  { 953, 17, 24, 20, 3, -24 },
  { 1004, 18, 24, 20, 1, -24 },
  { 1058, 16, 24, 20, 3, -24 },
  { 1106, 8, 18, 20, 6, -18 },
  { 1124, 11, 23, 20, 3, -18 },
  { 1156, 16, 18, 20, 3, -20 },
  { 1192, 16, 12, 20, 2, -17 },
  { 1216, 17, 18, 20, 1, -20 },
  { 1255, 14, 24, 20, 4, -24 },
  { 1297, 20, 30, 20, 0, -24 },
  { 1372, 17, 24, 20, 0, -24 },
  { 1423, 18, 24, 20, 1, -24 },
  { 1477, 17, 24, 20, 2, -24 },
  { 1528, 18, 24, 20, 1, -24 },
  { 1582, 18, 24, 20, 2, -24 },
  { 1636, 19, 24, 20, 1, -24 },
  { 1693, 17, 24, 20, 2, -24 },
  { 1744, 19, 24, 20, 1, -24 },
  { 1801, 17, 24, 20, 2, -24 },
  { 1852, 19, 24, 20, 0, -24 },
  { 1909, 20, 24, 20, 1, -24 },
  { 1969, 15, 24, 20, 2, -24 },
  { 2014, 19, 24, 20, 1, -24 },
  { 2071, 19, 24, 20, 1, -24 },
  { 2128, 17, 24, 20, 2, -24 },
  { 2179, 19, 24, 20, 1, -24 },
  { 2236, 17, 30, 20, 2, -24 },
  { 2300, 19, 24, 20, 1, -24 },
  { 2357, 18, 24, 20, 1, -24 },
  { 2411, 18, 24, 20, 3, -24 },
  { 2465, 18, 24, 20, 2, -24 },
  { 2519, 17, 24, 20, 4, -24 },
  { 2570, 20, 24, 20, 2, -24 },
  { 2630, 21, 24, 20, 0, -24 },
  { 2693, 18, 24, 20, 3, -24 },
  { 2747, 18, 24, 20, 1, -24 },
  { 2801, 14, 31, 20, 4, -27 },
  { 2856, 11, 31, 20, 5, -27 },
  { 2899, 13, 31, 20, 3, -27 },
  { 2950, 15, 13, 20, 3, -24 },
  { 2975, 16, 3, 20, 0, 1 },
  { 2981, 7, 5, 20, 8, -26 },
  { 2986, 17, 18, 20, 2, -18 },
  { 3025, 17, 24, 20, 1, -24 },
  { 3076, 16, 18, 20, 2, -18 },
  { 3112, 18, 24, 20, 2, -24 },
  { 3166, 16, 18, 20, 2, -18 },
  { 3202, 23, 30, 20, -2, -24 },
  { 3289, 17, 24, 20, 2, -18 },
  { 3340, 17, 24, 20, 1, -24 },
  { 3391, 16, 26, 20, 1, -26 },
  { 3443, 18, 32, 20, 0, -26 },
  { 3515, 19, 24, 20, 1, -24 },
  { 3572, 14, 24, 20, 3, -24 },
  { 3614, 19, 18, 20, 0, -18 },
  { 3657, 17, 18, 20, 1, -18 },
  { 3696, 16, 18, 20, 2, -18 },
  { 3732, 18, 24, 20, 0, -18 },
  { 3786, 17, 24, 20, 2, -18 },
  { 3837, 17, 18, 20, 2, -18 },
  { 3876, 17, 18, 20, 1, -18 },
  { 3915, 17, 23, 20, 2, -23 },
  { 3964, 17, 18, 20, 2, -18 },
  { 4003, 17, 18, 20, 3, -18 },
  { 4042, 18, 18, 20, 2, -18 },
  { 4083, 19, 18, 20, 0, -18 },
  { 4126, 17, 24, 20, 2, -18 },
  { 4177, 17, 18, 20, 1, -18 },
  { 4216, 17, 31, 20, 3, -27 },
  { 4282, 9, 31, 20, 6, -27 },
  { 4317, 17, 31, 20, 1, -27 },
  { 4383, 17, 7, 20, 2, -15 },
};

const GFXfont JetBrainsMono_SemiBoldItalic33pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic33pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC33PT7B_H_
