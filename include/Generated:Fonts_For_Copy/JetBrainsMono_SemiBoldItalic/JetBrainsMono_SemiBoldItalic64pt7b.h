#ifndef _JETBRAINSMONO_SEMIBOLDITALIC64PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x3F,
  0xC0, 0xFF, 0x3F, 0xC0, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0x81, 0xFE, 0x7F,
  0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFC, 0x7F,
  0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFE,
  0xFF, 0xFE, 0x01, 0xFF, 0x1E, 0x3F, 0xC0, 0x3F, 0xC3, 0xC7, 0xFC, 0x0F,
  0xF0, 0xF0, 0x7F, 0x81, 0xFE, 0x1E, 0x0F, 0xF0, 0x3F, 0x83, 0xC1, 0xFE,
  0x07, 0xF0, 0x78, 0x00, 0x01, 0xFE, 0x0F, 0x00, 0x00, 0x3F, 0xC1, 0xE0,
  0x00, 0x07, 0xF8, 0x78, 0x00, 0x00, 0xFF, 0x8F, 0x00, 0x00, 0x0F, 0xF9,
  0xE0, 0x00, 0x01, 0xFF, 0xBC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03,
  0xCF, 0xFC, 0x00, 0x00, 0x78, 0x7F, 0xC0, 0x00, 0x0F, 0x0F, 0xF8, 0x00,
  0x01, 0xE0, 0xFF, 0x00, 0x00, 0x3C, 0x1F, 0xE0, 0x00, 0x07, 0x83, 0xFC,
  0x00, 0x41, 0xE0, 0x7F, 0x87, 0xF0, 0x3C, 0x0F, 0xE0, 0xFE, 0x07, 0x81,
  0xFC, 0x1F, 0xE0, 0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0x1F, 0xE0, 0x7F, 0xC3,
  0xC7, 0xFC, 0x0F, 0xFE, 0xF3, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xF0,
  0x1F, 0x83, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x01,
  0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xFC, 0xFF,
  0x3F, 0x00, 0x00, 0x07, 0xFF, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC7,
  0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0xE1, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0x8F, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xE7, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0xFF, 0xE0, 0x00,
  0x01, 0xF8, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x3F, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x00, 0x0F,
  0xC1, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x01,
  0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x0F,
  0xF1, 0xFE, 0x7F, 0x80, 0xFE, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xFC, 0x3F,
  0xC3, 0xFC, 0x3F, 0x81, 0xFE, 0x3F, 0x83, 0xF8, 0x1F, 0xE7, 0xF0, 0x3F,
  0x80, 0xFF, 0xFF, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0x80, 0x7F, 0xFC,
  0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0x3F, 0xF8, 0x07, 0xF0, 0x01,
  0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x7F,
  0x00, 0x1F, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xDF, 0xE0, 0x1F, 0xFF, 0xF0, 0xFE, 0x00, 0xFF, 0xFE, 0x0F, 0xF0, 0x07,
  0xFF, 0x80, 0x7F, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xDF, 0xEF,
  0xF7, 0xFB, 0xFD, 0xFC, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xE7, 0xF3,
  0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x10,
  0x01, 0xF8, 0x00, 0x87, 0x00, 0x7E, 0x00, 0xE3, 0xF8, 0x1F, 0x81, 0xFC,
  0xFF, 0x87, 0xC1, 0xFF, 0x7F, 0xF0, 0xF1, 0xFF, 0xDF, 0xFE, 0x39, 0xFF,
  0xFF, 0xFF, 0xEE, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x80,
  0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x80, 0x0F, 0xC1, 0xFE, 0x3F, 0xF7, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFC, 0x3F, 0x80, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x03, 0x01, 0xFC, 0x1F, 0xC3,
  0xF0, 0x7F, 0x07, 0xF1, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0x87, 0xF0, 0xFF,
  0x1F, 0xE1, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0x3F, 0x83,
  0xF8, 0x3F, 0x0F, 0xE0, 0xFE, 0x03, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xEF, 0xF0, 0x03, 0xFF, 0x3F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F,
  0x83, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xC0, 0x7F, 0x80, 0x1C, 0x01,
  0xFE, 0x00, 0x60, 0x07, 0xF8, 0x02, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0xFF,
  0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F,
  0x0F, 0xF0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F,
  0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF8,
  0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0,
  0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x7F, 0x80,
  0x03, 0xFC, 0x7F, 0x00, 0x03, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x1E, 0x00, 0x01, 0xFC,
  0x7F, 0xF0, 0x00, 0x7F, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xEF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC7, 0xC0, 0x00, 0x3F, 0xCF, 0xFE, 0x00, 0x3F, 0xDF, 0xFF,
  0x80, 0x3F, 0xDF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x80,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x3F, 0xCF, 0xE0,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF1, 0xFF,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x7F, 0xC7, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x07, 0xF3,
  0xFC, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFE,
  0x7F, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x3F,
  0xE1, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF3,
  0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x01, 0xFE,
  0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFE,
  0x07, 0xFE, 0x03, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x1F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0,
  0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x0C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF8, 0xFC, 0x1F,
  0x80, 0x1F, 0xF9, 0xF8, 0x3F, 0x00, 0x7F, 0xFB, 0xF0, 0x7E, 0x01, 0xFF,
  0xF3, 0xE0, 0xFC, 0x07, 0xFC, 0xFF, 0xC1, 0xF8, 0x0F, 0xE0, 0x7F, 0x87,
  0xF0, 0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0xFC,
  0x01, 0xF8, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x07, 0xE0,
  0xFC, 0x0F, 0xC0, 0x1F, 0xC3, 0xF8, 0x1F, 0x80, 0x3F, 0x87, 0xF0, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x1F, 0x81, 0xFC, 0x01, 0xF8,
  0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x0F, 0xE1, 0xFC, 0x0F,
  0xC0, 0x1F, 0xC3, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x3F, 0x00, 0xFE,
  0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0xFF, 0x0F, 0xF8, 0x3F, 0x01,
  0xFF, 0xFB, 0xF0, 0x7E, 0x01, 0xFF, 0xF7, 0xE1, 0xFC, 0x01, 0xFF, 0xCF,
  0x83, 0xF8, 0x01, 0xFE, 0x1F, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x40, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x07, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x01,
  0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03,
  0xF8, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x03,
  0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xFC, 0x0F, 0xE0,
  0x00, 0x7F, 0x81, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x07,
  0xFC, 0x03, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xF8,
  0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x01,
  0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F,
  0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0xFF, 0x81, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x7F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF8,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xE0, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xF8,
  0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x1F,
  0xC0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x03, 0xF8,
  0x1F, 0xE0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03,
  0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF8,
  0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF8,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x03, 0xFF, 0xFC, 0x1F, 0xC0,
  0xFF, 0xFF, 0x0F, 0xF0, 0x3F, 0xFF, 0xC3, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0x81, 0xFF, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x83,
  0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0xFE, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01,
  0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xC0,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x07, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xF0,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x01, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0xFF,
  0xE0, 0x0F, 0xFE, 0x03, 0xF7, 0xC0, 0x7D, 0xF8, 0x0F, 0xDF, 0x01, 0xF7,
  0xE0, 0x3F, 0x7C, 0x0F, 0xDF, 0x80, 0xFD, 0xF0, 0x3E, 0xFC, 0x03, 0xF7,
  0xC1, 0xFB, 0xF0, 0x1F, 0x9F, 0x07, 0xCF, 0xC0, 0x7E, 0x7C, 0x3F, 0x3F,
  0x01, 0xF8, 0xF8, 0xF9, 0xFC, 0x07, 0xE3, 0xE3, 0xE7, 0xF0, 0x1F, 0x8F,
  0x9F, 0x1F, 0x80, 0x7E, 0x3E, 0x7C, 0x7E, 0x03, 0xF8, 0xFB, 0xE3, 0xF8,
  0x0F, 0xE3, 0xEF, 0x8F, 0xE0, 0x3F, 0x8F, 0xBE, 0x3F, 0x80, 0xFE, 0x1F,
  0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0xC3, 0xF0, 0x0F, 0xE1, 0xFE, 0x1F, 0xC0,
  0x7F, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x07, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x1F,
  0xF8, 0x00, 0x7F, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x1F, 0xFC, 0x00, 0xFE,
  0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x3F, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0xC0,
  0x0F, 0xE0, 0x3F, 0xFC, 0x00, 0xFE, 0x03, 0xF7, 0xE0, 0x0F, 0xC0, 0x3F,
  0x7E, 0x01, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xC0, 0x7F, 0x7E, 0x01, 0xFC,
  0x07, 0xF7, 0xE0, 0x1F, 0xC0, 0x7F, 0x3F, 0x01, 0xFC, 0x07, 0xF3, 0xF0,
  0x1F, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0x07, 0xE3, 0xF0, 0x3F, 0x80, 0xFE,
  0x3F, 0x03, 0xF8, 0x0F, 0xE3, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0x83, 0xF8,
  0x0F, 0xE1, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8,
  0x7F, 0x00, 0xFC, 0x1F, 0xC7, 0xF0, 0x1F, 0xC0, 0xFC, 0x7F, 0x01, 0xFC,
  0x0F, 0xC7, 0xF0, 0x1F, 0xC0, 0xFC, 0x7F, 0x01, 0xFC, 0x0F, 0xC7, 0xE0,
  0x1F, 0xC0, 0xFC, 0x7E, 0x01, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x80, 0x7E,
  0xFE, 0x03, 0xF8, 0x07, 0xEF, 0xE0, 0x3F, 0x80, 0x7E, 0xFE, 0x03, 0xF8,
  0x07, 0xEF, 0xE0, 0x3F, 0x80, 0x3F, 0xFC, 0x03, 0xF0, 0x03, 0xFF, 0xC0,
  0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0x3F,
  0xFC, 0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0x1F, 0xF8, 0x07, 0xF0,
  0x01, 0xFF, 0x80, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xE0, 0x01, 0xFF, 0x80,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xF8, 0x0F,
  0xF8, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x07, 0xF0, 0x7F, 0x80, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x01,
  0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFC, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F,
  0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xE0,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xC0, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xF0, 0x0F, 0xF8, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xE0,
  0x00, 0x7F, 0x81, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x02, 0x00, 0x03, 0xFC, 0x3F,
  0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xF0, 0x1F,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xF0, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x01, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00,
  0xFF, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00,
  0x07, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x1F,
  0xE0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x0F,
  0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0xFD, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x7E, 0x01,
  0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0x07, 0xE1, 0xF8, 0x0F, 0xF0, 0x1F,
  0xC7, 0xF0, 0x1F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0xC0, 0x7E, 0x1F, 0xC0,
  0xFF, 0x80, 0xFC, 0x3F, 0x81, 0xEF, 0x03, 0xF8, 0x7F, 0x03, 0xDE, 0x07,
  0xE0, 0xFC, 0x07, 0xBC, 0x0F, 0xC1, 0xF8, 0x1F, 0x78, 0x1F, 0x83, 0xF0,
  0x3C, 0xF0, 0x7F, 0x07, 0xE0, 0x7B, 0xE0, 0xFC, 0x0F, 0xC0, 0xF7, 0xC1,
  0xF8, 0x1F, 0x83, 0xCF, 0x03, 0xF0, 0x3F, 0x07, 0x9E, 0x0F, 0xC0, 0x7E,
  0x0F, 0x3C, 0x1F, 0x80, 0xFC, 0x3E, 0x78, 0x3F, 0x01, 0xF8, 0x78, 0xF0,
  0x7E, 0x03, 0xF0, 0xF1, 0xE1, 0xF8, 0x07, 0xE1, 0xE3, 0xC3, 0xF0, 0x0F,
  0xC7, 0xC7, 0x87, 0xE0, 0x1F, 0x8F, 0x0F, 0x0F, 0xC0, 0x7F, 0x1E, 0x1E,
  0x3F, 0x00, 0xFC, 0x7C, 0x3C, 0x7E, 0x01, 0xF8, 0xF0, 0x78, 0xFC, 0x03,
  0xF1, 0xE0, 0xF1, 0xF8, 0x07, 0xE3, 0xC1, 0xE7, 0xE0, 0x0F, 0xCF, 0x83,
  0xCF, 0xC0, 0x1F, 0x9E, 0x07, 0x9F, 0x80, 0x3F, 0x3C, 0x0F, 0x3E, 0x00,
  0x7E, 0x78, 0x1E, 0xFC, 0x00, 0xFD, 0xE0, 0x7D, 0xF8, 0x01, 0xFB, 0xC0,
  0xFB, 0xF0, 0x03, 0xF7, 0x81, 0xF7, 0xC0, 0x07, 0xFF, 0x03, 0xDF, 0x80,
  0x0F, 0xFC, 0x07, 0xBF, 0x00, 0x1F, 0x78, 0x0F, 0x7E, 0x00, 0x3E, 0xF0,
  0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x07,
  0xF8, 0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xE3,
  0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFC, 0x7E,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x0F, 0xC0,
  0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0x7F, 0x03, 0xF8,
  0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x3F, 0xC0, 0x1F, 0xFF, 0x9F,
  0xE0, 0x1F, 0xFF, 0xEF, 0xF0, 0x1F, 0xFF, 0xF7, 0xF0, 0x1F, 0xFF, 0xFB,
  0xF8, 0x1F, 0xFF, 0xFD, 0xFC, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xF8, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xC0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x1F,
  0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x83,
  0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xEF, 0xE0,
  0x3F, 0xFF, 0xE7, 0xF0, 0x0F, 0xFF, 0xF3, 0xF8, 0x03, 0xFF, 0xF3, 0xFC,
  0x00, 0xFF, 0xE1, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F,
  0x87, 0xFF, 0x00, 0x1F, 0xC7, 0xFF, 0xE0, 0x1F, 0xE7, 0xFF, 0xF0, 0x0F,
  0xF7, 0xFF, 0xFC, 0x07, 0xF7, 0xFF, 0xFF, 0x03, 0xFB, 0xFF, 0xFF, 0x81,
  0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8,
  0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07,
  0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xDF, 0xFF, 0xF8, 0x0F, 0xEF, 0xFF, 0xFC, 0x07, 0xF3,
  0xFF, 0xFC, 0x03, 0xF8, 0xFF, 0xF8, 0x03, 0xFC, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x07, 0xFC,
  0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0x80,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xFC,
  0x00, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF0, 0x1F, 0xC0, 0x03, 0xFF, 0xC7, 0xF8, 0x00, 0xFF, 0xFC,
  0xFF, 0x00, 0x3F, 0xFF, 0xDF, 0xE0, 0x0F, 0xFF, 0xFB, 0xF8, 0x03, 0xFF,
  0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0xEF, 0xE0, 0x1F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xDF, 0xC0, 0x1F, 0xFF, 0xF3, 0xF8,
  0x01, 0xFF, 0xFE, 0x7F, 0x00, 0x1F, 0xFF, 0x9F, 0xE0, 0x01, 0xFF, 0xC3,
  0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xF8,
  0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80,
  0x07, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0xFF,
  0x00, 0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xFE, 0xFF, 0x03, 0xFF, 0xFE, 0xFE,
  0x07, 0xFF, 0xFE, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x0F, 0xFE,
  0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x01, 0xFE,
  0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC,
  0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC,
  0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0,
  0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xFF, 0xF7, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xEF, 0xF0, 0x3F, 0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0x8F, 0xE0,
  0x0F, 0xFF, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x87, 0xFF, 0x00, 0x1F, 0xC7,
  0xFF, 0xE0, 0x1F, 0xEF, 0xFF, 0xF8, 0x0F, 0xF7, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x03, 0xFB, 0xFF, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC0, 0xFF,
  0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x3F,
  0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xF0, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x07, 0xFC,
  0x00, 0x7F, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x03, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x7E, 0x3F, 0x83, 0xFC, 0x07, 0xE7, 0xFC, 0xFF, 0xC0, 0x7E, 0xFF, 0xCF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0xFE, 0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0x7C, 0x0F, 0xE0, 0xFC, 0x07, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFC, 0x0F, 0xE1, 0xFC, 0x0F, 0xC0, 0xFE, 0x1F, 0xC0,
  0xFC, 0x0F, 0xE1, 0xFC, 0x0F, 0x80, 0xFC, 0x1F, 0x80, 0xF8, 0x0F, 0xC1,
  0xF8, 0x0F, 0x81, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0x81,
  0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0x01, 0xF8, 0x3F, 0x81,
  0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x03, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x87,
  0xF0, 0x3F, 0x03, 0xF8, 0x7F, 0x03, 0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0x03,
  0xF0, 0x7F, 0x03, 0xE0, 0x3F, 0x07, 0xE0, 0x3E, 0x07, 0xF0, 0x7E, 0x07,
  0xE0, 0x7F, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0x7F, 0x0F,
  0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0x7C, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0xF8, 0x00, 0xFE, 0x3F,
  0xFF, 0x00, 0xFF, 0x7F, 0xFF, 0xC0, 0x7F, 0xBF, 0xFF, 0xE0, 0x3F, 0xBF,
  0xFF, 0xF8, 0x1F, 0xDF, 0xFF, 0xFC, 0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xC1, 0xFE,
  0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFC,
  0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0,
  0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x3F, 0x80,
  0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x80,
  0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x00,
  0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0xC0,
  0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC3, 0xFF, 0x80, 0x03, 0xF8, 0xFF, 0xFC, 0x00,
  0xFF, 0x3F, 0xFF, 0xC0, 0x1F, 0xEF, 0xFF, 0xF8, 0x03, 0xFB, 0xFF, 0xFF,
  0x80, 0x7F, 0x7F, 0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF,
  0x81, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFE, 0xFF, 0xFF, 0xC0, 0x1F, 0xDF, 0xFF, 0xF8, 0x03, 0xF9,
  0xFF, 0xFE, 0x00, 0x7F, 0x1F, 0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0xC0, 0x03,
  0xFC, 0x07, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x1F,
  0xC0, 0x1F, 0xFF, 0x9F, 0xE0, 0x1F, 0xFF, 0xCF, 0xF0, 0x1F, 0xFF, 0xF7,
  0xF0, 0x1F, 0xFF, 0xFB, 0xF8, 0x1F, 0xFF, 0xFD, 0xFC, 0x1F, 0xF8, 0x0E,
  0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x87, 0xF8, 0x00,
  0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0,
  0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x3F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x07,
  0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xEF, 0xE0, 0x3F, 0xFF, 0xE7, 0xF0, 0x0F, 0xFF, 0xF7, 0xF8,
  0x03, 0xFF, 0xE3, 0xFC, 0x00, 0xFF, 0xE1, 0xFE, 0x00, 0x07, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0xFE, 0x00, 0x3F, 0x8F, 0xFF, 0xC0, 0x0F,
  0xEF, 0xFF, 0xF8, 0x07, 0xFB, 0xFF, 0xFF, 0x01, 0xFD, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFE, 0xFF, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF,
  0x81, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x07, 0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x0F,
  0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xF8, 0xFF,
  0x00, 0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x87, 0xF8,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F,
  0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC,
  0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x07,
  0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x03,
  0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x01, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xFC, 0x7F,
  0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F,
  0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0x80, 0x7E, 0xFC, 0x03, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x80,
  0xFC, 0xFC, 0x07, 0xF8, 0x0F, 0xCF, 0xC0, 0x7F, 0x80, 0xFC, 0xFC, 0x07,
  0xF8, 0x0F, 0xCF, 0xC0, 0xF7, 0x81, 0xF8, 0xFC, 0x0F, 0x78, 0x1F, 0x8F,
  0xC0, 0xF7, 0x81, 0xF8, 0xFC, 0x1E, 0x78, 0x3F, 0x0F, 0xC1, 0xE7, 0x83,
  0xF0, 0xFC, 0x1E, 0x78, 0x3F, 0x0F, 0xC3, 0xE7, 0x87, 0xE0, 0xFC, 0x3C,
  0x78, 0x7E, 0x0F, 0xC3, 0xC7, 0x87, 0xE0, 0xFC, 0x3C, 0x78, 0x7C, 0x0F,
  0xC7, 0x87, 0x8F, 0xC0, 0xFC, 0x78, 0x78, 0xFC, 0x0F, 0xC7, 0x87, 0x8F,
  0x80, 0xFC, 0xF0, 0x79, 0xF8, 0x0F, 0xCF, 0x07, 0x9F, 0x80, 0xFC, 0xF0,
  0x79, 0xF0, 0x0F, 0xDE, 0x07, 0xBF, 0x00, 0xFD, 0xE0, 0x7B, 0xF0, 0x0F,
  0xDE, 0x07, 0xBF, 0x00, 0xFD, 0xE0, 0x7B, 0xE0, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00,
  0x1F, 0xE3, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0xFE, 0x7F,
  0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x1F,
  0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFE,
  0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC,
  0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xF8,
  0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8,
  0x7F, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF0,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xEF, 0xF0,
  0x3F, 0xFF, 0xEF, 0xE0, 0x3F, 0xFF, 0xCF, 0xE0, 0x0F, 0xFF, 0x8F, 0xE0,
  0x07, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x10, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x20, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x04, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xF0, 0xFF, 0xF8, 0x01, 0xF8,
  0x7F, 0xFF, 0x00, 0x7E, 0x1F, 0xFF, 0xE0, 0x1F, 0x8F, 0xFF, 0xFC, 0x07,
  0xE3, 0xF8, 0xFF, 0x03, 0xF9, 0xFC, 0x1F, 0xE0, 0xFE, 0x7F, 0x03, 0xFC,
  0x7F, 0x1F, 0x80, 0xFF, 0xFF, 0xC7, 0xE0, 0x1F, 0xFF, 0xE1, 0xF8, 0x03,
  0xFF, 0xF0, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0x80, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xF8, 0x00,
};

const GFXglyph JetBrainsMono_SemiBoldItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 16, 47, 38, 12, -47 },
  { 95, 24, 19, 38, 11, -47 },
  { 152, 38, 47, 38, 1, -47 },
  { 376, 35, 65, 38, 2, -56 },
  { 661, 46, 47, 38, -3, -47 },
  { 932, 36, 48, 38, 1, -47 },
  { 1148, 9, 19, 38, 18, -47 },
  { 1170, 28, 62, 38, 9, -54 },
  { 1387, 27, 62, 38, 3, -54 },
  { 1597, 34, 33, 38, 3, -39 },
  { 1738, 32, 30, 38, 4, -36 },
  { 1858, 18, 20, 38, 5, -10 },
  { 1903, 22, 7, 38, 9, -25 },
  { 1923, 12, 12, 38, 11, -11 },
  { 1941, 40, 60, 38, 0, -53 },
  { 2241, 34, 48, 38, 3, -47 },
  { 2445, 30, 47, 38, 3, -47 },
  { 2622, 35, 47, 38, 2, -47 },
  { 2828, 33, 48, 38, 3, -47 },
  { 3026, 32, 47, 38, 3, -47 },
  { 3214, 34, 48, 38, 3, -47 },
  { 3418, 33, 48, 38, 2, -47 },
  { 3616, 32, 47, 38, 7, -47 },
  { 3804, 35, 48, 38, 2, -47 },
  { 4014, 33, 47, 38, 5, -47 },
  { 4208, 16, 37, 38, 11, -36 },
  { 4282, 21, 46, 38, 6, -36 },
  { 4403, 32, 34, 38, 5, -38 },
  { 4539, 31, 22, 38, 4, -32 },
  { 4625, 32, 34, 38, 3, -38 },
  { 4761, 27, 47, 38, 8, -47 },
  { 4920, 39, 59, 38, 0, -47 },
  { 5208, 33, 47, 38, 0, -47 },
  { 5402, 35, 47, 38, 2, -47 },
  { 5608, 34, 48, 38, 3, -47 },
  { 5812, 35, 47, 38, 2, -47 },
  { 6018, 35, 47, 38, 3, -47 },
  { 6224, 36, 47, 38, 3, -47 },
  { 6436, 34, 48, 38, 3, -47 },
  { 6640, 36, 47, 38, 2, -47 },
  { 6852, 34, 47, 38, 3, -47 },
  { 7052, 37, 48, 38, 0, -47 },
  { 7274, 38, 47, 38, 2, -47 },
  { 7498, 29, 47, 38, 4, -47 },
  { 7669, 38, 47, 38, 1, -47 },
  { 7893, 36, 47, 38, 2, -47 },
  { 8105, 34, 48, 38, 3, -47 },
  { 8309, 37, 47, 38, 2, -47 },
  { 8527, 34, 59, 38, 3, -47 },
  { 8778, 36, 47, 38, 2, -47 },
  { 8990, 35, 48, 38, 2, -47 },
  { 9200, 33, 47, 38, 7, -47 },
  { 9394, 35, 48, 38, 3, -47 },
  { 9604, 34, 47, 38, 7, -47 },
  { 9804, 39, 47, 38, 3, -47 },
  { 10034, 41, 47, 38, -1, -47 },
  { 10275, 35, 47, 38, 6, -47 },
  { 10481, 35, 47, 38, 2, -47 },
  { 10687, 27, 60, 38, 8, -53 },
  { 10890, 20, 60, 38, 10, -53 },
  { 11040, 27, 60, 38, 5, -53 },
  { 11243, 30, 25, 38, 5, -47 },
  { 11337, 31, 6, 38, 0, 2 },
  { 11361, 13, 9, 38, 16, -50 },
  { 11376, 33, 37, 38, 3, -36 },
  { 11529, 33, 48, 38, 2, -47 },
  { 11727, 33, 37, 38, 3, -36 },
  { 11880, 35, 48, 38, 3, -47 },
  { 12090, 32, 37, 38, 3, -36 },
  { 12238, 43, 59, 38, -3, -47 },
  { 12556, 32, 48, 38, 4, -36 },
  { 12748, 33, 47, 38, 2, -47 },
  { 12942, 32, 50, 38, 2, -50 },
  { 13142, 34, 62, 38, 1, -50 },
  { 13406, 36, 47, 38, 2, -47 },
  { 13618, 28, 47, 38, 6, -47 },
  { 13783, 36, 36, 38, 1, -36 },
  { 13945, 33, 36, 38, 2, -36 },
  { 14094, 32, 37, 38, 3, -36 },
  { 14242, 35, 48, 38, 0, -36 },
  { 14452, 33, 48, 38, 3, -36 },
  { 14650, 34, 36, 38, 3, -36 },
  { 14803, 32, 37, 38, 3, -36 },
  { 14951, 31, 45, 38, 5, -45 },
  { 15126, 33, 36, 38, 3, -35 },
  { 15275, 32, 35, 38, 6, -35 },
  { 15415, 36, 35, 38, 4, -35 },
  { 15573, 38, 35, 38, 0, -35 },
  { 15740, 32, 47, 38, 4, -35 },
  { 15928, 33, 35, 38, 2, -35 },
  { 16073, 34, 60, 38, 5, -53 },
  { 16328, 16, 60, 38, 12, -53 },
  { 16448, 34, 60, 38, 1, -53 },
  { 16703, 34, 15, 38, 3, -30 },
};

const GFXfont JetBrainsMono_SemiBoldItalic64pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic64pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic64pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC64PT7B_H_
