#ifndef _JETBRAINSMONO_SEMIBOLDITALIC26PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xCF, 0x3C, 0xE3, 0x8E, 0x38, 0xE3, 0x0C, 0x31, 0x00,
  0x00, 0xF3, 0xCF, 0x00, 0x71, 0xDC, 0x77, 0x1D, 0xCE, 0x73, 0x98, 0xEE,
  0x3B, 0x8E, 0x01, 0xC6, 0x01, 0x86, 0x03, 0x8E, 0x03, 0x0C, 0x03, 0x0C,
  0x1F, 0xFF, 0x3F, 0xFF, 0x06, 0x18, 0x0E, 0x38, 0x0C, 0x30, 0x0C, 0x30,
  0x1C, 0x70, 0x7F, 0xFC, 0xFF, 0xFC, 0x38, 0xE0, 0x30, 0xC0, 0x30, 0xC0,
  0x71, 0xC0, 0x61, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x07,
  0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0x67, 0x39, 0x9C, 0xE6, 0x03, 0x90, 0x0F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0x78, 0x08, 0xEE,
  0x23, 0xBD, 0x9C, 0xFF, 0xF1, 0xFF, 0x83, 0xF8, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x07, 0x80, 0xC7, 0xF0, 0x61, 0x8C, 0x30, 0x63,
  0x18, 0x38, 0xCE, 0x0E, 0x37, 0x03, 0xB9, 0x80, 0x7E, 0xC0, 0x0C, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x80, 0x0E, 0xF8, 0x07, 0x77, 0x01, 0xB8, 0xC0,
  0xCE, 0x30, 0x63, 0x1C, 0x30, 0xC6, 0x18, 0x3F, 0x8E, 0x07, 0xC0, 0x03,
  0xF0, 0x0F, 0xF0, 0x3C, 0xF0, 0x70, 0xE0, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0xEE, 0x3B, 0x9E, 0xE7, 0x1F, 0x8E,
  0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x7B, 0xF0, 0xFF, 0x70, 0xFC, 0xF0, 0x77,
  0x7F, 0xEE, 0xEE, 0x00, 0x60, 0x3C, 0x0F, 0x83, 0xC0, 0xE0, 0x38, 0x0F,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0,
  0x06, 0x00, 0x0C, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x03, 0xC0, 0xE0,
  0x00, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x73, 0x9F, 0xE5, 0xF7,
  0xFF, 0x80, 0xC0, 0x07, 0x80, 0x77, 0x03, 0xDE, 0x0E, 0x38, 0x70, 0xE0,
  0x41, 0x00, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x1F, 0x1E,
  0x1C, 0x3C, 0x38, 0x70, 0x70, 0xE0, 0x7F, 0xDF, 0xEF, 0xF8, 0x79, 0xE7,
  0x9E, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xE7, 0xCF, 0x07, 0x38, 0x1C,
  0xE0, 0x73, 0x81, 0xCC, 0x06, 0x73, 0xB9, 0xDE, 0xE7, 0x3B, 0x9C, 0x0E,
  0x70, 0x39, 0x80, 0xCE, 0x07, 0x1C, 0x1C, 0x79, 0xE1, 0xFF, 0x03, 0xF8,
  0x00, 0x01, 0xE0, 0x3F, 0x03, 0xF8, 0x79, 0xC3, 0x9C, 0x10, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x07, 0xF0, 0x3F, 0xE1,
  0xFF, 0x8F, 0x0F, 0x38, 0x1C, 0xE0, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0x80,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xF0, 0x07, 0xF0, 0x07, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xCE, 0x07, 0x38, 0x1C, 0x79, 0xE1,
  0xFF, 0x03, 0xF8, 0x00, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C,
  0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x39, 0xC1, 0xDE, 0x1E, 0xE0, 0xE7,
  0xFF, 0x3F, 0xFB, 0xFF, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x1F,
  0xFC, 0x7F, 0xF1, 0xFF, 0x87, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0xFC, 0x3F, 0xF0, 0xF1, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xCF,
  0x07, 0x3C, 0x1C, 0x79, 0xE1, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x98, 0x3B, 0xF1,
  0xFF, 0xDE, 0x1E, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFE, 0x0E, 0x79,
  0xE3, 0xFF, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xEE, 0x0F,
  0x70, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x3C, 0x00, 0x07,
  0xF0, 0x3F, 0xE1, 0xE7, 0x87, 0x0F, 0x38, 0x1C, 0xE0, 0xE3, 0x83, 0x87,
  0x1C, 0x0F, 0xE0, 0x3F, 0x01, 0xFE, 0x0E, 0x1C, 0x70, 0x73, 0xC0, 0xEE,
  0x07, 0x3C, 0x1C, 0x79, 0xF1, 0xFF, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFF,
  0x8F, 0x3E, 0xF0, 0x77, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xF0, 0x73,
  0xFF, 0x9F, 0xF8, 0x3B, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1E,
  0x00, 0xE0, 0x1E, 0x00, 0x08, 0x3C, 0xF9, 0xF1, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC7, 0x8F, 0x1E, 0x00, 0x03, 0x03, 0xC3, 0xE1, 0xF0, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE1, 0xE0, 0xE0, 0xF0, 0x70,
  0x78, 0x38, 0x38, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xE0, 0xFC,
  0x3F, 0x03, 0xE0, 0x1C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1E, 0x00, 0x30, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x20, 0x01, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x00, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x0F, 0x80, 0x60, 0x00, 0x3F, 0x07, 0xF8, 0xFF, 0x80, 0xF0, 0x0E, 0x01,
  0xC0, 0x38, 0x0E, 0x1F, 0xC7, 0xF0, 0xF8, 0x1C, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x1F, 0x01, 0xC0, 0x00, 0x03, 0xF8, 0x07, 0xFE, 0x0E,
  0x0E, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x30, 0x77, 0x31, 0xFE, 0x71,
  0xCE, 0x73, 0x8E, 0x73, 0x8E, 0x73, 0x8E, 0x63, 0x0E, 0x63, 0x0E, 0xE3,
  0x0C, 0xE3, 0x9C, 0xE3, 0xEC, 0xE0, 0x80, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x07, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x07, 0xE0, 0x3F, 0x03, 0xB8, 0x1C, 0xC0, 0xE6, 0x0E, 0x30, 0x71, 0xC7,
  0x0E, 0x38, 0x71, 0xFF, 0x9F, 0xFC, 0xE0, 0xEE, 0x07, 0x70, 0x3F, 0x81,
  0xF8, 0x0E, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xCE, 0x0F, 0x38, 0x1C, 0xE0,
  0x73, 0x83, 0x8E, 0x1E, 0x3F, 0xE1, 0xFF, 0x87, 0x0F, 0x1C, 0x1E, 0x70,
  0x39, 0xC0, 0xE7, 0x07, 0x98, 0x1C, 0xFF, 0xF3, 0xFF, 0x8F, 0xF8, 0x00,
  0x07, 0xF0, 0x3F, 0xE1, 0xF7, 0xC7, 0x07, 0x38, 0x1C, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x27, 0x07, 0x1C, 0x1C, 0x7D, 0xE1, 0xFF, 0x81, 0xF8, 0x00, 0x1F, 0xE0,
  0x7F, 0xE1, 0xFF, 0x8E, 0x0F, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x0E,
  0x38, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC1, 0xE7, 0x07,
  0x3C, 0x3C, 0xFF, 0xE3, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x3F, 0xF8,
  0x7F, 0xF0, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xF8,
  0x7F, 0xF1, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3F,
  0xF8, 0x7F, 0xF1, 0xFF, 0xC3, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0xE1,
  0xF7, 0xC7, 0x07, 0x38, 0x1C, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xC7, 0xE7, 0x1F, 0x9C, 0xFE, 0x70, 0x39, 0xC0, 0xE7, 0x07, 0x1C, 0x1C,
  0x7D, 0xE1, 0xFF, 0x81, 0xF8, 0x00, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xCE,
  0x07, 0x38, 0x1C, 0xE0, 0xF3, 0x83, 0x8E, 0x0E, 0x3F, 0xF9, 0xFF, 0xE7,
  0xFF, 0x9C, 0x1E, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0xE0, 0x73,
  0x81, 0xCE, 0x0E, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC0, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x7F, 0xE1, 0xFF, 0x8F,
  0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x38, 0x7D, 0xF0, 0xFF, 0xC0,
  0x7E, 0x00, 0x1C, 0x0E, 0x38, 0x38, 0x70, 0xF1, 0xC1, 0xC3, 0x87, 0x87,
  0x0E, 0x0E, 0x38, 0x1C, 0xF0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0x8E,
  0x07, 0x1E, 0x0E, 0x1C, 0x1C, 0x38, 0x78, 0x70, 0xE0, 0x71, 0xC0, 0xE3,
  0x81, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x0F, 0x1E, 0x1F, 0x1E, 0x1F, 0x1B,
  0x1E, 0x1B, 0x36, 0x1B, 0x36, 0x3B, 0x6E, 0x3B, 0x6E, 0x3B, 0xCE, 0x3B,
  0xCC, 0x39, 0xDC, 0x30, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70,
  0x18, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x38, 0x1E, 0x0C, 0x78, 0x73, 0xE1,
  0xCF, 0x87, 0x3E, 0x1C, 0xFC, 0x73, 0xF1, 0x8C, 0xCE, 0x33, 0x39, 0xCC,
  0xE7, 0x3B, 0x9C, 0xEE, 0x71, 0xB9, 0xC6, 0xC6, 0x1B, 0x38, 0x7C, 0xE1,
  0xF3, 0x87, 0xCE, 0x0F, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xF7, 0x8F, 0x0F,
  0x38, 0x1C, 0xE0, 0x73, 0x83, 0x8E, 0x0E, 0x78, 0x39, 0xC0, 0xE7, 0x03,
  0x9C, 0x0E, 0x70, 0x79, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0x7D, 0xE1, 0xFF,
  0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF1, 0xC0, 0xE3, 0x81,
  0xE7, 0x03, 0xCE, 0x07, 0x1C, 0x0E, 0x38, 0x78, 0xFF, 0xF1, 0xFF, 0x83,
  0xF8, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xF7, 0xCF, 0x0F, 0x38, 0x1C,
  0xE0, 0x73, 0x81, 0xCE, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E,
  0x70, 0x39, 0xC1, 0xCF, 0x07, 0x1C, 0x1C, 0x7D, 0xE1, 0xFF, 0x03, 0xF8,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x1F, 0xF0, 0x7F,
  0xE1, 0xFF, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x0F, 0x38,
  0x79, 0xFF, 0xC7, 0xFE, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x0E, 0x3C,
  0x38, 0xE0, 0xE3, 0x81, 0xCE, 0x07, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xF7,
  0xCF, 0x07, 0x38, 0x1C, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1F, 0x80, 0x3F,
  0x80, 0x3F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xEE, 0x03, 0xBC, 0x1C, 0xFD,
  0xF1, 0xFF, 0x83, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0x1C, 0x1C, 0x70, 0x73, 0xC1, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x83,
  0x8E, 0x0E, 0x38, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x79, 0xC1,
  0xC7, 0x07, 0x1C, 0x3C, 0x79, 0xE1, 0xFF, 0x03, 0xF8, 0x00, 0xE0, 0x3F,
  0x01, 0xF8, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x71, 0x83, 0x8E, 0x38, 0x71,
  0xC3, 0x8E, 0x1C, 0xE0, 0xE7, 0x07, 0x70, 0x3B, 0x81, 0xD8, 0x0F, 0xC0,
  0x7E, 0x01, 0xE0, 0x0F, 0x00, 0x71, 0xC7, 0x71, 0xC7, 0x71, 0xC6, 0x73,
  0xCE, 0x73, 0xCE, 0x72, 0xCE, 0x76, 0xCC, 0x66, 0xDC, 0x66, 0xDC, 0x64,
  0xD8, 0x6C, 0xD8, 0x6C, 0xF8, 0x6C, 0xB8, 0x68, 0xB0, 0x78, 0xB0, 0x78,
  0xB0, 0xF0, 0xF0, 0xF0, 0xE0, 0xF1, 0xE0, 0x1C, 0x07, 0x0E, 0x0E, 0x0E,
  0x1E, 0x0F, 0x1C, 0x07, 0x38, 0x07, 0x78, 0x07, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x0E, 0xE0, 0x1E, 0xF0, 0x1C,
  0x70, 0x38, 0x70, 0x78, 0x78, 0x70, 0x38, 0xE0, 0x3C, 0xE0, 0x3F, 0x80,
  0xEE, 0x07, 0x1C, 0x3C, 0x70, 0xE1, 0xC7, 0x03, 0x9C, 0x0E, 0xE0, 0x3B,
  0x80, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xFF,
  0xF3, 0xFF, 0xCF, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0x00, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F,
  0xC3, 0xF8, 0xFE, 0x00, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x70, 0x78,
  0x38, 0x38, 0x38, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E,
  0x0E, 0x07, 0x07, 0x07, 0x07, 0x0F, 0xE1, 0xFC, 0x3F, 0x88, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x3F,
  0x87, 0xF0, 0xFE, 0x00, 0x03, 0x80, 0x7C, 0x07, 0xC0, 0xEC, 0x0C, 0xC1,
  0xCE, 0x38, 0xE3, 0x86, 0x70, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xE3,
  0x9E, 0x02, 0x00, 0x3F, 0x71, 0xFF, 0x8F, 0x1E, 0x38, 0x39, 0xC0, 0xE7,
  0x03, 0x9C, 0x0E, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x1C, 0x3C, 0x79, 0xF1,
  0xFD, 0xC3, 0xEE, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x84,
  0x1D, 0xF8, 0xFF, 0xE7, 0x8F, 0x38, 0x3B, 0xC1, 0xDC, 0x0E, 0xE0, 0x77,
  0x07, 0xB8, 0x39, 0xC1, 0xDE, 0x0E, 0xF9, 0xE7, 0x7F, 0x3B, 0xF0, 0x01,
  0x00, 0x7F, 0x87, 0xFE, 0x78, 0xF3, 0x83, 0xB8, 0x1D, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x1C, 0xE0, 0xE7, 0x9E, 0x3F, 0xF0, 0xFE, 0x00,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x02, 0x1C, 0x3F, 0x71, 0xFF,
  0x8F, 0x1E, 0x38, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x71, 0xC1,
  0xC7, 0x07, 0x1C, 0x3C, 0x79, 0xF1, 0xFD, 0xC3, 0xEE, 0x00, 0x01, 0x80,
  0x7F, 0x87, 0xFC, 0x78, 0xF3, 0x83, 0xB8, 0x1D, 0xC0, 0xEF, 0xFF, 0x7F,
  0xFB, 0x80, 0x1C, 0x00, 0xE0, 0xE7, 0x8E, 0x3F, 0xF0, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x07, 0xF0, 0x03, 0xF0, 0x01,
  0xE0, 0x00, 0x02, 0x00, 0x3F, 0x71, 0xFF, 0x8F, 0x1E, 0x38, 0x39, 0xC0,
  0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x1F, 0xFC, 0x7F,
  0x70, 0xF9, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE1, 0xFF, 0x07, 0xF8, 0x1F,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x84, 0x1D, 0xF8, 0xFF,
  0xE7, 0x8F, 0x38, 0x3B, 0xC1, 0xDC, 0x0E, 0xE0, 0x77, 0x07, 0x38, 0x39,
  0xC1, 0xDE, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x07, 0xF8, 0x3F, 0xC0, 0xFC,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x27, 0x07,
  0x8E, 0x0E, 0x1C, 0x38, 0x38, 0xF0, 0x73, 0xC1, 0xFF, 0x03, 0xFC, 0x07,
  0xF8, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xF0, 0xE0, 0xE1, 0xC1, 0xE3, 0x81,
  0xC0, 0x7F, 0x0F, 0xF0, 0xFF, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1F, 0xF1, 0xFF, 0x0F, 0xE0, 0x01, 0x08, 0x7F, 0x78, 0xFF, 0xF9,
  0xCE, 0x73, 0x98, 0xE7, 0x31, 0xCC, 0x63, 0x38, 0xC6, 0x71, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x98, 0xE6, 0x31, 0x8C, 0x63, 0x38, 0xCE, 0x00, 0x00,
  0x41, 0xDF, 0x8F, 0xFE, 0x78, 0xF3, 0x83, 0xBC, 0x1D, 0xC0, 0xEE, 0x07,
  0x70, 0x73, 0x83, 0x9C, 0x1D, 0xE0, 0xEE, 0x07, 0x70, 0x3B, 0x83, 0xC0,
  0x01, 0x80, 0x7F, 0x87, 0xFC, 0x78, 0xF3, 0x83, 0xB8, 0x1D, 0xC0, 0xEE,
  0x07, 0x70, 0x7B, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x9E, 0x3F, 0xE0, 0xFE,
  0x00, 0x00, 0x20, 0x77, 0xE1, 0xFF, 0xC7, 0x8F, 0x1C, 0x1C, 0xF0, 0x73,
  0x81, 0xCE, 0x07, 0x38, 0x3C, 0xE0, 0xE3, 0x83, 0x9E, 0x0E, 0x7C, 0xF1,
  0xDF, 0xC7, 0x7E, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0x02, 0x00, 0x3F, 0x71, 0xFF, 0x8F, 0x1E, 0x38, 0x39, 0xC0, 0xE7, 0x03,
  0x9C, 0x0E, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x1C, 0x3C, 0x79, 0xF1, 0xFD,
  0xC3, 0xEE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x04,
  0x40, 0x6F, 0xE3, 0xBF, 0x8F, 0x0F, 0x38, 0x3C, 0xE0, 0xF3, 0x83, 0xCE,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x7F, 0x87, 0xFE, 0x70, 0x73, 0x80, 0x1C, 0x00,
  0xF8, 0x07, 0xFC, 0x07, 0xF0, 0x03, 0x80, 0x1D, 0xC0, 0xEF, 0x0F, 0x3F,
  0xF0, 0xFF, 0x00, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x0F, 0xFF, 0xFF,
  0xFC, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0xFC, 0x1F, 0xE0, 0x7E, 0x00, 0x38, 0x3C, 0xE0,
  0xE3, 0x83, 0x8E, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x1C, 0x70,
  0x71, 0xC1, 0xC7, 0x0F, 0x1E, 0x78, 0x7F, 0xC0, 0xFE, 0x00, 0xE0, 0x3D,
  0xC0, 0xE7, 0x07, 0x1C, 0x1C, 0x70, 0xE1, 0xC3, 0x87, 0x1C, 0x0E, 0x70,
  0x3B, 0x80, 0xEE, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x78, 0x00, 0xC7,
  0x1F, 0x1C, 0x7C, 0x71, 0xB3, 0xCE, 0xCF, 0x3B, 0x2C, 0xCD, 0xB3, 0x36,
  0xDC, 0xDB, 0x63, 0x4D, 0x8F, 0x3E, 0x3C, 0xF0, 0xE3, 0xC3, 0x8F, 0x00,
  0x1C, 0x1E, 0x3C, 0x78, 0x38, 0xE0, 0x7B, 0x80, 0x7E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x1D, 0xC0, 0x73, 0xC1, 0xC3, 0x87, 0x87,
  0x9E, 0x07, 0x00, 0x38, 0x3C, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x70, 0x39,
  0xC0, 0xE7, 0x07, 0x9C, 0x1C, 0x70, 0x71, 0xC3, 0xC7, 0xFF, 0x1F, 0xDC,
  0x1E, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x7F, 0xC1, 0xFE, 0x07, 0xE0,
  0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xFF, 0xEF, 0xFF, 0x7F, 0xF0,
  0x00, 0x1C, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x1F, 0xC0, 0xFE, 0x03, 0xFC,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x0E, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8F, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x8E, 0x1C, 0x38, 0x70, 0xE0, 0x0E, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xFF, 0x00, 0xFC, 0x0F, 0xF0, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x07, 0xE0, 0x1F, 0x00,
  0xF0, 0x00, 0x1E, 0x1D, 0xFC, 0x77, 0x71, 0xD8, 0xFE, 0xE1, 0xF8, 0x03,
  0x80,
};

const GFXglyph JetBrainsMono_SemiBoldItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 6, 19, 16, 5, -19 },
  { 16, 10, 8, 16, 4, -19 },
  { 26, 16, 19, 16, 0, -19 },
  { 64, 14, 27, 16, 1, -23 },
  { 112, 18, 19, 16, -1, -19 },
  { 155, 15, 19, 16, 0, -19 },
  { 191, 4, 8, 16, 7, -19 },
  { 195, 11, 25, 16, 4, -22 },
  { 230, 11, 25, 16, 1, -22 },
  { 265, 14, 14, 16, 1, -16 },
  { 290, 12, 13, 16, 2, -15 },
  { 310, 8, 8, 16, 2, -4 },
  { 318, 10, 3, 16, 3, -10 },
  { 322, 6, 4, 16, 4, -4 },
  { 325, 16, 25, 16, 0, -22 },
  { 375, 14, 19, 16, 1, -19 },
  { 409, 13, 19, 16, 1, -19 },
  { 440, 14, 19, 16, 1, -19 },
  { 474, 14, 19, 16, 1, -19 },
  { 508, 13, 19, 16, 1, -19 },
  { 539, 14, 19, 16, 1, -19 },
  { 573, 13, 19, 16, 1, -19 },
  { 604, 13, 19, 16, 3, -19 },
  { 635, 14, 19, 16, 1, -19 },
  { 669, 13, 19, 16, 2, -19 },
  { 700, 7, 15, 16, 4, -15 },
  { 714, 9, 19, 16, 2, -15 },
  { 736, 13, 14, 16, 2, -16 },
  { 759, 12, 9, 16, 2, -13 },
  { 773, 13, 14, 16, 1, -16 },
  { 796, 11, 19, 16, 3, -19 },
  { 823, 16, 24, 16, 0, -19 },
  { 871, 13, 19, 16, 0, -19 },
  { 902, 14, 19, 16, 1, -19 },
  { 936, 14, 19, 16, 1, -19 },
  { 970, 14, 19, 16, 1, -19 },
  { 1004, 15, 19, 16, 1, -19 },
  { 1040, 15, 19, 16, 1, -19 },
  { 1076, 14, 19, 16, 1, -19 },
  { 1110, 14, 19, 16, 1, -19 },
  { 1144, 14, 19, 16, 1, -19 },
  { 1178, 15, 19, 16, 0, -19 },
  { 1214, 15, 19, 16, 1, -19 },
  { 1250, 11, 19, 16, 2, -19 },
  { 1277, 16, 19, 16, 0, -19 },
  { 1315, 14, 19, 16, 1, -19 },
  { 1349, 14, 19, 16, 1, -19 },
  { 1383, 15, 19, 16, 1, -19 },
  { 1419, 14, 24, 16, 1, -19 },
  { 1461, 14, 19, 16, 1, -19 },
  { 1495, 14, 19, 16, 1, -19 },
  { 1529, 13, 19, 16, 3, -19 },
  { 1560, 14, 19, 16, 1, -19 },
  { 1594, 13, 19, 16, 3, -19 },
  { 1625, 16, 19, 16, 1, -19 },
  { 1663, 16, 19, 16, 0, -19 },
  { 1701, 14, 19, 16, 3, -19 },
  { 1735, 14, 19, 16, 1, -19 },
  { 1769, 11, 25, 16, 3, -22 },
  { 1804, 8, 25, 16, 4, -22 },
  { 1829, 11, 25, 16, 2, -22 },
  { 1864, 12, 10, 16, 2, -19 },
  { 1879, 13, 2, 16, 0, 1 },
  { 1883, 5, 3, 16, 7, -20 },
  { 1885, 14, 15, 16, 1, -15 },
  { 1912, 13, 19, 16, 1, -19 },
  { 1943, 13, 15, 16, 1, -15 },
  { 1968, 14, 19, 16, 1, -19 },
  { 2002, 13, 15, 16, 1, -15 },
  { 2027, 17, 24, 16, -1, -19 },
  { 2078, 14, 20, 16, 1, -15 },
  { 2113, 13, 19, 16, 1, -19 },
  { 2144, 13, 20, 16, 1, -20 },
  { 2177, 14, 25, 16, 0, -20 },
  { 2221, 15, 19, 16, 1, -19 },
  { 2257, 12, 19, 16, 2, -19 },
  { 2286, 15, 15, 16, 0, -15 },
  { 2315, 13, 15, 16, 1, -15 },
  { 2340, 13, 15, 16, 1, -15 },
  { 2365, 14, 20, 16, 0, -15 },
  { 2400, 14, 20, 16, 1, -15 },
  { 2435, 14, 15, 16, 1, -15 },
  { 2462, 13, 15, 16, 1, -15 },
  { 2487, 13, 18, 16, 2, -18 },
  { 2517, 14, 14, 16, 1, -14 },
  { 2542, 14, 14, 16, 2, -14 },
  { 2567, 14, 14, 16, 2, -14 },
  { 2592, 15, 14, 16, 0, -14 },
  { 2619, 14, 19, 16, 1, -14 },
  { 2653, 13, 14, 16, 1, -14 },
  { 2676, 14, 25, 16, 2, -22 },
  { 2720, 7, 25, 16, 5, -22 },
  { 2742, 14, 25, 16, 0, -22 },
  { 2786, 14, 6, 16, 1, -12 },
};

const GFXfont JetBrainsMono_SemiBoldItalic26pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic26pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC26PT7B_H_
