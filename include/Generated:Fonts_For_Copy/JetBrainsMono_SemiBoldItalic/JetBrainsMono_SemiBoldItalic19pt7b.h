#ifndef _JETBRAINSMONO_SEMIBOLDITALIC19PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xCE, 0x73, 0x18, 0xC6, 0x31, 0x00, 0x07, 0x70, 0x66, 0xCF,
  0x9F, 0x3C, 0xD9, 0x80, 0x06, 0x20, 0x46, 0x0C, 0x60, 0xC4, 0x3F, 0xF1,
  0x88, 0x18, 0x81, 0x18, 0x31, 0x0F, 0xFC, 0x23, 0x06, 0x20, 0x66, 0x04,
  0x60, 0x02, 0x00, 0x80, 0x20, 0x3E, 0x3F, 0xCD, 0x77, 0x4D, 0xD0, 0x74,
  0x0F, 0x81, 0xF0, 0x2E, 0x09, 0xB2, 0x6C, 0xBB, 0xFC, 0x7E, 0x04, 0x01,
  0x00, 0x40, 0x0E, 0x0C, 0x6C, 0x63, 0x33, 0x0C, 0xD8, 0x32, 0xC0, 0xFE,
  0x00, 0x10, 0x00, 0x80, 0x07, 0xE0, 0x34, 0xC1, 0xB3, 0x0C, 0xCC, 0x63,
  0x63, 0x07, 0x80, 0x07, 0x83, 0xF8, 0x63, 0x0C, 0x01, 0x80, 0x30, 0x0F,
  0x03, 0xE3, 0x66, 0xCC, 0xF1, 0x8E, 0x71, 0xC7, 0xF8, 0xF9, 0x80, 0x6F,
  0xFD, 0x80, 0x03, 0x0F, 0x1C, 0x38, 0x30, 0x70, 0x60, 0x60, 0x60, 0xE0,
  0xE0, 0xC0, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x18, 0x10, 0x1C, 0x0E, 0x06,
  0x07, 0x03, 0x03, 0x07, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x1C, 0x38,
  0xF0, 0xC0, 0x06, 0x01, 0x80, 0xC1, 0x33, 0xF7, 0xCF, 0xC1, 0xC0, 0xD8,
  0x77, 0x18, 0xC0, 0x0E, 0x03, 0x00, 0xC0, 0x31, 0xFF, 0xBF, 0xE1, 0xC0,
  0x70, 0x18, 0x00, 0x3B, 0x9C, 0xCC, 0x60, 0xFF, 0xF0, 0x7F, 0xE0, 0x00,
  0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60,
  0x0E, 0x00, 0x0F, 0x0F, 0xE3, 0x1D, 0x83, 0x60, 0xD8, 0x76, 0xD9, 0xB6,
  0xC1, 0xB0, 0x6C, 0x1B, 0x0C, 0xFF, 0x1F, 0x80, 0x07, 0x0F, 0x8F, 0x8C,
  0xC4, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x8F, 0xFF, 0xFC,
  0x0F, 0x0F, 0xE7, 0x1D, 0x87, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x03, 0x80, 0xFF, 0xBF, 0xC0, 0x3F, 0xCF, 0xF0, 0x18, 0x1C, 0x0E,
  0x03, 0x81, 0xF0, 0x0E, 0x01, 0x80, 0x6C, 0x3B, 0x0C, 0xFF, 0x1F, 0x00,
  0x01, 0xC0, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x19, 0x86, 0xC1, 0xBF,
  0xEF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xCF, 0xF3, 0x00, 0xC0, 0x70,
  0x1B, 0xC7, 0xF9, 0x86, 0x01, 0x80, 0x60, 0x3B, 0x0C, 0xFF, 0x1F, 0x80,
  0x03, 0x03, 0x03, 0x83, 0x81, 0x81, 0x91, 0xFE, 0xE7, 0xE1, 0xE0, 0xF0,
  0x78, 0x7F, 0xF3, 0xF0, 0x7F, 0xFF, 0xEC, 0x1B, 0x0E, 0x03, 0x01, 0x80,
  0x60, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x00, 0x0F, 0x0F,
  0xE3, 0x1D, 0xC3, 0x71, 0x8C, 0xE1, 0xE0, 0xFC, 0x63, 0xB0, 0x6C, 0x1B,
  0x0E, 0xFF, 0x1F, 0x80, 0x1E, 0x3F, 0xB8, 0xF8, 0x3C, 0x1E, 0x1F, 0x8D,
  0xFE, 0x36, 0x06, 0x07, 0x07, 0x03, 0x07, 0x00, 0x11, 0xCE, 0x00, 0x00,
  0x00, 0x67, 0xB8, 0x08, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x38, 0xC7, 0x18,
  0xE3, 0x00, 0x00, 0xC0, 0xF1, 0xF1, 0xF0, 0x60, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x40, 0x7F, 0xDF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xEF, 0xF8,
  0x60, 0x3C, 0x07, 0x80, 0xF0, 0x18, 0x3C, 0x78, 0xF0, 0xE0, 0x40, 0x00,
  0x3C, 0x3F, 0x81, 0xC0, 0x60, 0x30, 0x38, 0xF8, 0x78, 0x30, 0x18, 0x00,
  0x00, 0x07, 0x03, 0x00, 0x07, 0xC1, 0xFE, 0x38, 0x63, 0x03, 0x60, 0x26,
  0x3A, 0x66, 0x66, 0x46, 0x6C, 0x64, 0xC6, 0xCC, 0x6C, 0xEC, 0xC7, 0xCC,
  0x00, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x78, 0x36, 0x0D,
  0x87, 0x61, 0x98, 0x66, 0x31, 0x8F, 0xE7, 0xF9, 0x87, 0x60, 0xF0, 0x30,
  0x3F, 0x0F, 0xE3, 0x1D, 0xC3, 0x61, 0xD8, 0x67, 0xF1, 0xFC, 0x61, 0xB8,
  0x6C, 0x1B, 0x0E, 0xFF, 0x3F, 0x80, 0x0F, 0x0F, 0xE3, 0x1D, 0xC3, 0x60,
  0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x1B, 0x8C, 0x7F, 0x1F, 0x80,
  0x3F, 0x0F, 0xE7, 0x1D, 0xC3, 0x60, 0xD8, 0x76, 0x19, 0x86, 0x61, 0xB8,
  0x6C, 0x3B, 0x0C, 0xFF, 0x3F, 0x00, 0x3F, 0xCF, 0xF3, 0x00, 0xC0, 0x70,
  0x18, 0x07, 0xF9, 0xFC, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xFF, 0x3F, 0xC0,
  0x3F, 0xCF, 0xF3, 0x01, 0xC0, 0x60, 0x18, 0x07, 0xF9, 0xFE, 0x60, 0x38,
  0x0E, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x0F, 0x0F, 0xE3, 0x1D, 0xC3, 0x60,
  0x18, 0x06, 0x01, 0x9E, 0xEF, 0xB8, 0x6C, 0x1B, 0x8C, 0x7F, 0x1F, 0x80,
  0x30, 0xCC, 0x33, 0x0D, 0xC7, 0x61, 0xD8, 0x67, 0xF9, 0xFE, 0x61, 0xB8,
  0x6C, 0x3B, 0x0C, 0xC3, 0x30, 0xC0, 0x3F, 0xCF, 0xF0, 0x60, 0x38, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0xFF, 0x3F, 0xC0,
  0x07, 0xE0, 0xFC, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01,
  0xC0, 0x33, 0x86, 0x71, 0xC7, 0xF0, 0x7C, 0x00, 0x30, 0xE6, 0x18, 0xC6,
  0x39, 0xC6, 0x30, 0xCE, 0x1F, 0x83, 0xF0, 0x66, 0x1C, 0xE3, 0x1C, 0x61,
  0x8C, 0x31, 0x87, 0x00, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0F, 0xFF, 0xF8, 0x38, 0x73, 0x8E, 0x3C,
  0xA3, 0xDE, 0x3D, 0x63, 0xF6, 0x27, 0x66, 0x6C, 0x60, 0xC6, 0x0C, 0x60,
  0xC6, 0x0C, 0x60, 0xCC, 0x18, 0x38, 0xCE, 0x37, 0x8D, 0xE3, 0x68, 0xDB,
  0x66, 0xD9, 0xB6, 0xED, 0xB1, 0x6C, 0x7B, 0x1C, 0xC7, 0x31, 0xC0, 0x0F,
  0x0F, 0xE3, 0x1D, 0xC3, 0x61, 0xD8, 0x66, 0x19, 0x86, 0xE1, 0xB8, 0x6C,
  0x3B, 0x8C, 0xFF, 0x1F, 0x80, 0x3F, 0x07, 0xF8, 0xC7, 0x38, 0x66, 0x0C,
  0xC1, 0x98, 0xE3, 0xFC, 0x7C, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x00, 0x0F, 0x0F, 0xE3, 0x1D, 0x83, 0x61, 0xD8, 0x76, 0x19, 0x86, 0xE1,
  0xB0, 0x6C, 0x1B, 0x8C, 0xFF, 0x1F, 0x80, 0xC0, 0x18, 0x07, 0x00, 0x3F,
  0x0F, 0xF3, 0x1D, 0xC3, 0x60, 0xD8, 0x77, 0xF9, 0xFC, 0x66, 0x39, 0x8C,
  0x73, 0x0C, 0xC3, 0x30, 0xE0, 0x0F, 0x8F, 0xF3, 0x1D, 0xC3, 0x60, 0x1C,
  0x03, 0xE0, 0x7C, 0x03, 0x80, 0x6C, 0x1B, 0x0E, 0xFF, 0x1F, 0x80, 0xFF,
  0xFF, 0xF0, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03,
  0x80, 0xC0, 0x30, 0x0C, 0x00, 0x30, 0xCC, 0x37, 0x0D, 0x83, 0x61, 0xD8,
  0x66, 0x19, 0x86, 0x61, 0xB8, 0x6C, 0x3B, 0x8C, 0x7F, 0x1F, 0x80, 0xC0,
  0xF0, 0x6E, 0x1B, 0x8E, 0x63, 0x18, 0xC6, 0x61, 0x98, 0x6E, 0x1B, 0x06,
  0xC1, 0xE0, 0x78, 0x1E, 0x00, 0x66, 0x6C, 0xCD, 0x39, 0xA5, 0x3C, 0xAD,
  0x95, 0xB6, 0xB6, 0xB4, 0xD7, 0x9E, 0xF3, 0x9E, 0x73, 0x8E, 0x71, 0xCE,
  0x00, 0x38, 0x71, 0x86, 0x18, 0xC1, 0xDC, 0x0D, 0x80, 0xF0, 0x07, 0x00,
  0xE0, 0x0F, 0x01, 0xB0, 0x3B, 0x83, 0x18, 0x61, 0x8E, 0x1C, 0xC0, 0xF8,
  0x66, 0x39, 0x8C, 0x67, 0x0D, 0x83, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80,
  0xC0, 0x30, 0x0C, 0x00, 0x3F, 0xCF, 0xF0, 0x18, 0x0E, 0x03, 0x01, 0x80,
  0xE0, 0x70, 0x18, 0x0C, 0x07, 0x03, 0x80, 0xFF, 0x3F, 0xC0, 0x1F, 0x1F,
  0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x30, 0x70, 0x70, 0x60,
  0x60, 0x60, 0x7C, 0xFC, 0xC3, 0x0E, 0x18, 0x61, 0x86, 0x1C, 0x30, 0xC3,
  0x0E, 0x18, 0x61, 0x86, 0x1C, 0x30, 0x1F, 0x1F, 0x03, 0x03, 0x03, 0x07,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x7C, 0xFC,
  0x0C, 0x1E, 0x1E, 0x36, 0x66, 0x63, 0xC3, 0xC3, 0xFF, 0xFF, 0xC0, 0xC6,
  0x70, 0x0C, 0x0F, 0xF7, 0x39, 0x86, 0x61, 0xB8, 0x6E, 0x1B, 0x0E, 0xE3,
  0x3F, 0xC7, 0xB0, 0x30, 0x18, 0x0C, 0x0E, 0xC6, 0xFB, 0x9D, 0x86, 0xC3,
  0x61, 0xF0, 0xF0, 0xFC, 0x6F, 0xF6, 0xF0, 0x0E, 0x0F, 0xE7, 0x39, 0x86,
  0x60, 0x38, 0x0E, 0x03, 0x06, 0xE3, 0x1F, 0xC7, 0xE0, 0x00, 0xC0, 0x30,
  0x0C, 0x37, 0x3F, 0xDC, 0xE6, 0x19, 0x86, 0xE1, 0xB8, 0x6C, 0x3B, 0x8C,
  0xFF, 0x1E, 0xC0, 0x0E, 0x1F, 0xDC, 0x6C, 0x36, 0x1F, 0xFF, 0x01, 0x80,
  0xC3, 0xBF, 0x9F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0xC0, 0x06, 0x00, 0x30,
  0x0F, 0xF8, 0xFF, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0xF8, 0x00, 0x0C, 0x0F, 0xF7, 0x39,
  0x86, 0x61, 0xB8, 0x6E, 0x1B, 0x8E, 0xFF, 0x1F, 0xC0, 0x30, 0x0C, 0x0F,
  0x1F, 0x80, 0x30, 0x18, 0x0C, 0x0E, 0xC6, 0xFB, 0x9D, 0x86, 0xC3, 0x61,
  0xF0, 0xF0, 0xF8, 0x6C, 0x36, 0x18, 0x07, 0x03, 0x81, 0x80, 0x00, 0x01,
  0xF1, 0xF8, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC7, 0xFF, 0xFE, 0x00,
  0xC0, 0x70, 0x0C, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x06, 0x01, 0x80, 0xE0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x7E, 0x3F, 0x00, 0x30, 0x0C,
  0x03, 0x01, 0xC0, 0x61, 0xD8, 0xE6, 0x31, 0x98, 0x7E, 0x3F, 0x8E, 0x63,
  0x1C, 0xC3, 0x30, 0xE0, 0xF8, 0xF8, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x70, 0x3F, 0x3F, 0x04, 0xC7, 0xFC, 0xD9, 0xB3, 0x36,
  0x66, 0xCD, 0x99, 0x33, 0x26, 0x6C, 0xD9, 0x9B, 0x33, 0x00, 0x16, 0x37,
  0xDC, 0xEC, 0x36, 0x1B, 0x0F, 0x87, 0x87, 0xC3, 0x61, 0xB0, 0xC0, 0x0E,
  0x1F, 0xDC, 0xEC, 0x36, 0x1F, 0x0F, 0x87, 0x87, 0xE3, 0x7F, 0x9F, 0x80,
  0x0B, 0x0D, 0xF3, 0x9C, 0xC3, 0x30, 0xCC, 0x37, 0x0D, 0x87, 0x71, 0x9F,
  0xE6, 0xF1, 0x80, 0xE0, 0x38, 0x00, 0x0C, 0x0F, 0xF7, 0x39, 0x86, 0x61,
  0xB8, 0x6E, 0x1B, 0x0E, 0xE3, 0x3F, 0xC7, 0xB0, 0x0C, 0x03, 0x01, 0xC0,
  0x03, 0x0F, 0xE7, 0x1D, 0xC7, 0x61, 0xD8, 0x06, 0x01, 0x80, 0xE0, 0x30,
  0x0C, 0x00, 0x0E, 0x1F, 0xDC, 0x6C, 0x07, 0x03, 0xF8, 0x3E, 0x03, 0xC3,
  0xFF, 0x9F, 0x80, 0x0C, 0x03, 0x00, 0xC1, 0xFF, 0xFF, 0xC6, 0x01, 0x80,
  0x60, 0x18, 0x0E, 0x03, 0x80, 0xFC, 0x1F, 0x00, 0x71, 0xD8, 0x66, 0x19,
  0x86, 0x61, 0xB8, 0x6C, 0x3B, 0x8C, 0x7F, 0x1F, 0x80, 0xC1, 0xE1, 0xB0,
  0xD8, 0xC6, 0x63, 0x61, 0xB0, 0xF8, 0x78, 0x3C, 0x00, 0xCC, 0x79, 0x9B,
  0x33, 0x6E, 0x6D, 0x59, 0xAB, 0x3D, 0x67, 0x28, 0xE7, 0x1C, 0xE0, 0x38,
  0xE3, 0x38, 0x7E, 0x07, 0x80, 0xE0, 0x1C, 0x06, 0xC1, 0xD8, 0x71, 0x9C,
  0x38, 0x61, 0xD8, 0x66, 0x19, 0x86, 0xE1, 0xB8, 0xEE, 0x3B, 0xFC, 0x7B,
  0x00, 0xC0, 0x30, 0x3C, 0x7E, 0x00, 0x7F, 0xBF, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC1, 0xC1, 0xC0, 0xFF, 0x7F, 0x80, 0x01, 0xC1, 0xE0, 0x60, 0x38, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0xF8, 0x3E, 0x01, 0x80, 0x70, 0x18, 0x06, 0x01,
  0x80, 0xE0, 0x1E, 0x07, 0x80, 0x18, 0xC6, 0x31, 0x9C, 0xC6, 0x31, 0x8C,
  0xE7, 0x31, 0x8C, 0x67, 0x00, 0x1C, 0x07, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0xE0, 0x38, 0x07, 0xC1, 0xF0, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0,
  0x60, 0x78, 0x3C, 0x00, 0x38, 0xDF, 0x3C, 0xDF, 0x1E,
};

const GFXglyph JetBrainsMono_SemiBoldItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 14, 11, 3, -14 },
  { 10, 7, 6, 11, 3, -14 },
  { 16, 12, 14, 11, 0, -14 },
  { 37, 10, 20, 11, 1, -17 },
  { 62, 14, 14, 11, -1, -14 },
  { 87, 11, 14, 11, 0, -14 },
  { 107, 3, 6, 11, 5, -14 },
  { 110, 8, 18, 11, 3, -16 },
  { 128, 8, 18, 11, 1, -16 },
  { 146, 10, 10, 11, 1, -12 },
  { 159, 10, 9, 11, 1, -11 },
  { 171, 5, 6, 11, 2, -3 },
  { 175, 6, 2, 11, 3, -7 },
  { 177, 4, 3, 11, 3, -3 },
  { 179, 12, 18, 11, 0, -16 },
  { 206, 10, 14, 11, 1, -14 },
  { 224, 9, 14, 11, 1, -14 },
  { 240, 10, 14, 11, 1, -14 },
  { 258, 10, 14, 11, 1, -14 },
  { 276, 10, 14, 11, 1, -14 },
  { 294, 10, 14, 11, 1, -14 },
  { 312, 9, 14, 11, 1, -14 },
  { 328, 10, 14, 11, 2, -14 },
  { 346, 10, 14, 11, 1, -14 },
  { 364, 9, 14, 11, 2, -14 },
  { 380, 5, 11, 11, 3, -11 },
  { 387, 6, 14, 11, 2, -11 },
  { 398, 10, 10, 11, 1, -11 },
  { 411, 10, 7, 11, 1, -10 },
  { 420, 9, 10, 11, 1, -11 },
  { 432, 9, 14, 11, 2, -14 },
  { 448, 12, 17, 11, 0, -14 },
  { 474, 10, 14, 11, 0, -14 },
  { 492, 10, 14, 11, 1, -14 },
  { 510, 10, 14, 11, 1, -14 },
  { 528, 10, 14, 11, 1, -14 },
  { 546, 10, 14, 11, 1, -14 },
  { 564, 10, 14, 11, 1, -14 },
  { 582, 10, 14, 11, 1, -14 },
  { 600, 10, 14, 11, 1, -14 },
  { 618, 10, 14, 11, 1, -14 },
  { 636, 11, 14, 11, 0, -14 },
  { 656, 11, 14, 11, 1, -14 },
  { 676, 9, 14, 11, 1, -14 },
  { 692, 12, 14, 11, 0, -14 },
  { 713, 10, 14, 11, 1, -14 },
  { 731, 10, 14, 11, 1, -14 },
  { 749, 11, 14, 11, 1, -14 },
  { 769, 10, 17, 11, 1, -14 },
  { 791, 10, 14, 11, 1, -14 },
  { 809, 10, 14, 11, 1, -14 },
  { 827, 10, 14, 11, 2, -14 },
  { 845, 10, 14, 11, 1, -14 },
  { 863, 10, 14, 11, 2, -14 },
  { 881, 11, 14, 11, 1, -14 },
  { 901, 12, 14, 11, 0, -14 },
  { 922, 10, 14, 11, 2, -14 },
  { 940, 10, 14, 11, 1, -14 },
  { 958, 8, 18, 11, 2, -16 },
  { 976, 6, 18, 11, 3, -16 },
  { 990, 8, 18, 11, 1, -16 },
  { 1008, 8, 8, 11, 2, -14 },
  { 1016, 9, 2, 11, 0, 0 },
  { 1019, 4, 3, 11, 5, -15 },
  { 1021, 10, 11, 11, 1, -11 },
  { 1035, 9, 14, 11, 1, -14 },
  { 1051, 10, 11, 11, 1, -11 },
  { 1065, 10, 14, 11, 1, -14 },
  { 1083, 9, 11, 11, 1, -11 },
  { 1096, 13, 17, 11, -1, -14 },
  { 1124, 10, 14, 11, 1, -11 },
  { 1142, 9, 14, 11, 1, -14 },
  { 1158, 9, 15, 11, 1, -15 },
  { 1175, 10, 18, 11, 0, -15 },
  { 1198, 10, 14, 11, 1, -14 },
  { 1216, 8, 14, 11, 2, -14 },
  { 1230, 11, 11, 11, 0, -11 },
  { 1246, 9, 11, 11, 1, -11 },
  { 1259, 9, 11, 11, 1, -11 },
  { 1272, 10, 14, 11, 0, -11 },
  { 1290, 10, 14, 11, 1, -11 },
  { 1308, 10, 11, 11, 1, -11 },
  { 1322, 9, 11, 11, 1, -11 },
  { 1335, 10, 13, 11, 1, -13 },
  { 1352, 10, 10, 11, 1, -10 },
  { 1365, 9, 10, 11, 2, -10 },
  { 1377, 11, 10, 11, 1, -10 },
  { 1391, 11, 10, 11, 0, -10 },
  { 1405, 10, 13, 11, 1, -10 },
  { 1422, 9, 10, 11, 1, -10 },
  { 1434, 10, 18, 11, 2, -16 },
  { 1457, 5, 18, 11, 3, -16 },
  { 1469, 10, 18, 11, 0, -16 },
  { 1492, 10, 4, 11, 1, -9 },
};

const GFXfont JetBrainsMono_SemiBoldItalic19pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic19pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC19PT7B_H_
