#ifndef _JETBRAINSMONO_SEMIBOLDITALIC48PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xCF, 0x83, 0xF7, 0xE0,
  0xFD, 0xF8, 0x3E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xC1, 0xF9, 0xF0, 0x7E,
  0x7C, 0x1F, 0x1F, 0x07, 0xCF, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1E, 0x3E,
  0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01,
  0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xE0, 0x7C, 0x00,
  0x3C, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x7C, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0x01, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0,
  0x3C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x07, 0x80,
  0x07, 0xC0, 0xF8, 0x00, 0x78, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0x03, 0xE0,
  0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3C,
  0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0x80, 0xF0,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xE3, 0x9F, 0x83,
  0xF1, 0xC3, 0xE0, 0xFC, 0x70, 0xF8, 0x3E, 0x1C, 0x3E, 0x0F, 0x87, 0x00,
  0x03, 0xE1, 0xC0, 0x00, 0xFC, 0x70, 0x00, 0x3F, 0x38, 0x00, 0x0F, 0xEE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x1C, 0xFE, 0x00, 0x07, 0x1F, 0x80, 0x01, 0xC7, 0xE0, 0x00, 0xF0,
  0xF8, 0x00, 0x38, 0x3E, 0x3F, 0x0E, 0x1F, 0x8F, 0xC3, 0x87, 0xE3, 0xF0,
  0xE3, 0xF0, 0xFE, 0x39, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x07, 0xC0, 0x3F, 0xF0, 0x01, 0xE0, 0x1F, 0xFC, 0x00, 0xF0, 0x0F, 0x8F,
  0x80, 0x78, 0x03, 0xC1, 0xE0, 0x3C, 0x01, 0xE0, 0x78, 0x1E, 0x00, 0x78,
  0x1E, 0x0F, 0x80, 0x1E, 0x07, 0x87, 0xC0, 0x07, 0x83, 0xE1, 0xE0, 0x01,
  0xE0, 0xF0, 0xF0, 0x00, 0xF8, 0x3C, 0x78, 0x00, 0x1E, 0x1F, 0x3C, 0x00,
  0x07, 0xFF, 0x9E, 0x00, 0x01, 0xFF, 0xCF, 0x80, 0x00, 0x3F, 0xE7, 0xC0,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x0F,
  0x9F, 0xF0, 0x00, 0x07, 0xCF, 0xFE, 0x00, 0x01, 0xE7, 0xFF, 0x80, 0x00,
  0xF3, 0xE1, 0xF0, 0x00, 0x78, 0xF0, 0x3C, 0x00, 0x3C, 0x3C, 0x1F, 0x00,
  0x1E, 0x0F, 0x07, 0x80, 0x0F, 0x87, 0xC1, 0xE0, 0x07, 0xC1, 0xE0, 0x78,
  0x01, 0xE0, 0x78, 0x1E, 0x00, 0xF0, 0x1E, 0x0F, 0x80, 0x78, 0x07, 0xEF,
  0xC0, 0x3C, 0x00, 0xFF, 0xE0, 0x1F, 0x00, 0x3F, 0xF0, 0x0F, 0x80, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x9F, 0xFF, 0x03, 0xE3, 0xF3, 0xF0,
  0xFC, 0xFC, 0x3E, 0x3F, 0x1F, 0x87, 0xE7, 0xC3, 0xE0, 0x7D, 0xF8, 0x7C,
  0x0F, 0xFE, 0x0F, 0x80, 0xFF, 0x81, 0xF0, 0x1F, 0xE0, 0x7E, 0x01, 0xFC,
  0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x01, 0xFE, 0x07, 0xF0,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xEF, 0xC0, 0xFF, 0xF0, 0xFC,
  0x0F, 0xFC, 0x1F, 0x80, 0x3F, 0x3E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C,
  0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x03, 0x80,
  0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x01, 0x00, 0xF0,
  0x08, 0xF8, 0x3C, 0x1E, 0x7F, 0x0E, 0x1F, 0xDF, 0xF3, 0x9F, 0xFF, 0xFE,
  0xDF, 0xFC, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xF9, 0xF0,
  0x00, 0x7C, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0,
  0x7E, 0x01, 0xF0, 0x1F, 0x00, 0x38, 0x03, 0x00, 0x04, 0x00, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x0F, 0xE7, 0xF9, 0xFE, 0xFF, 0xBF, 0xE7, 0xF1, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF8, 0x7C,
  0x30, 0x7E, 0x3F, 0x3F, 0x1F, 0x0F, 0xCF, 0xC7, 0xC3, 0xE3, 0xF1, 0xF0,
  0xF8, 0xFC, 0x7C, 0x3E, 0x1E, 0x3F, 0x0F, 0x81, 0x0F, 0xC7, 0xE0, 0x03,
  0xE1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0,
  0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x07,
  0xE0, 0x1F, 0x81, 0xFF, 0x3F, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0x7C,
  0x03, 0xFC, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0x87, 0xE0, 0x1C, 0x0F, 0xC0,
  0x30, 0x1F, 0x80, 0x80, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7E, 0x03, 0xF8, 0x3F,
  0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x1F,
  0x8F, 0xC0, 0x0F, 0xC7, 0xF0, 0x0F, 0xC1, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x7E, 0x0F, 0xE0, 0x3E, 0x0F, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x87, 0xE0,
  0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF0, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0xFE, 0x00, 0x7D, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xE0, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC1, 0xFF,
  0x7F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE1, 0x80, 0x0F, 0xEF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x3F, 0xC0, 0xFE,
  0x3F, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFE, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7F, 0xCF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x7C,
  0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xE3, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0,
  0x0F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xE0, 0xFC,
  0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xF7, 0xF8, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x9F, 0x80, 0x0F,
  0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xFF, 0x9F,
  0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xF3, 0xFE, 0x3F, 0x80, 0x7E, 0x3F,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFE, 0x00, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xF3, 0xF0, 0x00, 0x87, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xE0, 0x3F, 0x83, 0xFC, 0x1F, 0xE1, 0xFF, 0x07, 0xF8,
  0x3F, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xF8, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03,
  0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x08, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0xF8, 0x7C, 0x07, 0xF3, 0xE1, 0xF0, 0x3F, 0xEF, 0x87, 0xC1, 0xFF, 0xFC,
  0x1E, 0x07, 0xC3, 0xF0, 0x78, 0x3E, 0x07, 0xC3, 0xE0, 0xF8, 0x1F, 0x0F,
  0x83, 0xC0, 0x7C, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x7C, 0x07, 0x83, 0xC1,
  0xF0, 0x1E, 0x0F, 0x07, 0xC0, 0xF8, 0x7C, 0x1F, 0x03, 0xE1, 0xF0, 0x78,
  0x0F, 0x87, 0xC3, 0xE0, 0x3E, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x3E, 0x07,
  0xC1, 0xE0, 0x7C, 0x3F, 0x07, 0x81, 0xFF, 0xBC, 0x3E, 0x07, 0xFC, 0xF0,
  0xF8, 0x0F, 0xE7, 0xC3, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x8F, 0x00,
  0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xF8,
  0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F,
  0x80, 0x7E, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x87, 0xE0,
  0x07, 0xC3, 0xF0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0x7C, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xF0, 0x0F, 0xE0, 0xFC,
  0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0,
  0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x1F,
  0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFC, 0x07, 0xF8, 0x3F, 0x00, 0x7E, 0x0F,
  0x80, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F,
  0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF8, 0x7C, 0x00,
  0xFC, 0x1F, 0x00, 0x7F, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xEF, 0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC7, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x8F, 0xC0, 0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xF8, 0x0F, 0xC1, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xF0, 0x1F, 0xE0, 0xFC, 0x03,
  0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8,
  0x00, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1,
  0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0x80,
  0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x01, 0xFC,
  0x1F, 0x01, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xEF,
  0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x8F, 0x80,
  0x0F, 0xC7, 0xC0, 0x07, 0xC7, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x87, 0xFF, 0x8F, 0xC3, 0xFF, 0xC7, 0xE1, 0xFF, 0xE3,
  0xE0, 0xFF, 0xF1, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x7C,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F,
  0x87, 0xE0, 0x0F, 0xC3, 0xF8, 0x0F, 0xC1, 0xFF, 0xBF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xE0, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x3F,
  0x07, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x3F, 0x00,
  0x3E, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x7E,
  0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x07, 0xC1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE0, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x1F, 0x83, 0xE0,
  0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x07,
  0xE0, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x3F, 0x00,
  0x7E, 0x0F, 0x80, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0xEF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x0F,
  0xE0, 0x7C, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x0F,
  0xC0, 0x0F, 0x81, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x01,
  0xF8, 0x7F, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x3F, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0,
  0x3E, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0xFC,
  0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07,
  0xE0, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xF0,
  0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x1E, 0xF0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8,
  0x3D, 0xE0, 0xFF, 0x83, 0xDE, 0x0F, 0x78, 0x39, 0xE0, 0xF3, 0x87, 0xBE,
  0x0F, 0x3C, 0x7B, 0xE0, 0xF3, 0xCF, 0x3E, 0x1F, 0x3C, 0xF3, 0xC1, 0xF3,
  0xDE, 0x7C, 0x1F, 0x3D, 0xE7, 0xC1, 0xF1, 0xDC, 0x7C, 0x1F, 0x1F, 0xC7,
  0xC1, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x8F, 0x83, 0xE1, 0xF8, 0xF8, 0x3E,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x83, 0xE0, 0x01,
  0xF8, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00,
  0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0,
  0xF8, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xF8, 0x1F,
  0xE0, 0x1F, 0x03, 0xFC, 0x03, 0xE0, 0xFF, 0x80, 0x7C, 0x1F, 0xF0, 0x0F,
  0x83, 0xFE, 0x03, 0xF0, 0x7F, 0xC0, 0x7C, 0x0F, 0xFC, 0x0F, 0x81, 0xEF,
  0x81, 0xF0, 0x7D, 0xF0, 0x3E, 0x0F, 0x9E, 0x07, 0xC1, 0xF3, 0xC1, 0xF8,
  0x3E, 0x7C, 0x3E, 0x07, 0xCF, 0x87, 0xC0, 0xF9, 0xF0, 0xF8, 0x1F, 0x1E,
  0x1F, 0x07, 0xC3, 0xC3, 0xE0, 0xF8, 0x7C, 0xFC, 0x1F, 0x0F, 0x9F, 0x03,
  0xE1, 0xF3, 0xE0, 0x7C, 0x1E, 0x7C, 0x0F, 0x83, 0xCF, 0x83, 0xF0, 0x7D,
  0xF0, 0x7C, 0x0F, 0xBE, 0x0F, 0x81, 0xF7, 0xC1, 0xF0, 0x1E, 0xF0, 0x3E,
  0x03, 0xDE, 0x07, 0xC0, 0x7F, 0xC1, 0xF8, 0x0F, 0xF8, 0x3E, 0x01, 0xFF,
  0x07, 0xC0, 0x3F, 0xE0, 0xF8, 0x03, 0xF8, 0x1F, 0x00, 0x7F, 0x03, 0xE0,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xEF, 0xF8, 0x3F, 0x01,
  0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0,
  0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xE0, 0x03, 0xE1,
  0xF0, 0x01, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E,
  0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F,
  0xC3, 0xF8, 0x0F, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x03,
  0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xE0, 0xF8,
  0x01, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0x3F, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F,
  0x83, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x80,
  0x1F, 0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC,
  0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xE1, 0xF8, 0x00,
  0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x07, 0xE1, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x1F, 0x81,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x83, 0xF0, 0x0F, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7C,
  0x03, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0x7C,
  0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x80, 0xF8, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0x3F, 0xE0,
  0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x03,
  0xE0, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE3, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x1F, 0xC1, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x00,
  0x1F, 0x03, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83,
  0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x03,
  0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x3F,
  0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x03, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x3F, 0x00,
  0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xCF,
  0x80, 0x07, 0xE7, 0xC0, 0x03, 0xF3, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF8,
  0xFC, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x7E,
  0x0F, 0xC0, 0x3F, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x83,
  0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC,
  0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07,
  0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0xF9, 0xF0, 0x3E, 0x07, 0xCF,
  0x81, 0xF0, 0x3E, 0x7C, 0x1F, 0x81, 0xE3, 0xE0, 0xFC, 0x1F, 0x1F, 0x07,
  0xE0, 0xF8, 0xF8, 0x3F, 0x07, 0xC7, 0xC3, 0xB8, 0x3C, 0x3E, 0x1D, 0xC3,
  0xE1, 0xE0, 0xEE, 0x1F, 0x0F, 0x0F, 0x70, 0xF8, 0x78, 0x73, 0x87, 0x83,
  0xC3, 0x9C, 0x7C, 0x1E, 0x1C, 0xE3, 0xE0, 0xF1, 0xC7, 0x1E, 0x0F, 0x8E,
  0x38, 0xF0, 0x7C, 0x71, 0xCF, 0x83, 0xE7, 0x9E, 0x7C, 0x1F, 0x38, 0xF3,
  0xC0, 0xF9, 0xC7, 0x1E, 0x07, 0xCE, 0x39, 0xF0, 0x3E, 0xF1, 0xCF, 0x81,
  0xF7, 0x0E, 0x78, 0x0F, 0xB8, 0x73, 0xC0, 0x79, 0xC3, 0xBE, 0x03, 0xDC,
  0x1D, 0xF0, 0x1E, 0xE0, 0xEF, 0x00, 0xF7, 0x07, 0x78, 0x07, 0xF8, 0x3F,
  0xC0, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00,
  0x7F, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x03,
  0xF1, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x83, 0xE0,
  0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0xFC, 0x01,
  0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x03, 0xE3, 0xF0,
  0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3F, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xEF, 0x00,
  0x1F, 0x3C, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x87, 0x80, 0x7C,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x03, 0xC3, 0xF0, 0x0F,
  0x8F, 0x80, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0xCF, 0xC0, 0xFF, 0xF7, 0xE0, 0xFF, 0xFB,
  0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x00,
  0x7E, 0x1F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0x87, 0xE0,
  0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xFC,
  0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x3F, 0x0F,
  0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFF, 0x3F, 0xF0,
  0xFF, 0xFD, 0xF0, 0x3F, 0xFE, 0xF8, 0x0F, 0xFE, 0x7C, 0x03, 0xFC, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC3, 0xE0, 0x0F, 0x8F, 0xF8, 0x0F, 0x9F, 0xFC, 0x1F, 0xBF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0, 0x7F, 0x1F, 0x80,
  0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00,
  0x3F, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7F, 0x01, 0xF8, 0xFF, 0xCF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFD, 0xFF, 0xE0, 0xFD, 0xFF, 0xC0, 0xF8, 0xFF, 0x80, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x1F, 0xC1, 0xFE, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3E, 0x00,
  0x3E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x01,
  0xF8, 0xFE, 0x03, 0xF8, 0xFF, 0xDF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x1F,
  0x80, 0x7F, 0xE7, 0xE0, 0x3F, 0xFD, 0xF8, 0x1F, 0xFF, 0x7E, 0x0F, 0xFF,
  0xFF, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x1F,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xF8,
  0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0xE1, 0xF8, 0x01,
  0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0xFF, 0xC0,
  0xFF, 0xFB, 0xE0, 0x3F, 0xFE, 0xF8, 0x07, 0xFF, 0x3E, 0x00, 0xFF, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F, 0x9F, 0x00, 0x3F,
  0x3E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x1F, 0x9F, 0x80, 0x3E, 0x3F, 0x81, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xFF, 0x3F, 0x07, 0xFF, 0xBF, 0x0F, 0xFF, 0xBF, 0x1F, 0xFF, 0xFE,
  0x1F, 0xC1, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0xDF, 0xF8,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFD, 0xF8, 0x3F, 0xF9, 0xF0, 0x0F, 0xF1, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xE0,
  0x0F, 0x8F, 0xF8, 0x0F, 0xBF, 0xFC, 0x1F, 0xBF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x1F, 0xE0, 0xFF, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F,
  0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E,
  0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0xFC,
  0x7C, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8,
  0xFC, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x21,
  0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0xC1, 0xF8, 0x07,
  0xF0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F,
  0x03, 0xF8, 0x03, 0xE0, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0x80,
  0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0x83,
  0xF0, 0x03, 0xF8, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x1E, 0x0F, 0x01, 0xE7, 0xE7, 0xF0, 0x7D, 0xFC, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x78, 0x3E, 0x3E, 0x0F, 0x07, 0xC7, 0xC1, 0xE0, 0xF8, 0xF8, 0x3C,
  0x1F, 0x1F, 0x07, 0x83, 0xE3, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F,
  0x87, 0x83, 0xE3, 0xE0, 0xF0, 0x7C, 0x7C, 0x1E, 0x0F, 0x8F, 0x83, 0xC1,
  0xF1, 0xF0, 0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xF1, 0xF0,
  0x78, 0x3E, 0x3E, 0x0F, 0x07, 0xC7, 0xC1, 0xE0, 0xF8, 0xF8, 0x3C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x0F,
  0x8F, 0xF8, 0x0F, 0xBF, 0xFC, 0x1F, 0xBF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F,
  0xE0, 0xFF, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x3F,
  0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3F,
  0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC,
  0x00, 0xF8, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0,
  0x3F, 0x9F, 0x80, 0x3F, 0x3E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01,
  0xFB, 0xF0, 0x03, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0xBF, 0x00, 0x3F,
  0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xE7,
  0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0xC0, 0x7E, 0x3F, 0xF7, 0xFC, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0xFF, 0x80, 0x3E, 0x7F, 0xF0, 0x1F, 0xBF, 0xFE,
  0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0x80,
  0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF8,
  0x3E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01,
  0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x1F, 0x83, 0xFF,
  0x3F, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0x7F, 0xF8, 0x0F, 0xDF, 0xFC, 0x03,
  0xE3, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0xCF, 0xC0, 0xFF, 0xF7, 0xE0, 0xFF, 0xFB, 0xF0, 0xFF, 0xFD, 0xF0,
  0x7F, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xE0, 0x03,
  0xE1, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x7E, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0,
  0x1F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFF, 0x3F, 0xF0, 0xFF, 0xFD, 0xF0, 0x3F,
  0xFE, 0xF8, 0x0F, 0xFE, 0x7C, 0x03, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x07, 0xCF, 0xFC, 0x07, 0xEF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC1, 0xF7, 0xFF, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x3F,
  0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x07, 0xE3, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFF, 0x03, 0xFC, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xF8,
  0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x8F, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x03,
  0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x3F, 0x00,
  0x3E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x87, 0xF0, 0x3F, 0x81, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xBE, 0x00, 0x1F, 0x9F, 0x00, 0x1F,
  0x8F, 0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03,
  0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0,
  0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x7E, 0x00, 0x7C,
  0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0xCF, 0x80, 0x07,
  0xEF, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xF8, 0x1F, 0x03, 0xFF, 0x07, 0xE0, 0x7B, 0xE0, 0xFC, 0x1F, 0x7C,
  0x1F, 0x83, 0xEF, 0x83, 0xF0, 0x79, 0xF0, 0xEE, 0x1F, 0x3E, 0x1D, 0xC3,
  0xE7, 0xC3, 0xB8, 0x78, 0xF8, 0xE7, 0x1F, 0x1F, 0x1C, 0xE3, 0xE3, 0xE3,
  0x9C, 0x78, 0x7C, 0xE3, 0x8F, 0x0F, 0x9C, 0x73, 0xE1, 0xF3, 0x8E, 0x78,
  0x3C, 0xE1, 0xCF, 0x07, 0x9C, 0x3B, 0xE0, 0xF3, 0x87, 0x78, 0x1E, 0xF0,
  0xEF, 0x03, 0xDC, 0x1F, 0xE0, 0x7B, 0x83, 0xF8, 0x0F, 0x70, 0x7F, 0x01,
  0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x0F,
  0xE0, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0xFE,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x7F, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF8,
  0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E,
  0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0xFC,
  0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFD, 0xF8, 0x3F, 0xFD, 0xF0, 0x3F, 0xF9, 0xF0, 0x0F, 0xE1, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xC7, 0xFE, 0x01, 0xE3,
  0xFF, 0xC0, 0xF8, 0xFF, 0xF8, 0x3E, 0x7E, 0x7F, 0x0F, 0x9F, 0x0F, 0xC7,
  0xE7, 0xC1, 0xFF, 0xF1, 0xF0, 0x3F, 0xFC, 0x78, 0x0F, 0xFE, 0x3E, 0x01,
  0xFE, 0x00, 0x00, 0x04, 0x00,
};

const GFXglyph JetBrainsMono_SemiBoldItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 12, 35, 29, 9, -35 },
  { 54, 18, 14, 29, 8, -35 },
  { 86, 28, 35, 29, 1, -35 },
  { 209, 26, 49, 29, 2, -42 },
  { 369, 34, 35, 29, -2, -35 },
  { 518, 27, 36, 29, 1, -36 },
  { 640, 8, 14, 29, 13, -35 },
  { 654, 21, 47, 29, 7, -41 },
  { 778, 21, 47, 29, 2, -41 },
  { 902, 26, 25, 29, 2, -29 },
  { 984, 24, 23, 29, 3, -27 },
  { 1053, 14, 15, 29, 4, -7 },
  { 1080, 17, 5, 29, 6, -18 },
  { 1091, 10, 8, 29, 8, -8 },
  { 1101, 30, 45, 29, 0, -40 },
  { 1270, 26, 36, 29, 2, -36 },
  { 1387, 23, 35, 29, 2, -35 },
  { 1488, 26, 36, 29, 2, -36 },
  { 1605, 25, 35, 29, 2, -35 },
  { 1715, 25, 35, 29, 2, -35 },
  { 1825, 25, 35, 29, 2, -35 },
  { 1935, 24, 35, 29, 2, -35 },
  { 2040, 24, 35, 29, 5, -35 },
  { 2145, 25, 36, 29, 2, -36 },
  { 2258, 24, 36, 29, 4, -36 },
  { 2366, 13, 27, 29, 8, -27 },
  { 2410, 17, 35, 29, 4, -27 },
  { 2485, 24, 26, 29, 4, -29 },
  { 2563, 24, 17, 29, 3, -24 },
  { 2614, 24, 26, 29, 2, -29 },
  { 2692, 21, 35, 29, 6, -35 },
  { 2784, 30, 45, 29, 0, -36 },
  { 2953, 25, 35, 29, 0, -35 },
  { 3063, 26, 35, 29, 2, -35 },
  { 3177, 25, 36, 29, 3, -36 },
  { 3290, 26, 35, 29, 2, -35 },
  { 3404, 27, 35, 29, 2, -35 },
  { 3523, 27, 35, 29, 2, -35 },
  { 3642, 25, 36, 29, 3, -36 },
  { 3755, 26, 35, 29, 2, -35 },
  { 3869, 26, 35, 29, 2, -35 },
  { 3983, 28, 35, 29, 0, -35 },
  { 4106, 28, 35, 29, 2, -35 },
  { 4229, 21, 35, 29, 3, -35 },
  { 4321, 28, 35, 29, 1, -35 },
  { 4444, 27, 35, 29, 2, -35 },
  { 4563, 25, 36, 29, 3, -36 },
  { 4676, 27, 35, 29, 2, -35 },
  { 4795, 26, 45, 29, 2, -36 },
  { 4942, 26, 35, 29, 2, -35 },
  { 5056, 26, 36, 29, 2, -36 },
  { 5173, 25, 35, 29, 5, -35 },
  { 5283, 27, 35, 29, 2, -35 },
  { 5402, 25, 35, 29, 5, -35 },
  { 5512, 29, 35, 29, 2, -35 },
  { 5639, 31, 35, 29, -1, -35 },
  { 5775, 26, 35, 29, 5, -35 },
  { 5889, 26, 35, 29, 2, -35 },
  { 6003, 20, 45, 29, 6, -40 },
  { 6116, 16, 45, 29, 7, -40 },
  { 6206, 20, 45, 29, 4, -40 },
  { 6319, 22, 19, 29, 4, -35 },
  { 6372, 24, 5, 29, 0, 1 },
  { 6387, 10, 7, 29, 12, -38 },
  { 6396, 25, 27, 29, 2, -27 },
  { 6481, 24, 35, 29, 2, -35 },
  { 6586, 24, 27, 29, 3, -27 },
  { 6667, 26, 35, 29, 2, -35 },
  { 6781, 23, 27, 29, 3, -27 },
  { 6859, 33, 44, 29, -3, -35 },
  { 7041, 24, 36, 29, 3, -27 },
  { 7149, 24, 35, 29, 2, -35 },
  { 7254, 23, 38, 29, 2, -38 },
  { 7364, 26, 47, 29, 0, -38 },
  { 7517, 27, 35, 29, 2, -35 },
  { 7636, 21, 35, 29, 4, -35 },
  { 7728, 27, 27, 29, 1, -27 },
  { 7820, 24, 27, 29, 2, -27 },
  { 7901, 23, 27, 29, 3, -27 },
  { 7979, 26, 36, 29, 0, -27 },
  { 8096, 25, 36, 29, 2, -27 },
  { 8209, 25, 27, 29, 3, -27 },
  { 8294, 24, 27, 29, 2, -27 },
  { 8375, 24, 34, 29, 3, -34 },
  { 8477, 25, 26, 29, 2, -26 },
  { 8559, 25, 26, 29, 4, -26 },
  { 8641, 27, 26, 29, 3, -26 },
  { 8729, 28, 26, 29, 0, -26 },
  { 8820, 24, 35, 29, 3, -26 },
  { 8925, 24, 26, 29, 2, -26 },
  { 9003, 25, 45, 29, 4, -40 },
  { 9144, 12, 45, 29, 9, -40 },
  { 9212, 25, 45, 29, 1, -40 },
  { 9353, 26, 11, 29, 2, -22 },
};

const GFXfont JetBrainsMono_SemiBoldItalic48pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic48pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic48pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC48PT7B_H_
