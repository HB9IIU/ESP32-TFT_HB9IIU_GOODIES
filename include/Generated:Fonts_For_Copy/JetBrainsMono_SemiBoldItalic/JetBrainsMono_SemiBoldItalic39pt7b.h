#ifndef _JETBRAINSMONO_SEMIBOLDITALIC39PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x7C, 0x3F, 0x8F, 0xC1, 0xF0,
  0x7C, 0x7D, 0xE1, 0xFF, 0x87, 0xFE, 0x1E, 0xF8, 0x7B, 0xE3, 0xEF, 0x0F,
  0xBC, 0x3E, 0xF0, 0xF3, 0xC3, 0xCE, 0x0F, 0x00, 0x00, 0x38, 0x3C, 0x00,
  0xF0, 0x78, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1C,
  0x0E, 0x00, 0x78, 0x3C, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0x0F, 0x07, 0x80, 0x1C, 0x0E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78,
  0x01, 0xC0, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1C, 0x0E, 0x03,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x07, 0x83, 0xC0, 0x0F,
  0x07, 0x80, 0x1C, 0x0E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x70, 0x01, 0xC0,
  0xE0, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFE,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xB7, 0xE0, 0xF8, 0xCF, 0x83,
  0xE7, 0x1E, 0x0F, 0x1C, 0x78, 0x3C, 0x70, 0x01, 0xF1, 0x80, 0x03, 0xE6,
  0x00, 0x0F, 0xD8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1C, 0xFC, 0x00,
  0x71, 0xF0, 0x01, 0xC7, 0xC7, 0x86, 0x1E, 0x1E, 0x18, 0x78, 0x7C, 0x63,
  0xE1, 0xF1, 0x9F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x10, 0x1F, 0xC0, 0x0E,
  0x03, 0xFE, 0x01, 0xE0, 0x78, 0xF0, 0x3C, 0x07, 0x0F, 0x07, 0x80, 0xF0,
  0xF0, 0xF0, 0x0F, 0x0F, 0x0E, 0x00, 0xF0, 0xE1, 0xC0, 0x0E, 0x0E, 0x38,
  0x00, 0xF1, 0xE7, 0x80, 0x0F, 0xFC, 0xF0, 0x00, 0x7F, 0xDE, 0x00, 0x03,
  0xF3, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xDF, 0xE0, 0x00, 0x7B, 0xFF, 0x00,
  0x0F, 0x3C, 0x70, 0x00, 0xE7, 0x87, 0x00, 0x1C, 0x70, 0x70, 0x03, 0x87,
  0x07, 0x00, 0x78, 0x70, 0x70, 0x0F, 0x07, 0x07, 0x01, 0xE0, 0x70, 0xF0,
  0x3C, 0x07, 0xFE, 0x03, 0x80, 0x7F, 0xC0, 0xF0, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xC3,
  0xE0, 0x1E, 0x07, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0x7C, 0xF8, 0xF9, 0xE1, 0xE7,
  0xC7, 0x87, 0xDE, 0x1E, 0x0F, 0xF0, 0xF8, 0x3F, 0xC3, 0xE0, 0x7E, 0x0F,
  0x01, 0xF0, 0x3C, 0x07, 0xE0, 0xF8, 0x3F, 0x83, 0xFB, 0xFF, 0x07, 0xFF,
  0xBC, 0x1F, 0xFC, 0xF8, 0x3F, 0xC1, 0xF0, 0x7D, 0xE7, 0xBE, 0xFB, 0xEF,
  0xBC, 0xF3, 0xCF, 0x00, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0xFF, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0x40, 0x02, 0x00, 0x03, 0xC0,
  0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x10, 0x3C, 0x09, 0xE1, 0xC1, 0xCF, 0xCE, 0x3E, 0xFF, 0x77, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xDE,
  0x00, 0x3E, 0xF8, 0x03, 0xE3, 0xC0, 0x1E, 0x1F, 0x01, 0xF0, 0xF8, 0x1F,
  0x03, 0xE0, 0x30, 0x1C, 0x00, 0x80, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xC1, 0xF8,
  0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x00, 0x7F, 0xFD,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFC,
  0x3F, 0x0F, 0x80, 0xF8, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x3E, 0x00, 0xF1,
  0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xE3, 0xC7, 0x1F, 0x1E, 0x78,
  0xF1, 0xF3, 0xE7, 0x8F, 0x9F, 0x3C, 0x78, 0xF1, 0xE3, 0xC0, 0x1F, 0x1E,
  0x00, 0xF8, 0xF0, 0x07, 0x8F, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xE0, 0x1F,
  0x1F, 0x00, 0xF0, 0xFC, 0x0F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x1F, 0xDE, 0x07, 0xC7, 0x81, 0xE3, 0xE0, 0x60, 0xF8, 0x10,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x07,
  0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7E, 0x1F, 0x87, 0xC0, 0x7C,
  0x3C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0xF8, 0x07, 0xCF, 0x00, 0x7C, 0xF8, 0x0F, 0x8F, 0x80,
  0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x83, 0xE1, 0xF0, 0x3E, 0x3E, 0x03,
  0xC7, 0xC0, 0x3C, 0x78, 0x07, 0xC7, 0x80, 0x7C, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x1E, 0xFF,
  0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xF0, 0xFC, 0x3E, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0x8F, 0xC0, 0xF8, 0x7F, 0xFF, 0x07,
  0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x20, 0x0F, 0xBF, 0x83,
  0xEF, 0xFC, 0x7F, 0xFF, 0x9F, 0xC3, 0xFB, 0xE0, 0x1F, 0x78, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xBE,
  0x01, 0xF7, 0xE0, 0x7C, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF0, 0x07,
  0xF8, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x78, 0x03, 0xEF, 0x80, 0x3C, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xC3,
  0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xF1, 0xE0,
  0x1E, 0x1F, 0x03, 0xE1, 0xF8, 0x7C, 0x0F, 0xDF, 0x80, 0x7F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0x9F, 0x83, 0xE0, 0xFC, 0x7C, 0x07, 0xC7,
  0x80, 0x3C, 0xF8, 0x03, 0xCF, 0x80, 0x3C, 0xF8, 0x07, 0xCF, 0x80, 0x7C,
  0xFC, 0x0F, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F,
  0x87, 0xE3, 0xE0, 0x3E, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x78, 0x01, 0xF7,
  0x80, 0x1F, 0x78, 0x01, 0xEF, 0x80, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7C,
  0x7F, 0xBF, 0xC3, 0xFF, 0xF8, 0x3F, 0xEF, 0x80, 0xFD, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x07, 0xE1, 0xFC, 0xFE, 0x3F, 0x87, 0xC0, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x1F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x00, 0x00, 0xE0, 0x1F, 0x80, 0xFE, 0x0F,
  0xE0, 0x7F, 0x01, 0xF0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x03,
  0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80,
  0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x03,
  0xE0, 0x00, 0x60, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F,
  0xFF, 0x87, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC1, 0xFF, 0xC0, 0xFF,
  0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFD, 0xFE, 0x07, 0xE0, 0x3E, 0x07, 0x80,
  0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x1C, 0x07, 0xCE, 0x3C, 0x1F, 0xEE, 0x3C, 0x1F, 0xEE, 0x3C, 0x3C,
  0x3E, 0x3C, 0x3C, 0x1E, 0x3C, 0x78, 0x1E, 0x3C, 0x78, 0x1C, 0x78, 0x78,
  0x3C, 0x78, 0x78, 0x3C, 0x78, 0x78, 0x3C, 0x78, 0x70, 0x3C, 0x78, 0xF0,
  0x3C, 0x78, 0xF0, 0x78, 0x70, 0x78, 0x78, 0xF0, 0x7F, 0xB8, 0xF0, 0x7F,
  0x38, 0xF0, 0x1E, 0x40, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xBC, 0x00, 0x7B,
  0xC0, 0x0F, 0xBC, 0x00, 0xF3, 0xC0, 0x1F, 0x3C, 0x01, 0xE3, 0xE0, 0x1E,
  0x3E, 0x03, 0xE1, 0xE0, 0x3C, 0x1E, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3,
  0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x83, 0xE0, 0xFE, 0x0F, 0x80, 0xF8, 0x3C, 0x03, 0xE0, 0xF0, 0x07,
  0x83, 0xC0, 0x1E, 0x0F, 0x00, 0xF8, 0x7C, 0x03, 0xC1, 0xF0, 0x1F, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0x81,
  0xF8, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x7C,
  0x3C, 0x01, 0xF1, 0xF0, 0x07, 0x87, 0xC0, 0x3E, 0x1F, 0x01, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFC, 0x3F, 0x0F,
  0x80, 0xF8, 0x7C, 0x03, 0xC3, 0xC0, 0x1E, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x01, 0xE3, 0xE0, 0x1F, 0x1F, 0x00,
  0xF8, 0x7C, 0x0F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x0F, 0x81, 0xF8, 0x3C, 0x03, 0xE0, 0xF0, 0x0F, 0x83, 0xC0,
  0x1E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E,
  0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xE0, 0x0F, 0x0F, 0x80, 0x7C, 0x3E,
  0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x03,
  0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x1F, 0x07, 0xF0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x20, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFC, 0x3F, 0x0F, 0x80, 0xF8, 0x7C, 0x03,
  0xC3, 0xC0, 0x1E, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0xFF, 0x8F, 0x8F, 0xFC,
  0x7C, 0x7F, 0xE3, 0xE3, 0xFF, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0xC7, 0x80,
  0x3C, 0x7C, 0x01, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0x7C, 0x0F, 0x83,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xC0, 0x7C, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1E, 0x0F, 0x80,
  0x78, 0x3E, 0x01, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x3E, 0x0F, 0x00, 0xF8,
  0x7C, 0x03, 0xC1, 0xF0, 0x0F, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xE0, 0xF8, 0x07,
  0x83, 0xE0, 0x3E, 0x0F, 0x00, 0xF8, 0x3C, 0x03, 0xE1, 0xF0, 0x0F, 0x87,
  0xC0, 0x3C, 0x1F, 0x00, 0xF0, 0x7C, 0x03, 0xC1, 0xE0, 0x1F, 0x07, 0x80,
  0x7C, 0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0xF8,
  0x3F, 0x03, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0x80, 0x3F, 0x07, 0x80, 0x7C, 0x0F, 0x80, 0x7C,
  0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x03, 0xE0,
  0x0F, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x3E, 0x1E, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3C, 0x0F, 0x00,
  0x3C, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x7C, 0x07, 0x80, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x03, 0xE0, 0x78, 0x03, 0xE0,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFE, 0x0F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC,
  0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x1D, 0xC3, 0xF8, 0x7F, 0x87,
  0xB8, 0xEF, 0x0F, 0x71, 0xDE, 0x1E, 0xE7, 0x38, 0x39, 0xCE, 0xF0, 0xF3,
  0xB9, 0xE1, 0xE7, 0x73, 0xC3, 0xCE, 0xE7, 0x87, 0x8F, 0x9F, 0x0F, 0x1F,
  0x3C, 0x1E, 0x3C, 0x78, 0x7C, 0x00, 0xF0, 0xF8, 0x01, 0xE1, 0xE0, 0x03,
  0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78,
  0x7C, 0x00, 0xF0, 0xF8, 0x01, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x87,
  0x80, 0x1E, 0x00, 0x07, 0xE0, 0x3C, 0x3F, 0x80, 0xF0, 0xFE, 0x03, 0xC3,
  0xF8, 0x1F, 0x0F, 0xE0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xBC,
  0x1E, 0x1E, 0xF0, 0x78, 0x79, 0xC3, 0xE1, 0xE7, 0x0F, 0x07, 0x9E, 0x3C,
  0x1E, 0x78, 0xF0, 0x79, 0xE3, 0xC3, 0xE3, 0x8F, 0x0F, 0x0E, 0x7C, 0x3C,
  0x3D, 0xF0, 0xF0, 0xF7, 0x83, 0xC3, 0xDE, 0x0F, 0x0F, 0x78, 0x7C, 0x1D,
  0xE1, 0xE0, 0x7F, 0x87, 0x81, 0xFE, 0x1E, 0x07, 0xF0, 0x78, 0x1F, 0xC1,
  0xE0, 0x3F, 0x07, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x1F,
  0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xC3, 0xF1, 0xF0, 0x1F, 0x1F,
  0x01, 0xF1, 0xE0, 0x0F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3,
  0xE0, 0x1F, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xE7, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03,
  0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0x7C, 0x0F, 0x87, 0xFF,
  0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xF8, 0x0F, 0xC1,
  0xF0, 0x0F, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xC1, 0xE0, 0x3F, 0x83, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFC, 0x3F, 0x0F, 0x80, 0xF8, 0x7C, 0x03,
  0xC3, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x78,
  0x03, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF1, 0xF0, 0x07, 0x8F, 0x80, 0x7C,
  0x7C, 0x03, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0x8F, 0x80,
  0x3C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF0, 0xFC, 0x0F, 0x83,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0x80, 0xFC, 0x3E, 0x01, 0xF0, 0xF0, 0x07,
  0xC3, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xE1, 0xF0, 0x0F, 0x87,
  0xC0, 0x7C, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFE, 0x00, 0xF8, 0x78, 0x03, 0xC1, 0xF0, 0x0F, 0x07, 0xC0,
  0x3C, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x78,
  0x07, 0xC1, 0xE0, 0x1F, 0x07, 0x80, 0x3C, 0x3E, 0x00, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xE1, 0xF8,
  0x3E, 0x03, 0xE0, 0xF8, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF1, 0xE0, 0x07, 0x87, 0x80,
  0x1E, 0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x78, 0xF8, 0x07,
  0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0x78,
  0x03, 0xC3, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x78,
  0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80,
  0x7C, 0x7C, 0x03, 0xE3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x8F,
  0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x0F, 0x81, 0xF0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0xFB,
  0xC0, 0x0F, 0x9E, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01,
  0xE1, 0xE0, 0x1F, 0x0F, 0x80, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F,
  0x03, 0xC0, 0xF8, 0x3E, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0xF8,
  0x07, 0x87, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x79,
  0xE0, 0x03, 0xEF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x78,
  0x3E, 0x1F, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x7C, 0x1C, 0x78,
  0x7C, 0x3C, 0x78, 0x6C, 0x3C, 0x78, 0x6C, 0x3C, 0x78, 0xEC, 0x38, 0x78,
  0xEC, 0x78, 0x78, 0xCC, 0x78, 0x79, 0xCC, 0x78, 0x79, 0xDC, 0x70, 0x79,
  0x9C, 0xF0, 0x71, 0x9C, 0xF0, 0x73, 0x9C, 0xE0, 0x73, 0x9C, 0xE0, 0x73,
  0x1D, 0xE0, 0x77, 0x1D, 0xE0, 0xF7, 0x1D, 0xC0, 0xF7, 0x1D, 0xC0, 0xF6,
  0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1B, 0x80, 0xFC, 0x1B, 0x80, 0xFC,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0x1E, 0x03, 0xE0, 0x07, 0xC0, 0xF8,
  0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xE7,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x7C,
  0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0x1E, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x03,
  0xE0, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0x9E,
  0x00, 0x78, 0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x1E, 0x03, 0xC0, 0xF8, 0x3E,
  0x07, 0xC3, 0xE0, 0x1E, 0x1F, 0x00, 0xF1, 0xF0, 0x07, 0xCF, 0x00, 0x3E,
  0xF8, 0x00, 0xF7, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03,
  0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xDE, 0x00,
  0xF3, 0x80, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x0F, 0x07, 0xC1, 0xE1, 0xE0,
  0x78, 0xF0, 0x1E, 0x7C, 0x07, 0x9E, 0x00, 0xFF, 0x80, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x78, 0x7C, 0x3C,
  0x1E, 0x1F, 0x01, 0xF0, 0x00, 0x7F, 0xDF, 0x0F, 0xFD, 0xF1, 0xFF, 0xFE,
  0x1F, 0x87, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xC0, 0x3E, 0x7C, 0x03,
  0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07, 0xC7, 0x80,
  0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0x8F, 0xC1, 0xF8, 0x7F,
  0xF7, 0x87, 0xFF, 0x78, 0x3F, 0xEF, 0x81, 0xFC, 0xF8, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x0F, 0x00, 0xF3, 0xFC, 0x1F, 0x7F, 0xE1, 0xFF, 0xFF, 0x1F, 0xC3,
  0xF1, 0xF8, 0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xF3, 0xE0,
  0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C,
  0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xC7, 0xE0, 0x7C, 0x7B, 0xFF, 0x87,
  0xBF, 0xF8, 0x7B, 0xFF, 0x0F, 0x9F, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x87, 0xE3, 0xE0, 0x3E, 0x3E, 0x01,
  0xE3, 0xC0, 0x1E, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0xF8,
  0x07, 0xC7, 0xC0, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x07, 0xC7, 0xC0, 0xFF, 0xBE, 0x0F,
  0xFD, 0xF0, 0xFF, 0xFF, 0x87, 0xE1, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E,
  0x1E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xC3, 0xC0,
  0x1E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3,
  0xE0, 0x3E, 0x1F, 0x83, 0xF0, 0x7F, 0xF7, 0x83, 0xFF, 0xBC, 0x0F, 0xFB,
  0xE0, 0x3F, 0x9F, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x07,
  0xFF, 0xE1, 0xF0, 0x7E, 0x7C, 0x07, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x7C,
  0x03, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0x80, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xCF, 0x01, 0xF1, 0xF8,
  0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F,
  0xDF, 0x0F, 0xFD, 0xF1, 0xFF, 0xFE, 0x1F, 0x87, 0xE3, 0xE0, 0x3E, 0x3E,
  0x03, 0xE3, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xC7,
  0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0xC7, 0xC0, 0xFC,
  0x7E, 0x1F, 0x87, 0xFF, 0x78, 0x3F, 0xF7, 0x81, 0xFE, 0xF8, 0x07, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x03, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x0F, 0x00, 0xF3, 0xFC, 0x1F, 0x7F, 0xE1, 0xFF, 0xFF, 0x1F, 0xC3,
  0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xF3, 0xE0,
  0x1F, 0x3E, 0x01, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x3E, 0x3C,
  0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x03, 0xC7,
  0x80, 0x7C, 0x78, 0x07, 0xCF, 0x80, 0x7C, 0x00, 0x02, 0x00, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x3F, 0x1E, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0x7C, 0x1F,
  0x83, 0xE1, 0xF8, 0x1E, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xF0, 0xF8, 0x07, 0x83, 0xE0,
  0x3C, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x0F, 0x87, 0x80,
  0x7C, 0x3C, 0x03, 0xE1, 0xE0, 0x0F, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x03, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0x38,
  0x70, 0x1D, 0xF9, 0xF8, 0x3B, 0xF7, 0xF0, 0xFD, 0xFB, 0xE1, 0xF1, 0xE3,
  0xC3, 0xC3, 0x87, 0x87, 0x87, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x3C, 0x3C,
  0x78, 0x78, 0xF8, 0xF0, 0xF1, 0xE1, 0xE1, 0xC3, 0xC3, 0xC3, 0x87, 0x87,
  0x87, 0x0F, 0x0F, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF0,
  0xE1, 0xE1, 0xE1, 0xC3, 0xC3, 0xC3, 0x87, 0x87, 0x87, 0x0F, 0x1F, 0x1E,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0xF3, 0xFC, 0x1F, 0x7F, 0xE1, 0xFF, 0xFF,
  0x1F, 0xC3, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x1F, 0x1E, 0x01,
  0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0,
  0x3E, 0x3C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3C, 0x7C,
  0x03, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0xCF, 0x80, 0x7C, 0x00, 0x7C, 0x00,
  0x7F, 0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xF8, 0x7E, 0x7C, 0x07, 0xCF,
  0x80, 0xF9, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBC,
  0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8,
  0x07, 0x8F, 0x81, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x3C, 0xFF, 0x03, 0xEF, 0xFC, 0x1F, 0xFF,
  0xF0, 0xFE, 0x1F, 0x87, 0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xE0, 0x1F, 0x0F,
  0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xE0, 0x0F,
  0x0F, 0x00, 0x78, 0x78, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xF8,
  0x1F, 0x0F, 0x7F, 0xF0, 0x7B, 0xFF, 0x83, 0xDF, 0xF8, 0x3E, 0x7F, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xDF,
  0x0F, 0xFD, 0xF1, 0xFF, 0xFE, 0x1F, 0x87, 0xE3, 0xE0, 0x3E, 0x3E, 0x03,
  0xE3, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xC7, 0x80,
  0x3C, 0x78, 0x07, 0xC7, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8,
  0x0F, 0x8F, 0xC1, 0xF8, 0x7F, 0xF7, 0x87, 0xFF, 0xF8, 0x3F, 0xEF, 0x81,
  0xFC, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0xFB,
  0xFE, 0x07, 0xFF, 0xF8, 0x3D, 0xFF, 0xE1, 0xF8, 0x3F, 0x0F, 0x80, 0xF8,
  0x78, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x3F,
  0xFF, 0x0F, 0xFF, 0xF1, 0xF0, 0x3E, 0x7C, 0x03, 0xCF, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0xF0, 0x07, 0xDF, 0x00,
  0xFB, 0xF8, 0x7E, 0x7F, 0xFF, 0x87, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x1E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3,
  0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xE7, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07,
  0xC7, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0x7C, 0x1F, 0x87, 0xFF,
  0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xF8, 0x01, 0xF7,
  0x80, 0x1E, 0x78, 0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0xC0, 0x78,
  0x3C, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x1F, 0x03, 0xC1, 0xF0, 0x3E, 0x3E,
  0x03, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xEF,
  0x80, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0x70, 0x78, 0x3D, 0xC1, 0xE0, 0xF7, 0x07, 0x83, 0x9C, 0x3E,
  0x1E, 0x70, 0xD8, 0x79, 0xC3, 0x61, 0xC7, 0x1D, 0x8F, 0x1C, 0x66, 0x3C,
  0x71, 0x98, 0xE1, 0xCE, 0x67, 0x87, 0x39, 0x9E, 0x1C, 0xC6, 0x70, 0x77,
  0x19, 0xC1, 0xDC, 0x6F, 0x07, 0x61, 0xB8, 0x1F, 0x86, 0xE0, 0x7E, 0x1F,
  0x83, 0xF0, 0x7C, 0x0F, 0xC1, 0xF0, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x00,
  0x0F, 0x80, 0x7E, 0x0F, 0x81, 0xF0, 0x1F, 0x07, 0xE0, 0x1F, 0x0F, 0x80,
  0x3E, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x7D, 0xE0, 0x01, 0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0x87,
  0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0xC0, 0x1F,
  0x00, 0x1E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xE3, 0xE0, 0x1E, 0x3C,
  0x01, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xC7,
  0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0xC7, 0x80, 0x7C,
  0x7C, 0x0F, 0xC7, 0xF7, 0xF8, 0x7F, 0xF7, 0x83, 0xFE, 0x78, 0x1F, 0xCF,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFC, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7F, 0xF0,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78,
  0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x03,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x0F, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xF3, 0xFE, 0x0F, 0x7F,
  0xE0, 0xF7, 0xFF, 0x0F, 0x78, 0xF9, 0xFF, 0x07, 0xFE, 0xF0, 0x7F, 0xEF,
  0x03, 0xF8, 0x00, 0x0E, 0x00,
};

const GFXglyph JetBrainsMono_SemiBoldItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 10, 28, 23, 7, -28 },
  { 36, 14, 11, 23, 7, -28 },
  { 56, 23, 28, 23, 1, -28 },
  { 137, 22, 39, 23, 1, -34 },
  { 245, 28, 29, 23, -2, -29 },
  { 347, 22, 29, 23, 1, -29 },
  { 427, 6, 11, 23, 11, -28 },
  { 436, 16, 38, 23, 6, -33 },
  { 512, 16, 38, 23, 2, -33 },
  { 588, 21, 21, 23, 2, -24 },
  { 644, 20, 18, 23, 2, -22 },
  { 689, 11, 12, 23, 3, -6 },
  { 706, 14, 4, 23, 5, -15 },
  { 713, 7, 7, 23, 7, -7 },
  { 720, 24, 36, 23, 0, -32 },
  { 828, 21, 29, 23, 2, -29 },
  { 905, 18, 28, 23, 2, -28 },
  { 968, 21, 29, 23, 1, -29 },
  { 1045, 20, 28, 23, 2, -28 },
  { 1115, 20, 28, 23, 2, -28 },
  { 1185, 20, 28, 23, 2, -28 },
  { 1255, 19, 28, 23, 2, -28 },
  { 1322, 20, 28, 23, 4, -28 },
  { 1392, 20, 29, 23, 2, -29 },
  { 1465, 20, 29, 23, 3, -29 },
  { 1538, 10, 22, 23, 7, -22 },
  { 1566, 13, 28, 23, 4, -22 },
  { 1612, 19, 21, 23, 3, -23 },
  { 1662, 20, 14, 23, 2, -20 },
  { 1697, 19, 21, 23, 2, -23 },
  { 1747, 17, 28, 23, 5, -28 },
  { 1807, 24, 36, 23, 0, -29 },
  { 1915, 20, 28, 23, 0, -28 },
  { 1985, 22, 28, 23, 1, -28 },
  { 2062, 21, 29, 23, 2, -29 },
  { 2139, 22, 28, 23, 1, -28 },
  { 2216, 21, 28, 23, 2, -28 },
  { 2290, 22, 29, 23, 2, -29 },
  { 2370, 21, 29, 23, 2, -29 },
  { 2447, 22, 28, 23, 1, -28 },
  { 2524, 21, 28, 23, 2, -28 },
  { 2598, 23, 28, 23, 0, -28 },
  { 2679, 24, 28, 23, 1, -28 },
  { 2763, 18, 28, 23, 2, -28 },
  { 2826, 23, 28, 23, 1, -28 },
  { 2907, 22, 28, 23, 1, -28 },
  { 2984, 20, 29, 23, 2, -29 },
  { 3057, 23, 28, 23, 1, -28 },
  { 3138, 21, 36, 23, 2, -29 },
  { 3233, 22, 28, 23, 1, -28 },
  { 3310, 22, 29, 23, 1, -29 },
  { 3390, 20, 29, 23, 4, -29 },
  { 3463, 21, 28, 23, 2, -28 },
  { 3537, 21, 28, 23, 4, -28 },
  { 3611, 24, 28, 23, 2, -28 },
  { 3695, 26, 28, 23, -1, -28 },
  { 3786, 21, 28, 23, 4, -28 },
  { 3860, 22, 28, 23, 1, -28 },
  { 3937, 16, 36, 23, 5, -32 },
  { 4009, 13, 36, 23, 6, -32 },
  { 4068, 16, 36, 23, 3, -32 },
  { 4140, 18, 15, 23, 3, -28 },
  { 4174, 19, 4, 23, 0, 1 },
  { 4184, 8, 6, 23, 10, -31 },
  { 4190, 20, 22, 23, 2, -22 },
  { 4245, 20, 28, 23, 1, -28 },
  { 4315, 20, 22, 23, 2, -22 },
  { 4370, 21, 28, 23, 2, -28 },
  { 4444, 19, 22, 23, 2, -22 },
  { 4497, 27, 35, 23, -2, -28 },
  { 4616, 20, 29, 23, 2, -22 },
  { 4689, 20, 28, 23, 1, -28 },
  { 4759, 20, 31, 23, 1, -31 },
  { 4837, 21, 38, 23, 0, -31 },
  { 4937, 21, 28, 23, 2, -28 },
  { 5011, 18, 28, 23, 3, -28 },
  { 5074, 23, 22, 23, 0, -22 },
  { 5138, 20, 22, 23, 1, -22 },
  { 5193, 19, 22, 23, 2, -22 },
  { 5246, 21, 29, 23, 0, -22 },
  { 5323, 20, 29, 23, 2, -22 },
  { 5396, 21, 22, 23, 2, -22 },
  { 5454, 19, 22, 23, 2, -22 },
  { 5507, 19, 27, 23, 3, -27 },
  { 5572, 20, 21, 23, 2, -21 },
  { 5625, 20, 21, 23, 3, -21 },
  { 5678, 22, 21, 23, 2, -21 },
  { 5736, 23, 21, 23, 0, -21 },
  { 5797, 20, 28, 23, 2, -21 },
  { 5867, 20, 21, 23, 1, -21 },
  { 5920, 21, 36, 23, 3, -32 },
  { 6015, 10, 36, 23, 7, -32 },
  { 6060, 20, 36, 23, 1, -32 },
  { 6150, 20, 9, 23, 2, -18 },
};

const GFXfont JetBrainsMono_SemiBoldItalic39pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic39pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC39PT7B_H_
