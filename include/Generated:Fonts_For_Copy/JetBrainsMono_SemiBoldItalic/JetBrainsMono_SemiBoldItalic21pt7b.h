#ifndef _JETBRAINSMONO_SEMIBOLDITALIC21PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0x63, 0x18, 0xC6, 0x63, 0x00, 0x06, 0x73, 0x80, 0xE7,
  0xCF, 0x3E, 0x7C, 0xD9, 0x80, 0x03, 0x38, 0x31, 0x81, 0x8C, 0x08, 0xC3,
  0xFF, 0x86, 0x30, 0x23, 0x03, 0x18, 0x18, 0xC3, 0xFF, 0x3F, 0xF8, 0x63,
  0x02, 0x30, 0x31, 0x81, 0x98, 0x00, 0x01, 0x00, 0x60, 0x0C, 0x0F, 0xE3,
  0xFE, 0x65, 0xCC, 0x9B, 0xB0, 0x3E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x5C,
  0x19, 0xB3, 0x77, 0x4E, 0xFF, 0x8F, 0xC0, 0x20, 0x04, 0x01, 0x80, 0x1F,
  0x06, 0x36, 0x18, 0xC4, 0x61, 0x99, 0x83, 0x36, 0x07, 0xD8, 0x03, 0x60,
  0x00, 0x80, 0x03, 0x70, 0x0D, 0xF0, 0x36, 0x60, 0xCC, 0xC3, 0x19, 0x8C,
  0x36, 0x30, 0x78, 0x00, 0x01, 0x00, 0xFC, 0x0F, 0xE1, 0x86, 0x18, 0x01,
  0x80, 0x1C, 0x01, 0xC0, 0x3E, 0x37, 0x66, 0x63, 0xE6, 0x3C, 0x61, 0x86,
  0x3C, 0x7F, 0xC3, 0xCE, 0xFF, 0xED, 0x80, 0x00, 0x81, 0xC1, 0xE1, 0xC1,
  0xC1, 0xC0, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x80,
  0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0x40, 0x10, 0x0E, 0x07, 0x80, 0xE0,
  0x30, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x18,
  0x1C, 0x0C, 0x1E, 0x3C, 0x1C, 0x08, 0x00, 0x07, 0x00, 0xC0, 0x18, 0x23,
  0x3F, 0x5E, 0xFF, 0x83, 0x80, 0xD8, 0x33, 0x0E, 0x70, 0x84, 0x00, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x07, 0xFF, 0xFF, 0x83, 0x00, 0x60, 0x0C, 0x03,
  0x80, 0x3C, 0xE7, 0x1C, 0x63, 0x00, 0xFF, 0xFC, 0x6F, 0xEE, 0x00, 0x38,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x38, 0x00, 0x03, 0x03, 0xF8, 0xFF, 0x98, 0x77, 0x06,
  0xE0, 0xD8, 0x3B, 0x77, 0x6E, 0xCC, 0x9B, 0x83, 0x70, 0x6E, 0x1D, 0xC3,
  0x1F, 0xE1, 0xF0, 0x07, 0x87, 0xC3, 0xB0, 0x8C, 0x43, 0x01, 0xC0, 0x70,
  0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x3F, 0xFF, 0xFC, 0x03, 0x03,
  0xF8, 0xFF, 0x98, 0x77, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x07, 0x81, 0xC0, 0x3F, 0xF7, 0xFC, 0x3F, 0xE7, 0xFC, 0x07,
  0x01, 0xC0, 0x60, 0x1E, 0x03, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x87, 0x60,
  0xEE, 0x39, 0xFE, 0x1F, 0x80, 0x01, 0xE0, 0x70, 0x1C, 0x03, 0x00, 0xE0,
  0x38, 0x0E, 0x33, 0x86, 0x61, 0xDC, 0x3B, 0xFF, 0x7F, 0xC0, 0x18, 0x03,
  0x00, 0xE0, 0x3F, 0xE7, 0xFC, 0xC0, 0x18, 0x03, 0x00, 0x6F, 0x1F, 0xF3,
  0x8E, 0x00, 0xC0, 0x18, 0x07, 0x70, 0xEE, 0x38, 0xFF, 0x0F, 0x80, 0x03,
  0x81, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x03, 0xF9, 0xEF, 0x60, 0xF8, 0x3C,
  0x0F, 0x07, 0xE1, 0x9F, 0xE3, 0xE0, 0x7F, 0xEF, 0xFF, 0x83, 0x70, 0xE0,
  0x18, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80,
  0xE0, 0x38, 0x00, 0x03, 0x03, 0xF8, 0xFF, 0x98, 0x73, 0x0E, 0x61, 0x8E,
  0x70, 0xFC, 0x1F, 0x0E, 0x71, 0x87, 0x70, 0x6E, 0x1D, 0xC3, 0x3F, 0xE3,
  0xF0, 0x06, 0x0F, 0xE7, 0xFD, 0x87, 0xE0, 0xF0, 0x3C, 0x1F, 0x87, 0xFF,
  0x9E, 0xC0, 0x70, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0x33, 0xDE, 0x60,
  0x00, 0x00, 0x07, 0x3D, 0xC0, 0x0C, 0x3C, 0x78, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x78, 0xE3, 0x87, 0x0C, 0x38, 0x00, 0x00, 0x40, 0x30, 0x7C, 0x7C,
  0x7C, 0x38, 0x0E, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x30, 0x04, 0x7F, 0xEF,
  0xF9, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x40, 0x0C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x70, 0x1C, 0x1F, 0x3E, 0x3E, 0x0E, 0x02, 0x00,
  0x7E, 0x3F, 0x81, 0xC0, 0x60, 0x30, 0x38, 0xF8, 0xF8, 0x70, 0x30, 0x18,
  0x00, 0x06, 0x07, 0x03, 0x80, 0x01, 0x80, 0x7F, 0x07, 0x1C, 0x70, 0x73,
  0x01, 0x98, 0x0D, 0x8F, 0x6C, 0x66, 0x66, 0x33, 0x31, 0x99, 0x8C, 0xCC,
  0x6C, 0x67, 0x63, 0xD3, 0x0D, 0x98, 0x00, 0xE0, 0x03, 0x80, 0x1F, 0x80,
  0x3C, 0x00, 0x03, 0x80, 0xF8, 0x1B, 0x03, 0x60, 0xEC, 0x19, 0x87, 0x30,
  0xC6, 0x18, 0xC7, 0xF8, 0xFF, 0x38, 0x76, 0x0E, 0xC1, 0xF8, 0x38, 0x3F,
  0xC7, 0xFC, 0xC3, 0x98, 0x77, 0x0E, 0xE1, 0x9F, 0xE3, 0xFC, 0x61, 0xCC,
  0x1B, 0x83, 0x70, 0xEE, 0x3D, 0xFF, 0x3F, 0x80, 0x03, 0x03, 0xF8, 0xFF,
  0x98, 0x73, 0x06, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70,
  0x0E, 0x1D, 0xC7, 0x1F, 0xE1, 0xF0, 0x3F, 0xC7, 0xF8, 0xC3, 0x98, 0x77,
  0x0E, 0xE1, 0xDC, 0x3B, 0x06, 0x60, 0xCC, 0x1B, 0x87, 0x70, 0xEE, 0x39,
  0xFE, 0x3F, 0x80, 0x3F, 0xF3, 0xFE, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x7F, 0xC7, 0xFC, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0F, 0xF8,
  0xFF, 0x80, 0x3F, 0xF3, 0xFE, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x7F,
  0xC7, 0xFC, 0x7F, 0xC6, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x00, 0x03, 0x03, 0xF8, 0xFF, 0x98, 0x73, 0x06, 0xE0, 0x1C, 0x03, 0x01,
  0x67, 0xCC, 0xF9, 0x83, 0x70, 0x6E, 0x1D, 0xC3, 0x1F, 0xE1, 0xF0, 0x38,
  0x66, 0x0C, 0xC1, 0x98, 0x77, 0x0E, 0xE1, 0x9F, 0xF3, 0xFE, 0x60, 0xCC,
  0x3B, 0x87, 0x70, 0xEE, 0x19, 0x83, 0x30, 0x60, 0x3F, 0xE7, 0xFC, 0x1C,
  0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC1, 0xFF, 0x3F, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0xE0, 0xCE, 0x0C, 0x61,
  0xC7, 0xF8, 0x3F, 0x00, 0x38, 0x73, 0x0E, 0x30, 0xC3, 0x1C, 0x73, 0x87,
  0x38, 0x7F, 0x07, 0xF0, 0x67, 0x06, 0x30, 0xE3, 0x8E, 0x38, 0xE1, 0x8C,
  0x1C, 0xC1, 0xC0, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01,
  0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x1F, 0xFF, 0xF8, 0x1C, 0x78,
  0xE3, 0xCF, 0x14, 0x69, 0xE3, 0x4B, 0x1B, 0xD8, 0xDC, 0xC6, 0xEE, 0x70,
  0x63, 0x83, 0x18, 0x18, 0xC0, 0xC6, 0x0E, 0x30, 0x73, 0x83, 0x00, 0x38,
  0x73, 0x86, 0x3C, 0x63, 0xC6, 0x7C, 0xE6, 0xCE, 0x6C, 0xC6, 0x6C, 0x66,
  0xC6, 0x6C, 0xE6, 0xCC, 0x6C, 0xC3, 0x8C, 0x38, 0xC3, 0x80, 0x03, 0x03,
  0xF8, 0xFF, 0x98, 0x73, 0x0E, 0xE1, 0xDC, 0x3B, 0x06, 0x60, 0xCC, 0x19,
  0x83, 0x70, 0xEE, 0x1D, 0xC7, 0x1F, 0xE1, 0xF0, 0x3F, 0xC3, 0xFE, 0x30,
  0x63, 0x07, 0x70, 0x67, 0x06, 0x70, 0xE7, 0xFC, 0x7F, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x03, 0xF8, 0xFF, 0x98,
  0x77, 0x06, 0xE1, 0xDC, 0x3B, 0x07, 0x60, 0xCC, 0x1B, 0x83, 0x70, 0xEE,
  0x1D, 0xC7, 0x1F, 0xE1, 0xF0, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x3F,
  0xC7, 0xFC, 0xC3, 0x98, 0x37, 0x06, 0xE1, 0xDC, 0x73, 0xFC, 0x7F, 0x0C,
  0xE3, 0x8C, 0x71, 0xCE, 0x39, 0x83, 0x30, 0x70, 0x03, 0x03, 0xF8, 0xFF,
  0x98, 0x73, 0x06, 0xE0, 0x0E, 0x01, 0xF0, 0x1F, 0x80, 0x78, 0x07, 0x00,
  0x6C, 0x1D, 0xC3, 0xBF, 0xE3, 0xF0, 0xFF, 0xFF, 0xFC, 0x38, 0x06, 0x00,
  0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x70, 0x0E, 0x00, 0x38, 0x73, 0x06, 0x30, 0x63, 0x0E, 0x70, 0xE7, 0x0E,
  0x60, 0xC6, 0x0C, 0x60, 0xC6, 0x1C, 0xE1, 0xCE, 0x1C, 0xE3, 0x87, 0xF8,
  0x3E, 0x00, 0xE0, 0xEC, 0x1D, 0x83, 0x30, 0xE6, 0x18, 0xC7, 0x18, 0xC3,
  0x18, 0x67, 0x0E, 0xC1, 0xD8, 0x3E, 0x03, 0xC0, 0x78, 0x0E, 0x00, 0x67,
  0x3B, 0x39, 0x99, 0xCC, 0xCE, 0x66, 0xF6, 0x35, 0xB1, 0xAD, 0x99, 0x6C,
  0xDB, 0xC6, 0x96, 0x34, 0xB1, 0xE5, 0x8F, 0x38, 0x71, 0xC3, 0x8E, 0x00,
  0x38, 0x38, 0xE3, 0x87, 0x18, 0x19, 0xC0, 0xFC, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x0F, 0x80, 0x7C, 0x07, 0x60, 0x73, 0x87, 0x1C, 0x38, 0x63, 0x83,
  0x80, 0xE0, 0xF6, 0x0C, 0x61, 0xC7, 0x18, 0x33, 0x83, 0x70, 0x3E, 0x03,
  0xE0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x00,
  0x3F, 0xE7, 0xFC, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C,
  0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0x8F, 0x8E,
  0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x03,
  0x03, 0x81, 0xC0, 0xE0, 0x7E, 0x3F, 0x00, 0xE0, 0xC1, 0x83, 0x07, 0x0E,
  0x0C, 0x18, 0x38, 0x70, 0x60, 0xC1, 0x83, 0x87, 0x06, 0x0C, 0x1C, 0x38,
  0x1F, 0x3F, 0x03, 0x07, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0E,
  0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0xFC, 0xF8, 0x0E, 0x07, 0x86, 0xC7, 0x63,
  0x33, 0x0D, 0x87, 0x83, 0xFF, 0xFF, 0xF0, 0xE1, 0xC0, 0x0E, 0xE7, 0xFC,
  0xE7, 0xB8, 0x66, 0x0C, 0xC1, 0x98, 0x77, 0x0E, 0xE1, 0xDC, 0x71, 0xFE,
  0x3E, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x19, 0xC7, 0xFC, 0xF3, 0x9C, 0x33,
  0x06, 0x60, 0xCC, 0x1B, 0x87, 0x70, 0xEE, 0x39, 0xBF, 0x37, 0xC0, 0x0F,
  0x03, 0xF8, 0xE7, 0x38, 0x66, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE1, 0xDC,
  0x31, 0xFE, 0x1F, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x87, 0x73, 0xFE, 0x73,
  0xDC, 0x33, 0x06, 0x60, 0xCC, 0x3B, 0x87, 0x70, 0xEE, 0x38, 0xFF, 0x1F,
  0x60, 0x0F, 0x07, 0xF3, 0x9D, 0xC3, 0x60, 0xDF, 0xF7, 0xFF, 0x80, 0xE0,
  0x78, 0x67, 0xF8, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x7F, 0xE1, 0xFF, 0x80, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x03, 0xF0, 0x0F,
  0x00, 0x00, 0x0E, 0xE7, 0xFC, 0xE7, 0xB8, 0x66, 0x0C, 0xC1, 0x98, 0x77,
  0x0E, 0xE1, 0xCF, 0xF1, 0xF6, 0x00, 0xC0, 0x38, 0x07, 0x1F, 0xC3, 0xE0,
  0x38, 0x06, 0x00, 0xC0, 0x19, 0xC7, 0xFC, 0xF3, 0x9C, 0x33, 0x06, 0x60,
  0xCC, 0x3B, 0x87, 0x70, 0xEE, 0x19, 0x83, 0x30, 0x60, 0x03, 0x81, 0xE0,
  0x00, 0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38,
  0x0E, 0x03, 0x0F, 0xFF, 0xFF, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x01, 0xFC,
  0x3F, 0x87, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x01, 0xE3, 0xF8, 0x7C, 0x00, 0x38, 0x03, 0x00,
  0x30, 0x03, 0x07, 0x70, 0xE7, 0x1C, 0x73, 0x86, 0x30, 0x7F, 0x07, 0xE0,
  0x67, 0x0E, 0x30, 0xE3, 0x8E, 0x38, 0xC1, 0xC0, 0xFC, 0x7E, 0x07, 0x03,
  0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x81, 0xFC,
  0x7E, 0x36, 0x63, 0xFF, 0x33, 0x33, 0x33, 0x72, 0x36, 0x27, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0xE6, 0x6E, 0xCE, 0x33, 0x8F, 0xF9, 0xE7, 0x38,
  0x66, 0x0C, 0xC1, 0x98, 0x77, 0x0E, 0xE1, 0xDC, 0x33, 0x06, 0x60, 0xC0,
  0x0F, 0x07, 0xF3, 0x9D, 0xC3, 0x60, 0xD8, 0x36, 0x0F, 0x87, 0xE1, 0xF8,
  0xE7, 0xF8, 0xF8, 0x19, 0xC3, 0xFE, 0x3C, 0xE3, 0x86, 0x30, 0x63, 0x06,
  0x30, 0x67, 0x0E, 0x70, 0xE7, 0x1C, 0x6F, 0xC6, 0xF8, 0x60, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0x0E, 0xE7, 0xFC, 0xE7, 0xB8, 0x66, 0x0C, 0xC1, 0x98,
  0x77, 0x0E, 0xE1, 0xDC, 0x71, 0xFE, 0x3E, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x18, 0x33, 0x86, 0xF8, 0xE7, 0xB8, 0x77, 0x0E, 0xE0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0x80, 0x70, 0x00, 0x0F, 0x87, 0xF8, 0xC7, 0x38, 0x07,
  0x00, 0xFE, 0x07, 0xE0, 0x0E, 0x01, 0xDC, 0x3B, 0xFE, 0x3F, 0x80, 0x0C,
  0x07, 0x01, 0xC3, 0xFF, 0xFF, 0xFF, 0xF1, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x0F, 0xC1, 0xF0, 0x30, 0xEE, 0x1D, 0xC3, 0xB8, 0x66,
  0x0C, 0xC1, 0x98, 0x77, 0x0E, 0xE1, 0xDC, 0x71, 0xFC, 0x1F, 0x00, 0xC0,
  0xF8, 0x1B, 0x87, 0x70, 0xC6, 0x38, 0xC6, 0x19, 0xC3, 0x30, 0x7E, 0x0F,
  0x80, 0xF0, 0x1C, 0x00, 0xC6, 0x3C, 0x63, 0xC6, 0x6C, 0xE6, 0xCA, 0x6C,
  0xAC, 0xDA, 0xCD, 0x2C, 0xD2, 0x8F, 0x38, 0xE3, 0x8E, 0x38, 0x38, 0x71,
  0x87, 0x1C, 0xE0, 0xDC, 0x0F, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x1F, 0x83,
  0x9C, 0x71, 0xCE, 0x0E, 0x30, 0xEE, 0x1D, 0xC3, 0x30, 0x66, 0x0C, 0xC1,
  0x98, 0x77, 0x0E, 0xE3, 0xCF, 0xF1, 0xF6, 0x00, 0xC0, 0x38, 0x07, 0x1F,
  0xC3, 0xE0, 0x3F, 0xE7, 0xF9, 0xFF, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xE0, 0x78, 0x1C, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0xFC, 0x1F, 0x03, 0xF0, 0x06, 0x00,
  0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xE0, 0x3C, 0x00, 0x18, 0xCE,
  0x73, 0x98, 0xC6, 0x73, 0x9C, 0xC6, 0x31, 0x9C, 0xE7, 0x30, 0x1F, 0x03,
  0xE0, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x07, 0xE0, 0x7C,
  0x1F, 0x87, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x0F, 0x83, 0xE0,
  0x00, 0x38, 0x0F, 0x8F, 0xB9, 0xE3, 0xEC, 0x38,
};

const GFXglyph JetBrainsMono_SemiBoldItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 15, 13, 4, -15 },
  { 11, 7, 6, 13, 4, -15 },
  { 17, 13, 15, 13, 0, -15 },
  { 42, 11, 21, 13, 1, -18 },
  { 71, 15, 15, 13, -1, -15 },
  { 100, 12, 16, 13, 0, -16 },
  { 124, 3, 6, 13, 6, -15 },
  { 127, 9, 21, 13, 3, -18 },
  { 151, 9, 21, 13, 1, -18 },
  { 175, 11, 11, 13, 1, -13 },
  { 191, 11, 10, 13, 1, -12 },
  { 205, 6, 6, 13, 2, -3 },
  { 210, 7, 2, 13, 3, -8 },
  { 212, 4, 4, 13, 4, -4 },
  { 214, 13, 19, 13, 0, -17 },
  { 245, 11, 16, 13, 1, -16 },
  { 267, 10, 15, 13, 1, -15 },
  { 286, 11, 16, 13, 1, -16 },
  { 308, 11, 15, 13, 1, -15 },
  { 329, 11, 15, 13, 1, -15 },
  { 350, 11, 15, 13, 1, -15 },
  { 371, 10, 15, 13, 1, -15 },
  { 390, 11, 15, 13, 2, -15 },
  { 411, 11, 16, 13, 1, -16 },
  { 433, 10, 16, 13, 2, -16 },
  { 453, 5, 12, 13, 4, -12 },
  { 461, 7, 15, 13, 2, -12 },
  { 475, 10, 12, 13, 2, -13 },
  { 490, 11, 8, 13, 1, -11 },
  { 501, 10, 12, 13, 1, -13 },
  { 516, 9, 15, 13, 3, -15 },
  { 533, 13, 20, 13, 0, -16 },
  { 566, 11, 15, 13, 0, -15 },
  { 587, 11, 15, 13, 1, -15 },
  { 608, 11, 16, 13, 1, -16 },
  { 630, 11, 15, 13, 1, -15 },
  { 651, 12, 15, 13, 1, -15 },
  { 674, 12, 15, 13, 1, -15 },
  { 697, 11, 16, 13, 1, -16 },
  { 719, 11, 15, 13, 1, -15 },
  { 740, 11, 15, 13, 1, -15 },
  { 761, 12, 15, 13, 0, -15 },
  { 784, 12, 15, 13, 1, -15 },
  { 807, 10, 15, 13, 1, -15 },
  { 826, 13, 15, 13, 0, -15 },
  { 851, 12, 15, 13, 1, -15 },
  { 874, 11, 16, 13, 1, -16 },
  { 896, 12, 15, 13, 1, -15 },
  { 919, 11, 20, 13, 1, -16 },
  { 947, 11, 15, 13, 1, -15 },
  { 968, 11, 16, 13, 1, -16 },
  { 990, 11, 15, 13, 2, -15 },
  { 1011, 12, 15, 13, 1, -15 },
  { 1034, 11, 15, 13, 2, -15 },
  { 1055, 13, 15, 13, 1, -15 },
  { 1080, 13, 15, 13, 0, -15 },
  { 1105, 12, 15, 13, 2, -15 },
  { 1128, 11, 15, 13, 1, -15 },
  { 1149, 9, 19, 13, 3, -17 },
  { 1171, 7, 19, 13, 3, -17 },
  { 1188, 8, 19, 13, 2, -17 },
  { 1207, 9, 8, 13, 2, -15 },
  { 1216, 10, 2, 13, 0, 1 },
  { 1219, 5, 2, 13, 5, -16 },
  { 1221, 11, 12, 13, 1, -12 },
  { 1238, 11, 15, 13, 1, -15 },
  { 1259, 11, 12, 13, 1, -12 },
  { 1276, 11, 15, 13, 1, -15 },
  { 1297, 10, 12, 13, 1, -12 },
  { 1312, 14, 19, 13, -1, -15 },
  { 1346, 11, 16, 13, 1, -12 },
  { 1368, 11, 15, 13, 1, -15 },
  { 1389, 10, 16, 13, 1, -16 },
  { 1409, 11, 20, 13, 0, -16 },
  { 1437, 12, 15, 13, 1, -15 },
  { 1460, 9, 15, 13, 2, -15 },
  { 1477, 12, 12, 13, 0, -12 },
  { 1495, 11, 12, 13, 1, -12 },
  { 1512, 10, 12, 13, 1, -12 },
  { 1527, 12, 16, 13, 0, -12 },
  { 1551, 11, 16, 13, 1, -12 },
  { 1573, 11, 12, 13, 1, -12 },
  { 1590, 11, 12, 13, 1, -12 },
  { 1607, 10, 15, 13, 2, -15 },
  { 1626, 11, 12, 13, 1, -12 },
  { 1643, 11, 12, 13, 2, -12 },
  { 1660, 12, 12, 13, 1, -12 },
  { 1678, 12, 12, 13, 0, -12 },
  { 1696, 11, 16, 13, 1, -12 },
  { 1718, 11, 12, 13, 1, -12 },
  { 1735, 11, 19, 13, 2, -17 },
  { 1762, 5, 19, 13, 4, -17 },
  { 1774, 11, 19, 13, 0, -17 },
  { 1801, 11, 5, 13, 1, -10 },
};

const GFXfont JetBrainsMono_SemiBoldItalic21pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic21pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic21pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC21PT7B_H_
