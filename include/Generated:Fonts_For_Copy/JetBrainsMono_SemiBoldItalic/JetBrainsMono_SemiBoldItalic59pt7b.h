#ifndef _JETBRAINSMONO_SEMIBOLDITALIC59PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xF0,
  0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0x81,
  0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xE0, 0xFE, 0x7F, 0x03, 0xF9,
  0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x07, 0xF1, 0xF8,
  0x1F, 0xC7, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xE3, 0xF8, 0x1F,
  0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x3E, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3E,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x79, 0xFF, 0x03, 0xF8, 0x78,
  0xFF, 0x03, 0xF8, 0x70, 0x7F, 0x07, 0xF0, 0x70, 0x7F, 0x07, 0xF0, 0xF0,
  0x7F, 0x07, 0xF0, 0xF0, 0x00, 0x07, 0xF0, 0xF0, 0x00, 0x07, 0xF0, 0xF0,
  0x00, 0x07, 0xF0, 0xF0, 0x00, 0x07, 0xF8, 0xE0, 0x00, 0x07, 0xFC, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xCF, 0xF8, 0x00, 0x03, 0x87, 0xF8, 0x00, 0x03, 0x83,
  0xF8, 0x00, 0x07, 0x83, 0xF8, 0x00, 0x07, 0x83, 0xF8, 0x00, 0x07, 0x83,
  0xF8, 0x7F, 0x07, 0x83, 0xF8, 0x7F, 0x07, 0x83, 0xF8, 0x7F, 0x07, 0x07,
  0xF0, 0x7F, 0x8F, 0x0F, 0xF0, 0x7F, 0xCF, 0x1F, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0x07,
  0xFF, 0x80, 0x01, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x3E, 0x00,
  0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0xF8, 0x00, 0x0F,
  0x80, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x1F, 0x0F, 0xC0, 0x00, 0x3E, 0x03,
  0xE1, 0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x7C, 0x00, 0x00, 0xFC, 0x3F, 0x1F,
  0x00, 0x00, 0x1F, 0xFF, 0xE7, 0xC0, 0x00, 0x01, 0xFF, 0xF9, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xCF, 0xFF, 0xC0, 0x00, 0x01, 0xF3, 0xFF, 0xFC, 0x00,
  0x00, 0x7C, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x81, 0xF0, 0x00, 0x07,
  0xC3, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x7C, 0x07, 0xC0, 0x00, 0x7E, 0x0F,
  0x80, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x1F, 0x00,
  0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xF1, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xC0, 0x00,
  0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFE,
  0x1F, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x7F,
  0x1F, 0xCF, 0xE0, 0x7F, 0x1F, 0xC3, 0xF8, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xE0, 0x7F, 0x3F, 0x83, 0xF0, 0x3F, 0xDF, 0x83, 0xF8, 0x0F, 0xFF,
  0xC1, 0xFC, 0x03, 0xFF, 0xC0, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0x00, 0x7F,
  0xC0, 0x3F, 0x00, 0x3F, 0xE0, 0x1F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xFC, 0x03, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0x1F,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF7, 0xF0, 0x1F, 0xFF,
  0xF1, 0xFC, 0x07, 0xFF, 0xE0, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0x80, 0x06,
  0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xF7, 0xFB, 0xF9, 0xFC, 0xFE,
  0x7F, 0x3F, 0x9F, 0xCF, 0xC7, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x38, 0x03, 0xE0, 0x0C, 0x3E, 0x03,
  0xE0, 0x7E, 0x7F, 0x83, 0xC1, 0xFE, 0x7F, 0xE3, 0xC7, 0xFE, 0xFF, 0xF3,
  0x8F, 0xFE, 0xFF, 0xFB, 0xBF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x02, 0x00,
  0x10, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x0F, 0x83, 0xFE, 0x3F, 0xE7, 0xFE,
  0x7F, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0x7F, 0xC3, 0xF8, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x01,
  0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F,
  0x0F, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF8,
  0x7E, 0x00, 0x07, 0xF1, 0xFC, 0x3E, 0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0x87,
  0xF1, 0xFC, 0x3F, 0x0F, 0xE3, 0xF8, 0xFE, 0x1F, 0x87, 0xF1, 0xFC, 0x3F,
  0x0F, 0xE3, 0xF8, 0x7E, 0x0F, 0x87, 0xF1, 0xFC, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0x80,
  0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x01,
  0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFE, 0xFC, 0x00, 0x7F,
  0xCF, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xF8, 0x1F,
  0xC0, 0x0F, 0x00, 0xFE, 0x00, 0x70, 0x07, 0xF0, 0x02, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x10, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0xF1, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x2A, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x3F,
  0x81, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xC1,
  0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF1, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF1, 0xFF, 0x00, 0x0F, 0xEF, 0xFF,
  0x80, 0x1F, 0xBF, 0xFF, 0x80, 0x3F, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xEF, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x07, 0xF8,
  0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x08, 0x00, 0x0F, 0xF7, 0xFE, 0x00, 0x7F, 0xBF, 0xFC, 0x01, 0xFD, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0x80, 0xFF,
  0x87, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x03,
  0xFC, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x01,
  0xFE, 0x7F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE,
  0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x01,
  0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x0F,
  0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x03,
  0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07,
  0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF9, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFE,
  0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00,
  0x03, 0xF9, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x7F,
  0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE1, 0xFF, 0x01, 0xFF, 0x87,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xBF, 0x80, 0x3F,
  0xFD, 0xFE, 0x00, 0x7F, 0xEF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x03,
  0xFE, 0x07, 0xF8, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x7F, 0x81, 0xFF,
  0x83, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80,
  0x18, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x80, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x3E, 0x0F,
  0xC0, 0x1F, 0xF3, 0xE0, 0xFC, 0x07, 0xFF, 0xBE, 0x0F, 0x80, 0xFF, 0xFB,
  0xE1, 0xF8, 0x0F, 0xF7, 0xFE, 0x1F, 0x81, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F,
  0x80, 0xFE, 0x1F, 0x81, 0xF0, 0x0F, 0xC1, 0xF8, 0x3F, 0x00, 0xFC, 0x1F,
  0x03, 0xF0, 0x0F, 0xC3, 0xF0, 0x3F, 0x00, 0xFC, 0x3F, 0x03, 0xF0, 0x0F,
  0xC3, 0xF0, 0x3E, 0x00, 0xFC, 0x3F, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x7E,
  0x01, 0xF8, 0x3E, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x7E, 0x01, 0xF8, 0x7E,
  0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x7E, 0x01, 0xF8, 0x7E, 0x07, 0xE0, 0x3F,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7C, 0x07, 0xFF, 0xFF, 0x07, 0xC0, 0x3F,
  0xFD, 0xF0, 0xFC, 0x03, 0xFF, 0x9F, 0x0F, 0xC0, 0x1F, 0xF3, 0xF0, 0xFC,
  0x00, 0x78, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x1F,
  0x80, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFD, 0xFE, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x03, 0xFE, 0x03, 0xF0,
  0x00, 0xFF, 0x03, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xE0,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF8, 0x1F, 0xC0,
  0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xFC, 0x3F, 0x80,
  0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80,
  0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xE0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xF7,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x0F, 0xFE, 0x03, 0xF8, 0x01,
  0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01,
  0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01,
  0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01,
  0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03,
  0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x07,
  0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x3F, 0xE0, 0x7F, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xF7, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x07,
  0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x3F, 0xFF, 0x0F, 0xE0, 0x7F, 0xFE, 0x1F, 0xC1, 0xFF,
  0xFC, 0x3F, 0x83, 0xFF, 0xF8, 0x7F, 0x07, 0xFF, 0xF0, 0xFE, 0x0F, 0xFF,
  0xE3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE,
  0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFF, 0x07,
  0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xFE, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8,
  0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03,
  0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x0F,
  0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0x7F,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xF8,
  0x07, 0xE0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x07,
  0xF0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7E, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x3F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x3D, 0xF0, 0x1F, 0xF8, 0x0F, 0xBE, 0x07, 0xEF, 0x01, 0xFF, 0xC0,
  0xFD, 0xE0, 0x7D, 0xF8, 0x1F, 0xBE, 0x0F, 0xBE, 0x03, 0xF7, 0xC3, 0xE7,
  0xC0, 0x7C, 0xF8, 0x7D, 0xF8, 0x0F, 0x9F, 0x1F, 0x3F, 0x01, 0xF3, 0xE3,
  0xE7, 0xE0, 0x7E, 0x3C, 0xF8, 0xFC, 0x0F, 0xC7, 0x9F, 0x3F, 0x01, 0xF8,
  0xFB, 0xC7, 0xE0, 0x3F, 0x1F, 0xF8, 0xFC, 0x07, 0xE3, 0xFF, 0x1F, 0x80,
  0xFC, 0x7F, 0xC3, 0xF0, 0x3F, 0x87, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x1F,
  0x80, 0xFC, 0x1F, 0xC3, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0xFF, 0x80,
  0x0F, 0xC0, 0xFF, 0xC0, 0x0F, 0xE0, 0x7F, 0xE0, 0x07, 0xF0, 0x3F, 0xF0,
  0x03, 0xF0, 0x1F, 0xF8, 0x01, 0xF8, 0x0F, 0xFC, 0x00, 0xFC, 0x07, 0xFF,
  0x00, 0x7E, 0x07, 0xFF, 0x80, 0x7F, 0x03, 0xFF, 0xC0, 0x3F, 0x81, 0xFB,
  0xE0, 0x1F, 0x80, 0xFD, 0xF0, 0x0F, 0xC0, 0x7E, 0xFC, 0x07, 0xE0, 0x3F,
  0x7E, 0x03, 0xF0, 0x3F, 0xBF, 0x03, 0xF8, 0x1F, 0x8F, 0x81, 0xFC, 0x0F,
  0xC7, 0xC0, 0xFC, 0x07, 0xE3, 0xF0, 0x7E, 0x03, 0xF1, 0xF8, 0x3F, 0x01,
  0xF8, 0xFC, 0x1F, 0x80, 0xFC, 0x3E, 0x0F, 0xC0, 0xFE, 0x1F, 0x0F, 0xE0,
  0x7E, 0x0F, 0xC7, 0xF0, 0x3F, 0x07, 0xE3, 0xF0, 0x1F, 0x83, 0xF1, 0xF8,
  0x0F, 0xC0, 0xF8, 0xFC, 0x07, 0xE0, 0x7C, 0x7E, 0x07, 0xF0, 0x3E, 0x3F,
  0x03, 0xF8, 0x1F, 0xBF, 0x81, 0xF8, 0x0F, 0xDF, 0x80, 0xFC, 0x07, 0xEF,
  0xC0, 0x7E, 0x01, 0xF7, 0xE0, 0x3F, 0x00, 0xFB, 0xF0, 0x3F, 0x80, 0x7F,
  0xF8, 0x1F, 0xC0, 0x3F, 0xFC, 0x0F, 0xC0, 0x1F, 0xFC, 0x07, 0xE0, 0x07,
  0xFE, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xF8, 0x01, 0xFF, 0x81, 0xFC, 0x00,
  0xFF, 0xC0, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0x00, 0x1F, 0xF0, 0x3F, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xF7, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF8,
  0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03,
  0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC,
  0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F,
  0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x07, 0xF0,
  0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0x80, 0x3F, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xE7, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFC,
  0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7E,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80,
  0x03, 0xF8, 0x7E, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01,
  0xFC, 0x3F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xFC,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xE0, 0x0F, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01,
  0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xCF,
  0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x0F,
  0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC,
  0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8,
  0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xF0,
  0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x07,
  0xF0, 0x7E, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFC,
  0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0xC0, 0x7E, 0x3F, 0x01, 0xFC, 0x07, 0xE3,
  0xF0, 0x1F, 0xC0, 0x7E, 0x3F, 0x01, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0xC0,
  0xFC, 0x3F, 0x03, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0xC0, 0xFC, 0x3F, 0x07,
  0xBC, 0x1F, 0x83, 0xF0, 0x7B, 0xC1, 0xF8, 0x3F, 0x07, 0xBC, 0x1F, 0x83,
  0xE0, 0x7B, 0xC1, 0xF0, 0x3E, 0x0F, 0x38, 0x3F, 0x03, 0xE0, 0xF3, 0x83,
  0xF0, 0x3E, 0x0F, 0x38, 0x3F, 0x07, 0xE0, 0xE3, 0x83, 0xE0, 0x7E, 0x1E,
  0x78, 0x7E, 0x07, 0xE1, 0xE7, 0x87, 0xE0, 0x7E, 0x1E, 0x78, 0x7E, 0x07,
  0xE3, 0xC7, 0x87, 0xC0, 0x7E, 0x3C, 0x78, 0xFC, 0x07, 0xE3, 0xC7, 0x8F,
  0xC0, 0x7E, 0x3C, 0x78, 0xFC, 0x07, 0xE7, 0x87, 0x8F, 0x80, 0x7E, 0x78,
  0x79, 0xF8, 0x07, 0xC7, 0x87, 0x9F, 0x80, 0x7C, 0xF0, 0x79, 0xF0, 0x07,
  0xCF, 0x07, 0x9F, 0x00, 0x7C, 0xF0, 0x7B, 0xF0, 0x07, 0xCF, 0x07, 0xBF,
  0x00, 0x7D, 0xE0, 0x7B, 0xE0, 0x07, 0xDE, 0x07, 0xBE, 0x00, 0x7D, 0xE0,
  0x7F, 0xE0, 0x07, 0xDC, 0x07, 0x7E, 0x00, 0xFF, 0xC0, 0x77, 0xC0, 0x0F,
  0xFC, 0x07, 0x7C, 0x00, 0xFF, 0xC0, 0xF7, 0xC0, 0x0F, 0xB8, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01,
  0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07,
  0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F,
  0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x07, 0xF3, 0xF0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xDF, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xF0, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xE0,
  0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x83,
  0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xE7, 0xF0, 0x00,
  0xFC, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF8, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x07,
  0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFF, 0xC7, 0xF0, 0x1F, 0xFF, 0x9F, 0xC0, 0xFF, 0xFF,
  0x7F, 0x07, 0xFF, 0xFD, 0xFC, 0x1F, 0xFF, 0xF7, 0xE0, 0xFF, 0x81, 0xDF,
  0x83, 0xFC, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03,
  0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE,
  0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0x07,
  0xF8, 0x07, 0xFC, 0x1F, 0xFC, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x7F, 0x03, 0xFF, 0xF9, 0xF8, 0x07, 0xFF, 0xC7, 0xE0, 0x07, 0xFC,
  0x3F, 0x80, 0x03, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x3F, 0x8F, 0xFE, 0x00, 0x7F, 0x3F, 0xFF, 0x00, 0xFE, 0xFF, 0xFE,
  0x01, 0xFB, 0xFF, 0xFE, 0x07, 0xF7, 0xFF, 0xFC, 0x0F, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80,
  0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0x83, 0xFE, 0x00,
  0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xFF, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0x7F, 0xFF, 0xC0, 0x7E, 0x7F, 0xFF, 0x01, 0xFC, 0x7F, 0xF8,
  0x03, 0xF8, 0x7F, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x1F,
  0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xF8,
  0x07, 0xFC, 0x1F, 0xFE, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x7F, 0xF1, 0xFC, 0x01, 0xFF, 0xF9, 0xFC, 0x03, 0xFF, 0xFD,
  0xFC, 0x07, 0xFF, 0xFD, 0xFC, 0x07, 0xFF, 0xFD, 0xF8, 0x0F, 0xF8, 0x1D,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x07,
  0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x07,
  0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07,
  0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xF3, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xDF, 0xC0, 0x3F, 0xFF, 0x9F,
  0x80, 0x1F, 0xFF, 0x1F, 0x80, 0x07, 0xFC, 0x3F, 0x80, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xBF, 0xF8, 0x3F,
  0xC0, 0x3F, 0xC1, 0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F,
  0x9F, 0xC0, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F,
  0xC0, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xC7, 0xF0, 0x1F, 0xFF, 0x9F, 0xC0, 0xFF,
  0xFF, 0x7F, 0x07, 0xFF, 0xFD, 0xFC, 0x1F, 0xFF, 0xF7, 0xE0, 0xFF, 0x81,
  0xDF, 0x83, 0xFC, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x1F,
  0xE1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7E, 0x1F, 0xC0,
  0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x01,
  0xFE, 0x1F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0xBF,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF7, 0xF0, 0x1F, 0xFF, 0x9F, 0xC0,
  0x3F, 0xFC, 0x7F, 0x00, 0x3F, 0xC1, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x07,
  0xF0, 0x01, 0xFC, 0x7F, 0xF0, 0x07, 0xF3, 0xFF, 0xF0, 0x1F, 0xDF, 0xFF,
  0xC0, 0x7E, 0xFF, 0xFF, 0x83, 0xFB, 0xFF, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC,
  0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F,
  0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0x7F,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0,
  0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0,
  0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF8,
  0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF8,
  0x01, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0x3F, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xF8, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x23, 0xE0, 0x7C, 0x03, 0xE7, 0xF8, 0xFF, 0x03, 0xF7, 0xFC, 0xFF,
  0xC1, 0xFB, 0xFF, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x07, 0xE0, 0xFE, 0x1F, 0x81, 0xF0, 0x7F, 0x0F, 0xC1, 0xF8,
  0x3F, 0x0F, 0xE0, 0xF8, 0x1F, 0x87, 0xE0, 0x7C, 0x0F, 0xC3, 0xF0, 0x3E,
  0x07, 0xE1, 0xF8, 0x1F, 0x03, 0xF0, 0xFC, 0x0F, 0x81, 0xF8, 0x7E, 0x0F,
  0xC1, 0xFC, 0x7F, 0x07, 0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0x7E, 0x1F, 0x81,
  0xF0, 0x3F, 0x0F, 0xC0, 0xF8, 0x1F, 0x87, 0xE0, 0x7C, 0x0F, 0xC3, 0xF0,
  0x3E, 0x0F, 0xE3, 0xF8, 0x3E, 0x07, 0xE1, 0xF8, 0x1F, 0x03, 0xF0, 0xFC,
  0x0F, 0x81, 0xF8, 0x7E, 0x07, 0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0x7E, 0x1F,
  0x81, 0xF0, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xE0, 0xF8, 0x1F, 0x87,
  0xE0, 0x7C, 0x0F, 0xC3, 0xF0, 0x3E, 0x07, 0xE1, 0xF8, 0x1F, 0x03, 0xF0,
  0xFC, 0x0F, 0x83, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC7, 0xFF,
  0x00, 0x7F, 0x3F, 0xFF, 0x01, 0xFD, 0xFF, 0xFC, 0x07, 0xEF, 0xFF, 0xF8,
  0x3F, 0xBF, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0x0F,
  0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF0,
  0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x7F,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0,
  0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x00,
  0xFE, 0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFE,
  0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0xFE, 0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xF8,
  0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC,
  0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0x3F,
  0xFF, 0x00, 0x3F, 0xBF, 0xFF, 0x80, 0x1F, 0xBF, 0xFF, 0xE0, 0x1F, 0xDF,
  0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x1F,
  0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0,
  0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xF8, 0x03, 0xFC,
  0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xCF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x7F, 0xFF, 0x00, 0x7F, 0x1F, 0xFE,
  0x00, 0x3F, 0x87, 0xFE, 0x00, 0x1F, 0xC0, 0x60, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xC7, 0xF0, 0x1F,
  0xFF, 0x9F, 0xC0, 0xFF, 0xFF, 0x7F, 0x07, 0xFF, 0xFD, 0xFC, 0x1F, 0xFF,
  0xF7, 0xE0, 0xFF, 0x81, 0xFF, 0x83, 0xFC, 0x03, 0xFE, 0x1F, 0xE0, 0x07,
  0xF8, 0x7F, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFC,
  0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F,
  0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xFC, 0xFF, 0xF0,
  0x7F, 0xFF, 0xDF, 0xC0, 0xFF, 0xFF, 0x7F, 0x03, 0xFF, 0xF9, 0xF8, 0x07,
  0xFF, 0xCF, 0xE0, 0x07, 0xFC, 0x3F, 0x80, 0x03, 0x80, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x0F, 0xE3, 0xFF, 0xC0, 0x1F, 0xCF, 0xFF, 0xC0,
  0x3F, 0x3F, 0xFF, 0xC0, 0x7E, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F,
  0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x05, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8,
  0x7E, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFC, 0x3F,
  0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0,
  0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F,
  0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0xC1,
  0xFE, 0x01, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0,
  0x3F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F,
  0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xF8,
  0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07,
  0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x3F, 0x1F, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0xFE, 0x03,
  0xF0, 0x1F, 0xBF, 0x03, 0xF8, 0x0F, 0xDF, 0x81, 0xFC, 0x07, 0xCF, 0x80,
  0xFE, 0x07, 0xE7, 0xC0, 0xFF, 0x03, 0xF3, 0xE0, 0x7F, 0x81, 0xF1, 0xF0,
  0x3F, 0xC0, 0xF8, 0xF8, 0x1D, 0xE0, 0xFC, 0x7C, 0x1E, 0xF0, 0x7C, 0x3E,
  0x0F, 0x78, 0x3E, 0x1F, 0x07, 0x3C, 0x3F, 0x0F, 0x87, 0x9E, 0x1F, 0x07,
  0xC3, 0xCF, 0x0F, 0x83, 0xE1, 0xC7, 0x8F, 0xC1, 0xF1, 0xE3, 0xC7, 0xC0,
  0xF8, 0xF1, 0xE3, 0xE0, 0x7C, 0x70, 0xF1, 0xF0, 0x3E, 0x78, 0x79, 0xF8,
  0x1F, 0x3C, 0x3C, 0xF8, 0x0F, 0x9E, 0x1E, 0x7C, 0x07, 0xDE, 0x0F, 0x7E,
  0x03, 0xEF, 0x07, 0xBE, 0x01, 0xF7, 0x83, 0xDF, 0x00, 0xFB, 0x81, 0xFF,
  0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xF8, 0x07,
  0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F,
  0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xFB,
  0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFC, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8,
  0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F,
  0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xC0,
  0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0xFF,
  0x87, 0xF8, 0x07, 0xFC, 0x1F, 0xFC, 0x7B, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x7F, 0x01, 0xFF, 0xFD, 0xFC, 0x03, 0xFF, 0xC7, 0xF0, 0x07,
  0xFE, 0x1F, 0xC0, 0x03, 0xC0, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFC,
  0x3F, 0xFC, 0x01, 0xF8, 0xFF, 0xFC, 0x03, 0xF3, 0xFF, 0xF8, 0x0F, 0xC7,
  0xFF, 0xF8, 0x1F, 0x9F, 0xC7, 0xF8, 0x3F, 0x3F, 0x07, 0xF0, 0xFE, 0x7E,
  0x07, 0xFF, 0xF9, 0xF8, 0x0F, 0xFF, 0xF3, 0xF0, 0x0F, 0xFF, 0xC7, 0xE0,
  0x0F, 0xFF, 0x0F, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
};

const GFXglyph JetBrainsMono_SemiBoldItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 15, 43, 35, 11, -43 },
  { 82, 22, 18, 35, 10, -43 },
  { 132, 35, 43, 35, 1, -43 },
  { 321, 32, 59, 35, 2, -51 },
  { 557, 43, 43, 35, -3, -43 },
  { 789, 33, 45, 35, 1, -44 },
  { 975, 9, 18, 35, 16, -43 },
  { 996, 25, 57, 35, 9, -50 },
  { 1175, 25, 57, 35, 3, -50 },
  { 1354, 32, 31, 35, 3, -36 },
  { 1478, 29, 28, 35, 4, -33 },
  { 1580, 17, 18, 35, 5, -9 },
  { 1619, 21, 7, 35, 8, -23 },
  { 1638, 12, 11, 35, 10, -10 },
  { 1655, 37, 55, 35, 0, -49 },
  { 1910, 31, 45, 35, 3, -44 },
  { 2085, 29, 43, 35, 2, -43 },
  { 2241, 32, 44, 35, 2, -44 },
  { 2417, 32, 44, 35, 2, -43 },
  { 2593, 30, 43, 35, 3, -43 },
  { 2755, 31, 44, 35, 3, -43 },
  { 2926, 30, 44, 35, 2, -43 },
  { 3091, 30, 43, 35, 6, -43 },
  { 3253, 32, 45, 35, 2, -44 },
  { 3433, 30, 44, 35, 5, -44 },
  { 3598, 15, 34, 35, 10, -33 },
  { 3662, 20, 42, 35, 5, -33 },
  { 3767, 29, 32, 35, 5, -35 },
  { 3883, 29, 21, 35, 4, -30 },
  { 3960, 29, 32, 35, 3, -35 },
  { 4076, 25, 43, 35, 8, -43 },
  { 4211, 36, 55, 35, 0, -44 },
  { 4459, 31, 43, 35, 0, -43 },
  { 4626, 32, 43, 35, 2, -43 },
  { 4798, 31, 45, 35, 3, -44 },
  { 4973, 32, 43, 35, 2, -43 },
  { 5145, 32, 43, 35, 3, -43 },
  { 5317, 34, 43, 35, 2, -43 },
  { 5500, 31, 45, 35, 3, -44 },
  { 5675, 33, 43, 35, 2, -43 },
  { 5853, 31, 43, 35, 3, -43 },
  { 6020, 34, 44, 35, 0, -43 },
  { 6207, 35, 43, 35, 2, -43 },
  { 6396, 26, 43, 35, 4, -43 },
  { 6536, 35, 43, 35, 1, -43 },
  { 6725, 33, 43, 35, 2, -43 },
  { 6903, 31, 45, 35, 3, -44 },
  { 7078, 34, 43, 35, 2, -43 },
  { 7261, 31, 55, 35, 3, -44 },
  { 7475, 33, 43, 35, 2, -43 },
  { 7653, 32, 45, 35, 2, -44 },
  { 7833, 31, 43, 35, 6, -43 },
  { 8000, 32, 44, 35, 3, -43 },
  { 8176, 30, 43, 35, 7, -43 },
  { 8338, 36, 43, 35, 3, -43 },
  { 8532, 38, 43, 35, -1, -43 },
  { 8737, 32, 43, 35, 6, -43 },
  { 8909, 32, 43, 35, 2, -43 },
  { 9081, 24, 55, 35, 8, -49 },
  { 9246, 19, 55, 35, 9, -49 },
  { 9377, 24, 55, 35, 5, -49 },
  { 9542, 27, 23, 35, 5, -43 },
  { 9620, 29, 7, 35, 0, 1 },
  { 9646, 12, 8, 35, 15, -46 },
  { 9658, 30, 34, 35, 3, -33 },
  { 9786, 31, 44, 35, 2, -43 },
  { 9957, 30, 34, 35, 3, -33 },
  { 10085, 32, 44, 35, 3, -43 },
  { 10261, 29, 34, 35, 3, -33 },
  { 10385, 40, 54, 35, -3, -43 },
  { 10655, 30, 44, 35, 3, -33 },
  { 10820, 30, 43, 35, 2, -43 },
  { 10982, 29, 46, 35, 2, -46 },
  { 11149, 31, 57, 35, 1, -46 },
  { 11370, 33, 43, 35, 2, -43 },
  { 11548, 26, 43, 35, 5, -43 },
  { 11688, 33, 33, 35, 1, -33 },
  { 11825, 30, 33, 35, 2, -33 },
  { 11949, 29, 34, 35, 3, -33 },
  { 12073, 33, 44, 35, 0, -33 },
  { 12255, 30, 44, 35, 3, -33 },
  { 12420, 31, 33, 35, 3, -33 },
  { 12548, 30, 34, 35, 2, -33 },
  { 12676, 30, 41, 35, 4, -41 },
  { 12830, 30, 33, 35, 3, -32 },
  { 12954, 30, 32, 35, 5, -32 },
  { 13074, 33, 32, 35, 4, -32 },
  { 13206, 35, 32, 35, 0, -32 },
  { 13346, 30, 43, 35, 3, -32 },
  { 13508, 31, 32, 35, 2, -32 },
  { 13632, 31, 55, 35, 5, -49 },
  { 13846, 15, 55, 35, 11, -49 },
  { 13950, 31, 55, 35, 1, -49 },
  { 14164, 31, 14, 35, 3, -28 },
};

const GFXfont JetBrainsMono_SemiBoldItalic59pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic59pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic59pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC59PT7B_H_
