#ifndef _JETBRAINSMONO_SEMIBOLDITALIC38PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F,
  0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01,
  0xC0, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0,
  0x3C, 0x3E, 0x78, 0x79, 0xF0, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x0F, 0x9E,
  0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xC1, 0xE7, 0x83, 0x80, 0x00,
  0x38, 0x3C, 0x01, 0xE0, 0xE0, 0x07, 0x03, 0x80, 0x3C, 0x1E, 0x00, 0xE0,
  0x70, 0x03, 0x81, 0xC0, 0x1E, 0x0F, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF2, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x07, 0x83, 0xC0, 0x1C,
  0x0E, 0x00, 0x70, 0x78, 0x03, 0xC1, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x3C,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xF0, 0x70, 0x03,
  0x81, 0xC0, 0x0E, 0x0F, 0x00, 0x78, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x07,
  0x80, 0x3C, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x80, 0x7F,
  0xFE, 0x07, 0xFF, 0xF0, 0x3E, 0xEF, 0xC3, 0xE7, 0x3E, 0x1E, 0x31, 0xF1,
  0xF1, 0x80, 0x0F, 0x8C, 0x00, 0x7C, 0x60, 0x01, 0xF7, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x01, 0xDF, 0x80, 0x0C, 0x7C, 0x00, 0x61, 0xE0, 0x03, 0x0F,
  0x1E, 0x18, 0xF8, 0xF1, 0xC7, 0x87, 0xCE, 0x7C, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0xF0,
  0x3F, 0xC0, 0x1C, 0x03, 0xFE, 0x03, 0xC0, 0x70, 0xE0, 0x78, 0x07, 0x0E,
  0x0F, 0x00, 0xF0, 0xE0, 0xE0, 0x0E, 0x0E, 0x1C, 0x00, 0xE0, 0xE3, 0x80,
  0x0E, 0x0E, 0x70, 0x00, 0xF1, 0xCF, 0x00, 0x0F, 0xFD, 0xE0, 0x00, 0x7F,
  0xBC, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x3D, 0xFE, 0x00, 0x07, 0xBF, 0xE0, 0x00,
  0xF3, 0xCF, 0x00, 0x0E, 0x70, 0x70, 0x01, 0xC7, 0x07, 0x00, 0x38, 0x70,
  0xF0, 0x07, 0x07, 0x0F, 0x00, 0xF0, 0xF0, 0xE0, 0x1E, 0x0F, 0x0E, 0x03,
  0xC0, 0x7F, 0xE0, 0x38, 0x07, 0xFC, 0x0F, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x78, 0x3E, 0x03,
  0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0xC1, 0xEF, 0x9E, 0x1E, 0x78, 0xF9, 0xF3, 0xC3, 0xDF, 0x1E, 0x1F, 0xF1,
  0xF0, 0x7F, 0x0F, 0x83, 0xF8, 0x78, 0x0F, 0x83, 0xC0, 0x7C, 0x1F, 0x07,
  0xF0, 0xFC, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFC, 0xF0, 0x7F, 0x87, 0xC0,
  0x3C, 0xF7, 0xDF, 0x7D, 0xE7, 0x9E, 0x79, 0xEF, 0x3C, 0x00, 0x03, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0x40, 0x03,
  0x00, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x07, 0x07, 0x07, 0x7C, 0x71, 0xFF, 0xE6, 0x7F, 0xFF, 0x6F, 0xF3,
  0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xB8, 0x00, 0x7B, 0xC0,
  0x1F, 0x3E, 0x01, 0xE1, 0xE0, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0x18, 0x0C,
  0x00, 0x80, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x03, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81,
  0xE0, 0x78, 0x00, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0x3E,
  0x7F, 0x7F, 0x7F, 0x7E, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0xFF, 0xFE, 0x1F, 0x83, 0xE1, 0xF0, 0x1F, 0x1E, 0x01, 0xF3, 0xE0,
  0x1F, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x7C,
  0xF1, 0xE7, 0xDF, 0x3E, 0x79, 0xF3, 0xE7, 0x8F, 0x3C, 0x78, 0x43, 0xC7,
  0x80, 0x3C, 0x78, 0x03, 0xCF, 0x80, 0x3C, 0xF0, 0x07, 0xCF, 0x00, 0x78,
  0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0x7F, 0x7F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF8,
  0x0F, 0xDE, 0x07, 0xEF, 0x81, 0xE3, 0xE0, 0x70, 0xF8, 0x10, 0x3C, 0x08,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFC, 0x1F, 0x07, 0xC0, 0x78, 0x7C, 0x03,
  0xE3, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0xF0, 0x07,
  0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x8F, 0x81, 0xF0, 0xFF, 0x7F, 0x07, 0xFF,
  0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x3C, 0x3E, 0x07, 0x8F, 0x81, 0xF3, 0xE0, 0x3E, 0x78, 0x07, 0xCF, 0x00,
  0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x7E, 0x03, 0xFF, 0xF8, 0x3D, 0xFF, 0x83, 0xFF, 0xFC,
  0x3E, 0x07, 0xC3, 0xC0, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x81,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xFB, 0xF0, 0x0F, 0x7F, 0xC1, 0xFF, 0xFC, 0x3F, 0xCF,
  0xE3, 0xE0, 0x3E, 0x3C, 0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80,
  0x1E, 0x78, 0x01, 0xE7, 0x80, 0x3E, 0x7C, 0x03, 0xC7, 0xC0, 0x7C, 0x3F,
  0xBF, 0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0x80, 0x3F, 0xF0, 0x0F, 0xBE,
  0x01, 0xF7, 0x80, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0xFC, 0x1F, 0x07, 0xC0, 0x78, 0x3C, 0x03, 0xC1, 0xE0,
  0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x83, 0xE0, 0xF8, 0x0F, 0x9F, 0x80,
  0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0x07,
  0xC1, 0xF0, 0x1E, 0x0F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0x80, 0x3E, 0x3C,
  0x01, 0xF1, 0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x7F, 0xBF, 0x81, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x3F,
  0xFE, 0x0F, 0xFF, 0xE3, 0xF0, 0x7E, 0x78, 0x07, 0xDF, 0x00, 0x7B, 0xC0,
  0x0F, 0x78, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xE7, 0xC0,
  0x7C, 0xFC, 0x3F, 0x9F, 0xFF, 0xE1, 0xFF, 0x78, 0x1F, 0xDF, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x83, 0xF1, 0xFC, 0x7F, 0x1F, 0x83, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x3E, 0x1F, 0xC7,
  0xF1, 0xF8, 0x7C, 0x00, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03,
  0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80,
  0x00, 0x10, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xF8, 0x10, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x3F,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0x3F,
  0x80, 0x0F, 0x80, 0x03, 0x80, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x3F,
  0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7E, 0x1F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x1F, 0x83, 0xE0, 0x7C, 0x03, 0xE1, 0xF0, 0x03, 0xC3, 0xC0,
  0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x38, 0x02, 0x3C, 0xF0, 0x3F,
  0x79, 0xE0, 0xFF, 0xF3, 0xC3, 0xE7, 0xC7, 0x87, 0x87, 0x8F, 0x1E, 0x0F,
  0x1C, 0x3C, 0x1E, 0x78, 0x78, 0x3C, 0xF0, 0xF0, 0x79, 0xE1, 0xC0, 0xE3,
  0xC7, 0x81, 0xC7, 0x8F, 0x07, 0x8E, 0x1E, 0x0F, 0x1C, 0x3E, 0x3E, 0x78,
  0x3F, 0xFC, 0xF0, 0x7F, 0x79, 0xE0, 0x7C, 0xE3, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7B, 0x80, 0x07,
  0xBC, 0x00, 0x7B, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x1F, 0x3C, 0x01,
  0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xE3, 0xC0, 0x3C, 0x3C, 0x07, 0xC3, 0xC0,
  0x78, 0x3C, 0x07, 0x83, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE3, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xC0, 0x1E, 0x7C, 0x01,
  0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x07, 0xFE, 0x00, 0x3F,
  0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xF0, 0x1F, 0x87, 0x80, 0x7C,
  0x3C, 0x03, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF0, 0xF8, 0x07, 0x87, 0x80,
  0x78, 0x3C, 0x0F, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x07,
  0xC3, 0xF8, 0x3E, 0x03, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03,
  0xC3, 0xC0, 0x1E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x01, 0xF8, 0x7F,
  0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x83, 0xF1, 0xF0,
  0x1F, 0x1E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0xC1, 0xF8, 0x7F, 0xFF,
  0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F,
  0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xF0, 0x7F, 0x07, 0x80, 0xF8,
  0x3C, 0x03, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0x87, 0xC0,
  0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x1F, 0x0F, 0x00, 0xF8, 0xF8, 0x07, 0xC7,
  0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07,
  0xC3, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0x83, 0xF0, 0x7F,
  0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0x83, 0xF1, 0xF0, 0x1F, 0x1E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC7,
  0xFE, 0x7C, 0x7F, 0xE7, 0xC7, 0xFE, 0x78, 0x7F, 0xC7, 0x80, 0x3C, 0x78,
  0x03, 0xC7, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x8F,
  0xC0, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00,
  0x07, 0x80, 0x78, 0x3C, 0x03, 0xC3, 0xE0, 0x1E, 0x1F, 0x01, 0xF0, 0xF8,
  0x0F, 0x87, 0x80, 0x7C, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x1F, 0x00, 0xF0,
  0xF8, 0x07, 0x87, 0xC0, 0x7C, 0x3C, 0x03, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F,
  0x00, 0xF8, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xF0, 0x1F,
  0x0F, 0x80, 0xF8, 0x78, 0x07, 0xC3, 0xC0, 0x3C, 0x1E, 0x01, 0xE1, 0xF0,
  0x0F, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x20, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x78, 0x03, 0xE1, 0xE0, 0x0F,
  0x07, 0xC0, 0x7C, 0x1F, 0x03, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01,
  0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0xF8, 0x3E,
  0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0xF8, 0x07, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x3C,
  0x00, 0xF0, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3E, 0x1E, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x7C, 0x01,
  0xE0, 0xF8, 0x03, 0xC0, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x78, 0x07, 0xC0, 0xF0, 0x0F, 0x81, 0xE0, 0x0F, 0x07, 0xC0,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0,
  0x77, 0x1F, 0xC1, 0xFC, 0x7F, 0x0E, 0xE1, 0xFC, 0x3B, 0x87, 0x71, 0xFE,
  0x1C, 0xE7, 0x78, 0x73, 0x9D, 0xE3, 0xCE, 0xE7, 0x8F, 0x3B, 0x9C, 0x3C,
  0xFC, 0xF0, 0xF3, 0xF3, 0xC3, 0xCF, 0x8F, 0x0F, 0x1E, 0x3C, 0x7C, 0x01,
  0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1,
  0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF0, 0x03, 0xC3, 0xC0,
  0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x7C, 0x3F, 0x01,
  0xE0, 0xFE, 0x07, 0x83, 0xF8, 0x1E, 0x0F, 0xE0, 0x78, 0x3B, 0x81, 0xE0,
  0xEE, 0x07, 0x87, 0xB8, 0x3C, 0x1E, 0xF0, 0xF0, 0x7B, 0xC3, 0xC1, 0xEF,
  0x0F, 0x07, 0x9C, 0x3C, 0x1E, 0x70, 0xF0, 0x79, 0xE7, 0xC3, 0xC7, 0x9E,
  0x0F, 0x1E, 0x78, 0x3C, 0x39, 0xE0, 0xF0, 0xE7, 0x83, 0xC3, 0xDE, 0x0F,
  0x0F, 0x78, 0x7C, 0x3D, 0xC1, 0xE0, 0x77, 0x07, 0x81, 0xFC, 0x1E, 0x07,
  0xF0, 0x78, 0x1F, 0xC1, 0xE0, 0x7F, 0x0F, 0x81, 0xF8, 0x3C, 0x03, 0xE0,
  0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0x83,
  0xE1, 0xF0, 0x1F, 0x1E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xE3, 0xE0,
  0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xC7, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0xC7,
  0x80, 0x7C, 0xF8, 0x07, 0x8F, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0xC1, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0x81, 0xF8,
  0x3C, 0x03, 0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C,
  0x01, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x3E, 0x1E, 0x01, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF,
  0xFE, 0x1F, 0x83, 0xE1, 0xF0, 0x1F, 0x1E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E,
  0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x7C, 0x03, 0xE7,
  0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C,
  0x78, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F,
  0x8F, 0x81, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE,
  0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xF8, 0x1F, 0x87, 0x80, 0x7C, 0x3C,
  0x03, 0xE1, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF8, 0x07, 0xC7, 0xC0, 0x3E,
  0x3C, 0x03, 0xE1, 0xE0, 0x3F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xE0, 0x3F, 0xFE, 0x01, 0xE1, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3E, 0x03,
  0xC1, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x78, 0x07,
  0x83, 0xC0, 0x3E, 0x1E, 0x01, 0xF1, 0xF0, 0x0F, 0x80, 0x00, 0x7F, 0x80,
  0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFC, 0x1F, 0x87, 0xC0,
  0x7C, 0x3C, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x0F, 0x80, 0xF8,
  0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF8,
  0xF8, 0x07, 0x87, 0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00,
  0xF8, 0x78, 0x07, 0xC3, 0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F,
  0x00, 0x78, 0x78, 0x07, 0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xF1, 0xF0, 0x0F,
  0x0F, 0x80, 0x78, 0x7C, 0x03, 0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xF0, 0xF0,
  0x0F, 0x8F, 0x80, 0x78, 0x7C, 0x03, 0xC3, 0xE0, 0x3E, 0x1F, 0x83, 0xE0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xE7, 0x80, 0x3E, 0x78, 0x03, 0xC7,
  0x80, 0x7C, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x0F, 0x87, 0x80, 0xF0,
  0x78, 0x1F, 0x07, 0xC1, 0xE0, 0x7C, 0x1E, 0x07, 0xC3, 0xE0, 0x3C, 0x3C,
  0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0xF8, 0x03, 0xCF,
  0x00, 0x3C, 0xF0, 0x03, 0xDE, 0x00, 0x3D, 0xE0, 0x03, 0xDC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x78, 0x3C, 0x1E,
  0xF0, 0x78, 0x3D, 0xE0, 0xF0, 0xF3, 0xC3, 0xE1, 0xE7, 0x86, 0xC3, 0xCF,
  0x0D, 0x87, 0x1E, 0x3F, 0x1E, 0x3C, 0x7E, 0x3C, 0x78, 0xDC, 0x78, 0xF1,
  0xB8, 0xE1, 0xE7, 0x73, 0xC3, 0x8E, 0xE7, 0x87, 0x19, 0xCF, 0x0E, 0x73,
  0x9C, 0x1C, 0xE6, 0x78, 0x39, 0x8C, 0xF0, 0x73, 0x19, 0xC1, 0xEE, 0x33,
  0x83, 0xDC, 0x6F, 0x07, 0xB0, 0xDE, 0x0F, 0x61, 0xB8, 0x1F, 0xC3, 0x70,
  0x3F, 0x87, 0xE0, 0x7E, 0x0F, 0xC0, 0xEC, 0x1F, 0x01, 0xF8, 0x7E, 0x03,
  0xE0, 0xFC, 0x07, 0xC1, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0x3C, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x87,
  0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0x7B, 0xE0, 0x00, 0x3D,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x1E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x03, 0xC0, 0x1F, 0x01, 0xF0,
  0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x3C, 0x1F, 0x80, 0x1F, 0x00, 0xF0, 0x00,
  0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0xF8, 0xF0, 0x07, 0xC7, 0xC0, 0x7C, 0x3E,
  0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x83, 0xE0, 0x3E, 0x1E, 0x00, 0xF1, 0xF0,
  0x07, 0x8F, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x03, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3D, 0xC0, 0x1E, 0xF0, 0x1E, 0x78, 0x0F,
  0x1C, 0x0F, 0x0F, 0x0F, 0x87, 0x87, 0x83, 0xC7, 0x80, 0xE3, 0xC0, 0x7B,
  0xC0, 0x3F, 0xE0, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xE0, 0xF1, 0xF1, 0xF1, 0xE3, 0xE0, 0x03, 0xF9, 0xE0, 0xFF, 0xBC,
  0x3F, 0xF7, 0x8F, 0xFE, 0xF3, 0xF0, 0x7E, 0x7C, 0x07, 0xCF, 0x00, 0xF3,
  0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x00, 0xF9, 0xE0, 0x1F, 0x3C, 0x03, 0xE7,
  0x80, 0x79, 0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0xC0, 0x7C, 0xF8, 0x1F, 0x8F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xF7, 0x81, 0xFC, 0xF0, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF3, 0xF8, 0x1F, 0x7F, 0xC1, 0xFF, 0xFE, 0x1E, 0xFF,
  0xE1, 0xF8, 0x3E, 0x1F, 0x01, 0xE1, 0xE0, 0x1F, 0x1E, 0x01, 0xE3, 0xE0,
  0x1E, 0x3E, 0x01, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xE3, 0xC0, 0x3E, 0x3C,
  0x03, 0xC7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0xE0, 0xFC, 0x7F, 0xBF, 0x87,
  0xBF, 0xF0, 0x7B, 0xFE, 0x0F, 0x9F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xF0,
  0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xF0, 0x7E, 0x7C, 0x07, 0xCF, 0x00, 0xFB,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF7, 0xC0, 0x7C, 0xFC, 0x0F, 0x8F,
  0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x7F, 0x3C, 0x07, 0xFD, 0xE0, 0x7F, 0xEF, 0x07,
  0xFF, 0x78, 0x7E, 0x0F, 0xC3, 0xE0, 0x3E, 0x1E, 0x01, 0xE1, 0xF0, 0x0F,
  0x0F, 0x80, 0x78, 0x78, 0x07, 0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xF0, 0xF0,
  0x0F, 0x0F, 0x80, 0x78, 0x7C, 0x03, 0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xF0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFB, 0xC0, 0x3F, 0x9E, 0x00, 0x01,
  0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xC7, 0xE3, 0xE0, 0x3C, 0x78,
  0x07, 0x8F, 0x00, 0xF3, 0xE0, 0x1E, 0x78, 0x03, 0xCF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE7, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x0F, 0x8F, 0x87, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF9, 0xE0, 0xFF, 0xBC,
  0x3F, 0xF7, 0x8F, 0xFF, 0xF3, 0xF0, 0x7E, 0x7C, 0x07, 0xCF, 0x00, 0xF3,
  0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x80, 0x79, 0xE0, 0x1F, 0x3C, 0x03, 0xE7,
  0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x03, 0xE3, 0xF1, 0xFC, 0x7F, 0xFF, 0x87,
  0xFF, 0xF0, 0xFF, 0x3C, 0x07, 0xC7, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF3, 0xF8, 0x1F, 0x7F,
  0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF8, 0x3E, 0x1F, 0x01, 0xE1, 0xE0,
  0x1E, 0x1E, 0x01, 0xE3, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xC0, 0x3E, 0x3C,
  0x03, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xC7, 0xC0, 0x3C, 0x7C, 0x03, 0xC7,
  0xC0, 0x7C, 0x78, 0x07, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0x8F, 0x80, 0x78,
  0x00, 0x07, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3F,
  0x0F, 0x00, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x1E,
  0x0F, 0xC0, 0x78, 0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0x0F, 0x80, 0x3C, 0x3E, 0x00,
  0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x81, 0xE0,
  0x1E, 0x07, 0x80, 0x7C, 0x3E, 0x01, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x0E, 0x78, 0xF8, 0x7B, 0xF7,
  0xE1, 0xFF, 0xFF, 0xC7, 0xCF, 0x9F, 0x1E, 0x1C, 0x3C, 0x78, 0x70, 0xF1,
  0xE3, 0xC7, 0x87, 0x8F, 0x1E, 0x3C, 0x38, 0x78, 0xF0, 0xE1, 0xE3, 0xC3,
  0x87, 0x8F, 0x0E, 0x1E, 0x3C, 0x78, 0xF0, 0xF1, 0xE3, 0xC7, 0x87, 0x0F,
  0x1E, 0x1C, 0x3C, 0x78, 0x70, 0xF1, 0xE1, 0xC3, 0xC7, 0x8F, 0x0E, 0x1E,
  0x3C, 0x78, 0xF0, 0xE1, 0xE0, 0x0F, 0x3F, 0x81, 0xF7, 0xFC, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x1F, 0x83, 0xE1, 0xF0, 0x1E, 0x1E, 0x01, 0xE3, 0xE0,
  0x1E, 0x3E, 0x01, 0xE3, 0xE0, 0x1E, 0x3C, 0x03, 0xE3, 0xC0, 0x3E, 0x3C,
  0x03, 0xE3, 0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7,
  0x80, 0x7C, 0x78, 0x07, 0xC7, 0x80, 0x78, 0xF8, 0x07, 0x80, 0x01, 0xFE,
  0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xF0, 0x7C, 0x7C, 0x07,
  0x8F, 0x00, 0xF3, 0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x1F,
  0x3C, 0x03, 0xE7, 0x80, 0x7D, 0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0xC0, 0x7C,
  0xFC, 0x1F, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0x00,
  0x07, 0x9F, 0xC0, 0x7D, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFC,
  0x1F, 0x07, 0xC0, 0x7C, 0x3C, 0x03, 0xE3, 0xE0, 0x1E, 0x1F, 0x00, 0xF0,
  0xF8, 0x07, 0x87, 0x80, 0x7C, 0x3C, 0x03, 0xE1, 0xE0, 0x1F, 0x0F, 0x00,
  0xF0, 0xF8, 0x07, 0x87, 0xC0, 0x7C, 0x3F, 0x07, 0xE1, 0xFE, 0xFE, 0x0F,
  0x7F, 0xE0, 0x7B, 0xFE, 0x07, 0xCF, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xF9, 0xE1, 0xFF, 0xBC, 0x3F, 0xF7, 0x8F, 0xFF, 0xF3,
  0xE0, 0x7E, 0x7C, 0x07, 0xCF, 0x00, 0xF3, 0xE0, 0x1E, 0x7C, 0x03, 0xCF,
  0x00, 0xF9, 0xE0, 0x1F, 0x3C, 0x03, 0xE7, 0x80, 0x79, 0xF0, 0x0F, 0x3E,
  0x01, 0xE7, 0xC0, 0x7C, 0xF8, 0x1F, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F,
  0xF7, 0x81, 0xFC, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1F, 0x3F, 0x81,
  0xE7, 0xFC, 0x1E, 0xFF, 0xE1, 0xFE, 0xFE, 0x1F, 0x03, 0xE3, 0xE0, 0x1F,
  0x3E, 0x01, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xC7, 0xF3,
  0xE0, 0x3E, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF7, 0x80, 0x3C, 0xF8, 0x0F, 0x9F, 0x83, 0xF3, 0xFF, 0xFC, 0x3F,
  0xFF, 0x03, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xDF, 0xFF, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7F,
  0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x1E, 0x01, 0xE7,
  0xC0, 0x3C, 0xF8, 0x07, 0x9F, 0x01, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0xCF,
  0x00, 0xF3, 0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x80, 0x79, 0xE0, 0x1F, 0x3C,
  0x03, 0xE7, 0x80, 0x7D, 0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0xC0, 0x7C, 0x7C,
  0x1F, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0xF8,
  0x01, 0xF7, 0x80, 0x3E, 0x78, 0x03, 0xE7, 0x80, 0x3C, 0x78, 0x07, 0xC7,
  0xC0, 0x78, 0x7C, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x1F, 0x03, 0xC1, 0xE0,
  0x3C, 0x3E, 0x03, 0xE3, 0xC0, 0x3E, 0x7C, 0x01, 0xE7, 0x80, 0x1E, 0xF8,
  0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x70, 0x78, 0x3D, 0xC1, 0xE0, 0xE7, 0x0F, 0x87,
  0x9C, 0x3E, 0x1C, 0x70, 0xF8, 0x71, 0xC7, 0xE3, 0xCF, 0x1F, 0x8F, 0x3C,
  0x6E, 0x38, 0xF1, 0xB9, 0xE3, 0xCE, 0xE7, 0x8F, 0x33, 0x9C, 0x3C, 0xCE,
  0xF0, 0xF7, 0x3B, 0xC3, 0xD8, 0xEE, 0x0F, 0x63, 0xB8, 0x3F, 0x8F, 0xE0,
  0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0x80, 0xF8,
  0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xE0, 0x7C, 0x1F, 0x01, 0xF0,
  0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7C, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x8F,
  0x80, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xF0,
  0x3E, 0x01, 0xE7, 0xC0, 0x3C, 0xF8, 0x0F, 0x9E, 0x01, 0xF3, 0xC0, 0x3E,
  0x78, 0x07, 0x8F, 0x00, 0xF3, 0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x00, 0xF9,
  0xE0, 0x1F, 0x3C, 0x03, 0xE7, 0x80, 0x79, 0xF0, 0x1F, 0x1F, 0x03, 0xE3,
  0xF1, 0xBC, 0x7F, 0xFF, 0x87, 0xFD, 0xF0, 0x7F, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x3F, 0xFE, 0x0F,
  0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0,
  0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xC0, 0x07, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x01,
  0xFC, 0x0F, 0x3F, 0xE0, 0xF7, 0xFE, 0x0E, 0x79, 0xF1, 0xEF, 0x0F, 0xFE,
  0xF0, 0x7F, 0xCF, 0x07, 0xF8, 0x00, 0x1F, 0x00,
};

const GFXglyph JetBrainsMono_SemiBoldItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 10, 28, 23, 7, -28 },
  { 36, 15, 12, 23, 6, -28 },
  { 59, 22, 28, 23, 1, -28 },
  { 136, 21, 38, 23, 1, -33 },
  { 236, 28, 28, 23, -2, -28 },
  { 334, 21, 28, 23, 1, -28 },
  { 408, 6, 12, 23, 10, -28 },
  { 417, 16, 37, 23, 6, -32 },
  { 491, 16, 37, 23, 2, -32 },
  { 565, 20, 20, 23, 2, -23 },
  { 615, 19, 18, 23, 2, -22 },
  { 658, 11, 12, 23, 3, -6 },
  { 675, 13, 4, 23, 5, -15 },
  { 682, 8, 7, 23, 6, -7 },
  { 689, 24, 36, 23, 0, -32 },
  { 797, 20, 28, 23, 2, -28 },
  { 867, 18, 28, 23, 2, -28 },
  { 930, 21, 28, 23, 1, -28 },
  { 1004, 20, 28, 23, 2, -28 },
  { 1074, 19, 28, 23, 2, -28 },
  { 1141, 20, 28, 23, 2, -28 },
  { 1211, 20, 28, 23, 1, -28 },
  { 1281, 19, 28, 23, 4, -28 },
  { 1348, 21, 28, 23, 1, -28 },
  { 1422, 19, 28, 23, 3, -28 },
  { 1489, 10, 21, 23, 6, -21 },
  { 1516, 13, 27, 23, 3, -21 },
  { 1560, 19, 21, 23, 3, -23 },
  { 1610, 19, 13, 23, 2, -19 },
  { 1641, 18, 21, 23, 2, -23 },
  { 1689, 16, 28, 23, 5, -28 },
  { 1745, 23, 35, 23, 0, -28 },
  { 1846, 20, 28, 23, 0, -28 },
  { 1916, 21, 28, 23, 1, -28 },
  { 1990, 20, 28, 23, 2, -28 },
  { 2060, 21, 28, 23, 1, -28 },
  { 2134, 21, 28, 23, 2, -28 },
  { 2208, 21, 28, 23, 2, -28 },
  { 2282, 20, 28, 23, 2, -28 },
  { 2352, 21, 28, 23, 1, -28 },
  { 2426, 20, 28, 23, 2, -28 },
  { 2496, 22, 28, 23, 0, -28 },
  { 2573, 23, 28, 23, 1, -28 },
  { 2654, 17, 28, 23, 2, -28 },
  { 2714, 22, 28, 23, 1, -28 },
  { 2791, 22, 28, 23, 1, -28 },
  { 2868, 20, 28, 23, 2, -28 },
  { 2938, 22, 28, 23, 1, -28 },
  { 3015, 20, 35, 23, 2, -28 },
  { 3103, 21, 28, 23, 1, -28 },
  { 3177, 21, 28, 23, 1, -28 },
  { 3251, 20, 28, 23, 4, -28 },
  { 3321, 21, 28, 23, 2, -28 },
  { 3395, 20, 28, 23, 4, -28 },
  { 3465, 23, 28, 23, 2, -28 },
  { 3546, 25, 28, 23, -1, -28 },
  { 3634, 21, 28, 23, 4, -28 },
  { 3708, 21, 28, 23, 1, -28 },
  { 3782, 16, 36, 23, 5, -32 },
  { 3854, 12, 36, 23, 6, -32 },
  { 3908, 16, 36, 23, 3, -32 },
  { 3980, 17, 15, 23, 3, -28 },
  { 4012, 19, 4, 23, 0, 1 },
  { 4022, 7, 5, 23, 10, -30 },
  { 4027, 19, 21, 23, 2, -21 },
  { 4077, 20, 28, 23, 1, -28 },
  { 4147, 19, 21, 23, 2, -21 },
  { 4197, 21, 28, 23, 2, -28 },
  { 4271, 19, 21, 23, 2, -21 },
  { 4321, 26, 35, 23, -2, -28 },
  { 4435, 19, 28, 23, 2, -21 },
  { 4502, 20, 28, 23, 1, -28 },
  { 4572, 19, 30, 23, 1, -30 },
  { 4644, 21, 37, 23, 0, -30 },
  { 4742, 22, 28, 23, 1, -28 },
  { 4819, 17, 28, 23, 3, -28 },
  { 4879, 22, 21, 23, 0, -21 },
  { 4937, 20, 21, 23, 1, -21 },
  { 4990, 19, 21, 23, 2, -21 },
  { 5040, 21, 28, 23, 0, -21 },
  { 5114, 19, 28, 23, 2, -21 },
  { 5181, 20, 21, 23, 2, -21 },
  { 5234, 19, 21, 23, 2, -21 },
  { 5284, 19, 27, 23, 3, -27 },
  { 5349, 19, 21, 23, 2, -21 },
  { 5399, 20, 21, 23, 3, -21 },
  { 5452, 22, 21, 23, 2, -21 },
  { 5510, 22, 21, 23, 0, -21 },
  { 5568, 19, 28, 23, 2, -21 },
  { 5635, 20, 21, 23, 1, -21 },
  { 5688, 20, 36, 23, 3, -32 },
  { 5778, 10, 36, 23, 7, -32 },
  { 5823, 20, 36, 23, 1, -32 },
  { 5913, 20, 9, 23, 2, -18 },
};

const GFXfont JetBrainsMono_SemiBoldItalic38pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic38pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC38PT7B_H_
