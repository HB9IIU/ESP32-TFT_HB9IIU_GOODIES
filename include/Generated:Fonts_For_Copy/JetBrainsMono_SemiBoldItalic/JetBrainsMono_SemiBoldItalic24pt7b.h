#ifndef _JETBRAINSMONO_SEMIBOLDITALIC24PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0x8E, 0x38, 0xE3, 0x8C, 0x30, 0x00,
  0x1C, 0xF1, 0xC0, 0x73, 0xB9, 0xD8, 0xFC, 0x6E, 0x77, 0x3B, 0x9D, 0x8E,
  0x01, 0x8C, 0x06, 0x18, 0x0C, 0x70, 0x18, 0xC0, 0x61, 0x87, 0xFF, 0xCF,
  0xFF, 0x06, 0x18, 0x0C, 0x70, 0x18, 0xC0, 0x61, 0x80, 0xC7, 0x0F, 0xFF,
  0x9F, 0xFF, 0x0C, 0x70, 0x18, 0xC0, 0x61, 0x80, 0xC7, 0x00, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x07, 0x80, 0xFF, 0x0F, 0xF8, 0xE4, 0xE7, 0x27, 0x3B,
  0x01, 0xD8, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF0, 0x1B, 0xC0, 0xCE,
  0xE6, 0x77, 0x27, 0x3D, 0x78, 0xFF, 0x83, 0xF8, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x02, 0x01, 0x87, 0xC1, 0x86, 0x61, 0x83, 0x31, 0xC3, 0x18, 0xC1,
  0x8C, 0xC0, 0xEE, 0xC0, 0x3E, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xEF,
  0x00, 0x6F, 0xC0, 0x6C, 0x60, 0x66, 0x30, 0x63, 0x18, 0x61, 0x98, 0x60,
  0xFC, 0x70, 0x7C, 0x00, 0x01, 0xC0, 0x1F, 0xC0, 0xFF, 0x03, 0x0E, 0x1C,
  0x38, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0xFC, 0x77, 0x3B, 0x9C,
  0xEC, 0x71, 0xF1, 0x87, 0x86, 0x0E, 0x1C, 0xF8, 0x7F, 0xF0, 0xF8, 0xE0,
  0xFF, 0xFF, 0xB6, 0x00, 0xE0, 0x3C, 0x1F, 0x07, 0x80, 0xE0, 0x38, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1C, 0x00, 0x80, 0x0C,
  0x03, 0x81, 0xF0, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0xF0,
  0x78, 0x3C, 0x0C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x07, 0x33,
  0xFD, 0x7C, 0xFF, 0x80, 0xE0, 0x0F, 0x80, 0xCC, 0x0E, 0x70, 0xE3, 0xC2,
  0x08, 0x00, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x07, 0xFF, 0x7F,
  0xF8, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x38, 0xF1, 0xC7,
  0x0E, 0x18, 0x70, 0xFF, 0xFF, 0x80, 0x77, 0xFF, 0xE0, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x7F, 0x87, 0xFC, 0x70, 0x73,
  0x83, 0x98, 0x1D, 0xC0, 0xCE, 0x06, 0x77, 0x73, 0xBB, 0x9C, 0x9C, 0xC0,
  0xE6, 0x07, 0x70, 0x33, 0x83, 0x8E, 0x38, 0x7F, 0xC1, 0xF8, 0x00, 0x01,
  0xC0, 0x7C, 0x0F, 0xC3, 0xDC, 0x39, 0xC2, 0x18, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x71, 0xFF,
  0xEF, 0xFE, 0x03, 0xC0, 0x7F, 0x07, 0xFC, 0x70, 0xF3, 0x83, 0xB8, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1F, 0xFC, 0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xC7,
  0xFC, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xF8, 0x07, 0xE0, 0x47,
  0x00, 0x1C, 0x00, 0xE0, 0x06, 0x70, 0x73, 0x83, 0x9E, 0x38, 0x7F, 0xC1,
  0xF8, 0x00, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x3C, 0x73, 0x87, 0x70, 0x66, 0x0E, 0xFF, 0xEF, 0xFE, 0x00,
  0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x1F, 0xF8, 0xFF, 0xC7, 0xFC, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE4, 0x07, 0xFC, 0x3F, 0xE3, 0xC7, 0x80, 0x1C, 0x00,
  0xE0, 0x06, 0x00, 0x73, 0x83, 0x8E, 0x3C, 0x7F, 0xC1, 0xF8, 0x00, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xDC, 0x3F,
  0xE7, 0xDF, 0x70, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xEF, 0x1E, 0x7F,
  0xC3, 0xF0, 0x7F, 0xFB, 0xFF, 0xDF, 0xFC, 0xE0, 0xE6, 0x07, 0x70, 0x70,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x7F, 0x87,
  0xFC, 0x70, 0xF3, 0x83, 0x9C, 0x18, 0xE1, 0xC3, 0x9C, 0x0F, 0xC0, 0xFE,
  0x0E, 0x78, 0xE1, 0xC6, 0x07, 0x70, 0x33, 0x83, 0x9E, 0x3C, 0x7F, 0xC1,
  0xF8, 0x00, 0x07, 0x81, 0xFE, 0x3F, 0xE7, 0x07, 0x60, 0x7E, 0x07, 0xE0,
  0x7E, 0x06, 0xF0, 0xE7, 0xFE, 0x3F, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x80, 0x3C, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xCF, 0xBE, 0xF0, 0x0F, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x1C, 0x3C, 0x38, 0x38, 0x70, 0x60, 0xE0, 0x00, 0x30, 0x1E, 0x07,
  0xE1, 0xF8, 0x7C, 0x0F, 0x00, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xC0, 0x0C, 0x00, 0x40, 0x7F, 0xEF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF7, 0xFE, 0x30, 0x03, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0x00, 0xF0, 0x3E, 0x0F, 0x87, 0xE0, 0xF8, 0x0E, 0x00, 0x80, 0x00, 0x3C,
  0x0F, 0xE7, 0xF8, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x3F, 0x8F, 0xC3,
  0xC0, 0xC0, 0x70, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x3C, 0x00, 0x01, 0xE0,
  0x0F, 0xF0, 0x3C, 0xF0, 0xE0, 0x63, 0x80, 0xE6, 0x01, 0xCC, 0x3B, 0x38,
  0xFE, 0x73, 0x9C, 0xE6, 0x19, 0x8C, 0x73, 0x18, 0xE6, 0x71, 0x8C, 0xE3,
  0x39, 0xCE, 0x71, 0xEC, 0xC1, 0x81, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0xF0, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x36, 0x07, 0x60,
  0x76, 0x06, 0x60, 0xE6, 0x0E, 0x71, 0xC7, 0x1C, 0x71, 0xFF, 0x3F, 0xF3,
  0xFF, 0x70, 0x77, 0x07, 0xE0, 0x3E, 0x03, 0x1F, 0x81, 0xFF, 0x8F, 0xFC,
  0x70, 0xF3, 0x83, 0x9C, 0x1C, 0xC1, 0xC6, 0x1C, 0x7F, 0xC3, 0xFF, 0x1C,
  0x38, 0xE0, 0xE7, 0x07, 0x30, 0x3B, 0x83, 0x9C, 0x3C, 0xFF, 0xC7, 0xF8,
  0x00, 0x03, 0xC0, 0x7F, 0x87, 0xFC, 0x70, 0x73, 0x83, 0x9C, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x33,
  0x83, 0x8E, 0x3C, 0x7F, 0xC1, 0xF8, 0x00, 0x1F, 0x01, 0xFF, 0x0F, 0xFC,
  0x70, 0xE3, 0x83, 0x9C, 0x1C, 0xC0, 0xCE, 0x06, 0x70, 0x73, 0x83, 0x9C,
  0x1C, 0xE0, 0xE7, 0x07, 0x30, 0x73, 0x83, 0x9F, 0xF8, 0xFF, 0x87, 0xF8,
  0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x3F, 0xE3, 0xFF, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x8E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x7F, 0xF1, 0xFF,
  0x87, 0xFE, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x7F, 0x87, 0xFC, 0x70, 0x73, 0x83, 0x9C,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x9F, 0x9C, 0xFC, 0xE0, 0xE6, 0x07,
  0x70, 0x33, 0x83, 0x8E, 0x3C, 0x7F, 0xC1, 0xF8, 0x00, 0x18, 0x39, 0xC1,
  0xCE, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x18, 0xE1, 0xC6, 0x0E, 0x7F, 0xF3,
  0xFF, 0x9C, 0x1C, 0xE0, 0xC7, 0x0E, 0x30, 0x73, 0x83, 0x9C, 0x1C, 0xE0,
  0xE7, 0x07, 0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xC4, 0xFF, 0xC7, 0xFE, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x73, 0x81, 0xCF, 0x0E, 0x1C,
  0x78, 0x7F, 0xC0, 0xFE, 0x00, 0x18, 0x1C, 0xE0, 0xE3, 0x83, 0x8E, 0x1C,
  0x38, 0xF0, 0xE3, 0x83, 0x9C, 0x0C, 0x70, 0x7F, 0x81, 0xFE, 0x07, 0x38,
  0x1C, 0x60, 0x71, 0xC1, 0x87, 0x0E, 0x1C, 0x38, 0x38, 0xE0, 0xE3, 0x83,
  0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xFF, 0x7F,
  0xFF, 0xFC, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0xF1, 0xE1, 0xE6, 0xC7,
  0xCD, 0x8F, 0xB7, 0x1D, 0xEE, 0x33, 0xD8, 0x67, 0x30, 0xC0, 0xE3, 0x81,
  0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0C, 0x30, 0x18, 0x60, 0x71, 0xC0, 0xE0,
  0x1C, 0x19, 0xE0, 0xCF, 0x0E, 0x7C, 0x73, 0x63, 0x9B, 0x1C, 0xD8, 0xCE,
  0xC6, 0x77, 0x73, 0xBB, 0x9C, 0xDC, 0xC6, 0xE6, 0x36, 0x71, 0xB3, 0x8F,
  0x9C, 0x3C, 0xE1, 0xE6, 0x0F, 0x00, 0x03, 0xC0, 0x7F, 0x87, 0xFC, 0x70,
  0xF3, 0x83, 0x9C, 0x1C, 0xC0, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x1C,
  0xE0, 0xE6, 0x06, 0x70, 0x73, 0x83, 0x8E, 0x38, 0x7F, 0xC1, 0xF8, 0x00,
  0x1F, 0x80, 0xFF, 0xC3, 0xFF, 0x8E, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x83,
  0x8C, 0x0E, 0x70, 0xF1, 0xFF, 0x87, 0xFC, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x7F, 0x87,
  0xFC, 0x70, 0xF3, 0x83, 0x98, 0x1D, 0xC0, 0xCE, 0x0E, 0x70, 0x73, 0x83,
  0x9C, 0x1C, 0xC0, 0xE6, 0x07, 0x70, 0x73, 0x83, 0x8E, 0x38, 0x7F, 0xC1,
  0xF8, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x1F, 0x01, 0xFF, 0x8F,
  0xFC, 0x70, 0xF3, 0x83, 0x9C, 0x1C, 0xC0, 0xE6, 0x0E, 0x7F, 0xF3, 0xFF,
  0x1F, 0xE0, 0xE7, 0x07, 0x18, 0x30, 0xE3, 0x87, 0x1C, 0x38, 0xE0, 0xE7,
  0x07, 0x00, 0x03, 0xC0, 0x7F, 0x87, 0xFC, 0x70, 0x73, 0x83, 0x9C, 0x00,
  0xE0, 0x07, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x70,
  0x3B, 0x83, 0x9E, 0x3C, 0x7F, 0xC1, 0xF8, 0x00, 0x7F, 0xFB, 0xFF, 0xFF,
  0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x00, 0x18, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x1C,
  0xC0, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE6, 0x06, 0x30,
  0x73, 0x83, 0x8E, 0x38, 0x7F, 0xC1, 0xF8, 0x00, 0xE0, 0x7E, 0x07, 0xE0,
  0x6E, 0x0E, 0xE0, 0xEE, 0x1C, 0xE1, 0xCE, 0x18, 0xE3, 0x86, 0x30, 0x67,
  0x06, 0x70, 0x66, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x71,
  0x8E, 0xE7, 0x19, 0x8E, 0x33, 0x14, 0xE6, 0x39, 0xCC, 0xF3, 0x19, 0xE6,
  0x32, 0xDC, 0x6D, 0xB8, 0xDB, 0x61, 0xA6, 0xC3, 0x4F, 0x87, 0x9E, 0x1F,
  0x3C, 0x3C, 0x78, 0x68, 0xB0, 0xF1, 0xC1, 0xE3, 0x80, 0x1C, 0x0E, 0x38,
  0x38, 0x38, 0x70, 0x71, 0xC0, 0xE7, 0x00, 0xEE, 0x01, 0xF8, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0xEE, 0x03, 0x9C, 0x0E,
  0x38, 0x3C, 0x38, 0x70, 0x71, 0xC0, 0xF0, 0xE0, 0x3D, 0xC0, 0xE7, 0x07,
  0x1C, 0x1C, 0x30, 0xE0, 0xE7, 0x03, 0x9C, 0x06, 0xE0, 0x1B, 0x00, 0x7C,
  0x01, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x1F, 0xF8, 0xFF, 0xCF, 0xFE, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0,
  0x1C, 0x01, 0xC0, 0x1F, 0xFC, 0xFF, 0xE7, 0xFE, 0x00, 0x0F, 0xC7, 0xF1,
  0xFC, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xFE, 0x3F,
  0x8F, 0xE0, 0xE1, 0xC3, 0x87, 0x06, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0xE1,
  0xC3, 0x83, 0x07, 0x0E, 0x1C, 0x38, 0x30, 0x70, 0xE1, 0xC1, 0x80, 0x1F,
  0xC7, 0xF1, 0xFC, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38,
  0xFE, 0x3F, 0x8F, 0xC0, 0x03, 0x00, 0xF0, 0x3E, 0x06, 0xC1, 0xD8, 0x33,
  0x8E, 0x33, 0x86, 0x60, 0xFC, 0x1C, 0xFF, 0xFF, 0xFF, 0xE3, 0x8C, 0x70,
  0x1F, 0xB9, 0xFF, 0x8E, 0x3C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0x8C,
  0x1C, 0xE0, 0xE7, 0x07, 0x1C, 0x78, 0xFF, 0xC3, 0xEE, 0x00, 0x18, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xBE, 0x37, 0xF3, 0x8F, 0x70, 0x77,
  0x07, 0x70, 0x77, 0x07, 0x70, 0x66, 0x0E, 0xF0, 0xEF, 0x1E, 0xFF, 0xCE,
  0xF8, 0x0F, 0xE1, 0xFF, 0x38, 0x77, 0x07, 0x70, 0x07, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x0E, 0x0E, 0x71, 0xE7, 0xFC, 0x3F, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x8F, 0xD8, 0xFF, 0xC7, 0x1E, 0x70, 0x73,
  0x83, 0x9C, 0x1C, 0xE0, 0xC6, 0x0E, 0x70, 0x73, 0x83, 0x8E, 0x3C, 0x7F,
  0xE1, 0xF7, 0x00, 0x0F, 0xC1, 0xFE, 0x38, 0x77, 0x07, 0x70, 0x77, 0xFF,
  0x7F, 0xF6, 0x00, 0xE0, 0x0E, 0x00, 0x71, 0xE7, 0xFC, 0x3F, 0x00, 0x00,
  0x0F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x1F,
  0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x1F, 0xB9, 0xFF, 0x8E, 0x3C,
  0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0x8C, 0x1C, 0x70, 0xE3, 0x8F, 0x1F,
  0xF8, 0x7D, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x0F, 0xF0, 0x7F, 0x00, 0x18,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xBE, 0x37, 0xF3, 0x8F, 0x70,
  0x77, 0x07, 0x70, 0x77, 0x07, 0x70, 0x66, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0,
  0xEE, 0x0E, 0x00, 0x80, 0x3C, 0x03, 0xC0, 0x08, 0x00, 0x00, 0x00, 0x3F,
  0x83, 0xF8, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x00, 0x30, 0x03, 0xC0, 0x1E,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x78, 0x3F, 0x83, 0xF8, 0x00, 0x1C, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x1C, 0xE1, 0xC6, 0x1C, 0x71, 0xC3,
  0x9E, 0x1F, 0xE0, 0xFE, 0x07, 0x38, 0x31, 0xC3, 0x87, 0x1C, 0x38, 0xE0,
  0xE7, 0x07, 0x00, 0xFE, 0x1F, 0xC3, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01,
  0xFF, 0x1F, 0xE1, 0xF8, 0x3F, 0xF8, 0xFF, 0xF3, 0x19, 0xCC, 0x67, 0x33,
  0x99, 0xCC, 0x67, 0x31, 0x9C, 0xCE, 0x63, 0x39, 0x8C, 0xE6, 0x73, 0x39,
  0x8C, 0xE6, 0x30, 0x3B, 0xE3, 0x7F, 0x38, 0xF7, 0x07, 0x70, 0x77, 0x07,
  0x70, 0x77, 0x06, 0x60, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xE0, 0x0F,
  0xE1, 0xFE, 0x38, 0xF7, 0x07, 0x70, 0x77, 0x07, 0x70, 0x76, 0x06, 0xE0,
  0xEE, 0x0E, 0x71, 0xC7, 0xFC, 0x3F, 0x00, 0x1D, 0xF0, 0xDF, 0xC7, 0x0E,
  0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x06, 0x30, 0x73, 0xC3, 0x9E,
  0x3C, 0xFF, 0xC7, 0x7C, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x1F,
  0xB9, 0xFF, 0x8E, 0x3C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0x8C, 0x1C,
  0xE0, 0xE7, 0x07, 0x1C, 0x78, 0xFF, 0xC3, 0xEE, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x3B, 0xE1, 0xFF, 0x8F, 0x1E, 0x70, 0x73, 0x03, 0x38,
  0x21, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0x00, 0x1F, 0xE3, 0xFF, 0x38, 0x77, 0x00, 0x70, 0x03, 0xF8, 0x1F, 0xE0,
  0x1E, 0x00, 0xEE, 0x0E, 0xE0, 0xE7, 0xFC, 0x3F, 0x80, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xFE, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x3F, 0xC1, 0xFC, 0x1F, 0x80, 0x38,
  0x39, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x0C,
  0x60, 0xE7, 0x07, 0x1C, 0x70, 0xFF, 0x83, 0xF0, 0x00, 0xE0, 0x7E, 0x07,
  0x60, 0xE6, 0x0E, 0x71, 0xC7, 0x1C, 0x73, 0x87, 0x38, 0x37, 0x03, 0x70,
  0x36, 0x03, 0xE0, 0x3C, 0x00, 0xC6, 0x3E, 0x31, 0xB3, 0x8D, 0x94, 0xEC,
  0xA6, 0x6D, 0x33, 0x69, 0x9A, 0x58, 0xF2, 0xC7, 0x96, 0x38, 0xE1, 0xC7,
  0x0E, 0x38, 0x00, 0x3C, 0x3C, 0x70, 0xE0, 0xE7, 0x03, 0xB8, 0x07, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x73, 0x83, 0x8E, 0x1C, 0x1C,
  0xF0, 0x70, 0x38, 0x33, 0x07, 0x70, 0x77, 0x07, 0x70, 0x77, 0x07, 0x70,
  0x66, 0x0E, 0x70, 0xE7, 0xBE, 0x7F, 0xE3, 0xCE, 0x00, 0xC0, 0x1C, 0x01,
  0xC7, 0xF8, 0x7F, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0xFE, 0xFF, 0xE0,
  0x00, 0x78, 0x0F, 0x80, 0xFC, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x3F, 0x81, 0xF8, 0x0F, 0xE0, 0x03, 0x80, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF8, 0x07, 0xC0,
  0x0E, 0x00, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x70, 0xE1,
  0xC3, 0x87, 0x0C, 0x38, 0x70, 0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x00, 0x0F,
  0x00, 0x7C, 0x03, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x3C, 0x00, 0xFE, 0x03, 0xF0, 0x7F, 0x83, 0x80, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x07, 0xC0, 0x3C, 0x03, 0x80,
  0x00, 0x3C, 0x3B, 0xF1, 0xD9, 0xCD, 0xC7, 0xEE, 0x3E, 0x00,
};

const GFXglyph JetBrainsMono_SemiBoldItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 18, 14, 4, -18 },
  { 15, 9, 8, 14, 4, -18 },
  { 24, 15, 18, 14, 0, -18 },
  { 58, 13, 24, 14, 1, -21 },
  { 97, 17, 18, 14, -1, -18 },
  { 136, 14, 18, 14, 0, -18 },
  { 168, 3, 8, 14, 7, -18 },
  { 171, 11, 23, 14, 3, -20 },
  { 203, 10, 23, 14, 1, -20 },
  { 232, 13, 13, 14, 1, -15 },
  { 254, 12, 12, 14, 1, -14 },
  { 272, 7, 8, 14, 2, -4 },
  { 279, 9, 2, 14, 3, -9 },
  { 282, 5, 4, 14, 4, -4 },
  { 285, 15, 23, 14, 0, -20 },
  { 329, 13, 18, 14, 1, -18 },
  { 359, 12, 18, 14, 1, -18 },
  { 386, 13, 18, 14, 1, -18 },
  { 416, 13, 18, 14, 1, -18 },
  { 446, 12, 18, 14, 1, -18 },
  { 473, 13, 18, 14, 1, -18 },
  { 503, 12, 18, 14, 1, -18 },
  { 530, 13, 18, 14, 2, -18 },
  { 560, 13, 18, 14, 1, -18 },
  { 590, 12, 18, 14, 2, -18 },
  { 617, 6, 13, 14, 4, -13 },
  { 627, 8, 17, 14, 2, -13 },
  { 644, 12, 13, 14, 2, -14 },
  { 664, 11, 8, 14, 2, -12 },
  { 675, 12, 13, 14, 1, -14 },
  { 695, 10, 18, 14, 3, -18 },
  { 718, 15, 22, 14, 0, -18 },
  { 760, 12, 18, 14, 0, -18 },
  { 787, 13, 18, 14, 1, -18 },
  { 817, 13, 18, 14, 1, -18 },
  { 847, 13, 18, 14, 1, -18 },
  { 877, 13, 18, 14, 1, -18 },
  { 907, 14, 18, 14, 1, -18 },
  { 939, 13, 18, 14, 1, -18 },
  { 969, 13, 18, 14, 1, -18 },
  { 999, 13, 18, 14, 1, -18 },
  { 1029, 14, 18, 14, 0, -18 },
  { 1061, 14, 18, 14, 1, -18 },
  { 1093, 11, 18, 14, 1, -18 },
  { 1118, 15, 18, 14, 0, -18 },
  { 1152, 13, 18, 14, 1, -18 },
  { 1182, 13, 18, 14, 1, -18 },
  { 1212, 14, 18, 14, 1, -18 },
  { 1244, 13, 22, 14, 1, -18 },
  { 1280, 13, 18, 14, 1, -18 },
  { 1310, 13, 18, 14, 1, -18 },
  { 1340, 13, 18, 14, 2, -18 },
  { 1370, 13, 18, 14, 1, -18 },
  { 1400, 12, 18, 14, 3, -18 },
  { 1427, 15, 18, 14, 1, -18 },
  { 1461, 15, 18, 14, 0, -18 },
  { 1495, 14, 18, 14, 2, -18 },
  { 1527, 13, 18, 14, 1, -18 },
  { 1557, 10, 23, 14, 3, -20 },
  { 1586, 7, 23, 14, 4, -20 },
  { 1607, 10, 23, 14, 2, -20 },
  { 1636, 11, 10, 14, 2, -18 },
  { 1650, 12, 2, 14, 0, 1 },
  { 1653, 5, 4, 14, 6, -19 },
  { 1656, 13, 13, 14, 1, -13 },
  { 1678, 12, 18, 14, 1, -18 },
  { 1705, 12, 13, 14, 1, -13 },
  { 1725, 13, 18, 14, 1, -18 },
  { 1755, 12, 13, 14, 1, -13 },
  { 1775, 16, 22, 14, -1, -18 },
  { 1819, 13, 17, 14, 1, -13 },
  { 1847, 12, 18, 14, 1, -18 },
  { 1874, 12, 19, 14, 1, -19 },
  { 1903, 13, 23, 14, 0, -19 },
  { 1941, 13, 18, 14, 1, -18 },
  { 1971, 11, 18, 14, 2, -18 },
  { 1996, 14, 13, 14, 0, -13 },
  { 2019, 12, 13, 14, 1, -13 },
  { 2039, 12, 13, 14, 1, -13 },
  { 2059, 13, 17, 14, 0, -13 },
  { 2087, 13, 17, 14, 1, -13 },
  { 2115, 13, 13, 14, 1, -13 },
  { 2137, 12, 13, 14, 1, -13 },
  { 2157, 12, 17, 14, 2, -17 },
  { 2183, 13, 13, 14, 1, -13 },
  { 2205, 12, 13, 14, 2, -13 },
  { 2225, 13, 13, 14, 2, -13 },
  { 2247, 14, 13, 14, 0, -13 },
  { 2270, 12, 17, 14, 1, -13 },
  { 2296, 12, 13, 14, 1, -13 },
  { 2316, 13, 23, 14, 2, -20 },
  { 2354, 7, 23, 14, 4, -20 },
  { 2375, 13, 23, 14, 0, -20 },
  { 2413, 13, 5, 14, 1, -11 },
};

const GFXfont JetBrainsMono_SemiBoldItalic24pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic24pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC24PT7B_H_
