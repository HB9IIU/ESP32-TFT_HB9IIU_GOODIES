#ifndef _JETBRAINSMONO_SEMIBOLDITALIC36PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xF8, 0x7C, 0x1F, 0x00, 0x7C, 0x7B,
  0xC3, 0xDE, 0x1E, 0xF1, 0xF7, 0x8F, 0xFC, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0,
  0xF7, 0x87, 0xBC, 0x38, 0x00, 0x38, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0x07,
  0x00, 0x1C, 0x1C, 0x00, 0xF0, 0x70, 0x03, 0x83, 0x80, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x07, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xE0,
  0xE0, 0x03, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x27, 0x83, 0x80, 0x1C,
  0x1C, 0x00, 0x70, 0x70, 0x03, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x38, 0x38,
  0x01, 0xC1, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE,
  0x0F, 0xDB, 0xE0, 0xF1, 0x9F, 0x1F, 0x39, 0xF1, 0xE3, 0x1F, 0x1E, 0x30,
  0x01, 0xF3, 0x00, 0x1F, 0xB0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x6F, 0xC0, 0x06, 0x7C, 0x00,
  0xE3, 0xC0, 0x0E, 0x3C, 0x78, 0xC3, 0xC7, 0x8C, 0x7C, 0x7C, 0xCF, 0x87,
  0xEF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x01, 0xF8,
  0x03, 0xC0, 0xFF, 0x01, 0xE0, 0x79, 0xE0, 0x70, 0x3C, 0x38, 0x38, 0x0E,
  0x0E, 0x1C, 0x03, 0x87, 0x8E, 0x00, 0xE1, 0xC7, 0x00, 0x38, 0x73, 0xC0,
  0x0E, 0x3D, 0xE0, 0x03, 0xFE, 0x70, 0x00, 0x7F, 0x38, 0x00, 0x02, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x01,
  0xEF, 0xF0, 0x00, 0x77, 0xFC, 0x00, 0x39, 0xC7, 0x80, 0x1C, 0xE0, 0xE0,
  0x0E, 0x38, 0x38, 0x07, 0x0E, 0x1C, 0x03, 0xC3, 0x87, 0x01, 0xE0, 0xE1,
  0xC0, 0x70, 0x3F, 0xE0, 0x38, 0x0F, 0xF8, 0x3C, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0x87, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE1,
  0xF7, 0x9F, 0x1E, 0x78, 0xF3, 0xC7, 0x8F, 0xFC, 0xF0, 0x7F, 0x8F, 0x03,
  0xF0, 0xF0, 0x3E, 0x0F, 0x01, 0xE0, 0xF0, 0x3F, 0x0F, 0x8F, 0xF0, 0xFF,
  0xFF, 0x87, 0xFE, 0x78, 0x3F, 0x87, 0xC0, 0x7B, 0xDF, 0xFF, 0xFB, 0xDE,
  0xF7, 0xB8, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x20,
  0x07, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x3F, 0xC0, 0x7F, 0x00,
  0xF8, 0x01, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xC1, 0xC1, 0x9F, 0x38, 0xFF, 0xF7,
  0x7F, 0xFF, 0x7F, 0xE3, 0xFF, 0xE0, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x77,
  0x80, 0x1E, 0xF0, 0x07, 0x8F, 0x01, 0xE1, 0xF0, 0x7C, 0x3E, 0x07, 0x03,
  0x80, 0x40, 0x40, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C,
  0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3C, 0xFD, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0x7C, 0x3C, 0x07, 0x8F, 0x00, 0xF9,
  0xE0, 0x0F, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x3C, 0x21, 0xE7,
  0x9E, 0x3C, 0xF3, 0xE7, 0x9E, 0x7D, 0xE3, 0xC7, 0x3C, 0x78, 0x07, 0x9E,
  0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x3E,
  0x07, 0xC7, 0xE3, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x81, 0xF3, 0xC0, 0xF1,
  0xE0, 0x61, 0xF0, 0x60, 0xF8, 0x20, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xC3, 0xE0, 0xF0, 0x1E, 0x1E,
  0x01, 0xE1, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF,
  0xF8, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x84,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1F, 0x1F, 0x8F, 0xC1, 0xFF,
  0xF0, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x1E, 0x3E, 0x07, 0x8F,
  0x01, 0xE7, 0xC0, 0xF9, 0xE0, 0x3E, 0xF0, 0x0F, 0x3F, 0xFF, 0xCF, 0xFF,
  0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x0F, 0xFF, 0xE1, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x9F, 0xC0, 0xF7, 0xFC, 0x1F, 0xFF, 0x83, 0xF1, 0xF8,
  0x78, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x8F, 0x00, 0xF1, 0xF0, 0x3E, 0x3F, 0x1F, 0x83,
  0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x7E, 0x1F, 0x8F, 0x81, 0xF3, 0xE0, 0x1E, 0x78, 0x03, 0xCF,
  0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x78, 0xF8, 0x1F, 0x1F,
  0x8F, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xBC, 0x03, 0xCF, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xC3, 0xE0, 0xF0, 0x1E, 0x0F,
  0x01, 0xE1, 0xF0, 0x1E, 0x1F, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x87, 0xC0,
  0xFD, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFE, 0x00, 0xF9, 0xF8,
  0x1E, 0x0F, 0x83, 0xC0, 0x7C, 0x7C, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07,
  0xC7, 0x80, 0x78, 0x7C, 0x0F, 0x87, 0xE1, 0xF0, 0x3F, 0xFF, 0x03, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x70, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F,
  0xFE, 0x3F, 0x0F, 0x9F, 0x01, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x7B, 0xE0, 0x1E, 0xF8, 0x0F, 0x9F, 0x9F, 0xC7,
  0xFF, 0xF0, 0xFF, 0x78, 0x0F, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF0, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0xF8, 0x7E,
  0x7F, 0x3F, 0x8F, 0x80, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x78, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80,
  0x00, 0xE0, 0x00, 0x08, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x9F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0x20, 0x00, 0x1C, 0x00, 0x0F,
  0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10,
  0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0xE0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0xFF,
  0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xE0, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0xFE, 0xFE, 0x07, 0x80, 0x78, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC7, 0x80,
  0x0F, 0x1C, 0x00, 0x3C, 0x70, 0x08, 0xF3, 0xC1, 0xFB, 0x8F, 0x0F, 0xFE,
  0x3C, 0x7C, 0x78, 0xE1, 0xE1, 0xE3, 0x87, 0x07, 0x8E, 0x1C, 0x1E, 0x78,
  0xF0, 0x79, 0xE3, 0xC1, 0xC7, 0x8F, 0x07, 0x1C, 0x38, 0x1C, 0x70, 0xE0,
  0xF1, 0xC3, 0xC3, 0xCF, 0x0F, 0xFF, 0x3C, 0x1F, 0xB8, 0xF0, 0x3C, 0xE3,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0x78, 0x01, 0xEF,
  0x00, 0x3D, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x0F, 0x1E,
  0x01, 0xE3, 0xC0, 0x7C, 0x38, 0x0F, 0x07, 0x01, 0xE0, 0xF0, 0x78, 0x1E,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0x01, 0xE3, 0xC0, 0x3C,
  0x78, 0x07, 0x9F, 0x00, 0xF3, 0xC0, 0x1E, 0xF8, 0x03, 0xDE, 0x00, 0x7C,
  0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xF0, 0x7E, 0x0F, 0x01,
  0xF0, 0xF0, 0x1F, 0x1F, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0,
  0x3C, 0x1E, 0x1F, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x3C,
  0x0F, 0xC3, 0xC0, 0x7C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x07, 0xC7, 0x80, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x1F, 0xFE,
  0x07, 0xFF, 0xE1, 0xF8, 0x7C, 0x3C, 0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x1F,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0xF9, 0xF0, 0x1E, 0x3E, 0x07, 0xC3,
  0xF3, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0x03, 0xE0, 0xF0,
  0x1E, 0x1F, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E,
  0x01, 0xE1, 0xE0, 0x1E, 0x3E, 0x03, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xC3,
  0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0xC0, 0x78,
  0x78, 0x0F, 0x87, 0x81, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8,
  0xFF, 0xFF, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF,
  0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1,
  0xF8, 0x7C, 0x3C, 0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x1F, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0xFF, 0x9E,
  0x1F, 0xF3, 0xC7, 0xFC, 0x78, 0xFF, 0x8F, 0x00, 0xF3, 0xE0, 0x1E, 0x7C,
  0x03, 0xCF, 0x00, 0xF9, 0xF0, 0x1E, 0x3E, 0x07, 0xC3, 0xF3, 0xF0, 0x7F,
  0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0xF0, 0x0F,
  0x0F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x1E, 0x1F, 0x01,
  0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C,
  0x07, 0xC3, 0xC0, 0x78, 0x3C, 0x07, 0x87, 0xC0, 0x78, 0x78, 0x07, 0x87,
  0x80, 0x78, 0x78, 0x0F, 0x87, 0x80, 0xF8, 0x78, 0x0F, 0x0F, 0x80, 0xF0,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x87, 0x80, 0x78, 0x3E, 0x07, 0xC1,
  0xFC, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0x80, 0x7C, 0x3C, 0x03, 0xE0, 0xF0, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x03,
  0xE0, 0x3C, 0x1F, 0x01, 0xF0, 0x78, 0x07, 0x83, 0xE0, 0x1E, 0x1F, 0x00,
  0x78, 0x78, 0x01, 0xE3, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3E, 0x00, 0xF0, 0x78,
  0x07, 0xC1, 0xE0, 0x1F, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF8, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x83, 0xE0, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x6E, 0x3F,
  0x07, 0xE1, 0xD8, 0x3F, 0x0E, 0xE3, 0xB8, 0x77, 0x1D, 0xC3, 0xB9, 0xDE,
  0x3D, 0xCE, 0xF1, 0xEE, 0xE7, 0x0F, 0x37, 0x38, 0x79, 0xB3, 0xC3, 0xCF,
  0x9E, 0x1C, 0x7C, 0xF1, 0xE3, 0xC7, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xC3,
  0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01,
  0xE3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x00,
  0x0F, 0xC0, 0xF0, 0xFC, 0x0F, 0x0F, 0xC0, 0xF0, 0xFC, 0x0F, 0x0F, 0xC0,
  0xF1, 0xFE, 0x0F, 0x1F, 0xE1, 0xE1, 0xEE, 0x1E, 0x1E, 0xE1, 0xE1, 0xEE,
  0x1E, 0x1C, 0xF1, 0xE3, 0xCF, 0x1E, 0x3C, 0x71, 0xC3, 0xC7, 0x3C, 0x3C,
  0x73, 0xC3, 0xC7, 0xBC, 0x3C, 0x7B, 0xC3, 0x87, 0xBC, 0x78, 0x3B, 0x87,
  0x83, 0xB8, 0x78, 0x3B, 0x87, 0x83, 0xF8, 0x78, 0x3F, 0x87, 0x01, 0xF8,
  0xF0, 0x1F, 0x8F, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x1F, 0xFE,
  0x07, 0xFF, 0xE1, 0xF8, 0x7C, 0x3C, 0x07, 0x8F, 0x80, 0xF1, 0xE0, 0x1E,
  0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0xC0, 0x7C,
  0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF3,
  0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x00, 0xF1, 0xF0, 0x1E, 0x3E, 0x07, 0xC3,
  0xF3, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xF0, 0x1F, 0x07,
  0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07,
  0x87, 0x80, 0x7C, 0x3C, 0x0F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x07, 0xFF, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0x7C, 0x3C, 0x07, 0x8F, 0x80, 0xF9,
  0xE0, 0x1F, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x3E, 0x01, 0xE7,
  0x80, 0x3C, 0xF0, 0x0F, 0x9E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x9F,
  0x00, 0xF3, 0xE0, 0x1E, 0x78, 0x07, 0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x3E,
  0x07, 0xC7, 0xF3, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xF0, 0x7F,
  0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x01,
  0xF1, 0xE0, 0x1E, 0x1E, 0x03, 0xE1, 0xE0, 0xFC, 0x3F, 0xFF, 0x83, 0xFF,
  0xF0, 0x3F, 0xFE, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xE0, 0x7C,
  0x1E, 0x07, 0xC1, 0xE0, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0x78, 0x0F, 0x07,
  0x80, 0xF8, 0x78, 0x0F, 0x8F, 0x80, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0xF8,
  0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xC3, 0xE0, 0xF0, 0x1F, 0x1F, 0x01,
  0xF1, 0xE0, 0x1F, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x78, 0x03, 0xC7,
  0x80, 0x7C, 0x7C, 0x0F, 0x87, 0xF3, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1,
  0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7,
  0x80, 0x78, 0xF0, 0x0F, 0x3E, 0x03, 0xE7, 0xC0, 0x78, 0xF0, 0x0F, 0x1E,
  0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xF3, 0xE0, 0x3C, 0x78,
  0x07, 0x8F, 0x80, 0xF1, 0xF0, 0x3E, 0x1F, 0x9F, 0x83, 0xFF, 0xE0, 0x3F,
  0xF8, 0x03, 0xFC, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x1F, 0x7C,
  0x03, 0xCF, 0x80, 0x78, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0xF8, 0x78,
  0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x87, 0xC0, 0xF0,
  0xF0, 0x1E, 0x1E, 0x03, 0xC7, 0x80, 0x3C, 0xF0, 0x07, 0xBC, 0x00, 0xF7,
  0x80, 0x1E, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x78, 0x78, 0x3D, 0xE1, 0xE1, 0xE7,
  0x87, 0x87, 0x9E, 0x3E, 0x1E, 0x78, 0xF8, 0x71, 0xC3, 0x63, 0xC7, 0x0D,
  0x8F, 0x1C, 0x76, 0x38, 0x71, 0x98, 0xE1, 0xC6, 0x67, 0x87, 0x1B, 0x9E,
  0x1C, 0xEE, 0x70, 0x73, 0x39, 0xC3, 0xCC, 0xEF, 0x0F, 0x73, 0xBC, 0x3D,
  0xCE, 0xE0, 0xF6, 0x3B, 0x83, 0xD8, 0xDE, 0x0F, 0xE3, 0x78, 0x3B, 0x0D,
  0xC0, 0xEC, 0x37, 0x03, 0xF0, 0xDC, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0x80,
  0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0x0F, 0x00, 0xF0,
  0x1F, 0x03, 0xE0, 0x1E, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0x7C, 0x7C, 0x00,
  0x79, 0xF0, 0x00, 0xF3, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xBE, 0x00, 0x1E, 0x3C,
  0x00, 0x7C, 0x78, 0x01, 0xF0, 0xF8, 0x03, 0xC0, 0xF0, 0x0F, 0x81, 0xF0,
  0x3E, 0x03, 0xE0, 0x78, 0x03, 0xC1, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xFE,
  0x00, 0x7B, 0xE0, 0x1F, 0x3C, 0x07, 0xC7, 0x80, 0xF0, 0xF8, 0x3E, 0x0F,
  0x07, 0x81, 0xE1, 0xE0, 0x3C, 0x7C, 0x03, 0xCF, 0x00, 0x7B, 0xE0, 0x0F,
  0x78, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x00, 0xF8, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x80, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xFC, 0x07,
  0xBC, 0x07, 0x9C, 0x0F, 0x1C, 0x0F, 0x1E, 0x1E, 0x1E, 0x3C, 0x0E, 0x3C,
  0x0E, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xF8, 0x7C, 0x3C, 0x1E, 0x1F, 0x03, 0xF3, 0xC3,
  0xFE, 0xF1, 0xFF, 0xBC, 0x7F, 0xEF, 0x3E, 0x0F, 0xCF, 0x01, 0xE7, 0xC0,
  0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0xF9, 0xE0, 0x3C,
  0xF8, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xF3, 0xE0, 0x7C, 0xFC, 0x6F, 0x1F,
  0xFF, 0xC7, 0xFD, 0xE0, 0xFE, 0x78, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xCF, 0xC0, 0xF3,
  0xFC, 0x1E, 0xFF, 0xC3, 0xFF, 0xF8, 0x7C, 0x0F, 0x0F, 0x01, 0xE3, 0xE0,
  0x3C, 0x7C, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80,
  0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xC7, 0xC0, 0x78, 0xF8, 0x1F, 0x1F, 0xCF,
  0xC3, 0xFF, 0xF8, 0x7B, 0xFE, 0x1F, 0x3F, 0x00, 0x01, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3E, 0x07, 0xCF, 0x01, 0xF7, 0xC0, 0x7D,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x03, 0xEF, 0x80, 0xF3, 0xE0, 0x7C, 0x7E, 0x7E, 0x1F, 0xFF,
  0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0xFC, 0xF0, 0x7F, 0xDE,
  0x1F, 0xFB, 0xC3, 0xFF, 0x78, 0xF8, 0x3F, 0x1E, 0x03, 0xC7, 0xC0, 0x78,
  0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F, 0x8F, 0x01, 0xF3,
  0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xF1, 0xF0, 0x3E, 0x3F, 0x1B, 0xC3,
  0xFF, 0xF8, 0x7F, 0xDE, 0x07, 0xF3, 0xC0, 0x01, 0xFC, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x7C, 0x3E, 0x3E, 0x07, 0x8F, 0x01, 0xE7, 0x80, 0x79, 0xE0,
  0x1E, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFB, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x7C, 0x7C, 0x3E, 0x1F, 0xFF, 0x03,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF3, 0xC3, 0xFE,
  0xF1, 0xFF, 0xBC, 0x7F, 0xEF, 0x3E, 0x0F, 0xCF, 0x01, 0xE7, 0xC0, 0x79,
  0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0xF9, 0xE0, 0x3C, 0xF8,
  0x0F, 0x3E, 0x07, 0xC7, 0xC3, 0xF1, 0xFF, 0xFC, 0x7F, 0xEF, 0x0F, 0xF7,
  0xC0, 0xF1, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC1,
  0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xCF, 0xC0,
  0xF7, 0xFC, 0x1E, 0xFF, 0xC3, 0xFF, 0xF8, 0x7C, 0x1F, 0x0F, 0x01, 0xE3,
  0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0xC7,
  0x80, 0xF9, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E,
  0x01, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x1F, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x01, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x1E, 0x03,
  0xE0, 0xF0, 0x3E, 0x07, 0x83, 0xE0, 0x3C, 0x1E, 0x01, 0xE1, 0xF0, 0x1F,
  0x1F, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0,
  0x0F, 0x0F, 0x00, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3C, 0x0F, 0x81, 0xE0,
  0x7C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x87, 0xC0, 0x3E, 0x00, 0x7F, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF,
  0x03, 0xFF, 0x1E, 0xF1, 0xE0, 0xFF, 0xDF, 0x87, 0xFE, 0xFC, 0x3C, 0x79,
  0xF1, 0xE3, 0x87, 0x8E, 0x1C, 0x38, 0x70, 0xE3, 0xC7, 0x87, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0x87, 0x8F, 0x1C, 0x3C, 0x78, 0xE1, 0xC3, 0x87, 0x1E,
  0x3C, 0x38, 0xF1, 0xE1, 0xC7, 0x8F, 0x1C, 0x3C, 0x78, 0xE1, 0xE3, 0xC7,
  0x0E, 0x1C, 0x38, 0x71, 0xE1, 0xC7, 0x80, 0x1F, 0x3F, 0x03, 0xDF, 0xF0,
  0x7B, 0xFF, 0x0F, 0xFF, 0xE1, 0xF0, 0x7C, 0x3C, 0x07, 0x8F, 0x80, 0xF1,
  0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1F, 0x1E, 0x03, 0xE7,
  0xC0, 0x78, 0xF8, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F,
  0x01, 0xF1, 0xE0, 0x3C, 0x7C, 0x07, 0x80, 0x01, 0xFC, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x7F, 0xFE, 0x3E, 0x0F, 0x8F, 0x01, 0xE7, 0xC0, 0x79, 0xE0,
  0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x7B, 0xE0, 0x3E, 0xF8, 0x0F,
  0xBC, 0x03, 0xCF, 0x00, 0xF3, 0xE0, 0x7C, 0x7E, 0x7E, 0x1F, 0xFF, 0x03,
  0xFF, 0x80, 0x7F, 0x80, 0x0F, 0x9F, 0x80, 0xF3, 0xFC, 0x0F, 0x7F, 0xE0,
  0xFF, 0xFE, 0x0F, 0x81, 0xE0, 0xF0, 0x1E, 0x1F, 0x01, 0xE1, 0xF0, 0x1E,
  0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x3E, 0x3E, 0x03,
  0xE3, 0xE0, 0x3C, 0x3E, 0x03, 0xC3, 0xE0, 0x7C, 0x3F, 0x9F, 0x83, 0xFF,
  0xF8, 0x3D, 0xFF, 0x07, 0xCF, 0xC0, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF3, 0xC3,
  0xFE, 0xF1, 0xFF, 0xBC, 0xFF, 0xEF, 0x3E, 0x0F, 0xCF, 0x01, 0xE7, 0xC0,
  0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0xFB, 0xE0, 0x3C,
  0xF8, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xF3, 0xE0, 0x7C, 0xFC, 0x6F, 0x1F,
  0xFF, 0xC7, 0xFD, 0xE0, 0xFE, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x7F, 0x03, 0xDF,
  0xF0, 0x7F, 0xFF, 0x0F, 0xEF, 0xE3, 0xF0, 0x7C, 0x7C, 0x07, 0x8F, 0x00,
  0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF,
  0xF0, 0x3F, 0xFF, 0x0F, 0xC3, 0xE1, 0xE0, 0x3E, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xE3, 0xC0, 0x3C, 0x7C, 0x0F,
  0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0x81, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x3E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C,
  0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x01, 0xF7, 0xC0, 0x79, 0xE0, 0x1E, 0x78,
  0x07, 0x9E, 0x01, 0xE7, 0x80, 0xF9, 0xE0, 0x3E, 0xF8, 0x0F, 0x3E, 0x03,
  0xCF, 0x80, 0xF3, 0xE0, 0x78, 0x7E, 0x7E, 0x1F, 0xFF, 0x03, 0xFF, 0x80,
  0x7F, 0x80, 0xF0, 0x03, 0xFF, 0x00, 0x79, 0xE0, 0x1E, 0x3C, 0x03, 0xC7,
  0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x07, 0xC3, 0xC0, 0xF0, 0x3C, 0x3E, 0x07,
  0x87, 0x80, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xCF, 0x80, 0x79, 0xE0, 0x07,
  0xBC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x00, 0xF0, 0xF0, 0x7F, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0E,
  0xF1, 0xB0, 0xEF, 0x1B, 0x1E, 0xF1, 0xB1, 0xCF, 0x3B, 0x1C, 0xF3, 0x33,
  0xCF, 0x33, 0x38, 0xF7, 0x33, 0x8F, 0x63, 0x78, 0xF6, 0x37, 0x0F, 0xE3,
  0x70, 0xFC, 0x37, 0x0E, 0xC3, 0xE0, 0xEC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xC0, 0x0F, 0x00, 0xF8, 0x7C, 0x0F, 0x81, 0xE0, 0x78,
  0x0F, 0x87, 0xC0, 0x3C, 0x7C, 0x01, 0xF7, 0xC0, 0x07, 0xBC, 0x00, 0x3F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xE0, 0x03, 0xEF, 0x00, 0x3E, 0x7C, 0x01, 0xE1, 0xE0, 0x1F, 0x0F,
  0x81, 0xF0, 0x3C, 0x1F, 0x01, 0xF1, 0xF0, 0x07, 0xC0, 0x3E, 0x03, 0xCF,
  0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1F, 0x3C, 0x07, 0xDF, 0x01, 0xE7, 0xC0,
  0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0xFB, 0xE0, 0x3C,
  0xF8, 0x0F, 0x3E, 0x07, 0xCF, 0xC3, 0xF1, 0xFF, 0xBC, 0x7F, 0xFF, 0x0F,
  0xF7, 0x80, 0x41, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07,
  0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x00, 0x07, 0xC0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x1F, 0xFC, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x07, 0xF0, 0x3D, 0xFF, 0x07, 0x3F, 0xF0, 0xEF, 0x1F,
  0x3D, 0xE1, 0xFF, 0xBC, 0x3F, 0xE7, 0x03, 0xF8,
};

const GFXglyph JetBrainsMono_SemiBoldItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 10, 26, 22, 6, -26 },
  { 34, 13, 11, 22, 6, -26 },
  { 52, 22, 26, 22, 0, -26 },
  { 124, 20, 36, 22, 1, -31 },
  { 214, 26, 26, 22, -2, -26 },
  { 299, 20, 27, 22, 1, -27 },
  { 367, 5, 11, 22, 10, -26 },
  { 374, 16, 35, 22, 5, -30 },
  { 444, 15, 35, 22, 2, -30 },
  { 510, 19, 19, 22, 2, -22 },
  { 556, 18, 17, 22, 2, -20 },
  { 595, 10, 11, 22, 3, -5 },
  { 609, 12, 4, 22, 5, -14 },
  { 615, 7, 6, 22, 6, -6 },
  { 621, 22, 34, 22, 0, -30 },
  { 715, 19, 27, 22, 2, -27 },
  { 780, 17, 26, 22, 2, -26 },
  { 836, 20, 27, 22, 1, -27 },
  { 904, 19, 26, 22, 1, -26 },
  { 966, 18, 26, 22, 2, -26 },
  { 1025, 19, 26, 22, 2, -26 },
  { 1087, 19, 26, 22, 1, -26 },
  { 1149, 18, 26, 22, 4, -26 },
  { 1208, 20, 27, 22, 1, -27 },
  { 1276, 18, 27, 22, 3, -27 },
  { 1337, 9, 20, 22, 6, -20 },
  { 1360, 12, 26, 22, 3, -20 },
  { 1399, 18, 20, 22, 3, -22 },
  { 1444, 18, 12, 22, 2, -18 },
  { 1471, 17, 20, 22, 2, -22 },
  { 1514, 15, 26, 22, 5, -26 },
  { 1563, 22, 33, 22, 0, -27 },
  { 1654, 19, 26, 22, 0, -26 },
  { 1716, 20, 26, 22, 1, -26 },
  { 1781, 19, 27, 22, 2, -27 },
  { 1846, 20, 26, 22, 1, -26 },
  { 1911, 19, 26, 22, 2, -26 },
  { 1973, 21, 26, 22, 1, -26 },
  { 2042, 19, 27, 22, 2, -27 },
  { 2107, 20, 26, 22, 1, -26 },
  { 2172, 19, 26, 22, 2, -26 },
  { 2234, 21, 26, 22, 0, -26 },
  { 2303, 22, 26, 22, 1, -26 },
  { 2375, 16, 26, 22, 2, -26 },
  { 2427, 21, 26, 22, 1, -26 },
  { 2496, 20, 26, 22, 1, -26 },
  { 2561, 19, 27, 22, 2, -27 },
  { 2626, 21, 26, 22, 1, -26 },
  { 2695, 19, 33, 22, 2, -27 },
  { 2774, 20, 26, 22, 1, -26 },
  { 2839, 20, 27, 22, 1, -27 },
  { 2907, 18, 26, 22, 4, -26 },
  { 2966, 19, 26, 22, 2, -26 },
  { 3028, 19, 26, 22, 4, -26 },
  { 3090, 22, 26, 22, 2, -26 },
  { 3162, 23, 26, 22, 0, -26 },
  { 3237, 19, 26, 22, 4, -26 },
  { 3299, 20, 26, 22, 1, -26 },
  { 3364, 15, 34, 22, 5, -30 },
  { 3428, 12, 34, 22, 5, -30 },
  { 3479, 15, 34, 22, 3, -30 },
  { 3543, 16, 14, 22, 3, -26 },
  { 3571, 18, 4, 22, 0, 1 },
  { 3580, 8, 5, 22, 9, -28 },
  { 3585, 18, 20, 22, 2, -20 },
  { 3630, 19, 26, 22, 1, -26 },
  { 3692, 18, 20, 22, 2, -20 },
  { 3737, 19, 26, 22, 2, -26 },
  { 3799, 18, 20, 22, 2, -20 },
  { 3844, 25, 32, 22, -2, -26 },
  { 3944, 18, 26, 22, 2, -20 },
  { 4003, 19, 26, 22, 1, -26 },
  { 4065, 18, 28, 22, 1, -28 },
  { 4128, 20, 34, 22, 0, -28 },
  { 4213, 21, 26, 22, 1, -26 },
  { 4282, 16, 26, 22, 3, -26 },
  { 4334, 21, 20, 22, 0, -20 },
  { 4387, 19, 20, 22, 1, -20 },
  { 4435, 18, 20, 22, 2, -20 },
  { 4480, 20, 26, 22, 0, -20 },
  { 4545, 18, 26, 22, 2, -20 },
  { 4604, 19, 20, 22, 2, -20 },
  { 4652, 19, 20, 22, 1, -20 },
  { 4700, 18, 25, 22, 3, -25 },
  { 4757, 18, 20, 22, 2, -20 },
  { 4802, 19, 20, 22, 3, -20 },
  { 4850, 20, 20, 22, 2, -20 },
  { 4900, 21, 20, 22, 0, -20 },
  { 4953, 18, 26, 22, 2, -20 },
  { 5012, 19, 20, 22, 1, -20 },
  { 5060, 19, 34, 22, 3, -30 },
  { 5141, 9, 34, 22, 7, -30 },
  { 5180, 18, 34, 22, 1, -30 },
  { 5257, 19, 8, 22, 2, -17 },
};

const GFXfont JetBrainsMono_SemiBoldItalic36pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic36pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic36pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC36PT7B_H_
