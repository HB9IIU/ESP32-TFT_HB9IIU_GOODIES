#ifndef _JETBRAINSMONO_SEMIBOLDITALIC62PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x7F, 0x81,
  0xFC, 0xFF, 0x03, 0xF9, 0xFC, 0x0F, 0xF3, 0xF8, 0x1F, 0xE7, 0xF0, 0x3F,
  0xCF, 0xE0, 0x7F, 0x3F, 0xC0, 0xFE, 0x7F, 0x81, 0xFC, 0xFE, 0x03, 0xF9,
  0xFC, 0x07, 0xF3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xC0, 0x7F, 0x1F,
  0x80, 0xFE, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF1, 0xFC, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x3F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xF8, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0xF3, 0xFE,
  0x01, 0xFC, 0x3C, 0x7F, 0x80, 0xFF, 0x0F, 0x0F, 0xE0, 0x3F, 0x83, 0xC3,
  0xFC, 0x0F, 0xE1, 0xE0, 0xFE, 0x07, 0xF8, 0x78, 0x00, 0x01, 0xFE, 0x1E,
  0x00, 0x00, 0x7F, 0x87, 0x80, 0x00, 0x1F, 0xE1, 0xE0, 0x00, 0x07, 0xF8,
  0x78, 0x00, 0x01, 0xFF, 0x1C, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xE7, 0xFE, 0x00, 0x00, 0x78, 0xFF, 0x80, 0x00, 0x3C,
  0x1F, 0xE0, 0x00, 0x0F, 0x07, 0xF8, 0x00, 0x03, 0xC1, 0xFE, 0x00, 0x00,
  0xF0, 0x7F, 0x87, 0xF0, 0x3C, 0x1F, 0xC1, 0xFC, 0x0F, 0x07, 0xF0, 0x7F,
  0x07, 0x81, 0xFC, 0x1F, 0xE1, 0xE0, 0xFF, 0x07, 0xF8, 0x78, 0x7F, 0x81,
  0xFF, 0x9E, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x80, 0x00,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x00,
  0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x00, 0x0F,
  0x80, 0xFC, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x0F,
  0x87, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xC7,
  0xE0, 0x00, 0x03, 0xFD, 0xFE, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xE3, 0xE0,
  0x00, 0x00, 0x7F, 0xFE, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xE3, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x8F, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0x9F, 0xFF, 0xC0, 0x00, 0x01, 0xF9, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x8F,
  0xC3, 0xF0, 0x00, 0x00, 0xF8, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0x87, 0xC0,
  0x7E, 0x00, 0x00, 0xFC, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0xC1, 0xF0, 0x1F,
  0x80, 0x00, 0xFC, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x07, 0xC0,
  0x00, 0x7C, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00,
  0x7C, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x00, 0x7E,
  0x00, 0x7F, 0xBF, 0xC0, 0x07, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7E, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xF8,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x1F, 0xE3, 0xF8, 0xFE, 0x03, 0xF8, 0xFF, 0x1F, 0xE0,
  0xFE, 0x1F, 0xC1, 0xFE, 0x3F, 0x83, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0x03,
  0xFD, 0xFC, 0x0F, 0xE0, 0x3F, 0xFF, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x7F,
  0x00, 0x7F, 0xF8, 0x0F, 0xE0, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0x80, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xFC, 0x03, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xEF, 0xF0, 0x1F,
  0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xE0, 0x0F, 0xFE, 0x01, 0xFE,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x7F, 0x9F,
  0xE7, 0xF9, 0xFC, 0x7F, 0x1F, 0xC7, 0xF3, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x10, 0x01, 0xF8, 0x01, 0x0E, 0x00, 0xF8, 0x03, 0x8F,
  0xE0, 0x7C, 0x0F, 0xC7, 0xF8, 0x3C, 0x1F, 0xF7, 0xFF, 0x1E, 0x3F, 0xFF,
  0xFF, 0xCE, 0x7F, 0xFF, 0xFF, 0xF7, 0x7F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x07,
  0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x02, 0x01,
  0xFC, 0x3F, 0xE7, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF,
  0xFC, 0x7F, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFE, 0x1F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x38, 0x1F, 0xC1, 0xFC, 0x7E,
  0x0F, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x1F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0xC3, 0xF8, 0xFE, 0x0F, 0xE0,
  0xF8, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFE, 0xFE, 0x00, 0xFF, 0xCF, 0xF0, 0x07, 0xFC, 0x7F, 0x80, 0x3F, 0x83,
  0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0x00, 0xFE, 0x00, 0x70, 0x07, 0xF0,
  0x06, 0x00, 0x7F, 0x80, 0x20, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xF8,
  0x7F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0xC7,
  0xF0, 0x00, 0x7F, 0x8F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x0F, 0xE3,
  0xFF, 0xC0, 0x0F, 0xE7, 0xFF, 0xE0, 0x0F, 0xEF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xF0,
  0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x3F, 0x00, 0x03, 0xFC,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x07, 0xFE, 0x1F, 0xF0,
  0x03, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x03, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x9F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8,
  0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xF3, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x1F,
  0xE0, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF9, 0xFC,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFE, 0xFE, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x7F, 0x8F, 0xF8, 0x01, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0xFF,
  0x00, 0x1F, 0xF9, 0xFC, 0x00, 0x0B, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x03, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0xE0, 0x7F,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F,
  0x80, 0x0C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF1, 0xF8, 0x3F, 0x00, 0x7F,
  0xF7, 0xE0, 0xFC, 0x03, 0xFF, 0xDF, 0x83, 0xF0, 0x1F, 0xFF, 0x3E, 0x0F,
  0xC0, 0xFF, 0x0F, 0xF8, 0x7E, 0x03, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0xC0,
  0x3F, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x7E,
  0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0xFE, 0x01,
  0xF8, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF0,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x03, 0xF0, 0x07,
  0xE1, 0xFC, 0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x7F, 0x00, 0xFC, 0x1F, 0x81,
  0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFF,
  0x07, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0x80, 0xFF, 0xFB, 0xF0, 0xFC, 0x01,
  0xFF, 0xCF, 0x83, 0xF0, 0x03, 0xFE, 0x3E, 0x0F, 0xC0, 0x01, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x07, 0xF1, 0xF8, 0x00,
  0x07, 0xF1, 0xF8, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x0F, 0xE1, 0xF8, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x1F,
  0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xE0, 0x7F, 0xFC, 0x07, 0xF0, 0x01, 0xFF, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFE,
  0x07, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC,
  0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0xC0,
  0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xB4, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0x80, 0x7F, 0xF8, 0x0F, 0xE0, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x0F, 0xF8, 0x1F, 0xE0,
  0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03,
  0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x03, 0xFF,
  0xF8, 0x3F, 0x83, 0xFF, 0xFC, 0x3F, 0xC1, 0xFF, 0xFE, 0x1F, 0xC0, 0xFF,
  0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0x07, 0xF0, 0x3F, 0xFF, 0x83, 0xF8, 0x1F,
  0xFF, 0xC1, 0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x07, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xB4, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x7F, 0x80, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xE8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x1F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x3F, 0xC0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xC0,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F,
  0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x03, 0xFF,
  0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0xBE, 0x01, 0xFF, 0xC0, 0x7D, 0xF0,
  0x1F, 0xFE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xDF, 0x00,
  0xF9, 0xE0, 0x7D, 0xF8, 0x0F, 0xCF, 0x83, 0xEF, 0xC0, 0x7E, 0x7C, 0x3E,
  0x7E, 0x03, 0xF3, 0xE1, 0xF3, 0xF0, 0x1F, 0x9F, 0x1F, 0x3F, 0x80, 0xFC,
  0xF8, 0xF9, 0xF8, 0x07, 0xE7, 0xCF, 0x8F, 0xC0, 0x7F, 0x1E, 0x7C, 0x7E,
  0x03, 0xF8, 0xF3, 0xE3, 0xF0, 0x1F, 0xC7, 0xFE, 0x3F, 0x80, 0xFC, 0x3F,
  0xF1, 0xFC, 0x07, 0xE1, 0xFF, 0x0F, 0xC0, 0x3F, 0x0F, 0xF8, 0x7E, 0x03,
  0xF8, 0x7F, 0x87, 0xF0, 0x1F, 0xC1, 0xFC, 0x3F, 0x80, 0xFE, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x3F,
  0xE0, 0x01, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0xFF, 0xC0, 0x07, 0xE0,
  0x3F, 0xF8, 0x01, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0xE0, 0x07,
  0xF0, 0x1F, 0xFE, 0x00, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xC0, 0x7F, 0xF8,
  0x03, 0xF0, 0x0F, 0xFF, 0x00, 0x7E, 0x03, 0xFB, 0xE0, 0x1F, 0xC0, 0x7E,
  0x7E, 0x03, 0xF8, 0x0F, 0xCF, 0xC0, 0x7F, 0x01, 0xF9, 0xF8, 0x0F, 0xE0,
  0x3F, 0x3F, 0x01, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x01, 0xFC, 0x7C, 0x0F,
  0xE0, 0x3F, 0x8F, 0xC1, 0xFC, 0x07, 0xF1, 0xF8, 0x3F, 0x80, 0xFE, 0x3F,
  0x07, 0xF0, 0x1F, 0x87, 0xE0, 0xFC, 0x03, 0xF0, 0x7C, 0x1F, 0x80, 0xFE,
  0x0F, 0xC7, 0xF0, 0x1F, 0xC1, 0xF8, 0xFE, 0x03, 0xF8, 0x3F, 0x1F, 0xC0,
  0x7F, 0x07, 0xE3, 0xF8, 0x0F, 0xC0, 0x7C, 0x7E, 0x01, 0xF8, 0x0F, 0xCF,
  0xC0, 0x7F, 0x01, 0xF9, 0xF8, 0x0F, 0xE0, 0x3F, 0x3F, 0x01, 0xFC, 0x07,
  0xE7, 0xE0, 0x3F, 0x80, 0xFD, 0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0x80, 0xFC,
  0x01, 0xFF, 0xE0, 0x1F, 0x80, 0x3F, 0xFC, 0x07, 0xF0, 0x07, 0xFF, 0x80,
  0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xC0, 0x0F, 0xFE, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xC0, 0x07, 0xFE, 0x03, 0xF8, 0x00,
  0xFF, 0xC0, 0x7F, 0x00, 0x0F, 0xF8, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01,
  0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x80,
  0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x0F,
  0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0x80, 0x03,
  0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x01,
  0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xE0, 0x07, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xBF, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0,
  0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE,
  0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0xF0, 0x1F, 0xC0, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x7F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x7F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFA, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0,
  0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0x81, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x01,
  0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF8,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x1F,
  0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x01, 0xFC, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x3F,
  0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x01, 0xFC,
  0xFE, 0x03, 0xF8, 0x07, 0xE3, 0xF8, 0x0F, 0xE0, 0x1F, 0x8F, 0xE0, 0x3F,
  0x80, 0xFE, 0x3F, 0x01, 0xFE, 0x03, 0xF0, 0xFC, 0x07, 0xF8, 0x0F, 0xC3,
  0xF0, 0x1F, 0xE0, 0x3F, 0x0F, 0xC0, 0x7F, 0x81, 0xF8, 0x3F, 0x03, 0xDE,
  0x07, 0xE0, 0xFC, 0x0F, 0x78, 0x1F, 0x83, 0xF0, 0x3D, 0xE0, 0x7E, 0x0F,
  0xC0, 0xF7, 0x83, 0xF0, 0x3F, 0x07, 0x9E, 0x0F, 0xC0, 0xFC, 0x1E, 0x78,
  0x3F, 0x03, 0xF0, 0x79, 0xE0, 0xFC, 0x0F, 0xC3, 0xE7, 0x87, 0xE0, 0x3F,
  0x0F, 0x1E, 0x1F, 0x80, 0xFC, 0x3C, 0x78, 0x7E, 0x03, 0xF0, 0xF3, 0xC1,
  0xF8, 0x0F, 0x87, 0x8F, 0x0F, 0xC0, 0x7E, 0x1E, 0x3C, 0x3F, 0x01, 0xF8,
  0x78, 0xF0, 0xFC, 0x07, 0xE3, 0xE3, 0xC3, 0xE0, 0x1F, 0x8F, 0x0F, 0x1F,
  0x80, 0x7E, 0x3C, 0x3C, 0x7E, 0x01, 0xF8, 0xF0, 0xF1, 0xF8, 0x07, 0xE7,
  0xC3, 0xC7, 0xC0, 0x1F, 0x9E, 0x0F, 0x3F, 0x00, 0x7E, 0x78, 0x3C, 0xFC,
  0x01, 0xF9, 0xE0, 0xF3, 0xF0, 0x07, 0xEF, 0x03, 0xCF, 0x80, 0x1F, 0xBC,
  0x0F, 0x7E, 0x00, 0x7E, 0xF0, 0x3D, 0xF8, 0x01, 0xF7, 0xC0, 0xF7, 0xC0,
  0x07, 0xDE, 0x03, 0xDF, 0x00, 0x1F, 0x78, 0x0F, 0xFC, 0x00, 0x7D, 0xE0,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x1E, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x07,
  0xF9, 0xFC, 0x00, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x1F, 0xE7, 0xF0,
  0x00, 0x07, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x0F,
  0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x07, 0xF8, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x0F,
  0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0,
  0xFF, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFE, 0x1F, 0x80,
  0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x81, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xFE,
  0x1F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE7, 0xF0,
  0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0x00, 0x7F, 0xFC, 0xFF, 0x01,
  0xFF, 0xFE, 0xFF, 0x03, 0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0xFE, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xF0, 0x03, 0xFE, 0x1F,
  0xE0, 0x03, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F,
  0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F,
  0x80, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F,
  0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0xCF, 0xE0, 0x0F,
  0xFF, 0x8F, 0xE0, 0x07, 0xFE, 0x1F, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0x80, 0x03, 0xF8, 0x7F, 0xE0, 0x07,
  0xF9, 0xFF, 0xF8, 0x07, 0xF3, 0xFF, 0xF8, 0x07, 0xF7, 0xFF, 0xFC, 0x07,
  0xF7, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x0F,
  0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x1F,
  0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F,
  0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F,
  0xC0, 0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF0, 0x7F,
  0x7F, 0xFF, 0xE0, 0x7F, 0x7F, 0xFF, 0xE0, 0x7F, 0x7F, 0xFF, 0xC0, 0x7F,
  0x7F, 0xFF, 0x80, 0xFF, 0x3F, 0xFE, 0x00, 0xFE, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x0F, 0xF0,
  0x03, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFE, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x7F, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x07, 0xF0, 0x00, 0xFF,
  0xE1, 0xFC, 0x00, 0x7F, 0xFC, 0xFF, 0x00, 0x7F, 0xFF, 0xBF, 0xC0, 0x3F,
  0xFF, 0xEF, 0xE0, 0x0F, 0xFF, 0xFB, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0xF8,
  0x1F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0xFF, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFB, 0xF8, 0x01, 0xFF, 0xFC,
  0xFE, 0x00, 0x3F, 0xFE, 0x3F, 0x80, 0x07, 0xFE, 0x1F, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xE0,
  0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x7F, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xFE, 0x0F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x20, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x40, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x7F, 0x00, 0x7F, 0xFC, 0xFF, 0x01, 0xFF, 0xFE, 0xFF, 0x03, 0xFF, 0xFE,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x07,
  0xFE, 0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x03, 0xFE, 0x1F, 0xE0, 0x01,
  0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01,
  0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03,
  0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x03,
  0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07,
  0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F,
  0xF0, 0x3F, 0xF9, 0xFF, 0xF0, 0x3F, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xEF, 0xE0, 0x0F, 0xFF, 0xCF, 0xE0, 0x07, 0xFF, 0x0F,
  0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x0F, 0x00, 0x03, 0xF8, 0x7F, 0xE0, 0x07, 0xF9, 0xFF,
  0xF8, 0x07, 0xF3, 0xFF, 0xFC, 0x07, 0xF7, 0xFF, 0xFC, 0x07, 0xF7, 0xFF,
  0xFE, 0x07, 0xFF, 0xDF, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00,
  0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x01,
  0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01,
  0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03,
  0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03,
  0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x07,
  0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07,
  0xF0, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0x80, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x0F,
  0xF8, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x1F,
  0xC0, 0x7F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x80, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01,
  0xE0, 0x0C, 0x00, 0xFC, 0xFE, 0x0F, 0xE0, 0x1F, 0xBF, 0xE3, 0xFE, 0x03,
  0xF7, 0xFE, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0x83, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7F, 0x0F, 0xE0,
  0x7C, 0x0F, 0xE1, 0xFC, 0x0F, 0x81, 0xFC, 0x3F, 0x81, 0xF0, 0x3F, 0x87,
  0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x1F,
  0x87, 0xF0, 0x3E, 0x07, 0xF0, 0xFE, 0x07, 0xC0, 0xFE, 0x1F, 0xC0, 0xF8,
  0x1F, 0xC3, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0x03, 0xF8, 0x7F, 0x03, 0xE0, 0x7F, 0x0F,
  0xE0, 0x7C, 0x0F, 0xE1, 0xF8, 0x0F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3F,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0x80, 0xFC, 0x3F, 0x81, 0xF0,
  0x3F, 0x87, 0xF0, 0x3E, 0x07, 0xF0, 0xFE, 0x07, 0xC0, 0xFC, 0x1F, 0x81,
  0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x03, 0xF8, 0x7F, 0xE0, 0x07, 0xF9, 0xFF, 0xF8, 0x07, 0xF3, 0xFF, 0xFC,
  0x07, 0xF7, 0xFF, 0xFC, 0x07, 0xF7, 0xFF, 0xFE, 0x07, 0xFF, 0xDF, 0xFE,
  0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFE,
  0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC,
  0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8,
  0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF0,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F,
  0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF0, 0xFE,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xFC, 0x7F, 0x00,
  0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x03,
  0xFC, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x87, 0xFE, 0x00, 0x1F, 0xE7, 0xFF,
  0xE0, 0x07, 0xF3, 0xFF, 0xF8, 0x01, 0xFD, 0xFF, 0xFF, 0x00, 0x7F, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFC, 0x07, 0xF7, 0xFF, 0xFE, 0x01, 0xFD, 0xFF, 0xFF, 0x80,
  0x7F, 0x7F, 0xFF, 0xC0, 0x1F, 0xCF, 0xFF, 0xE0, 0x0F, 0xF3, 0xFF, 0xF0,
  0x03, 0xFC, 0x3F, 0xF0, 0x00, 0xFE, 0x01, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x7F,
  0x00, 0x7F, 0xFC, 0xFF, 0x01, 0xFF, 0xFE, 0xFF, 0x03, 0xFF, 0xFE, 0xFE,
  0x07, 0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x07, 0xFE,
  0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x03, 0xFE, 0x1F, 0xE0, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xF8,
  0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8,
  0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0,
  0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xEF, 0xE0, 0x3F, 0xFF, 0xEF, 0xE0,
  0x1F, 0xFF, 0xCF, 0xE0, 0x0F, 0xFF, 0x8F, 0xE0, 0x07, 0xFE, 0x1F, 0xE0,
  0x00, 0x70, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x01, 0xFC, 0x3F, 0xF8, 0x01, 0xFC, 0x7F, 0xFE, 0x00, 0xFE, 0x7F, 0xFF,
  0x80, 0x7F, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x3F,
  0xFC, 0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x01, 0xFF,
  0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFC,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0xFF, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFF, 0x0F,
  0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x1F,
  0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F,
  0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F,
  0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F,
  0x80, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F,
  0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x7F,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x3F,
  0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F,
  0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x1F,
  0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F,
  0xE1, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0xFF,
  0xF0, 0x1F, 0xC0, 0x7E, 0xFC, 0x07, 0xF0, 0x1F, 0xBF, 0x03, 0xFC, 0x07,
  0xEF, 0xC0, 0xFF, 0x01, 0xF3, 0xF0, 0x3F, 0xC0, 0xFC, 0xFC, 0x0E, 0xF0,
  0x3F, 0x3F, 0x07, 0xBC, 0x0F, 0x8F, 0xC1, 0xEF, 0x07, 0xE3, 0xF0, 0x73,
  0xC1, 0xF8, 0xFC, 0x3C, 0xF0, 0x7C, 0x3F, 0x0F, 0x3C, 0x3F, 0x0F, 0xC3,
  0xCF, 0x0F, 0xC3, 0xF1, 0xE3, 0xC3, 0xE0, 0xFC, 0x78, 0xF0, 0xF8, 0x3F,
  0x1E, 0x3C, 0x7E, 0x0F, 0xCF, 0x0F, 0x1F, 0x83, 0xF3, 0xC3, 0xC7, 0xC0,
  0xFC, 0xF0, 0xF3, 0xF0, 0x3F, 0x78, 0x3C, 0xFC, 0x0F, 0xDE, 0x0F, 0x3E,
  0x03, 0xF7, 0x83, 0xDF, 0x80, 0xFD, 0xC0, 0xF7, 0xE0, 0x3E, 0xF0, 0x3D,
  0xF0, 0x0F, 0xBC, 0x0F, 0x7C, 0x03, 0xEF, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x03,
  0xFB, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x1F,
  0xF3, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xC0,
  0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80,
  0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80,
  0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80,
  0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0xC0,
  0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0xCF, 0xE0, 0x0F, 0xFF,
  0x8F, 0xE0, 0x03, 0xFF, 0x0F, 0xE0, 0x00, 0x60, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xC3, 0xFF, 0xE0, 0x0F, 0xC3, 0xFF,
  0xF8, 0x07, 0xE3, 0xFF, 0xFC, 0x03, 0xF1, 0xFF, 0xFF, 0x01, 0xF9, 0xFC,
  0x3F, 0xC1, 0xFC, 0xFC, 0x0F, 0xF0, 0xFC, 0x7E, 0x07, 0xFF, 0xFE, 0x3F,
  0x01, 0xFF, 0xFF, 0x1F, 0x80, 0x7F, 0xFF, 0x1F, 0xC0, 0x3F, 0xFF, 0x0F,
  0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
};

const GFXglyph JetBrainsMono_SemiBoldItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 16, 45, 37, 11, -45 },
  { 91, 23, 18, 37, 10, -45 },
  { 143, 37, 45, 37, 1, -45 },
  { 352, 34, 63, 37, 2, -54 },
  { 620, 45, 46, 37, -3, -46 },
  { 879, 35, 47, 37, 1, -46 },
  { 1085, 10, 18, 37, 17, -45 },
  { 1108, 27, 60, 37, 9, -52 },
  { 1311, 26, 60, 37, 3, -52 },
  { 1506, 33, 32, 37, 3, -38 },
  { 1638, 30, 29, 37, 4, -35 },
  { 1747, 18, 19, 37, 5, -9 },
  { 1790, 22, 7, 37, 8, -24 },
  { 1810, 12, 12, 37, 11, -11 },
  { 1828, 39, 58, 37, 0, -51 },
  { 2111, 33, 47, 37, 3, -46 },
  { 2305, 29, 45, 37, 3, -45 },
  { 2469, 34, 46, 37, 2, -46 },
  { 2665, 33, 46, 37, 2, -45 },
  { 2855, 31, 45, 37, 3, -45 },
  { 3030, 32, 46, 37, 3, -45 },
  { 3214, 32, 46, 37, 2, -45 },
  { 3398, 32, 45, 37, 6, -45 },
  { 3578, 33, 47, 37, 2, -46 },
  { 3772, 31, 46, 37, 5, -46 },
  { 3951, 16, 36, 37, 11, -35 },
  { 4023, 21, 45, 37, 6, -35 },
  { 4142, 31, 33, 37, 5, -37 },
  { 4270, 30, 21, 37, 4, -31 },
  { 4349, 30, 33, 37, 3, -37 },
  { 4473, 26, 45, 37, 8, -45 },
  { 4620, 38, 57, 37, 0, -46 },
  { 4891, 32, 45, 37, 0, -45 },
  { 5071, 34, 45, 37, 2, -45 },
  { 5263, 33, 47, 37, 3, -46 },
  { 5457, 34, 45, 37, 2, -45 },
  { 5649, 34, 45, 37, 3, -45 },
  { 5841, 35, 45, 37, 2, -45 },
  { 6038, 33, 47, 37, 3, -46 },
  { 6232, 35, 45, 37, 2, -45 },
  { 6429, 33, 45, 37, 3, -45 },
  { 6615, 36, 46, 37, 0, -45 },
  { 6822, 37, 45, 37, 2, -45 },
  { 7031, 28, 45, 37, 4, -45 },
  { 7189, 37, 45, 37, 1, -45 },
  { 7398, 35, 45, 37, 2, -45 },
  { 7595, 33, 47, 37, 3, -46 },
  { 7789, 36, 45, 37, 2, -45 },
  { 7992, 33, 57, 37, 3, -46 },
  { 8228, 35, 45, 37, 2, -45 },
  { 8425, 34, 47, 37, 2, -46 },
  { 8625, 33, 45, 37, 6, -45 },
  { 8811, 34, 46, 37, 3, -45 },
  { 9007, 32, 45, 37, 7, -45 },
  { 9187, 38, 45, 37, 3, -45 },
  { 9401, 40, 45, 37, -1, -45 },
  { 9626, 34, 45, 37, 6, -45 },
  { 9818, 34, 45, 37, 2, -45 },
  { 10010, 26, 58, 37, 8, -51 },
  { 10199, 20, 58, 37, 9, -51 },
  { 10344, 26, 58, 37, 5, -51 },
  { 10533, 28, 24, 37, 5, -45 },
  { 10617, 31, 6, 37, 0, 2 },
  { 10641, 12, 9, 37, 16, -49 },
  { 10655, 32, 36, 37, 3, -35 },
  { 10799, 32, 46, 37, 2, -45 },
  { 10983, 31, 36, 37, 3, -35 },
  { 11123, 34, 46, 37, 3, -45 },
  { 11319, 31, 36, 37, 3, -35 },
  { 11459, 42, 56, 37, -3, -45 },
  { 11753, 32, 46, 37, 3, -35 },
  { 11937, 32, 45, 37, 2, -45 },
  { 12117, 31, 49, 37, 2, -49 },
  { 12307, 33, 60, 37, 1, -49 },
  { 12555, 35, 45, 37, 2, -45 },
  { 12752, 28, 45, 37, 5, -45 },
  { 12910, 35, 35, 37, 1, -35 },
  { 13064, 32, 35, 37, 2, -35 },
  { 13204, 31, 36, 37, 3, -35 },
  { 13344, 34, 46, 37, 0, -35 },
  { 13540, 32, 46, 37, 3, -35 },
  { 13724, 33, 35, 37, 3, -35 },
  { 13869, 31, 36, 37, 3, -35 },
  { 14009, 30, 43, 37, 5, -43 },
  { 14171, 32, 35, 37, 3, -34 },
  { 14311, 32, 34, 37, 5, -34 },
  { 14447, 34, 34, 37, 4, -34 },
  { 14592, 37, 34, 37, 0, -34 },
  { 14750, 32, 45, 37, 3, -34 },
  { 14930, 32, 34, 37, 2, -34 },
  { 15066, 33, 58, 37, 5, -51 },
  { 15306, 17, 58, 37, 11, -51 },
  { 15430, 33, 58, 37, 1, -51 },
  { 15670, 33, 14, 37, 3, -29 },
};

const GFXfont JetBrainsMono_SemiBoldItalic62pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic62pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic62pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC62PT7B_H_
