#ifndef _JETBRAINSMONO_SEMIBOLDITALIC17PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x33, 0x22, 0x66, 0x00, 0xEE, 0xEF, 0x3C, 0xF2, 0xC8, 0x0C,
  0xC3, 0x20, 0x88, 0xFF, 0x19, 0x04, 0x43, 0x33, 0xFE, 0xFF, 0x99, 0x86,
  0x41, 0x30, 0x04, 0x02, 0x03, 0x07, 0xE7, 0x7B, 0x4D, 0xA0, 0xF0, 0x3E,
  0x0F, 0x82, 0xC2, 0x6D, 0x37, 0xF1, 0xF0, 0x20, 0x30, 0x00, 0x08, 0x01,
  0xE3, 0x32, 0x62, 0x6C, 0x26, 0x83, 0xD0, 0x02, 0x00, 0x48, 0x0F, 0xE1,
  0xA6, 0x32, 0x62, 0x24, 0xC3, 0xC0, 0x06, 0x07, 0xE1, 0x98, 0xC0, 0x30,
  0x06, 0x03, 0x81, 0xB7, 0x6D, 0x91, 0xCC, 0x71, 0xFC, 0x79, 0x80, 0xFF,
  0x80, 0x03, 0x0E, 0x1C, 0x38, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60,
  0x60, 0x60, 0x70, 0x38, 0x08, 0x30, 0x78, 0x30, 0x30, 0x60, 0xC1, 0x83,
  0x0C, 0x18, 0x30, 0x61, 0x86, 0x38, 0x60, 0x0C, 0x06, 0x32, 0x7F, 0xF0,
  0x81, 0xE1, 0x99, 0xCC, 0x0C, 0x0C, 0x0C, 0xFF, 0xFF, 0x18, 0x18, 0x18,
  0x19, 0xCC, 0xC6, 0x60, 0x7F, 0xF0, 0x7F, 0x80, 0x00, 0xE0, 0x18, 0x06,
  0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x0C, 0x1F, 0x9C, 0xEC, 0x36, 0x1B,
  0x0B, 0x6D, 0xB6, 0xC3, 0x61, 0xB0, 0xDF, 0xC7, 0xC0, 0x1E, 0x36, 0x6C,
  0x4C, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0xFF, 0xFF, 0x0C, 0x1F, 0x9C,
  0xEC, 0x30, 0x30, 0x18, 0x18, 0x1C, 0x1C, 0x18, 0x18, 0x1F, 0xEF, 0xE0,
  0x3F, 0x81, 0x81, 0x81, 0x81, 0xE0, 0xF8, 0x0C, 0x06, 0x03, 0x63, 0x3F,
  0x8F, 0x80, 0x07, 0x06, 0x0C, 0x18, 0x30, 0x63, 0xE3, 0xC3, 0xFE, 0x06,
  0x06, 0x06, 0x3F, 0x90, 0x18, 0x0C, 0x07, 0xE3, 0xB8, 0x0C, 0x06, 0x03,
  0x63, 0x3F, 0x8F, 0x80, 0x06, 0x0C, 0x18, 0x30, 0x7C, 0x7F, 0xE3, 0xC3,
  0xC3, 0xC3, 0xFE, 0x7C, 0xFF, 0xC3, 0xC3, 0x06, 0x0C, 0x0C, 0x18, 0x18,
  0x30, 0x70, 0x60, 0xC0, 0x0C, 0x1F, 0x9C, 0xEC, 0x36, 0x33, 0xB8, 0x70,
  0xFC, 0xC3, 0x61, 0xB0, 0xDF, 0xC7, 0xC0, 0x0C, 0x1F, 0x9C, 0xEC, 0x36,
  0x1B, 0x0D, 0x9C, 0xF6, 0x06, 0x06, 0x06, 0x07, 0x07, 0x00, 0x27, 0x70,
  0x00, 0x04, 0xEE, 0x11, 0xCE, 0x00, 0x00, 0x06, 0x73, 0x39, 0x88, 0x00,
  0x01, 0x83, 0x87, 0x8E, 0x0C, 0x07, 0x80, 0xF0, 0x1E, 0x02, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x60, 0x78, 0x1C, 0x07, 0x03, 0x0F, 0x78,
  0xE0, 0x80, 0x7C, 0x1C, 0x18, 0x30, 0xE7, 0x9E, 0x30, 0x00, 0x03, 0x87,
  0x00, 0x03, 0x07, 0xF3, 0x0C, 0x81, 0x60, 0x59, 0xD6, 0xCD, 0x33, 0x4C,
  0xF2, 0x2C, 0xDB, 0x3A, 0xC0, 0x30, 0x07, 0x00, 0xF0, 0x07, 0x07, 0x83,
  0xC3, 0x61, 0xB0, 0xD8, 0xCC, 0x7E, 0x7F, 0x30, 0xD8, 0x78, 0x30, 0x7F,
  0x31, 0xD8, 0x6C, 0x26, 0x33, 0xE3, 0x1D, 0x86, 0xC3, 0x61, 0xBF, 0x9F,
  0x80, 0x0C, 0x1F, 0x9C, 0xEC, 0x36, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60,
  0x30, 0xDF, 0xC7, 0xC0, 0x7F, 0x31, 0x98, 0x6C, 0x36, 0x33, 0x1B, 0x0D,
  0x86, 0xC3, 0x63, 0x3F, 0x9F, 0x00, 0x3F, 0xB0, 0x18, 0x0C, 0x06, 0x03,
  0xF9, 0x80, 0x80, 0xC0, 0x60, 0x3F, 0x9F, 0xC0, 0x3F, 0xB0, 0x18, 0x0C,
  0x06, 0x03, 0xF9, 0xFD, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x00, 0x0C, 0x1F,
  0x9C, 0xEC, 0x36, 0x03, 0x01, 0xBD, 0x9E, 0xC3, 0x61, 0xB0, 0xDF, 0xC7,
  0xC0, 0x71, 0xB0, 0xD8, 0x6C, 0x66, 0x33, 0xFB, 0x0D, 0x86, 0xC3, 0x63,
  0x31, 0x98, 0xC0, 0x3F, 0x86, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x3F, 0x9F, 0xC0, 0x07, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0xC3, 0x30, 0xC7, 0xF1, 0xF0, 0x71, 0xD8, 0xC6, 0x31,
  0x98, 0x6E, 0x1F, 0x0C, 0xC3, 0x30, 0xC6, 0x31, 0x8C, 0x63, 0x0C, 0x30,
  0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xFF, 0xFE, 0x38,
  0xCA, 0x52, 0x9C, 0xAF, 0x6A, 0xDB, 0xA6, 0xD9, 0x86, 0x61, 0x98, 0x64,
  0x1B, 0x06, 0x71, 0xB8, 0xDE, 0x6F, 0x27, 0x92, 0xDB, 0x2D, 0x96, 0xCF,
  0x67, 0xB3, 0x90, 0xC0, 0x0C, 0x1F, 0x9C, 0xEC, 0x36, 0x1B, 0x19, 0x8D,
  0x86, 0xC3, 0x61, 0xB1, 0x9F, 0xC7, 0xC0, 0x7F, 0x31, 0xD8, 0x6C, 0x36,
  0x1B, 0xFB, 0xF9, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x00, 0x0C, 0x1F, 0x9C,
  0xEC, 0x36, 0x1B, 0x1B, 0x0D, 0x86, 0xC3, 0x61, 0xB1, 0xDF, 0xC7, 0xC0,
  0x60, 0x30, 0x0C, 0x7F, 0x31, 0xD8, 0x6C, 0x36, 0x33, 0xFB, 0xF9, 0x98,
  0xCE, 0x63, 0x31, 0x98, 0xE0, 0x0C, 0x1F, 0x9C, 0xEC, 0x36, 0x03, 0x80,
  0xF8, 0x1E, 0x03, 0x01, 0xB0, 0xDF, 0xC7, 0xC0, 0xFF, 0x8C, 0x06, 0x03,
  0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x00, 0x71, 0xB0,
  0xD8, 0x6C, 0x26, 0x33, 0x1B, 0x0D, 0x86, 0xC3, 0x63, 0x3F, 0x8F, 0x80,
  0xC3, 0xE1, 0xB0, 0xD8, 0xCC, 0x66, 0x61, 0x30, 0x90, 0x78, 0x3C, 0x1C,
  0x0E, 0x00, 0xCC, 0xF3, 0x3C, 0xCB, 0x56, 0xD5, 0xB5, 0x6D, 0x53, 0x9C,
  0xE7, 0x39, 0x8E, 0x63, 0x18, 0x30, 0xE3, 0x30, 0x6E, 0x0D, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0xF0, 0x33, 0x06, 0x61, 0x8C, 0x60, 0xC0, 0xC3, 0xE1,
  0x99, 0x8C, 0xC6, 0xC3, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x00,
  0x3F, 0xA1, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x60, 0x70, 0x3F,
  0x9F, 0xC0, 0x1E, 0x7C, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x3E, 0x7C, 0xC6, 0x31, 0x86, 0x31, 0x8C, 0x61, 0x8C, 0x63,
  0x0C, 0x63, 0x1E, 0x3C, 0x18, 0x30, 0x60, 0xC3, 0x06, 0x0C, 0x18, 0x30,
  0x61, 0x83, 0x1E, 0x7C, 0x0E, 0x1E, 0x16, 0x32, 0x63, 0xE3, 0xFF, 0xFF,
  0xE3, 0x08, 0x9F, 0x98, 0xCC, 0x6C, 0x36, 0x1B, 0x0D, 0x8C, 0xFE, 0x3F,
  0x00, 0x70, 0x60, 0x64, 0x7F, 0x73, 0x63, 0xC3, 0xC3, 0xC3, 0xC6, 0xFE,
  0xFC, 0x08, 0x3F, 0x63, 0x63, 0xC0, 0xC0, 0xC0, 0xC3, 0xFE, 0x7C, 0x01,
  0x80, 0xC2, 0x67, 0xE6, 0x33, 0x1B, 0x0D, 0x86, 0xC3, 0x63, 0x3F, 0x8F,
  0xC0, 0x08, 0x3F, 0x63, 0x63, 0xCF, 0xFF, 0xC0, 0xC1, 0xEE, 0x7C, 0x03,
  0xF0, 0x30, 0x06, 0x00, 0x60, 0x3F, 0xE0, 0x60, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x0F, 0x80, 0xF0, 0x00, 0x08, 0x9F,
  0x98, 0xCC, 0x6C, 0x36, 0x1B, 0x0D, 0xCC, 0x7E, 0x03, 0x01, 0x8F, 0xCF,
  0x80, 0x70, 0x60, 0x64, 0x7F, 0x63, 0x63, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6,
  0xC6, 0x0E, 0x0E, 0x00, 0x00, 0x7C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18,
  0xFF, 0xFF, 0x01, 0x81, 0xC0, 0x00, 0x01, 0xF1, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x01, 0x80, 0xC0, 0x60, 0x33, 0xF1, 0xF0, 0x70, 0x30, 0x18, 0x0C,
  0x76, 0x73, 0x31, 0xF1, 0xF8, 0xCC, 0x67, 0x31, 0x98, 0xE0, 0x7C, 0x98,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x3F, 0x1F, 0x08, 0x8F,
  0xF6, 0x4D, 0x93, 0x64, 0x9B, 0x66, 0xD9, 0x26, 0xC9, 0xB2, 0x60, 0x04,
  0x7F, 0x63, 0x63, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xC6, 0x08, 0x3F, 0x63,
  0x63, 0xC3, 0xC3, 0xC3, 0xC6, 0xFE, 0x7C, 0x02, 0x1F, 0xCE, 0x66, 0x36,
  0x1B, 0x0D, 0x86, 0xC6, 0x7F, 0x3F, 0x18, 0x18, 0x0C, 0x00, 0x08, 0x9F,
  0x98, 0xCC, 0x6C, 0x36, 0x1B, 0x0D, 0x8C, 0xFE, 0x3F, 0x01, 0x80, 0xC0,
  0x60, 0x04, 0x37, 0x9C, 0xEC, 0x36, 0x33, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x00, 0x08, 0x3F, 0x63, 0x60, 0x78, 0x3E, 0x03, 0x03, 0xEE, 0x7C, 0x18,
  0x0C, 0x06, 0x1F, 0xF1, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0x83,
  0xC0, 0x63, 0xB1, 0x98, 0xD8, 0x6C, 0x36, 0x1B, 0x19, 0xFC, 0x7C, 0x00,
  0xE1, 0xB1, 0x98, 0xCC, 0xC6, 0x63, 0x60, 0xF0, 0x70, 0x38, 0x00, 0xCC,
  0xF5, 0x6D, 0x5B, 0x54, 0xF7, 0x39, 0xCE, 0x63, 0x98, 0xCE, 0x00, 0x31,
  0xC6, 0xE1, 0xB0, 0x38, 0x0C, 0x07, 0x83, 0x61, 0x8C, 0xE3, 0x80, 0x63,
  0xB1, 0x98, 0xD8, 0x6C, 0x36, 0x1B, 0xB8, 0xFC, 0x06, 0x03, 0x1F, 0x9F,
  0x00, 0x7F, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFE, 0xFE, 0x03, 0x83,
  0xC1, 0x80, 0xC0, 0x40, 0x60, 0x30, 0xF0, 0xF8, 0x06, 0x03, 0x03, 0x01,
  0x80, 0xC0, 0x78, 0x1C, 0x39, 0x8C, 0x63, 0x18, 0xCC, 0x63, 0x18, 0xC6,
  0x63, 0x18, 0x1C, 0x0F, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x0F, 0x0F,
  0x8C, 0x06, 0x03, 0x01, 0x80, 0xC1, 0xC1, 0xC0, 0x71, 0xFC, 0xF3, 0xD9,
  0xC0,
};

const GFXglyph JetBrainsMono_SemiBoldItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 12, 10, 3, -12 },
  { 7, 6, 5, 10, 3, -12 },
  { 11, 10, 12, 10, 0, -12 },
  { 26, 9, 17, 10, 1, -15 },
  { 46, 12, 13, 10, -1, -13 },
  { 66, 10, 13, 10, 0, -13 },
  { 83, 2, 5, 10, 5, -12 },
  { 85, 8, 16, 10, 2, -14 },
  { 101, 7, 16, 10, 1, -14 },
  { 115, 9, 8, 10, 1, -10 },
  { 124, 8, 8, 10, 1, -10 },
  { 132, 5, 6, 10, 1, -3 },
  { 136, 6, 2, 10, 2, -7 },
  { 138, 3, 3, 10, 3, -3 },
  { 140, 11, 16, 10, 0, -14 },
  { 162, 9, 13, 10, 1, -13 },
  { 177, 8, 12, 10, 1, -12 },
  { 189, 9, 13, 10, 1, -13 },
  { 204, 9, 12, 10, 1, -12 },
  { 218, 8, 12, 10, 1, -12 },
  { 230, 9, 12, 10, 1, -12 },
  { 244, 8, 12, 10, 1, -12 },
  { 256, 8, 12, 10, 2, -12 },
  { 268, 9, 13, 10, 1, -13 },
  { 283, 9, 13, 10, 1, -13 },
  { 298, 4, 10, 10, 3, -10 },
  { 303, 5, 13, 10, 2, -10 },
  { 312, 9, 9, 10, 1, -10 },
  { 323, 8, 6, 10, 1, -9 },
  { 329, 8, 9, 10, 1, -10 },
  { 338, 7, 12, 10, 2, -12 },
  { 349, 10, 16, 10, 0, -13 },
  { 369, 9, 12, 10, 0, -12 },
  { 383, 9, 12, 10, 1, -12 },
  { 397, 9, 13, 10, 1, -13 },
  { 412, 9, 12, 10, 1, -12 },
  { 426, 9, 12, 10, 1, -12 },
  { 440, 9, 12, 10, 1, -12 },
  { 454, 9, 13, 10, 1, -13 },
  { 469, 9, 12, 10, 1, -12 },
  { 483, 9, 12, 10, 1, -12 },
  { 497, 10, 12, 10, 0, -12 },
  { 512, 10, 12, 10, 1, -12 },
  { 527, 8, 12, 10, 1, -12 },
  { 539, 10, 12, 10, 0, -12 },
  { 554, 9, 12, 10, 1, -12 },
  { 568, 9, 13, 10, 1, -13 },
  { 583, 9, 12, 10, 1, -12 },
  { 597, 9, 16, 10, 1, -13 },
  { 615, 9, 12, 10, 1, -12 },
  { 629, 9, 13, 10, 1, -13 },
  { 644, 9, 12, 10, 2, -12 },
  { 658, 9, 12, 10, 1, -12 },
  { 672, 9, 12, 10, 2, -12 },
  { 686, 10, 12, 10, 1, -12 },
  { 701, 11, 12, 10, 0, -12 },
  { 718, 9, 12, 10, 2, -12 },
  { 732, 9, 12, 10, 1, -12 },
  { 746, 7, 16, 10, 2, -14 },
  { 760, 5, 16, 10, 3, -14 },
  { 770, 7, 16, 10, 1, -14 },
  { 784, 8, 6, 10, 1, -12 },
  { 790, 8, 2, 10, 0, 0 },
  { 792, 4, 2, 10, 4, -13 },
  { 793, 9, 10, 10, 1, -10 },
  { 805, 8, 12, 10, 1, -12 },
  { 817, 8, 10, 10, 1, -10 },
  { 827, 9, 12, 10, 1, -12 },
  { 841, 8, 10, 10, 1, -10 },
  { 851, 12, 15, 10, -1, -12 },
  { 874, 9, 13, 10, 1, -10 },
  { 889, 8, 12, 10, 1, -12 },
  { 901, 8, 13, 10, 1, -13 },
  { 914, 9, 16, 10, 0, -13 },
  { 932, 9, 12, 10, 1, -12 },
  { 946, 8, 12, 10, 1, -12 },
  { 958, 10, 10, 10, 0, -10 },
  { 971, 8, 10, 10, 1, -10 },
  { 981, 8, 10, 10, 1, -10 },
  { 991, 9, 13, 10, 0, -10 },
  { 1006, 9, 13, 10, 1, -10 },
  { 1021, 9, 10, 10, 1, -10 },
  { 1033, 8, 10, 10, 1, -10 },
  { 1043, 9, 12, 10, 1, -12 },
  { 1057, 9, 9, 10, 1, -9 },
  { 1068, 9, 9, 10, 1, -9 },
  { 1079, 10, 9, 10, 1, -9 },
  { 1091, 10, 9, 10, 0, -9 },
  { 1103, 9, 12, 10, 1, -9 },
  { 1117, 8, 9, 10, 1, -9 },
  { 1126, 9, 16, 10, 1, -14 },
  { 1144, 5, 16, 10, 3, -14 },
  { 1154, 9, 16, 10, 0, -14 },
  { 1172, 9, 4, 10, 1, -8 },
};

const GFXfont JetBrainsMono_SemiBoldItalic17pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic17pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC17PT7B_H_
