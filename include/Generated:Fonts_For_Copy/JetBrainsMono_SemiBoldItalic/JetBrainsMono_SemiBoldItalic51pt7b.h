#ifndef _JETBRAINSMONO_SEMIBOLDITALIC51PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0xFC, 0x3F, 0xE1, 0xFE, 0x07,
  0xE0, 0x00, 0x7F, 0x0F, 0xEF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7,
  0xE0, 0xFD, 0xFC, 0x3F, 0xBF, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F,
  0x83, 0xF3, 0xF0, 0x7E, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0xF8,
  0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x7C, 0x07,
  0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x78, 0x0F, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x3C, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x3C, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80,
  0xF8, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x07, 0xF1, 0xCF, 0xE0, 0x7E, 0x3C, 0x7E, 0x0F, 0xE3,
  0x87, 0xE0, 0xFC, 0x38, 0x7E, 0x0F, 0xC3, 0x80, 0x00, 0xFC, 0x38, 0x00,
  0x0F, 0xC3, 0x80, 0x00, 0xFE, 0x78, 0x00, 0x0F, 0xE7, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xE7, 0xF8, 0x00, 0x0E, 0x3F, 0x80, 0x01, 0xE1,
  0xF8, 0x00, 0x1E, 0x1F, 0x80, 0x01, 0xC1, 0xF8, 0xFC, 0x1C, 0x1F, 0x8F,
  0xC1, 0xC3, 0xF0, 0xFE, 0x1C, 0x3F, 0x0F, 0xE1, 0xC7, 0xF0, 0x7F, 0x3C,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01,
  0xF0, 0x0F, 0xFE, 0x00, 0x3E, 0x01, 0xFF, 0xE0, 0x07, 0xC0, 0x3F, 0x3F,
  0x00, 0xF8, 0x03, 0xC1, 0xF0, 0x0F, 0x00, 0x7C, 0x0F, 0x01, 0xE0, 0x07,
  0xC0, 0xF0, 0x3C, 0x00, 0x78, 0x1F, 0x07, 0xC0, 0x07, 0x81, 0xF0, 0xF8,
  0x00, 0x78, 0x1E, 0x1F, 0x00, 0x07, 0x81, 0xE3, 0xE0, 0x00, 0x78, 0x3E,
  0x3C, 0x00, 0x07, 0xC7, 0xE7, 0x80, 0x00, 0x7F, 0xFC, 0xF0, 0x00, 0x03,
  0xFF, 0x9F, 0x00, 0x00, 0x1F, 0xE3, 0xE0, 0x00, 0x00, 0x70, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00, 0x7C, 0xFF, 0x80, 0x00,
  0x0F, 0x9F, 0xFC, 0x00, 0x01, 0xF3, 0xFF, 0xE0, 0x00, 0x3E, 0x7C, 0x3E,
  0x00, 0x03, 0xC7, 0x81, 0xE0, 0x00, 0x78, 0x78, 0x1E, 0x00, 0x0F, 0x07,
  0x81, 0xE0, 0x01, 0xF0, 0xF8, 0x1E, 0x00, 0x3E, 0x0F, 0x81, 0xE0, 0x07,
  0xC0, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x03, 0xE0, 0x0F, 0x00, 0xF8, 0x7C,
  0x01, 0xE0, 0x0F, 0xFF, 0xC0, 0x3E, 0x00, 0x7F, 0xF8, 0x07, 0xC0, 0x07,
  0xFF, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x13, 0xFB, 0xF0, 0x3F, 0x1F,
  0x8F, 0xC3, 0xF0, 0xF8, 0x7E, 0x1F, 0x8F, 0xC1, 0xF9, 0xF8, 0x7E, 0x0F,
  0xDF, 0x83, 0xF0, 0x3F, 0xFC, 0x1F, 0x81, 0xFF, 0xC0, 0xF8, 0x07, 0xFC,
  0x07, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x1F,
  0x80, 0x7F, 0x80, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x7F, 0x03, 0xFF, 0xE1, 0xF8, 0x07, 0xFC, 0x07,
  0xE0, 0x06, 0x00, 0x00, 0x00, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0xFE, 0xFC, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x01, 0x80, 0x78, 0x0E,
  0x3F, 0x07, 0x87, 0xE3, 0xF8, 0x70, 0xFE, 0x7F, 0xE7, 0x3F, 0xFF, 0xFF,
  0x6F, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x3E, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x81, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0x00, 0xF8, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0xFF, 0xE0, 0x0E, 0x0F, 0xE7, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFC,
  0x7E, 0x04, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0xFE,
  0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1,
  0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03,
  0xF3, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x3E, 0x3E, 0x1E, 0x1F, 0x8F, 0x8F,
  0xC7, 0xE7, 0xE3, 0xF1, 0xF9, 0xF8, 0xFC, 0x7E, 0x7E, 0x3F, 0x1F, 0x1F,
  0x8F, 0xC7, 0xC7, 0xC0, 0xC1, 0xF1, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x3F,
  0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xF8, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0xFE,
  0x03, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xEF, 0xC0, 0x1F, 0xE7, 0xE0, 0x0F, 0xC3, 0xF0, 0x07,
  0xC3, 0xF0, 0x07, 0x81, 0xF8, 0x03, 0x80, 0xFC, 0x01, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x81, 0xFC, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xC0, 0x07,
  0xE1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x08, 0x00, 0xFC, 0x7E, 0x00,
  0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x83,
  0xF8, 0x0F, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0xFC,
  0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3,
  0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x20, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE7, 0xFC, 0x01, 0xFB,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFC, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xBF, 0xF0, 0x0F, 0xDF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0x80,
  0x3F, 0x8F, 0xC0, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E,
  0x00, 0x1F, 0x9F, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E,
  0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xF1, 0xFC, 0x07,
  0xF8, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFC, 0xFF, 0x81, 0xFC, 0x03, 0xF8, 0x3F, 0x00,
  0x7F, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87,
  0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x01, 0xF8, 0x0F,
  0xE0, 0x3F, 0x83, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xF7, 0xFC,
  0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0,
  0x07, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF0,
  0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF8, 0x7F, 0x00,
  0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x03, 0xFE, 0x7F, 0xE1, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00,
  0x3F, 0x7E, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8,
  0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF8, 0x1F, 0xF0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xBF, 0x00, 0xFF, 0xDF,
  0x80, 0x07, 0x8F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xC0, 0x3F, 0x83, 0xFC, 0x1F, 0xF1, 0xFF, 0x8F, 0xF8,
  0x7F, 0xC1, 0xFC, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFE, 0x07,
  0xE0, 0x08, 0x00, 0x00, 0x08, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x00, 0x08,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xC7,
  0xC0, 0x3F, 0xCF, 0x0F, 0x80, 0xFF, 0xDE, 0x1F, 0x03, 0xFF, 0xBC, 0x3E,
  0x0F, 0xC1, 0xF8, 0x7C, 0x1F, 0x03, 0xF0, 0xF8, 0x3E, 0x03, 0xE3, 0xE0,
  0xF8, 0x0F, 0xC7, 0xC1, 0xF0, 0x1F, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x07,
  0xC0, 0x7C, 0x3E, 0x0F, 0x80, 0xF8, 0x7C, 0x3F, 0x01, 0xF1, 0xF0, 0x7C,
  0x03, 0xE3, 0xE0, 0xF8, 0x0F, 0x87, 0xC1, 0xF0, 0x1F, 0x0F, 0x83, 0xE0,
  0x3E, 0x1F, 0x07, 0xE0, 0xFC, 0x3E, 0x0F, 0xFF, 0xF8, 0xF8, 0x0F, 0xFD,
  0xF1, 0xF0, 0x1F, 0xF3, 0xC3, 0xE0, 0x0F, 0xC7, 0x87, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x1F,
  0xBF, 0x00, 0x07, 0xE7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xFC, 0x7C, 0x00,
  0x3F, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0,
  0x7E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF3, 0xF8, 0x00,
  0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x7E, 0x01, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7C, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x1F, 0x80,
  0x3F, 0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0xFF, 0x03, 0xF0,
  0x03, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F,
  0x83, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x1F,
  0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x83, 0xFC, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x3F, 0x87, 0xF0, 0x07, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xC0, 0xFF, 0x81, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xC0,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF8,
  0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x7F, 0x83, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFC, 0x07,
  0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x3F, 0xFE, 0x1F, 0x87, 0xFF, 0xC7, 0xE0, 0xFF, 0xF8,
  0xFC, 0x1F, 0xFE, 0x1F, 0x83, 0xFF, 0xC3, 0xF0, 0x7F, 0xF8, 0x7E, 0x00,
  0x3F, 0x0F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xF0, 0x07,
  0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC,
  0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F,
  0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x03,
  0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x07,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F,
  0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x1F, 0x80,
  0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x07,
  0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x03,
  0xF0, 0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8,
  0x3F, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F,
  0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x01,
  0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0,
  0x03, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1,
  0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B,
  0xC0, 0xF7, 0x81, 0xEF, 0x07, 0xFE, 0x0F, 0xBC, 0x1E, 0xF8, 0x3E, 0xF0,
  0xFB, 0xE0, 0xFB, 0xC3, 0xCF, 0x03, 0xE7, 0x9F, 0x7C, 0x0F, 0x9E, 0x79,
  0xF0, 0x3E, 0x79, 0xE7, 0xC1, 0xF9, 0xEF, 0x1F, 0x07, 0xE7, 0xBC, 0xFC,
  0x1F, 0x1F, 0xE3, 0xF0, 0x7C, 0x7F, 0x8F, 0x81, 0xF0, 0xFE, 0x3E, 0x07,
  0xC3, 0xF0, 0xF8, 0x3F, 0x0F, 0xC7, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xF8, 0x01, 0xF0, 0x7F,
  0x80, 0x1F, 0x07, 0xF8, 0x03, 0xF0, 0x7F, 0xC0, 0x3F, 0x07, 0xFC, 0x03,
  0xF0, 0x7F, 0xC0, 0x3E, 0x07, 0xFC, 0x03, 0xE0, 0xFB, 0xC0, 0x3E, 0x0F,
  0xBE, 0x07, 0xE0, 0xFB, 0xE0, 0x7E, 0x0F, 0xBE, 0x07, 0xE0, 0xFB, 0xE0,
  0x7E, 0x0F, 0x9E, 0x07, 0xC1, 0xF9, 0xF0, 0x7C, 0x1F, 0x9F, 0x07, 0xC1,
  0xF1, 0xF0, 0xFC, 0x1F, 0x1F, 0x0F, 0xC1, 0xF1, 0xF0, 0xFC, 0x1F, 0x0F,
  0x0F, 0x83, 0xF0, 0xF8, 0xF8, 0x3F, 0x0F, 0x8F, 0x83, 0xF0, 0xF9, 0xF8,
  0x3E, 0x0F, 0x9F, 0x83, 0xE0, 0x79, 0xF8, 0x3E, 0x07, 0xDF, 0x07, 0xE0,
  0x7D, 0xF0, 0x7E, 0x07, 0xDF, 0x07, 0xE0, 0x7D, 0xF0, 0x7C, 0x03, 0xDF,
  0x07, 0xC0, 0x3F, 0xF0, 0x7C, 0x03, 0xFE, 0x07, 0xC0, 0x3F, 0xE0, 0xFC,
  0x03, 0xFE, 0x0F, 0xC0, 0x3F, 0xE0, 0xFC, 0x01, 0xFE, 0x0F, 0x80, 0x1F,
  0xE0, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0xFF, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0,
  0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xCF,
  0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8,
  0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF8, 0x07,
  0xF0, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xF0, 0x0F, 0xF8, 0x1F, 0x80,
  0x1F, 0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80,
  0x3F, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF,
  0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF1,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03,
  0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x1F,
  0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x3F,
  0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0xFF,
  0x03, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x05, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7E, 0x01, 0xFE, 0x07, 0xE0, 0x07,
  0xF0, 0x7C, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00,
  0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0xFC,
  0x07, 0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0xFC,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7E,
  0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x0F, 0xE0,
  0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8,
  0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC3,
  0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x01,
  0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x00,
  0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x1F,
  0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x0F,
  0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F,
  0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xE0, 0x00, 0xFD, 0xF8, 0x00,
  0x3F, 0x7C, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x7D, 0xF8, 0x1F,
  0x81, 0xF7, 0xE0, 0x7E, 0x07, 0xDF, 0x03, 0xF8, 0x3E, 0x7C, 0x0F, 0xC0,
  0xF9, 0xF0, 0x3F, 0x03, 0xE7, 0xC1, 0xFC, 0x0F, 0x9F, 0x07, 0x70, 0x7C,
  0x7C, 0x1D, 0xC1, 0xF1, 0xF0, 0x77, 0x07, 0xC7, 0xC3, 0xDC, 0x1E, 0x1F,
  0x0E, 0x70, 0xF8, 0x7C, 0x39, 0xC3, 0xE1, 0xF1, 0xE7, 0x0F, 0x87, 0xC7,
  0x9C, 0x3C, 0x1F, 0x1C, 0x71, 0xF0, 0x7C, 0x71, 0xC7, 0xC1, 0xF3, 0xC7,
  0x1F, 0x07, 0x8E, 0x3C, 0x78, 0x1E, 0x38, 0xF3, 0xE0, 0xF8, 0xE3, 0xCF,
  0x83, 0xE7, 0x8F, 0x3E, 0x0F, 0x9C, 0x3C, 0xF0, 0x3E, 0x70, 0xF7, 0xC0,
  0xFB, 0xC3, 0xDF, 0x03, 0xEF, 0x0E, 0x78, 0x0F, 0xB8, 0x39, 0xE0, 0x3E,
  0xE0, 0xEF, 0x80, 0xFF, 0x83, 0xBE, 0x03, 0xFC, 0x0E, 0xF0, 0x0F, 0xF0,
  0x3B, 0xC0, 0x3D, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x0F,
  0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xF0,
  0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F,
  0x0F, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7F, 0x3F, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xFC,
  0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x81, 0xF8,
  0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0xBC, 0x00,
  0x3E, 0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xE1, 0xF0, 0x0F,
  0x83, 0xE0, 0x3F, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF0, 0x0F, 0x87, 0xE0,
  0x1F, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x7E, 0xFC, 0x00, 0x7D, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0xFC,
  0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0xF8, 0xFC, 0x07, 0xFF, 0x9F, 0x01, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xF8, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x1F,
  0x80, 0x1F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x0F,
  0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8,
  0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0xC0,
  0x3F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xEF, 0xC0,
  0xFF, 0xFD, 0xF8, 0x0F, 0xFF, 0x3F, 0x00, 0x7F, 0x8F, 0xC0, 0x01, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x40, 0x03, 0xF1, 0xFF, 0x00, 0xFC,
  0xFF, 0xE0, 0x3F, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xEF, 0xFF, 0xE1,
  0xFF, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0xC7, 0xE0, 0x07,
  0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F,
  0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F,
  0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x0F, 0xE1, 0xFE, 0x07, 0xF8, 0x7D, 0xFF,
  0xFC, 0x3F, 0x7F, 0xFE, 0x0F, 0xDF, 0xFF, 0x83, 0xF3, 0xFF, 0x80, 0xFC,
  0x7F, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x7F, 0x01, 0xFE, 0x3F, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0x9F, 0x80,
  0x0F, 0xCF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7,
  0xE0, 0x03, 0xF3, 0xF8, 0x03, 0xF1, 0xFE, 0x07, 0xF8, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x0E, 0x07, 0xE0,
  0x07, 0xFC, 0x7E, 0x01, 0xFF, 0xE7, 0xE0, 0x3F, 0xFE, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x01, 0xFC,
  0x1F, 0x80, 0x1F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF0,
  0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F,
  0x83, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E,
  0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07,
  0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0x7E, 0x01, 0xFF, 0xE7, 0xE0, 0x07, 0xF8,
  0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0x87, 0xF8,
  0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x0F,
  0x8F, 0x80, 0x07, 0xCF, 0xC0, 0x03, 0xE7, 0xE0, 0x7F, 0xF3, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x13, 0xF0, 0x03, 0xF1, 0xFC, 0x03, 0xF8, 0x7F, 0x87, 0xF8, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xE3, 0xF0, 0x3F, 0xFC, 0xF8, 0x1F,
  0xFF, 0x7E, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFC, 0x07, 0xF8,
  0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0,
  0x03, 0xF1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x8F,
  0xE0, 0x07, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0xFF,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0xFC, 0x07, 0xFF,
  0x3F, 0x00, 0xFF, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x60, 0x03, 0xF1,
  0xFF, 0x00, 0xFC, 0xFF, 0xE0, 0x3F, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0x83,
  0xEF, 0xFF, 0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x1F,
  0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC,
  0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xE1, 0xF8, 0x01,
  0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0,
  0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x04,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xC3, 0xF0, 0x01,
  0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0xFC,
  0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFC,
  0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xF0,
  0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x10, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00,
  0x04, 0x01, 0x00, 0xF9, 0xF8, 0xFE, 0x0F, 0xBF, 0x9F, 0xE0, 0xFF, 0xFF,
  0xFF, 0x1F, 0x7F, 0xFF, 0xF1, 0xF8, 0x7E, 0x3F, 0x1F, 0x87, 0xC1, 0xF1,
  0xF0, 0x7C, 0x1F, 0x1F, 0x07, 0xC3, 0xF1, 0xF0, 0x78, 0x3F, 0x3F, 0x07,
  0x83, 0xF3, 0xF0, 0x78, 0x3E, 0x3F, 0x0F, 0x83, 0xE3, 0xE0, 0xF8, 0x3E,
  0x3E, 0x0F, 0x83, 0xE3, 0xE0, 0xF0, 0x7E, 0x3E, 0x0F, 0x07, 0xE7, 0xE0,
  0xF0, 0x7C, 0x7E, 0x0F, 0x07, 0xC7, 0xC1, 0xF0, 0x7C, 0x7C, 0x1F, 0x07,
  0xC7, 0xC1, 0xE0, 0xFC, 0x7C, 0x1E, 0x0F, 0xCF, 0xC1, 0xE0, 0xF8, 0xFC,
  0x1E, 0x0F, 0x8F, 0x83, 0xE0, 0xF8, 0xF8, 0x3E, 0x0F, 0x8F, 0x83, 0xE0,
  0xF8, 0xF8, 0x3C, 0x1F, 0x80, 0x00, 0x00, 0x60, 0x03, 0xF1, 0xFF, 0x00,
  0xFC, 0xFF, 0xE0, 0x3F, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xEF, 0xFF,
  0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0x87, 0xE0,
  0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E,
  0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F,
  0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F,
  0xC0, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x07,
  0xE3, 0xF8, 0x07, 0xF1, 0xFE, 0x07, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x3F, 0x1F, 0xF0, 0x03, 0xF3, 0xFF,
  0x80, 0x3F, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3E, 0xFF, 0xFE, 0x07,
  0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xF0, 0x7E, 0x00,
  0x7F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC,
  0x1F, 0x80, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0x7F, 0xFF, 0x03, 0xF7, 0xFF, 0xE0, 0x3F, 0x7F, 0xFE,
  0x03, 0xF3, 0xFF, 0x80, 0x3F, 0x1F, 0xF0, 0x03, 0xF0, 0x10, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xF8, 0xFC, 0x07, 0xFF,
  0x9F, 0x01, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0xF8, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x03,
  0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0,
  0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xFC, 0x0F, 0xF0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xEF, 0xC0, 0xFF, 0xFD, 0xF8, 0x0F, 0xFF,
  0x3F, 0x00, 0xFF, 0x8F, 0xC0, 0x01, 0x81, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xC0, 0x03, 0xF1, 0xFF, 0x00, 0xFC, 0xFF, 0xF0, 0x3E, 0x7F,
  0xFC, 0x0F, 0xBF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFE, 0x03, 0xFC, 0x7F,
  0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC,
  0x7C, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0xFC, 0x01, 0xFC, 0x7E, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xE0,
  0x03, 0xF3, 0xF8, 0x01, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03,
  0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x0F,
  0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F,
  0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF8, 0xFC,
  0x00, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xF9,
  0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x0F, 0x80, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x01, 0xF0, 0x3F,
  0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x87, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xCF, 0xC0,
  0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0xFC, 0x0F, 0xBE,
  0x07, 0xE0, 0x7D, 0xF0, 0x3F, 0x03, 0xCF, 0x81, 0xF8, 0x3E, 0x7C, 0x1D,
  0xC1, 0xF3, 0xE0, 0xEE, 0x0F, 0x9F, 0x07, 0x70, 0xF8, 0xF8, 0x7B, 0x87,
  0xC7, 0xC3, 0x9C, 0x3E, 0x3E, 0x1C, 0xE1, 0xE1, 0xF1, 0xE7, 0x1F, 0x0F,
  0x8E, 0x38, 0xF8, 0x7C, 0x71, 0xC7, 0x83, 0xE7, 0x8E, 0x7C, 0x1F, 0x38,
  0x73, 0xE0, 0xF9, 0xC3, 0x9E, 0x07, 0xDE, 0x1D, 0xF0, 0x3E, 0xE0, 0xEF,
  0x81, 0xF7, 0x07, 0x78, 0x0F, 0xB8, 0x3B, 0xC0, 0x7F, 0xC1, 0xFE, 0x03,
  0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF0,
  0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x03,
  0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0x3F,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFE, 0x07, 0xE0,
  0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x00, 0xFE, 0x07,
  0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xC7, 0xE0,
  0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0xFC,
  0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF8,
  0x7F, 0x87, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xEF, 0xC0, 0xFF, 0xF3,
  0xF0, 0x1F, 0xF8, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFE, 0x01, 0xF3, 0xFF, 0xC0,
  0x7C, 0xFF, 0xF0, 0x1F, 0x7F, 0xFE, 0x07, 0xDF, 0x1F, 0xC3, 0xFF, 0x83,
  0xF8, 0xFB, 0xE0, 0x7F, 0xFE, 0xF8, 0x1F, 0xFF, 0x3E, 0x03, 0xFF, 0x8F,
  0x80, 0x7F, 0xC0, 0x00, 0x07, 0x80,
};

const GFXglyph JetBrainsMono_SemiBoldItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 13, 37, 31, 9, -37 },
  { 62, 19, 15, 31, 9, -37 },
  { 98, 30, 37, 31, 1, -37 },
  { 237, 28, 51, 31, 2, -44 },
  { 416, 36, 37, 31, -2, -37 },
  { 583, 29, 39, 31, 1, -38 },
  { 725, 8, 15, 31, 14, -37 },
  { 740, 22, 49, 31, 7, -43 },
  { 875, 21, 49, 31, 3, -43 },
  { 1004, 28, 26, 31, 2, -31 },
  { 1095, 25, 24, 31, 3, -29 },
  { 1170, 15, 16, 31, 4, -8 },
  { 1200, 18, 6, 31, 7, -20 },
  { 1214, 10, 10, 31, 9, -9 },
  { 1227, 32, 48, 31, 0, -42 },
  { 1419, 26, 39, 31, 3, -38 },
  { 1546, 25, 37, 31, 2, -37 },
  { 1662, 27, 38, 31, 2, -38 },
  { 1791, 27, 38, 31, 2, -37 },
  { 1920, 26, 37, 31, 2, -37 },
  { 2041, 26, 38, 31, 3, -37 },
  { 2165, 26, 38, 31, 2, -37 },
  { 2289, 26, 37, 31, 5, -37 },
  { 2410, 27, 39, 31, 2, -38 },
  { 2542, 26, 38, 31, 4, -38 },
  { 2666, 13, 30, 31, 9, -29 },
  { 2715, 17, 37, 31, 5, -29 },
  { 2794, 25, 28, 31, 4, -31 },
  { 2882, 25, 18, 31, 3, -26 },
  { 2939, 25, 28, 31, 2, -31 },
  { 3027, 21, 37, 31, 7, -37 },
  { 3125, 31, 47, 31, 0, -38 },
  { 3308, 26, 37, 31, 0, -37 },
  { 3429, 28, 37, 31, 2, -37 },
  { 3559, 27, 39, 31, 3, -38 },
  { 3691, 27, 37, 31, 2, -37 },
  { 3816, 28, 37, 31, 2, -37 },
  { 3946, 29, 37, 31, 2, -37 },
  { 4081, 27, 39, 31, 3, -38 },
  { 4213, 28, 37, 31, 2, -37 },
  { 4343, 26, 37, 31, 3, -37 },
  { 4464, 29, 38, 31, 0, -37 },
  { 4602, 30, 37, 31, 2, -37 },
  { 4741, 23, 37, 31, 3, -37 },
  { 4848, 30, 37, 31, 1, -37 },
  { 4987, 28, 37, 31, 2, -37 },
  { 5117, 26, 39, 31, 3, -38 },
  { 5244, 29, 37, 31, 2, -37 },
  { 5379, 26, 47, 31, 3, -38 },
  { 5532, 28, 37, 31, 2, -37 },
  { 5662, 28, 39, 31, 2, -38 },
  { 5799, 27, 37, 31, 5, -37 },
  { 5924, 27, 38, 31, 3, -37 },
  { 6053, 26, 37, 31, 6, -37 },
  { 6174, 30, 37, 31, 3, -37 },
  { 6313, 33, 37, 31, -1, -37 },
  { 6466, 28, 37, 31, 5, -37 },
  { 6596, 28, 37, 31, 2, -37 },
  { 6726, 21, 48, 31, 7, -42 },
  { 6852, 16, 48, 31, 8, -42 },
  { 6948, 21, 48, 31, 4, -42 },
  { 7074, 23, 20, 31, 4, -37 },
  { 7132, 25, 6, 31, 0, 1 },
  { 7151, 10, 7, 31, 13, -40 },
  { 7160, 27, 30, 31, 2, -29 },
  { 7262, 26, 38, 31, 2, -37 },
  { 7386, 25, 30, 31, 3, -29 },
  { 7480, 28, 38, 31, 2, -37 },
  { 7613, 25, 30, 31, 3, -29 },
  { 7707, 35, 46, 31, -3, -37 },
  { 7909, 26, 38, 31, 3, -29 },
  { 8033, 26, 37, 31, 2, -37 },
  { 8154, 25, 40, 31, 2, -40 },
  { 8279, 27, 49, 31, 1, -40 },
  { 8445, 29, 37, 31, 2, -37 },
  { 8580, 23, 37, 31, 4, -37 },
  { 8687, 28, 29, 31, 1, -29 },
  { 8789, 26, 29, 31, 2, -29 },
  { 8884, 25, 30, 31, 3, -29 },
  { 8978, 28, 38, 31, 0, -29 },
  { 9111, 27, 38, 31, 2, -29 },
  { 9240, 26, 29, 31, 3, -29 },
  { 9335, 26, 30, 31, 2, -29 },
  { 9433, 25, 36, 31, 4, -36 },
  { 9546, 26, 29, 31, 3, -28 },
  { 9641, 27, 28, 31, 4, -28 },
  { 9736, 29, 28, 31, 3, -28 },
  { 9838, 30, 28, 31, 0, -28 },
  { 9943, 26, 37, 31, 3, -28 },
  { 10064, 26, 28, 31, 2, -28 },
  { 10155, 27, 48, 31, 4, -42 },
  { 10317, 14, 48, 31, 9, -42 },
  { 10401, 27, 48, 31, 1, -42 },
  { 10563, 26, 12, 31, 3, -24 },
};

const GFXfont JetBrainsMono_SemiBoldItalic51pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic51pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic51pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC51PT7B_H_
