#ifndef _JETBRAINSMONO_SEMIBOLDITALIC52PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x81, 0xFE,
  0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x07, 0xEF, 0xE0,
  0xFD, 0xF8, 0x3F, 0xBF, 0x07, 0xF7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83,
  0xF7, 0xF0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F,
  0xCF, 0x81, 0xF9, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x7C, 0x07,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0xF8, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x00, 0xF0,
  0x0F, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF0, 0x0F,
  0x00, 0x01, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xF9, 0xCF, 0xE0,
  0x7F, 0x1C, 0x7F, 0x07, 0xE1, 0xC7, 0xF0, 0xFE, 0x3C, 0x3F, 0x0F, 0xC3,
  0xC3, 0xF0, 0xFC, 0x38, 0x00, 0x0F, 0xC3, 0x80, 0x00, 0xFE, 0x38, 0x00,
  0x0F, 0xE3, 0x80, 0x00, 0xFF, 0x78, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x0E, 0x3F, 0x80, 0x00, 0xE1, 0xF8, 0x00, 0x0E, 0x1F, 0xC0, 0x00, 0xE1,
  0xF8, 0x00, 0x1E, 0x1F, 0x8F, 0xE1, 0xE1, 0xF8, 0xFE, 0x1C, 0x1F, 0x8F,
  0xE1, 0xC3, 0xF8, 0xFE, 0x1C, 0x7F, 0x07, 0xF9, 0xCF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x07, 0xFF, 0x00,
  0x0F, 0x80, 0x7F, 0xFC, 0x00, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0x80, 0x3E,
  0x0F, 0x00, 0xF8, 0x01, 0xE0, 0x78, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x78,
  0x00, 0xF8, 0x1E, 0x07, 0xC0, 0x07, 0xC0, 0xF0, 0x7C, 0x00, 0x3C, 0x0F,
  0x87, 0xC0, 0x01, 0xE0, 0x7C, 0x7C, 0x00, 0x0F, 0x03, 0xC7, 0xC0, 0x00,
  0x7C, 0x3E, 0x3C, 0x00, 0x03, 0xFF, 0xF3, 0xC0, 0x00, 0x1F, 0xFF, 0x3E,
  0x00, 0x00, 0x7F, 0xF3, 0xE0, 0x00, 0x00, 0xFE, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF1, 0xFC, 0x00, 0x00, 0x1F,
  0x3F, 0xF0, 0x00, 0x01, 0xF3, 0xFF, 0xC0, 0x00, 0x1F, 0x3F, 0xFF, 0x00,
  0x01, 0xF1, 0xE0, 0xF8, 0x00, 0x0F, 0x1F, 0x07, 0xC0, 0x00, 0xF0, 0xF0,
  0x3E, 0x00, 0x0F, 0x87, 0x81, 0xF0, 0x00, 0xF8, 0x3C, 0x0F, 0x80, 0x0F,
  0x83, 0xE0, 0x78, 0x00, 0xF8, 0x1F, 0x03, 0xC0, 0x0F, 0x80, 0xF8, 0x1E,
  0x00, 0x78, 0x07, 0xC1, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0x00, 0x7C, 0x00,
  0xFF, 0xF0, 0x07, 0xC0, 0x03, 0xFF, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x03,
  0xF3, 0xF9, 0xF8, 0x3F, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x1F, 0x8F,
  0xC1, 0xF9, 0xF8, 0x7E, 0x07, 0xEF, 0xC3, 0xF0, 0x3F, 0xFC, 0x1F, 0x80,
  0xFF, 0xC0, 0xFC, 0x07, 0xFC, 0x07, 0xC0, 0x1F, 0xE0, 0x7E, 0x00, 0x7E,
  0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0xC0, 0xFE, 0x07, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x3F, 0x03, 0xFF,
  0xE1, 0xFC, 0x07, 0xFE, 0x07, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x3F, 0x3F,
  0x3F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xFC,
  0xF8, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8,
  0x00, 0x03, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x01, 0x00, 0x7C, 0x02,
  0x3E, 0x07, 0x81, 0xF3, 0xF8, 0x78, 0x7F, 0x7F, 0xC7, 0x1F, 0xF7, 0xFF,
  0x73, 0xFF, 0xFF, 0xFE, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00,
  0xF0, 0x07, 0x80, 0x06, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x1F, 0x0F, 0xE7,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xF8,
  0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC,
  0x7C, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00,
  0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x1F, 0x0F, 0xC7,
  0xC7, 0xE1, 0xF1, 0xF8, 0xFE, 0x3E, 0x3F, 0x1F, 0xCF, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x3E, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xE0, 0x00, 0xF8, 0x7C,
  0x00, 0x1F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F,
  0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xF0,
  0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xF7, 0xE0,
  0x0F, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xC0, 0xFC, 0x03, 0xC0, 0xFE,
  0x01, 0x80, 0x7E, 0x00, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0,
  0x0F, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE,
  0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x01, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x07,
  0xE0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xE1, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x20, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x81, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x0F, 0xE0, 0x07, 0xE7, 0xFF, 0x00, 0xFD, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x3F, 0x83,
  0xF0, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x87, 0xF0, 0x07, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xDF, 0xF0, 0x07, 0xEF, 0xFE, 0x03,
  0xF7, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xE7, 0xFE, 0x3F, 0xC0, 0x3F,
  0xCF, 0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00,
  0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xBF, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xF1, 0xFC, 0x01, 0xFC,
  0x7F, 0x80, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0x80, 0x07, 0xF3, 0xF0,
  0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE3, 0xF8, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x1F,
  0xC0, 0x7F, 0x03, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x83,
  0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00,
  0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0,
  0x7F, 0x00, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0x7F,
  0x07, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xCF, 0xC0,
  0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC,
  0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7F, 0x00,
  0x3F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFF, 0x8F, 0xFC, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xF7, 0xE0, 0x3F, 0xFD, 0xF8, 0x01, 0xFE, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x3F, 0x83, 0xFE, 0x1F, 0xF1, 0xFF, 0x87, 0xFC, 0x3F,
  0xC0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0xFE, 0x0F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xE1, 0xFF, 0x07, 0xF0,
  0x04, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1F,
  0x80, 0x7F, 0x3E, 0x1F, 0x01, 0xFF, 0xBE, 0x1F, 0x01, 0xFF, 0xBE, 0x1F,
  0x03, 0xF9, 0xFE, 0x1F, 0x07, 0xE0, 0x7E, 0x1F, 0x07, 0xC0, 0x7C, 0x1F,
  0x07, 0xC0, 0x7C, 0x3E, 0x0F, 0xC0, 0x7C, 0x3E, 0x0F, 0x80, 0x7C, 0x3E,
  0x0F, 0x80, 0x7C, 0x3E, 0x0F, 0x80, 0xFC, 0x3E, 0x0F, 0x80, 0xF8, 0x3E,
  0x0F, 0x80, 0xF8, 0x7E, 0x0F, 0x80, 0xF8, 0x7C, 0x1F, 0x80, 0xF8, 0x7C,
  0x1F, 0x00, 0xF8, 0x7C, 0x1F, 0x81, 0xF8, 0x7C, 0x1F, 0x83, 0xF0, 0x7C,
  0x0F, 0xFF, 0xF0, 0xFC, 0x0F, 0xFE, 0xF0, 0xF8, 0x07, 0xFD, 0xF0, 0xF8,
  0x03, 0xF1, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x40, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF3,
  0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xF1, 0xF0, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x1F,
  0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x07, 0xC0, 0x1F,
  0x80, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF1,
  0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xF9, 0xF8, 0x00,
  0x1F, 0xBF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7E, 0x01, 0xFE, 0x07, 0xE0, 0x0F,
  0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0xFC, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x07, 0xF8, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x01, 0xF0, 0x07, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC,
  0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x87, 0xE0, 0x07, 0xF0, 0x7E, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x03,
  0xF8, 0x7E, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0x87, 0xF0, 0x07,
  0xF0, 0x7F, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xE0,
  0x1F, 0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x7F,
  0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07,
  0xE1, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F,
  0x80, 0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x01,
  0xFC, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x87,
  0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF0, 0x7E, 0x00,
  0x7F, 0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0x83, 0xF8,
  0x03, 0xF8, 0x7E, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x1F, 0xFF, 0x1F, 0x87, 0xFF, 0xC7, 0xE0, 0xFF,
  0xF8, 0xFC, 0x1F, 0xFF, 0x1F, 0x83, 0xFF, 0xE3, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F,
  0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0x87, 0xF0,
  0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x00,
  0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8,
  0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x7F,
  0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00,
  0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00,
  0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC,
  0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00,
  0x7F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0xFC,
  0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x03,
  0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFE,
  0x07, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03,
  0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8,
  0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x07,
  0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0,
  0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x7B, 0xC0,
  0x7F, 0xC0, 0xF7, 0x80, 0xFF, 0x81, 0xEF, 0x03, 0xFF, 0x03, 0xDE, 0x07,
  0xBE, 0x07, 0xBC, 0x1F, 0x78, 0x1F, 0x7C, 0x3D, 0xF0, 0x3E, 0x78, 0x7B,
  0xE0, 0x7C, 0xF1, 0xE7, 0xC0, 0xF9, 0xE3, 0xCF, 0x81, 0xF3, 0xCF, 0x3F,
  0x03, 0xE7, 0x9E, 0x7C, 0x0F, 0xCF, 0x7C, 0xF8, 0x1F, 0x9E, 0xF1, 0xF0,
  0x3F, 0x1F, 0xE3, 0xE0, 0x7C, 0x3F, 0x8F, 0xC0, 0xF8, 0x7F, 0x1F, 0x81,
  0xF0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x7C, 0x0F, 0xC0, 0x00, 0xF8, 0x1F,
  0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0,
  0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xC1, 0xFF, 0x00, 0x7E, 0x0F, 0xF8, 0x03,
  0xE0, 0x7F, 0xC0, 0x1F, 0x03, 0xFE, 0x01, 0xF8, 0x1F, 0xF0, 0x0F, 0xC0,
  0xFF, 0xC0, 0x7E, 0x0F, 0xBE, 0x03, 0xF0, 0x7D, 0xF0, 0x1F, 0x03, 0xEF,
  0x80, 0xF8, 0x1F, 0x7C, 0x07, 0xC0, 0xF9, 0xF0, 0x7E, 0x07, 0xCF, 0x83,
  0xF0, 0x7E, 0x7C, 0x1F, 0x83, 0xF3, 0xE0, 0xF8, 0x1F, 0x9F, 0x07, 0xC0,
  0xF8, 0x7C, 0x3E, 0x07, 0xC3, 0xE3, 0xF0, 0x3E, 0x1F, 0x1F, 0x83, 0xF0,
  0xF8, 0xFC, 0x1F, 0x87, 0xC7, 0xE0, 0xFC, 0x1E, 0x3E, 0x07, 0xE0, 0xF9,
  0xF0, 0x3E, 0x07, 0xCF, 0x81, 0xF0, 0x3E, 0x7C, 0x0F, 0x81, 0xF7, 0xE0,
  0xFC, 0x0F, 0xBF, 0x07, 0xE0, 0x3F, 0xF0, 0x3F, 0x01, 0xFF, 0x81, 0xF0,
  0x0F, 0xFC, 0x0F, 0x80, 0x7F, 0xE0, 0x7C, 0x03, 0xFF, 0x07, 0xE0, 0x0F,
  0xF8, 0x3F, 0x00, 0x7F, 0x81, 0xF8, 0x03, 0xFC, 0x0F, 0xC0, 0x1F, 0xE0,
  0x7C, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xF0, 0x7F,
  0x83, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFE, 0x3F, 0x00,
  0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC7,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01,
  0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x3F,
  0x87, 0xF0, 0x07, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0xFE, 0x07, 0xE0,
  0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F,
  0x07, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0x7E, 0x01, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xF0, 0x7F, 0x83,
  0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F,
  0xC7, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0,
  0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF8,
  0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00,
  0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87,
  0xF0, 0x07, 0xF0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x03, 0xF0, 0x1F, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x07,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x1F,
  0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xC0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x1F,
  0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x0F, 0xF0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07,
  0xE1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F,
  0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x01,
  0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83,
  0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0x7E, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F, 0x03, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xEF,
  0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01,
  0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E,
  0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xF8,
  0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3,
  0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xE0, 0x00,
  0x3E, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x3E, 0x7C,
  0x0F, 0xC0, 0xFC, 0xF8, 0x1F, 0x81, 0xF3, 0xF0, 0x3F, 0x03, 0xE7, 0xE0,
  0xFE, 0x07, 0xCF, 0xC1, 0xDC, 0x1F, 0x9F, 0x03, 0xB8, 0x3E, 0x3E, 0x07,
  0xF0, 0x7C, 0x7C, 0x1F, 0xE0, 0xF8, 0xF8, 0x3B, 0xC3, 0xE1, 0xF0, 0x77,
  0x87, 0xC3, 0xE1, 0xEF, 0x0F, 0x87, 0xC3, 0xDE, 0x1F, 0x0F, 0x87, 0x38,
  0x7C, 0x1F, 0x0E, 0x70, 0xF8, 0x3E, 0x3C, 0xE1, 0xF0, 0x7C, 0x71, 0xC3,
  0xE0, 0xF8, 0xE3, 0x8F, 0x81, 0xF3, 0xC7, 0x1F, 0x03, 0xE7, 0x8E, 0x3E,
  0x07, 0xCE, 0x1C, 0x7C, 0x0F, 0x1C, 0x39, 0xF0, 0x3E, 0x78, 0x73, 0xE0,
  0x7C, 0xF0, 0xE7, 0xC0, 0xF9, 0xC1, 0xCF, 0x01, 0xF3, 0x83, 0xBE, 0x03,
  0xEF, 0x0F, 0x7C, 0x07, 0xDC, 0x1E, 0xF8, 0x0F, 0xB8, 0x3D, 0xE0, 0x1F,
  0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0x81, 0xFF, 0x00, 0xFF,
  0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x7F,
  0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x07, 0xF0,
  0x3F, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x3F,
  0x9F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xFC, 0x1F,
  0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x7D, 0xF0,
  0x00, 0xF9, 0xF0, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8,
  0x03, 0xE0, 0xFC, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0x7C,
  0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0xFE,
  0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x87,
  0xE0, 0x1F, 0xFC, 0xFC, 0x07, 0xFF, 0x9F, 0x81, 0xFF, 0xFB, 0xF0, 0x7F,
  0xFF, 0x7E, 0x1F, 0xF0, 0xEF, 0x83, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE,
  0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF8, 0x3F, 0xFF, 0xBE, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFD, 0xF8, 0x0F, 0xFF, 0x3F, 0x00, 0x7F, 0xC7, 0xE0, 0x01,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x3F,
  0x80, 0x3F, 0x1F, 0xF8, 0x07, 0xE7, 0xFF, 0x80, 0xFD, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xC0, 0x0F,
  0xC3, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8,
  0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0xC7, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0xC3,
  0xF8, 0x03, 0xF8, 0x7F, 0x81, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xF7, 0xFF,
  0xF0, 0x7E, 0xFF, 0xFC, 0x0F, 0xCF, 0xFF, 0x01, 0xF8, 0xFF, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFC, 0x3F, 0xE1, 0xFC,
  0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7F, 0x3F,
  0x80, 0x1F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0xFC, 0x01, 0xFF, 0xCF, 0xC0, 0x3F, 0xFC, 0xFC, 0x07,
  0xFF, 0xEF, 0xC0, 0xFF, 0xFE, 0xFC, 0x1F, 0xF0, 0xEF, 0x81, 0xFC, 0x03,
  0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83,
  0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF0, 0x7E, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFF, 0x03, 0xFE,
  0x07, 0xFF, 0xF7, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xEF, 0xC0, 0x3F,
  0xFC, 0xFC, 0x00, 0xFF, 0x8F, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x7F, 0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x3F,
  0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0xFC, 0x03,
  0xF8, 0x7F, 0xC7, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x7F, 0xF3, 0xF0, 0x3F,
  0xFE, 0xFC, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF, 0xEF, 0xC7, 0xFC, 0x3B, 0xE1,
  0xFC, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07,
  0xE3, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0xFE,
  0x1F, 0xE0, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFD, 0xF8, 0x3F, 0xFE,
  0xFC, 0x07, 0xFF, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x1F, 0xF8, 0x07, 0xEF, 0xFF,
  0x80, 0xFD, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0xFF,
  0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xE1, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFC,
  0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00,
  0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x00,
  0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xFC, 0x00,
  0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC0, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x02, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F,
  0x8F, 0x07, 0xC0, 0x7D, 0xFC, 0x7F, 0x83, 0xEF, 0xF7, 0xFC, 0x1F, 0xFF,
  0xBF, 0xE1, 0xFC, 0x7F, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7E, 0x0F, 0x07,
  0xE3, 0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x8F,
  0xC1, 0xF0, 0x7C, 0x7E, 0x0F, 0x07, 0xE3, 0xF0, 0x78, 0x3F, 0x1F, 0x03,
  0xC1, 0xF8, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83,
  0xE3, 0xF0, 0x78, 0x3F, 0x1F, 0x83, 0xC1, 0xF8, 0xFC, 0x1E, 0x0F, 0xC7,
  0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x1F, 0x83,
  0xC0, 0xF8, 0xFC, 0x1E, 0x0F, 0xC7, 0xE0, 0xF0, 0x7E, 0x3E, 0x0F, 0x83,
  0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xFC,
  0x01, 0xF8, 0xFF, 0xC0, 0x3F, 0x7F, 0xFC, 0x07, 0xEF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE,
  0x1F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xE3, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0xFE, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x1F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xEF, 0xC0, 0x03,
  0xF7, 0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00,
  0x7E, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80,
  0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF0, 0xFE,
  0x07, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x03, 0xF0, 0x7F,
  0x00, 0x1F, 0x8F, 0xFC, 0x00, 0xFC, 0xFF, 0xF0, 0x07, 0xEF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0xFE,
  0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF0,
  0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E,
  0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0x81, 0xFC, 0x00,
  0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xFC, 0x0F, 0xF0,
  0x1F, 0xFF, 0xFF, 0x81, 0xFB, 0xFF, 0xF8, 0x0F, 0xDF, 0xFF, 0x80, 0x7E,
  0x7F, 0xF8, 0x03, 0xF1, 0xFF, 0x00, 0x1F, 0x81, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x1F, 0xFC, 0xFC, 0x07, 0xFF,
  0x9F, 0x81, 0xFF, 0xFB, 0xF0, 0x7F, 0xFF, 0x7E, 0x1F, 0xF0, 0xFF, 0x83,
  0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01,
  0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x8F, 0xE0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF8,
  0x3F, 0xFF, 0xBE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFD, 0xF8, 0x0F, 0xFF,
  0x3F, 0x00, 0x7F, 0xC7, 0xE0, 0x01, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC3, 0xFC, 0x01, 0xF9, 0xFF, 0xE0, 0x3F, 0x7F, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0xFB, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0x87, 0xF8, 0x07, 0xF0,
  0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00,
  0x3F, 0x0F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF0,
  0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF9, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF8, 0x7F,
  0xE7, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xCF, 0xE0, 0x07,
  0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x1F,
  0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F,
  0x1F, 0x80, 0x0F, 0xCF, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0x7E, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xC1, 0xFC, 0x0F, 0xF0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x3F,
  0x00, 0x1F, 0xC7, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x3E, 0x03,
  0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0x7E, 0x7E, 0x00,
  0x1F, 0x9F, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C,
  0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x3F, 0x03, 0xEF, 0x81, 0xF8, 0x1F,
  0x7C, 0x0F, 0xC0, 0xFB, 0xE0, 0xFE, 0x0F, 0x9F, 0x07, 0x70, 0x7C, 0xF8,
  0x3B, 0x83, 0xE7, 0xC3, 0xDC, 0x1E, 0x3E, 0x1C, 0xE1, 0xF1, 0xF0, 0xE7,
  0x0F, 0x8F, 0x8F, 0x38, 0x78, 0x7C, 0x71, 0xC7, 0xC3, 0xE3, 0x8E, 0x3E,
  0x1F, 0x1C, 0x71, 0xE0, 0xF9, 0xE3, 0x9F, 0x07, 0xCE, 0x1C, 0xF8, 0x3E,
  0x70, 0xE7, 0x81, 0xF7, 0x87, 0x7C, 0x0F, 0xB8, 0x3B, 0xE0, 0x7D, 0xC1,
  0xDF, 0x03, 0xFE, 0x0E, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC,
  0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F,
  0xE0, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xCF,
  0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x3F,
  0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x0F,
  0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80,
  0x1F, 0xCF, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFC,
  0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0x7E, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x07, 0xE3, 0xF8,
  0x03, 0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xF1, 0xFF, 0x87, 0xFF, 0xF7, 0xE0,
  0xFF, 0xFD, 0xF8, 0x3F, 0xFE, 0xFC, 0x07, 0xFF, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x08, 0x7F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07,
  0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0xFC, 0xFF, 0xF0, 0x1F, 0xBF, 0xFF, 0x03, 0xE7, 0xFF, 0xF0, 0x7D,
  0xF8, 0x7E, 0x0F, 0xBF, 0x07, 0xE3, 0xF7, 0xC0, 0xFF, 0xFC, 0xF8, 0x0F,
  0xFF, 0x9F, 0x00, 0xFF, 0xE3, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x20, 0x00,
};

const GFXglyph JetBrainsMono_SemiBoldItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 14, 38, 31, 9, -38 },
  { 68, 19, 16, 31, 9, -38 },
  { 106, 31, 38, 31, 1, -38 },
  { 254, 28, 52, 31, 2, -45 },
  { 436, 37, 38, 31, -2, -38 },
  { 612, 29, 39, 31, 1, -38 },
  { 754, 8, 16, 31, 14, -38 },
  { 770, 22, 51, 31, 8, -44 },
  { 911, 22, 51, 31, 3, -44 },
  { 1052, 28, 27, 31, 2, -32 },
  { 1147, 26, 24, 31, 3, -29 },
  { 1225, 15, 16, 31, 4, -8 },
  { 1255, 18, 6, 31, 7, -20 },
  { 1269, 10, 10, 31, 9, -9 },
  { 1282, 32, 49, 31, 0, -43 },
  { 1478, 27, 39, 31, 3, -38 },
  { 1610, 25, 38, 31, 2, -38 },
  { 1729, 28, 38, 31, 2, -38 },
  { 1862, 28, 39, 31, 2, -38 },
  { 1999, 27, 38, 31, 2, -38 },
  { 2128, 27, 39, 31, 3, -38 },
  { 2260, 26, 39, 31, 2, -38 },
  { 2387, 27, 38, 31, 5, -38 },
  { 2516, 28, 40, 31, 2, -39 },
  { 2656, 27, 38, 31, 4, -38 },
  { 2785, 13, 30, 31, 9, -29 },
  { 2834, 17, 37, 31, 5, -29 },
  { 2913, 26, 28, 31, 4, -31 },
  { 3004, 26, 18, 31, 3, -26 },
  { 3063, 26, 28, 31, 2, -31 },
  { 3154, 22, 38, 31, 7, -38 },
  { 3259, 32, 47, 31, 0, -38 },
  { 3447, 27, 38, 31, 0, -38 },
  { 3576, 28, 38, 31, 2, -38 },
  { 3709, 27, 39, 31, 3, -38 },
  { 3841, 28, 38, 31, 2, -38 },
  { 3974, 29, 38, 31, 2, -38 },
  { 4112, 29, 38, 31, 2, -38 },
  { 4250, 27, 39, 31, 3, -38 },
  { 4382, 29, 38, 31, 2, -38 },
  { 4520, 27, 38, 31, 3, -38 },
  { 4649, 30, 39, 31, 0, -38 },
  { 4796, 31, 38, 31, 2, -38 },
  { 4944, 24, 38, 31, 3, -38 },
  { 5058, 31, 38, 31, 1, -38 },
  { 5206, 29, 38, 31, 2, -38 },
  { 5344, 27, 39, 31, 3, -38 },
  { 5476, 30, 38, 31, 2, -38 },
  { 5619, 27, 47, 31, 3, -38 },
  { 5778, 29, 38, 31, 2, -38 },
  { 5916, 28, 40, 31, 2, -39 },
  { 6056, 27, 38, 31, 5, -38 },
  { 6185, 28, 39, 31, 3, -38 },
  { 6322, 27, 38, 31, 6, -38 },
  { 6451, 31, 38, 31, 3, -38 },
  { 6599, 34, 38, 31, -1, -38 },
  { 6761, 29, 38, 31, 5, -38 },
  { 6899, 28, 38, 31, 2, -38 },
  { 7032, 22, 49, 31, 7, -43 },
  { 7167, 17, 49, 31, 8, -43 },
  { 7272, 22, 49, 31, 4, -43 },
  { 7407, 24, 20, 31, 4, -38 },
  { 7467, 26, 6, 31, 0, 1 },
  { 7487, 11, 7, 31, 13, -41 },
  { 7497, 27, 30, 31, 2, -29 },
  { 7599, 27, 39, 31, 2, -38 },
  { 7731, 26, 30, 31, 3, -29 },
  { 7829, 28, 39, 31, 3, -38 },
  { 7966, 25, 30, 31, 3, -29 },
  { 8060, 36, 47, 31, -3, -38 },
  { 8272, 26, 38, 31, 3, -29 },
  { 8396, 27, 38, 31, 2, -38 },
  { 8525, 25, 41, 31, 2, -41 },
  { 8654, 27, 50, 31, 1, -41 },
  { 8823, 29, 38, 31, 2, -38 },
  { 8961, 23, 38, 31, 5, -38 },
  { 9071, 29, 29, 31, 1, -29 },
  { 9177, 27, 29, 31, 2, -29 },
  { 9275, 25, 30, 31, 3, -29 },
  { 9369, 29, 38, 31, 0, -29 },
  { 9507, 27, 38, 31, 2, -29 },
  { 9636, 27, 29, 31, 3, -29 },
  { 9734, 27, 30, 31, 2, -29 },
  { 9836, 26, 36, 31, 4, -36 },
  { 9953, 26, 30, 31, 3, -29 },
  { 10051, 26, 29, 31, 5, -29 },
  { 10146, 29, 29, 31, 3, -29 },
  { 10252, 31, 29, 31, 0, -29 },
  { 10365, 26, 38, 31, 3, -29 },
  { 10489, 27, 29, 31, 2, -29 },
  { 10587, 28, 49, 31, 4, -43 },
  { 10759, 14, 49, 31, 9, -43 },
  { 10845, 27, 49, 31, 1, -43 },
  { 11011, 27, 12, 31, 3, -24 },
};

const GFXfont JetBrainsMono_SemiBoldItalic52pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic52pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic52pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC52PT7B_H_
