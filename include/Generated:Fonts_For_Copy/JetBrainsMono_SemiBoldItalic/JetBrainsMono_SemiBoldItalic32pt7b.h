#ifndef _JETBRAINSMONO_SEMIBOLDITALIC32PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C,
  0x3C, 0x38, 0x38, 0x38, 0x38, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF0,
  0x78, 0xF7, 0x8F, 0x78, 0xF7, 0x8F, 0x78, 0xE7, 0x0E, 0x70, 0xE7, 0x1E,
  0xF1, 0xE0, 0x00, 0x70, 0xE0, 0x0E, 0x0C, 0x00, 0xE1, 0xC0, 0x0C, 0x1C,
  0x01, 0xC1, 0x80, 0x1C, 0x38, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x03, 0x87,
  0x00, 0x30, 0x70, 0x07, 0x06, 0x00, 0x70, 0xE0, 0x06, 0x0E, 0x00, 0xE0,
  0xC0, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x81, 0xC3, 0x80, 0x18,
  0x38, 0x03, 0x83, 0x00, 0x38, 0x70, 0x03, 0x07, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x78, 0x00,
  0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0x67, 0x87, 0x98, 0xE1, 0xE6,
  0x38, 0x71, 0x80, 0x1E, 0x60, 0x07, 0xD8, 0x01, 0xFC, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0x3C, 0x01, 0x8F, 0x00,
  0x63, 0xCF, 0x18, 0xF3, 0xC6, 0x78, 0x79, 0xBE, 0x1F, 0xFF, 0x03, 0xFF,
  0x80, 0x7F, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x1F, 0x80, 0x70, 0xFF, 0x03, 0x87, 0x1C, 0x1C, 0x1C,
  0x30, 0xE0, 0x71, 0xC7, 0x01, 0xC7, 0x18, 0x06, 0x1C, 0xE0, 0x1C, 0xE7,
  0x00, 0x7F, 0xB8, 0x00, 0xF9, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x84, 0x00, 0x0E, 0xFC, 0x00, 0x77, 0xF8, 0x03, 0xB8, 0x60, 0x1C,
  0xE1, 0x80, 0xE3, 0x86, 0x07, 0x0E, 0x38, 0x18, 0x38, 0xE0, 0xE0, 0xE7,
  0x87, 0x03, 0xFC, 0x38, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x3F, 0xC0, 0x0F,
  0xFC, 0x03, 0xFF, 0xC0, 0x78, 0x78, 0x0E, 0x0F, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x03, 0xFE,
  0x1E, 0x7B, 0xC7, 0x8E, 0x3C, 0xE3, 0xC7, 0xB8, 0x78, 0x7F, 0x0F, 0x0F,
  0xC1, 0xE0, 0xF0, 0x38, 0x1E, 0x07, 0x87, 0xE0, 0xFF, 0xFE, 0x0F, 0xFB,
  0xC0, 0xFC, 0x3C, 0x7B, 0xBD, 0xEF, 0x7B, 0x9C, 0xE0, 0x00, 0x08, 0x03,
  0xC0, 0x3E, 0x07, 0xF0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01,
  0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xC0, 0x06, 0x00,
  0x0C, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x78, 0x07, 0x80, 0x7C, 0x0F, 0xC1, 0xFC, 0x0F, 0x80, 0x78,
  0x02, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x03, 0x0E, 0x1B, 0xE6, 0x3D, 0xFB, 0x7F, 0x7F, 0xFE, 0x01, 0xC0,
  0x01, 0xF0, 0x01, 0xDC, 0x01, 0xEF, 0x01, 0xE7, 0x81, 0xE1, 0xE0, 0xF0,
  0xF0, 0x30, 0x20, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x8F,
  0x87, 0x87, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x70, 0x00, 0x7F, 0xEF,
  0xFF, 0xFF, 0x80, 0x08, 0x79, 0xFB, 0xE7, 0xCF, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3,
  0xE0, 0xF1, 0xE0, 0x38, 0xE0, 0x1C, 0xF0, 0x0E, 0x78, 0x0F, 0x3C, 0x07,
  0x9E, 0x63, 0xCE, 0x79, 0xC7, 0x3C, 0xE3, 0x9E, 0x73, 0xC0, 0x79, 0xE0,
  0x3C, 0xF0, 0x1E, 0x70, 0x0F, 0x38, 0x07, 0x1E, 0x07, 0x8F, 0x07, 0x87,
  0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xF8,
  0x1F, 0xB8, 0x1E, 0x78, 0x1C, 0x78, 0x10, 0x78, 0x20, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x7F, 0xFF,
  0x7F, 0xFE, 0xFF, 0xFE, 0x00, 0x78, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF,
  0xF1, 0xF0, 0x78, 0xF0, 0x3C, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x03, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x78, 0x0F, 0x1C, 0x07, 0x8F,
  0x07, 0x87, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0xF0, 0x1C,
  0xF0, 0x1C, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF,
  0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x39, 0xF8,
  0x3B, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E, 0x78, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xFF, 0xF8,
  0x7F, 0xF0, 0x3F, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0xFC,
  0x1F, 0xFE, 0x3F, 0xFF, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x78, 0x3E, 0x7F, 0xFC, 0x3F, 0xF8,
  0x1F, 0xE0, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCE, 0x01, 0xE7, 0x01,
  0xE7, 0x80, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF1,
  0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x0F, 0x8F,
  0x83, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xE0, 0xF8, 0x78, 0x78,
  0x1C, 0x78, 0x0F, 0x38, 0x07, 0x9C, 0x03, 0x8F, 0x03, 0xC7, 0x83, 0xE3,
  0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xC0, 0x01, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xFE, 0x7C, 0x1E, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF8, 0x3C, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x0F, 0x0F, 0x87, 0xE3, 0xE1, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3C, 0x00, 0x03, 0xC0, 0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x07, 0xC0,
  0xF8, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x00, 0x00,
  0x01, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F,
  0x80, 0x7C, 0x00, 0x70, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x0C, 0x3F, 0xFF, 0x3F,
  0xFE, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x18, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x07, 0x00, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0x7C,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x80, 0x3E,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x07, 0xC1, 0xFE,
  0x07, 0xF0, 0x1F, 0x80, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x78, 0x3E, 0x0F, 0x00, 0xE1, 0xE0,
  0x0E, 0x1C, 0x00, 0xE3, 0xC0, 0x0E, 0x38, 0x0C, 0xE3, 0x83, 0xEE, 0x38,
  0x7F, 0xE3, 0x8F, 0x1E, 0x38, 0xE1, 0xE7, 0x8E, 0x1C, 0x71, 0xE1, 0xC7,
  0x1C, 0x1C, 0x71, 0xC1, 0xC7, 0x1C, 0x1C, 0x71, 0xC3, 0xCF, 0x1E, 0x3C,
  0xE1, 0xFD, 0x8E, 0x0F, 0xB8, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1E, 0xE0,
  0x0F, 0x70, 0x07, 0x38, 0x07, 0x9C, 0x03, 0x8E, 0x03, 0xC7, 0x01, 0xE3,
  0x80, 0xE1, 0xC0, 0xF0, 0xF0, 0x70, 0x78, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x1E, 0x07, 0x8F, 0x01, 0xCF, 0x00, 0xE7, 0x80, 0x77, 0x80, 0x3B,
  0xC0, 0x1E, 0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x78, 0x1E, 0x1E,
  0x07, 0x87, 0x81, 0xE1, 0xC0, 0x78, 0x70, 0x1E, 0x3C, 0x0F, 0x0F, 0xFF,
  0x83, 0xFF, 0x80, 0xFF, 0xF0, 0x38, 0x3E, 0x0E, 0x03, 0xC3, 0x80, 0xF1,
  0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x81, 0xE1, 0xC0, 0xF8, 0x7F,
  0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0xF0, 0x03, 0xFE, 0x03, 0xFF,
  0x83, 0xFF, 0xE1, 0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x1C, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x3C, 0x07, 0x1E, 0x07,
  0x8F, 0x87, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xFC, 0x07,
  0xFF, 0x87, 0xFF, 0xE3, 0xC1, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x70, 0x1E,
  0x38, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xE3, 0xC0,
  0xF1, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x1E,
  0x07, 0x8E, 0x1F, 0x87, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xFE, 0x03, 0xFF,
  0x83, 0xFF, 0xE1, 0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x1C, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x27, 0x9F, 0xE3, 0x8F, 0xF1,
  0xC7, 0xF9, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x1E, 0x07,
  0x8F, 0x87, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0x03, 0xC3,
  0x80, 0xF1, 0xE0, 0x38, 0x78, 0x0E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0,
  0x78, 0x70, 0x1E, 0x3C, 0x07, 0x8F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x0E, 0x03, 0xC3, 0x80, 0xF1, 0xE0, 0x38, 0x78, 0x1E, 0x1E,
  0x07, 0x87, 0x81, 0xE1, 0xC0, 0x78, 0x70, 0x1E, 0x3C, 0x07, 0x0F, 0x03,
  0xC0, 0x1F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC0, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x70, 0x0F, 0x0E, 0x01, 0xE1, 0xE0, 0x78, 0x3E,
  0x1F, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x0F, 0x01, 0xE1,
  0xC0, 0x78, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x3C, 0x07,
  0x87, 0x80, 0xE1, 0xE0, 0x3C, 0x7C, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x70, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78,
  0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x38, 0x0F, 0x07, 0x01, 0xE1, 0xE0,
  0x3C, 0x3C, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x03, 0xE3,
  0xE0, 0xF8, 0x6C, 0x1F, 0x0D, 0x87, 0xE3, 0xB0, 0xDC, 0x77, 0x3B, 0x8E,
  0xE6, 0xE1, 0xDD, 0xDC, 0x3B, 0xBB, 0x87, 0x36, 0x70, 0xE7, 0xDE, 0x3C,
  0xF3, 0xC7, 0x9E, 0x78, 0xF0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70,
  0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x0E, 0x00, 0xE1, 0xC0,
  0x1C, 0x38, 0x07, 0x80, 0x0F, 0x83, 0xC7, 0xE0, 0xF1, 0xF8, 0x3C, 0x7E,
  0x0E, 0x1F, 0x83, 0x87, 0xE0, 0xE1, 0xDC, 0x38, 0x77, 0x1E, 0x3D, 0xC7,
  0x8F, 0x71, 0xC3, 0x9C, 0x70, 0xE3, 0x9C, 0x38, 0xE7, 0x0E, 0x3B, 0xC7,
  0x8E, 0xF1, 0xE3, 0xBC, 0x78, 0x7E, 0x1C, 0x1F, 0x87, 0x07, 0xE1, 0xC1,
  0xF8, 0xF0, 0x7E, 0x3C, 0x1F, 0x8F, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0xFC,
  0x0F, 0xFE, 0x1F, 0xFF, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F,
  0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x70, 0x1E,
  0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF8, 0x78, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xC0, 0x0F, 0xFE, 0x03, 0xFF,
  0xE1, 0xFF, 0xF8, 0x78, 0x1F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C,
  0x70, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xE3, 0xC3, 0xF8, 0xFF, 0xFC, 0x3F,
  0xFC, 0x0F, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xE0, 0xF1, 0xE0,
  0x78, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF,
  0x01, 0xC7, 0x00, 0xE3, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E,
  0x78, 0x0F, 0x3C, 0x07, 0x1E, 0x07, 0x8F, 0x87, 0x87, 0xFF, 0xC1, 0xFF,
  0xC0, 0x7F, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x78,
  0x1E, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xC0, 0x3C, 0x70, 0x1E, 0x3C, 0x07,
  0x8F, 0x03, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x07,
  0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC0,
  0xF0, 0x70, 0x1C, 0x3C, 0x07, 0x8F, 0x01, 0xE0, 0x00, 0x70, 0x00, 0xFF,
  0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0x07, 0x87, 0x80, 0xE1, 0xE0, 0x38,
  0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xCF, 0x00, 0xF3, 0xC0, 0x78, 0x78, 0x3E, 0x1F, 0xFF, 0x03, 0xFF, 0x80,
  0x7F, 0x80, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x1C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xE3,
  0xC0, 0x71, 0xE0, 0x78, 0xE0, 0x3C, 0x70, 0x1E, 0x78, 0x0F, 0x3C, 0x07,
  0x1E, 0x03, 0x8F, 0x03, 0xC7, 0x01, 0xE3, 0x80, 0xF3, 0xC0, 0x79, 0xE0,
  0x3C, 0xF0, 0x1C, 0x78, 0x1E, 0x3C, 0x0F, 0x1F, 0x0F, 0x07, 0xFF, 0x83,
  0xFF, 0x80, 0xFF, 0x00, 0xE0, 0x0F, 0xE0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x70,
  0x70, 0xF0, 0x70, 0xE0, 0x71, 0xE0, 0x71, 0xE0, 0x71, 0xC0, 0x7B, 0xC0,
  0x7B, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x70, 0xF1, 0xEE, 0x1E, 0x39, 0xC7, 0x87, 0x38, 0xF0, 0xE7,
  0x1E, 0x3C, 0xE3, 0xC7, 0x3C, 0xD8, 0xE7, 0x9B, 0x1C, 0xE3, 0x67, 0x9C,
  0xEC, 0xE3, 0x99, 0x9C, 0x73, 0x33, 0x8E, 0x66, 0xE1, 0xDC, 0xDC, 0x3B,
  0x1B, 0x87, 0x63, 0x70, 0xEC, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C,
  0x3E, 0x0F, 0x87, 0x81, 0xE1, 0xF0, 0x3C, 0x3E, 0x00, 0x0F, 0x01, 0xF0,
  0xF0, 0x1E, 0x07, 0x83, 0xC0, 0x78, 0x78, 0x03, 0x87, 0x80, 0x3C, 0xF0,
  0x03, 0xDE, 0x00, 0x1D, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xBC, 0x00, 0x7B,
  0xC0, 0x0F, 0x3C, 0x01, 0xF1, 0xE0, 0x1E, 0x1E, 0x03, 0xC1, 0xE0, 0x7C,
  0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0xDC, 0x01, 0xE7,
  0x80, 0xF1, 0xE0, 0x78, 0x38, 0x1E, 0x0F, 0x0F, 0x03, 0xC3, 0x80, 0x71,
  0xE0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x0F,
  0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x7F, 0xFE, 0x3F, 0xFF,
  0x0F, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x00, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x81, 0xE0, 0x38, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0x70, 0x1E, 0x07, 0x81, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0x80,
  0x7F, 0x01, 0xDC, 0x0F, 0x70, 0x39, 0xC1, 0xC7, 0x8F, 0x0E, 0x38, 0x39,
  0xE0, 0xF7, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0,
  0xF0, 0xF1, 0xF0, 0x07, 0xCF, 0x0F, 0xEF, 0x1F, 0xFF, 0x3E, 0x7F, 0x7C,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1E, 0x70, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0x7C, 0xFF, 0xFC, 0x7F,
  0xB8, 0x3F, 0x38, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF3, 0xE0, 0x73, 0xF8, 0x3B, 0xFE, 0x3F, 0x1F, 0x1F, 0x07,
  0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xC0, 0x79, 0xE0, 0x3C, 0xF0,
  0x1E, 0x78, 0x0E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x87, 0x87, 0xFF, 0xC7,
  0xBF, 0xC3, 0xCF, 0xC0, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0x3E,
  0x7C, 0x1E, 0x78, 0x0E, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0xF0, 0x3C, 0xF8, 0x7C, 0x7F, 0xF8,
  0x7F, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x3E, 0x78, 0x3F, 0xBC, 0x3F, 0xFE, 0x3E, 0x7F, 0x3E,
  0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x01, 0xE3, 0x80, 0xF3, 0xC0, 0x79,
  0xE0, 0x38, 0xF0, 0x1C, 0x78, 0x1E, 0x3C, 0x0F, 0x1F, 0x0F, 0x8F, 0xFF,
  0xC3, 0xFD, 0xC0, 0xFC, 0xE0, 0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF1, 0xF1,
  0xF3, 0x81, 0xEF, 0x01, 0xDE, 0x03, 0xB8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x07, 0xBC, 0x1E, 0x3F, 0xFC, 0x7F,
  0xF0, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xCF, 0x0F, 0xEF, 0x1F, 0xFF, 0x3E, 0x7F, 0x7C, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x70, 0x1E, 0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0,
  0x3C, 0xFC, 0xFC, 0x7F, 0xFC, 0x7F, 0xBC, 0x1F, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x01, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF3, 0xE0,
  0x7F, 0xF8, 0x3B, 0xFE, 0x3F, 0x1F, 0x1F, 0x07, 0x8F, 0x03, 0xC7, 0x81,
  0xE3, 0xC0, 0xF1, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1C, 0x78, 0x0E, 0x3C,
  0x0F, 0x1E, 0x07, 0x8E, 0x03, 0xC7, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x70,
  0x00, 0x38, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x83,
  0xFF, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x0F,
  0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xF1, 0xE0, 0x78,
  0x70, 0x3E, 0x1C, 0x1F, 0x0F, 0x07, 0x83, 0xC3, 0xC0, 0xF1, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x78, 0xF8, 0x1E, 0x1E,
  0x07, 0x87, 0x81, 0xE0, 0xF0, 0x70, 0x3C, 0x3C, 0x07, 0x8F, 0x01, 0xF0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F,
  0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0x1C, 0xE3, 0x83, 0xBE, 0xF8, 0x7F, 0xFF,
  0x0E, 0x38, 0xE3, 0xC7, 0x1C, 0x78, 0xE3, 0x8F, 0x18, 0x71, 0xC7, 0x1E,
  0x38, 0xE3, 0xC7, 0x1C, 0x70, 0xE3, 0x8E, 0x3C, 0x71, 0xC7, 0x8C, 0x38,
  0xE1, 0x8F, 0x1C, 0x71, 0xE3, 0x8E, 0x38, 0x71, 0xC7, 0x1E, 0x38, 0xE0,
  0x1E, 0x7C, 0x0E, 0xFF, 0x07, 0x7F, 0xC7, 0xE3, 0xE3, 0xE0, 0xF1, 0xE0,
  0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x38, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0x8F,
  0x01, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xC0, 0x78, 0xE0, 0x3C, 0xF0, 0x1E,
  0x78, 0x0E, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF1, 0xF3, 0xF7, 0xC1,
  0xEF, 0x03, 0xDE, 0x07, 0xB8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xEF, 0x03, 0xDE, 0x07, 0xBE, 0x1E, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F,
  0x80, 0x0F, 0x3E, 0x03, 0x9F, 0xC0, 0xEF, 0xF8, 0x7E, 0x3E, 0x1F, 0x07,
  0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1C, 0x07, 0x8F, 0x01, 0xE3,
  0xC0, 0x78, 0xF0, 0x1C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xE1, 0xE0, 0xFF,
  0xF8, 0x7B, 0xFC, 0x1E, 0x7E, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xCF, 0x0F, 0xEF, 0x1F,
  0xFF, 0x3E, 0x7F, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8,
  0x7C, 0xFF, 0xFC, 0x7F, 0xB8, 0x3F, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x3C, 0x78, 0x3D, 0xFE, 0x3F,
  0xFF, 0x3F, 0x1F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x78, 0x0F, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0x07,
  0xFF, 0xC3, 0xC1, 0xE3, 0xC0, 0x71, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0x00,
  0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0xE7, 0x80,
  0x71, 0xE0, 0x78, 0xFF, 0xF8, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x0F, 0xFC, 0x0F, 0xF8, 0x03, 0xF8, 0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0F,
  0x78, 0x0F, 0x78, 0x0E, 0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0x78,
  0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xC0, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E,
  0xF0, 0x1E, 0x70, 0x3C, 0x70, 0x3C, 0x70, 0x78, 0x78, 0x78, 0x78, 0xF0,
  0x78, 0xF0, 0x38, 0xE0, 0x39, 0xE0, 0x39, 0xC0, 0x3F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0xE1, 0xC1, 0xF8, 0x70, 0xEE, 0x1C,
  0x3B, 0x8F, 0x0E, 0xE3, 0xC3, 0xB8, 0xF1, 0xCE, 0x7C, 0x73, 0x9B, 0x1C,
  0xE6, 0xCE, 0x39, 0xB3, 0x8E, 0xCC, 0xE3, 0xB3, 0x70, 0xEC, 0xDC, 0x3E,
  0x37, 0x0F, 0x8D, 0x83, 0xE3, 0xE0, 0xF0, 0xF8, 0x3C, 0x3C, 0x00, 0x1E,
  0x03, 0xE1, 0xE0, 0x78, 0x3C, 0x1E, 0x03, 0xC7, 0x80, 0x79, 0xF0, 0x07,
  0xBC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0xFB, 0xC0, 0x1E, 0x78, 0x07, 0x87, 0x81, 0xE0,
  0xF0, 0x78, 0x0F, 0x1F, 0x01, 0xE0, 0x3C, 0x0F, 0x38, 0x0F, 0x78, 0x0F,
  0x78, 0x0E, 0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1E, 0x70, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x7C, 0xFF, 0xFC, 0x7F, 0xFC,
  0x7F, 0xBC, 0x0C, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x01, 0xF0,
  0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0xFF, 0x80, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x70, 0x07,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x78, 0x78, 0x70,
  0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x0E, 0x00, 0x0F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xFF,
  0x00, 0x3F, 0x01, 0xFF, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x7F, 0x07,
  0x7F, 0x87, 0xF3, 0xC7, 0xE3, 0xFF, 0xE1, 0xFE, 0xE0, 0xFC,
};

const GFXglyph JetBrainsMono_SemiBoldItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 8, 23, 19, 6, -23 },
  { 24, 12, 9, 19, 5, -23 },
  { 38, 20, 23, 19, 0, -23 },
  { 96, 18, 32, 19, 1, -28 },
  { 168, 22, 24, 19, -1, -24 },
  { 234, 19, 24, 19, 0, -24 },
  { 291, 5, 9, 19, 9, -23 },
  { 297, 13, 31, 19, 5, -27 },
  { 348, 13, 31, 19, 2, -27 },
  { 399, 17, 17, 19, 2, -20 },
  { 436, 16, 15, 19, 2, -18 },
  { 466, 9, 10, 19, 3, -5 },
  { 478, 11, 3, 19, 4, -12 },
  { 483, 7, 6, 19, 5, -6 },
  { 489, 20, 31, 19, 0, -27 },
  { 567, 17, 24, 19, 2, -24 },
  { 618, 16, 23, 19, 1, -23 },
  { 664, 17, 24, 19, 1, -24 },
  { 715, 17, 23, 19, 1, -23 },
  { 764, 16, 23, 19, 2, -23 },
  { 810, 16, 23, 19, 2, -23 },
  { 856, 16, 23, 19, 1, -23 },
  { 902, 17, 23, 19, 3, -23 },
  { 951, 17, 24, 19, 1, -24 },
  { 1002, 16, 24, 19, 3, -24 },
  { 1050, 9, 18, 19, 5, -18 },
  { 1071, 11, 23, 19, 3, -18 },
  { 1103, 16, 17, 19, 2, -19 },
  { 1137, 16, 11, 19, 2, -16 },
  { 1159, 16, 17, 19, 1, -19 },
  { 1193, 14, 23, 19, 4, -23 },
  { 1234, 20, 30, 19, 0, -24 },
  { 1309, 17, 23, 19, 0, -23 },
  { 1358, 18, 23, 19, 1, -23 },
  { 1410, 17, 24, 19, 2, -24 },
  { 1461, 17, 23, 19, 1, -23 },
  { 1510, 18, 23, 19, 1, -23 },
  { 1562, 18, 23, 19, 1, -23 },
  { 1614, 17, 24, 19, 2, -24 },
  { 1665, 18, 23, 19, 1, -23 },
  { 1717, 17, 23, 19, 2, -23 },
  { 1766, 19, 23, 19, 0, -23 },
  { 1821, 19, 23, 19, 1, -23 },
  { 1876, 14, 23, 19, 2, -23 },
  { 1917, 19, 23, 19, 1, -23 },
  { 1972, 18, 23, 19, 1, -23 },
  { 2024, 16, 24, 19, 2, -24 },
  { 2072, 18, 23, 19, 1, -23 },
  { 2124, 17, 30, 19, 2, -24 },
  { 2188, 18, 23, 19, 1, -23 },
  { 2240, 18, 24, 19, 1, -24 },
  { 2294, 17, 23, 19, 3, -23 },
  { 2343, 17, 23, 19, 2, -23 },
  { 2392, 16, 23, 19, 4, -23 },
  { 2438, 19, 23, 19, 2, -23 },
  { 2493, 20, 23, 19, 0, -23 },
  { 2551, 18, 23, 19, 3, -23 },
  { 2603, 18, 23, 19, 1, -23 },
  { 2655, 14, 31, 19, 4, -27 },
  { 2710, 10, 31, 19, 5, -27 },
  { 2749, 14, 31, 19, 2, -27 },
  { 2804, 14, 12, 19, 3, -23 },
  { 2825, 16, 3, 19, 0, 1 },
  { 2831, 7, 4, 19, 8, -25 },
  { 2835, 16, 18, 19, 2, -18 },
  { 2871, 17, 23, 19, 1, -23 },
  { 2920, 16, 18, 19, 2, -18 },
  { 2956, 17, 23, 19, 2, -23 },
  { 3005, 15, 18, 19, 2, -18 },
  { 3039, 22, 29, 19, -2, -23 },
  { 3119, 16, 24, 19, 2, -18 },
  { 3167, 17, 23, 19, 1, -23 },
  { 3216, 16, 25, 19, 1, -25 },
  { 3266, 17, 31, 19, 0, -25 },
  { 3332, 18, 23, 19, 1, -23 },
  { 3384, 14, 23, 19, 3, -23 },
  { 3425, 19, 18, 19, 0, -18 },
  { 3468, 17, 18, 19, 1, -18 },
  { 3507, 15, 18, 19, 2, -18 },
  { 3541, 18, 24, 19, 0, -18 },
  { 3595, 16, 24, 19, 2, -18 },
  { 3643, 16, 18, 19, 2, -18 },
  { 3679, 17, 18, 19, 1, -18 },
  { 3718, 16, 22, 19, 2, -22 },
  { 3762, 16, 18, 19, 2, -18 },
  { 3798, 16, 18, 19, 3, -18 },
  { 3834, 18, 18, 19, 2, -18 },
  { 3875, 19, 18, 19, 0, -18 },
  { 3918, 16, 24, 19, 2, -18 },
  { 3966, 17, 18, 19, 1, -18 },
  { 4005, 16, 31, 19, 3, -27 },
  { 4067, 8, 31, 19, 6, -27 },
  { 4098, 16, 31, 19, 1, -27 },
  { 4160, 16, 7, 19, 2, -15 },
};

const GFXfont JetBrainsMono_SemiBoldItalic32pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic32pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC32PT7B_H_
