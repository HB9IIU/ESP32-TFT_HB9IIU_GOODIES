#ifndef _JETBRAINSMONO_SEMIBOLDITALIC57PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xFC, 0x0F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x03, 0xFB, 0xF8,
  0x1F, 0xDF, 0xC0, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xF9,
  0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xE7, 0xF0, 0x3F, 0x3F, 0x81,
  0xF9, 0xF8, 0x1F, 0xCF, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F,
  0x81, 0xF8, 0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0x9C, 0xFF, 0x01, 0xFC, 0x78, 0xFF, 0x07, 0xF0, 0xF0, 0xFE, 0x0F, 0xE1,
  0xE1, 0xFC, 0x1F, 0xC3, 0x83, 0xF8, 0x3F, 0x07, 0x00, 0x00, 0x7E, 0x0E,
  0x00, 0x00, 0xFE, 0x3C, 0x00, 0x01, 0xFC, 0x78, 0x00, 0x03, 0xFC, 0xF0,
  0x00, 0x07, 0xFD, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0x3F, 0xE0, 0x00, 0x1E, 0x3F, 0xC0, 0x00, 0x3C, 0x3F, 0x80,
  0x00, 0x78, 0x7F, 0x00, 0x00, 0xE0, 0xFE, 0x00, 0x01, 0xC1, 0xFC, 0x3F,
  0x03, 0x83, 0xF8, 0x7E, 0x0F, 0x07, 0xF0, 0xFE, 0x1E, 0x1F, 0xC1, 0xFC,
  0x3C, 0x3F, 0x83, 0xFC, 0x71, 0xFE, 0x07, 0xFE, 0xEF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x3F, 0xF0, 0x00, 0x3E, 0x00,
  0xFF, 0xF8, 0x00, 0x7C, 0x01, 0xFF, 0xFC, 0x00, 0xFC, 0x01, 0xFD, 0xFC,
  0x00, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x03, 0xE0,
  0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0x07, 0xC0,
  0x7C, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x3F, 0x00, 0x07, 0xC0, 0x7C, 0x3E,
  0x00, 0x07, 0xC0, 0xF8, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0xF8, 0x00, 0x07,
  0xE1, 0xF9, 0xF0, 0x00, 0x07, 0xFF, 0xF3, 0xE0, 0x00, 0x03, 0xFF, 0xE7,
  0xC0, 0x00, 0x01, 0xFF, 0xC7, 0xC0, 0x00, 0x00, 0xFF, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x00, 0x01, 0xF1, 0xFF, 0x00, 0x00, 0x03, 0xE7, 0xFF, 0xC0, 0x00,
  0x07, 0xCF, 0xFF, 0xC0, 0x00, 0x0F, 0x9F, 0xFF, 0xE0, 0x00, 0x1F, 0x1F,
  0x03, 0xE0, 0x00, 0x3E, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x3E, 0x03, 0xE0,
  0x00, 0x7C, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x3E, 0x03, 0xC0, 0x01, 0xF0,
  0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x1F,
  0x00, 0x3F, 0xFF, 0x80, 0x3E, 0x00, 0x1F, 0xFF, 0x00, 0x7C, 0x00, 0x1F,
  0xFE, 0x00, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0x1F,
  0xDF, 0xC0, 0x7E, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x87, 0xE1, 0xFC, 0x3F,
  0x07, 0xF1, 0xF8, 0x3F, 0x03, 0xFB, 0xF8, 0x7F, 0x03, 0xFF, 0xF0, 0x7F,
  0x01, 0xFF, 0xE0, 0x7E, 0x01, 0xFF, 0xE0, 0x7E, 0x00, 0xFF, 0xC0, 0x7E,
  0x00, 0xFF, 0x80, 0x7E, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0x87, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xEF, 0xE0, 0x3F, 0xFF, 0xC7, 0xF0, 0x1F,
  0xFF, 0x83, 0xF0, 0x0F, 0xFE, 0x03, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x3F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0xFE, 0xFE, 0xFE, 0xFE, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x38,
  0x07, 0xC0, 0x18, 0xF8, 0x1F, 0x03, 0xF7, 0xF8, 0x7C, 0x3F, 0xDF, 0xF0,
  0xE3, 0xFF, 0xFF, 0xF3, 0xBF, 0xFF, 0xFF, 0xED, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x1F,
  0xE0, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x10, 0x00, 0x40, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x0F, 0x07, 0xF9, 0xFF, 0x3F, 0xEF, 0xFF, 0xFF, 0xBF,
  0xF7, 0xFE, 0xFF, 0x8F, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFC, 0x00, 0xFE,
  0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF8, 0xFE, 0x0C,
  0x0F, 0xC3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC7, 0xF0, 0xFC, 0x3F, 0x1F, 0xE3,
  0xF0, 0xFC, 0x7F, 0x8F, 0xC3, 0xF1, 0xFC, 0x7F, 0x1F, 0xC3, 0xF1, 0xFC,
  0x7F, 0x07, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F,
  0x80, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xE7, 0xE0, 0x03, 0xFC, 0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0x07,
  0xE0, 0xFE, 0x00, 0x78, 0x0F, 0xE0, 0x07, 0x00, 0xFE, 0x00, 0x40, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF0,
  0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x10, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF8, 0x7E, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x01,
  0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0,
  0xFF, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x7E, 0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF1, 0xFF,
  0x80, 0x0F, 0xCF, 0xFF, 0x00, 0x3F, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0x80, 0x7F, 0x81,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8,
  0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x38, 0x00, 0x1F, 0xDF, 0xF8,
  0x01, 0xFD, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xC0, 0x3F, 0xC7, 0xF8, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0,
  0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xC0, 0x00, 0xFE,
  0x7E, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xF1, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x03,
  0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x3F,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xFC,
  0x7F, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0x7F,
  0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE,
  0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x07,
  0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xA0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF3,
  0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0xFE, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF9,
  0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xEF, 0xE0, 0x0F, 0xFE, 0xFE, 0x00, 0x1F, 0xCF,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0x83, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x3F, 0x81, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x0C, 0x00, 0x00, 0x0F,
  0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0x83, 0xF0, 0x03,
  0xE1, 0xF0, 0x7C, 0x01, 0xFF, 0x3E, 0x0F, 0x80, 0x7F, 0xF7, 0xC3, 0xF0,
  0x1F, 0xFE, 0xF8, 0x7E, 0x07, 0xF8, 0xFF, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1,
  0xF8, 0x3F, 0x01, 0xF8, 0x3E, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0xF8, 0x07,
  0xE1, 0xF8, 0x1F, 0x00, 0xFC, 0x3F, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0xFC,
  0x03, 0xF0, 0xFC, 0x1F, 0x80, 0x7C, 0x1F, 0x03, 0xF0, 0x0F, 0x83, 0xE0,
  0x7C, 0x03, 0xF0, 0x7C, 0x0F, 0x80, 0x7E, 0x1F, 0x83, 0xF0, 0x0F, 0xC3,
  0xF0, 0x7E, 0x01, 0xF8, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0x81, 0xFC, 0x0F,
  0xC1, 0xF0, 0x1F, 0xC7, 0xF8, 0x3E, 0x03, 0xFF, 0xDF, 0x0F, 0xC0, 0x7F,
  0xF3, 0xE1, 0xF8, 0x07, 0xFC, 0x7C, 0x3F, 0x00, 0x3E, 0x10, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x01, 0xF9, 0xF0,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E,
  0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0xFD, 0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFC, 0x01, 0xFF, 0x01, 0xF8, 0x00, 0xFE,
  0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8,
  0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F,
  0x80, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0,
  0x1F, 0xF0, 0x1F, 0x80, 0x0F, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xC0, 0x7F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x80,
  0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF0,
  0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x1F,
  0xE0, 0x1F, 0xE0, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFC, 0x0F, 0xFF, 0x03, 0xF8, 0x01,
  0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03,
  0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC,
  0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F,
  0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x07,
  0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x81, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFC,
  0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x83, 0xFF, 0xF0, 0xFE, 0x0F, 0xFF, 0xC3, 0xF8, 0x3F, 0xFF, 0x0F, 0xC0,
  0xFF, 0xFC, 0x3F, 0x07, 0xFF, 0xF1, 0xFC, 0x1F, 0xFF, 0x87, 0xF0, 0x00,
  0x7E, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F,
  0x87, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F,
  0xE3, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0,
  0x01, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xE0,
  0x01, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x07, 0xF0, 0x1F, 0x80,
  0x07, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x3F, 0x80, 0x07, 0xE0, 0x3F, 0x80,
  0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x40, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0,
  0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0x1F, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x0F,
  0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x07, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0,
  0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xF7,
  0x80, 0x7F, 0xE0, 0x3D, 0xE0, 0x1F, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07,
  0xDF, 0x03, 0xFF, 0x81, 0xF7, 0xC1, 0xF7, 0xC0, 0x7D, 0xF0, 0x7D, 0xF0,
  0x1F, 0x3C, 0x1E, 0x7C, 0x07, 0xCF, 0x0F, 0xBF, 0x03, 0xF3, 0xC3, 0xCF,
  0xC0, 0xFC, 0xF9, 0xF3, 0xF0, 0x3F, 0x3E, 0x78, 0xF8, 0x0F, 0xCF, 0xBE,
  0x7E, 0x03, 0xF3, 0xEF, 0x9F, 0x80, 0xFC, 0x7B, 0xC7, 0xE0, 0x3F, 0x1F,
  0xF1, 0xF8, 0x1F, 0x87, 0xF8, 0x7E, 0x07, 0xE1, 0xFE, 0x3F, 0x01, 0xF8,
  0x7F, 0x0F, 0xC0, 0x7E, 0x1F, 0xC3, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0,
  0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x3F, 0x03, 0xFE, 0x00, 0x3F, 0x03, 0xFE, 0x00, 0x7F,
  0x03, 0xFE, 0x00, 0x7E, 0x03, 0xFE, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0x7E,
  0x03, 0xFF, 0x00, 0x7E, 0x07, 0xFF, 0x00, 0x7E, 0x07, 0xFF, 0x00, 0x7E,
  0x07, 0xFF, 0x00, 0xFC, 0x07, 0xDF, 0x80, 0xFC, 0x07, 0xDF, 0x80, 0xFC,
  0x07, 0xCF, 0x80, 0xFC, 0x0F, 0xCF, 0x80, 0xFC, 0x0F, 0xCF, 0x80, 0xFC,
  0x0F, 0xCF, 0xC1, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0x0F, 0xC7, 0xC1, 0xF8,
  0x0F, 0xC7, 0xC1, 0xF8, 0x1F, 0x87, 0xC1, 0xF8, 0x1F, 0x87, 0xC1, 0xF8,
  0x1F, 0x87, 0xE3, 0xF8, 0x1F, 0x87, 0xE3, 0xF0, 0x1F, 0x83, 0xE3, 0xF0,
  0x1F, 0x83, 0xE3, 0xF0, 0x3F, 0x83, 0xE3, 0xF0, 0x3F, 0x03, 0xF3, 0xF0,
  0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x01, 0xF3, 0xE0, 0x3F, 0x01, 0xF3, 0xE0,
  0x3F, 0x01, 0xF7, 0xE0, 0x3F, 0x01, 0xFF, 0xE0, 0x7E, 0x01, 0xFF, 0xE0,
  0x7E, 0x00, 0xFF, 0xE0, 0x7E, 0x00, 0xFF, 0xE0, 0x7E, 0x00, 0xFF, 0xC0,
  0x7E, 0x00, 0xFF, 0xC0, 0x7E, 0x00, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xC0,
  0xFC, 0x00, 0x7F, 0xC0, 0xFC, 0x00, 0x7F, 0xC0, 0xFC, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xC0, 0x7F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x03,
  0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE,
  0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7F, 0x0F,
  0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F,
  0xE0, 0x1F, 0xE0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xF8, 0x07,
  0xE0, 0x03, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xF0,
  0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0xFF,
  0x01, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xC0, 0x7F, 0x81, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80,
  0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x01,
  0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFE,
  0x1F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0,
  0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x1F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF0,
  0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xF8, 0x1F,
  0xC0, 0x1F, 0xE0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xFE, 0x03, 0xF0, 0x01, 0xFE, 0x07,
  0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F,
  0xE0, 0x03, 0xFC, 0x0F, 0xC0, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xFC, 0x01, 0xFE, 0x07, 0xFF,
  0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC,
  0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F,
  0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x7E,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x03,
  0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8,
  0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07,
  0xFE, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFE, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0,
  0x7F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07,
  0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x1F, 0x8F, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E,
  0x03, 0xF3, 0xF0, 0x1F, 0x80, 0xFC, 0xFC, 0x0F, 0xE0, 0x3E, 0x3F, 0x03,
  0xF8, 0x1F, 0x8F, 0xC0, 0xFE, 0x07, 0xE3, 0xE0, 0x3F, 0x81, 0xF8, 0xF8,
  0x1F, 0xE0, 0x7C, 0x3E, 0x07, 0xF8, 0x3F, 0x0F, 0x81, 0xDE, 0x0F, 0xC3,
  0xE0, 0xF7, 0x83, 0xF0, 0xF8, 0x3D, 0xE0, 0xF8, 0x7E, 0x0F, 0x78, 0x7E,
  0x1F, 0x83, 0x9E, 0x1F, 0x87, 0xE1, 0xE7, 0x87, 0xC1, 0xF8, 0x79, 0xE1,
  0xF0, 0x7E, 0x1C, 0x70, 0xFC, 0x1F, 0x8F, 0x1C, 0x3F, 0x07, 0xE3, 0xC7,
  0x0F, 0x81, 0xF8, 0xF1, 0xC3, 0xE0, 0x7C, 0x38, 0x71, 0xF8, 0x1F, 0x1E,
  0x1C, 0x7E, 0x07, 0xC7, 0x8F, 0x1F, 0x01, 0xF1, 0xE3, 0xC7, 0xC0, 0x7C,
  0x70, 0xF3, 0xF0, 0x1F, 0x3C, 0x3C, 0xFC, 0x07, 0xCF, 0x0F, 0x3E, 0x01,
  0xF3, 0x83, 0xCF, 0x80, 0x7D, 0xE0, 0xF7, 0xE0, 0x1F, 0x78, 0x3D, 0xF0,
  0x07, 0xDE, 0x0F, 0x7C, 0x03, 0xF7, 0x03, 0xDF, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xBC, 0x0F, 0xF8, 0x03, 0xEE, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x3F,
  0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x03,
  0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x01,
  0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x80,
  0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x1F,
  0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00,
  0x1F, 0x87, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F,
  0x80, 0x7E, 0x03, 0xE0, 0x3F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xE0,
  0x0F, 0xC3, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xBF,
  0x80, 0x07, 0xEF, 0xC0, 0x00, 0xFC, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0x1F, 0xC0, 0x7F,
  0xFC, 0xFE, 0x07, 0xFF, 0xF7, 0xF0, 0x7F, 0xFF, 0xBF, 0x07, 0xFF, 0xFD,
  0xF8, 0x3F, 0xC0, 0xFF, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0,
  0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x7E, 0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01,
  0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x83, 0xF8, 0x07,
  0xFC, 0x1F, 0xF0, 0xF7, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFB, 0xF8,
  0x1F, 0xFF, 0x9F, 0xC0, 0x7F, 0xF8, 0xFC, 0x01, 0xFF, 0x87, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xE3, 0xFF, 0x00, 0x7E,
  0x7F, 0xFC, 0x03, 0xF7, 0xFF, 0xF0, 0x3F, 0xBF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC3, 0xF8, 0x00, 0xFE,
  0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xF0, 0xFC, 0x00,
  0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F,
  0x1F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x3F,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF0, 0xFF, 0x80,
  0x7F, 0x87, 0xFF, 0x0F, 0xF8, 0x3F, 0x7F, 0xFF, 0xC1, 0xFB, 0xFF, 0xFC,
  0x1F, 0xDF, 0xFF, 0xC0, 0xFE, 0x7F, 0xFC, 0x07, 0xF1, 0xFF, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF0,
  0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x83, 0xFC, 0x03,
  0xFC, 0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xFF,
  0x1F, 0xC0, 0x1F, 0xFF, 0x3F, 0x80, 0x7F, 0xFF, 0x7F, 0x01, 0xFF, 0xFE,
  0xFE, 0x07, 0xFF, 0xFD, 0xF8, 0x0F, 0xF0, 0x3F, 0xF0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x7F, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xF0,
  0x3F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x1F,
  0x80, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xFC, 0x07, 0xFC,
  0x3D, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF,
  0x9F, 0xC0, 0x1F, 0xFE, 0x3F, 0x00, 0x1F, 0xF8, 0x7E, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xE7, 0xFE, 0x0F,
  0xF0, 0x0F, 0xE1, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xF1, 0xF8, 0x00,
  0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x7E, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x04, 0x7E, 0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0x1F, 0xC0, 0x7F, 0xFC, 0xFE, 0x07,
  0xFF, 0xF7, 0xF0, 0x7F, 0xFF, 0xBF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0,
  0x7F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F,
  0x80, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0x0F,
  0xF0, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0xFC, 0x0F, 0xFF,
  0xEF, 0xE0, 0x3F, 0xFF, 0x7F, 0x00, 0xFF, 0xE3, 0xF8, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x1F,
  0x80, 0x0F, 0xE3, 0xFF, 0x00, 0x7E, 0x7F, 0xFE, 0x03, 0xF7, 0xFF, 0xF0,
  0x3F, 0xBF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F,
  0x80, 0x3F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00,
  0x3F, 0x8F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E,
  0x1F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF0, 0xFE, 0x00,
  0x3F, 0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F,
  0x1F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xFC, 0x3F,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00,
  0x1F, 0x87, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x07,
  0xF0, 0x01, 0xFE, 0x07, 0xE0, 0x03, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F,
  0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x3F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x1F,
  0xC0, 0xFF, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0xC0, 0x7E,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xC0, 0xF8, 0x0F, 0xCF, 0xE3, 0xFC, 0x0F, 0xDF, 0xF7, 0xFE, 0x0F,
  0xFF, 0xF7, 0xFE, 0x0F, 0xBF, 0xFF, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F,
  0xC1, 0xF0, 0x7F, 0x1F, 0x81, 0xF0, 0x7E, 0x1F, 0x81, 0xF0, 0x7E, 0x1F,
  0x81, 0xF0, 0x7E, 0x1F, 0x81, 0xE0, 0x7E, 0x1F, 0x83, 0xE0, 0x7E, 0x1F,
  0x83, 0xE0, 0x7E, 0x1F, 0x83, 0xE0, 0x7E, 0x3F, 0x03, 0xE0, 0xFC, 0x3F,
  0x03, 0xE0, 0xFC, 0x3F, 0x03, 0xE0, 0xFC, 0x3F, 0x07, 0xC0, 0xFC, 0x3F,
  0x07, 0xC0, 0xFC, 0x3F, 0x07, 0xC0, 0xFC, 0x7E, 0x07, 0xC1, 0xF8, 0x7E,
  0x07, 0xC1, 0xF8, 0x7E, 0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0x81, 0xF8, 0x7E,
  0x0F, 0x81, 0xF8, 0x7E, 0x0F, 0x81, 0xF8, 0xFC, 0x0F, 0x81, 0xF0, 0xFC,
  0x0F, 0x83, 0xF0, 0xFC, 0x0F, 0x83, 0xF0, 0xFC, 0x0F, 0x03, 0xF0, 0xFC,
  0x1F, 0x03, 0xF0, 0xFC, 0x1F, 0x03, 0xF0, 0x00, 0x10, 0x7E, 0x00, 0x3F,
  0x0F, 0xFC, 0x01, 0xF9, 0xFF, 0xF8, 0x0F, 0xDF, 0xFF, 0xC0, 0xFE, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x3F, 0xE1, 0xFE, 0x00, 0xFF,
  0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F,
  0x80, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F,
  0x8F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F,
  0x80, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x3F,
  0x87, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7E, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xF8, 0x1F, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF1, 0xF8,
  0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07,
  0xF3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0xFC, 0x7E, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF,
  0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0xE3,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x04, 0x1F, 0x80, 0x03, 0xF0, 0xFF, 0xC0, 0x07, 0xE7, 0xFF, 0xE0, 0x0F,
  0xDF, 0xFF, 0xC0, 0x3F, 0xBF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07,
  0xF0, 0x7F, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x7E, 0xF0, 0xFF, 0x80, 0xFD, 0xFF, 0xFF, 0x01,
  0xFB, 0xFF, 0xFC, 0x07, 0xF7, 0xFF, 0xF0, 0x0F, 0xE7, 0xFF, 0xC0, 0x1F,
  0xC7, 0xFE, 0x00, 0x3F, 0x80, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF,
  0x1F, 0xC0, 0x7F, 0xFC, 0xFE, 0x07, 0xFF, 0xF7, 0xF0, 0x7F, 0xFF, 0xBF,
  0x07, 0xFF, 0xFD, 0xF8, 0x3F, 0xC0, 0xEF, 0xC3, 0xFC, 0x01, 0xFE, 0x1F,
  0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x3F,
  0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7E, 0x1F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xFC, 0x7F, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x3F,
  0x83, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFB, 0xF8, 0x1F, 0xFF, 0x9F, 0xC0, 0x7F, 0xF8, 0xFC, 0x01, 0xFF,
  0x87, 0xE0, 0x00, 0xC0, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x8F, 0xFF, 0x00, 0x7E,
  0x7F, 0xFE, 0x01, 0xFB, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x03,
  0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE,
  0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x1F, 0xC0, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x0F,
  0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F,
  0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0x80,
  0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x87,
  0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0,
  0x07, 0xF0, 0x7F, 0x80, 0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0x9F, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0xFE, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0,
  0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E,
  0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0x7E, 0x07,
  0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xF8, 0x0F, 0xC0, 0x3F, 0xF0, 0x1F, 0x80, 0xFF, 0xE0, 0x3F, 0x01, 0xF7,
  0xC0, 0x7E, 0x03, 0xEF, 0x81, 0xFC, 0x0F, 0xDF, 0x03, 0xB8, 0x1F, 0x3E,
  0x07, 0x70, 0x3E, 0x7C, 0x1E, 0xE0, 0x7C, 0xF8, 0x3D, 0xC1, 0xF1, 0xF0,
  0x73, 0x83, 0xE3, 0xE1, 0xE7, 0x07, 0xC7, 0xC3, 0xCE, 0x1F, 0x8F, 0x87,
  0x1C, 0x3E, 0x1F, 0x1E, 0x38, 0x7C, 0x3E, 0x3C, 0x71, 0xF8, 0x7C, 0x70,
  0xE3, 0xE0, 0xF9, 0xE1, 0xC7, 0xC1, 0xF3, 0xC3, 0x8F, 0x83, 0xE7, 0x07,
  0x3E, 0x07, 0xCE, 0x0E, 0x7C, 0x0F, 0xBC, 0x1C, 0xF8, 0x1F, 0x78, 0x7B,
  0xE0, 0x3E, 0xE0, 0xF7, 0xC0, 0x7F, 0xC1, 0xEF, 0x80, 0xFF, 0x83, 0xFE,
  0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xE0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x03,
  0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE,
  0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF8, 0x7E,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00,
  0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFE,
  0x1F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xF8, 0x7F,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00,
  0x3F, 0x87, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xE1, 0xFF, 0x07, 0xFE,
  0x0F, 0xFF, 0xFB, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFD, 0xFC, 0x07,
  0xFF, 0xCF, 0xE0, 0x1F, 0xFC, 0x7F, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xF0, 0x03,
  0xF0, 0xFF, 0xE0, 0x0F, 0x87, 0xFF, 0xC0, 0x3E, 0x3F, 0xFF, 0x81, 0xF9,
  0xFF, 0xFE, 0x07, 0xE7, 0xE1, 0xFC, 0x1F, 0x9F, 0x03, 0xF8, 0xFE, 0xFC,
  0x0F, 0xFF, 0xF3, 0xF0, 0x1F, 0xFF, 0xCF, 0xC0, 0x3F, 0xFE, 0x3F, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
};

const GFXglyph JetBrainsMono_SemiBoldItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 15, 42, 34, 10, -42 },
  { 80, 21, 17, 34, 10, -42 },
  { 125, 34, 42, 34, 1, -42 },
  { 304, 31, 58, 34, 2, -50 },
  { 529, 40, 42, 34, -2, -42 },
  { 739, 32, 43, 34, 1, -42 },
  { 911, 8, 17, 34, 16, -42 },
  { 928, 25, 55, 34, 8, -48 },
  { 1100, 24, 55, 34, 3, -48 },
  { 1265, 30, 30, 34, 3, -35 },
  { 1378, 29, 27, 34, 3, -32 },
  { 1476, 16, 18, 34, 5, -9 },
  { 1512, 20, 6, 34, 8, -22 },
  { 1527, 11, 11, 34, 10, -10 },
  { 1543, 36, 53, 34, 0, -47 },
  { 1782, 30, 43, 34, 3, -42 },
  { 1944, 28, 42, 34, 2, -42 },
  { 2091, 31, 42, 34, 2, -42 },
  { 2254, 30, 43, 34, 2, -42 },
  { 2416, 29, 42, 34, 3, -42 },
  { 2569, 30, 43, 34, 3, -42 },
  { 2731, 29, 43, 34, 2, -42 },
  { 2887, 29, 42, 34, 6, -42 },
  { 3040, 31, 43, 34, 2, -42 },
  { 3207, 29, 42, 34, 5, -42 },
  { 3360, 14, 33, 34, 10, -32 },
  { 3418, 19, 41, 34, 5, -32 },
  { 3516, 29, 31, 34, 4, -34 },
  { 3629, 28, 20, 34, 4, -29 },
  { 3699, 29, 31, 34, 2, -34 },
  { 3812, 25, 42, 34, 7, -42 },
  { 3944, 35, 52, 34, 0, -42 },
  { 4172, 29, 42, 34, 0, -42 },
  { 4325, 31, 42, 34, 2, -42 },
  { 4488, 30, 43, 34, 3, -42 },
  { 4650, 31, 42, 34, 2, -42 },
  { 4813, 31, 42, 34, 3, -42 },
  { 4976, 32, 42, 34, 2, -42 },
  { 5144, 30, 43, 34, 3, -42 },
  { 5306, 32, 42, 34, 2, -42 },
  { 5474, 30, 42, 34, 3, -42 },
  { 5632, 33, 43, 34, 0, -42 },
  { 5810, 34, 42, 34, 2, -42 },
  { 5989, 25, 42, 34, 4, -42 },
  { 6121, 34, 42, 34, 1, -42 },
  { 6300, 32, 42, 34, 2, -42 },
  { 6468, 30, 43, 34, 3, -42 },
  { 6630, 33, 42, 34, 2, -42 },
  { 6804, 30, 52, 34, 3, -42 },
  { 6999, 32, 42, 34, 2, -42 },
  { 7167, 31, 43, 34, 2, -42 },
  { 7334, 30, 42, 34, 6, -42 },
  { 7492, 31, 43, 34, 3, -42 },
  { 7659, 30, 42, 34, 6, -42 },
  { 7817, 34, 42, 34, 3, -42 },
  { 7996, 37, 42, 34, -1, -42 },
  { 8191, 31, 42, 34, 6, -42 },
  { 8354, 31, 42, 34, 2, -42 },
  { 8517, 24, 53, 34, 7, -47 },
  { 8676, 18, 53, 34, 9, -47 },
  { 8796, 24, 53, 34, 4, -47 },
  { 8955, 26, 23, 34, 5, -42 },
  { 9030, 28, 6, 34, 0, 1 },
  { 9051, 12, 8, 34, 14, -45 },
  { 9063, 29, 33, 34, 3, -32 },
  { 9183, 29, 43, 34, 2, -42 },
  { 9339, 29, 33, 34, 3, -32 },
  { 9459, 31, 43, 34, 3, -42 },
  { 9626, 28, 33, 34, 3, -32 },
  { 9742, 39, 52, 34, -3, -42 },
  { 9996, 29, 42, 34, 3, -32 },
  { 10149, 29, 42, 34, 2, -42 },
  { 10302, 28, 45, 34, 2, -45 },
  { 10460, 30, 55, 34, 1, -45 },
  { 10667, 32, 42, 34, 2, -42 },
  { 10835, 25, 42, 34, 5, -42 },
  { 10967, 32, 32, 34, 1, -32 },
  { 11095, 29, 32, 34, 2, -32 },
  { 11211, 28, 33, 34, 3, -32 },
  { 11327, 31, 42, 34, 0, -32 },
  { 11490, 29, 42, 34, 3, -32 },
  { 11643, 30, 32, 34, 3, -32 },
  { 11763, 29, 33, 34, 2, -32 },
  { 11883, 28, 40, 34, 4, -40 },
  { 12023, 29, 32, 34, 3, -31 },
  { 12139, 29, 31, 34, 5, -31 },
  { 12252, 31, 31, 34, 4, -31 },
  { 12373, 34, 31, 34, 0, -31 },
  { 12505, 29, 41, 34, 3, -31 },
  { 12654, 29, 31, 34, 2, -31 },
  { 12767, 30, 53, 34, 5, -47 },
  { 12966, 15, 53, 34, 10, -47 },
  { 13066, 30, 53, 34, 1, -47 },
  { 13265, 30, 13, 34, 3, -27 },
};

const GFXfont JetBrainsMono_SemiBoldItalic57pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic57pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic57pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC57PT7B_H_
