#ifndef _ROBOTOCONDENSED_BLACKITALIC52PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF0, 0x01, 0x00,
  0x00, 0x3F, 0x1F, 0x9F, 0x8F, 0x8F, 0xC7, 0xC7, 0xE7, 0xE3, 0xE3, 0xF3,
  0xF1, 0xF9, 0xF8, 0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x3F, 0x1F, 0x1F,
  0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0xCF, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x3E, 0x7C,
  0x00, 0x0F, 0x9F, 0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x03, 0xE7, 0xC0, 0x00,
  0xF1, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80,
  0x03, 0xE3, 0xC0, 0x00, 0xF9, 0xF0, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x3E,
  0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xC7, 0xC0, 0x01, 0xF1, 0xE0, 0x00,
  0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE7, 0xC0,
  0x00, 0xF9, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0x8F,
  0xF0, 0x7F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0,
  0xFF, 0x87, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF1, 0xFF, 0x07, 0xF8,
  0xFF, 0x03, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0xFF,
  0x07, 0xF8, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xF3, 0xE0,
  0x61, 0xF1, 0xF8, 0x7C, 0xF8, 0xFC, 0x7E, 0x7C, 0x7E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x1F, 0x1F, 0x3F, 0x0F, 0x8F, 0x9F, 0x07, 0xCF, 0xDF, 0x03, 0xFF,
  0xDF, 0x80, 0xFF, 0xEF, 0x80, 0x7F, 0xEF, 0x80, 0x1F, 0xEF, 0xC0, 0x01,
  0x87, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE7, 0xF0, 0x01, 0xF7, 0xFC, 0x01, 0xF7, 0xFF,
  0x01, 0xF7, 0xFF, 0xC1, 0xFB, 0xF3, 0xE0, 0xFB, 0xF1, 0xF0, 0xF9, 0xF8,
  0xF8, 0xFC, 0xF8, 0x7C, 0x7C, 0x7C, 0x3E, 0x7C, 0x3E, 0x1F, 0x7E, 0x1F,
  0x1F, 0x9E, 0x0F, 0xCF, 0x82, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xE7, 0xF0, 0x03,
  0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F,
  0x00, 0x3F, 0x9F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x83, 0xF0, 0x7F, 0xF8, 0xFE, 0x1F, 0xFF, 0x1F, 0xC7, 0xFF,
  0xF3, 0xF9, 0xFF, 0xFE, 0x7F, 0x3F, 0xDF, 0xFF, 0xCF, 0xF3, 0xFF, 0xF9,
  0xFE, 0x3F, 0xFF, 0x3F, 0xC7, 0xFF, 0xC7, 0xF8, 0x7F, 0xF8, 0xFF, 0x0F,
  0xFE, 0x1F, 0xE0, 0xFF, 0xC3, 0xFC, 0x3F, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xF7,
  0xFC, 0x0F, 0xFC, 0x7F, 0x80, 0x18, 0x00, 0x00, 0x1F, 0x8F, 0xCF, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xC3, 0xE1,
  0xF0, 0x00, 0x02, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0x80, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x70, 0x00, 0x40, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x06, 0x03, 0xC0,
  0xDF, 0x1F, 0x1F, 0xFF, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x80, 0x1F, 0x9F, 0x00, 0xFE, 0x7C, 0x07, 0xF0, 0xF8, 0x3F, 0x83, 0xE0,
  0x3C, 0x0F, 0x80, 0x60, 0x1C, 0x00, 0x80, 0x40, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC,
  0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xE0, 0x7C, 0x01, 0x80,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0x80, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFE, 0x08, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x07, 0xF8, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC,
  0x7F, 0x07, 0xF9, 0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xDF,
  0xF0, 0x7F, 0xBF, 0xC0, 0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x07, 0xFD, 0xFE,
  0x0F, 0xF3, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xDF, 0xE0, 0x7F, 0xBF, 0xC0,
  0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xF3, 0xFC, 0x1F,
  0xE7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC,
  0x3F, 0x8F, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF,
  0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0x7F, 0x8C,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xF1, 0xFF, 0x0F, 0xF0, 0x7F, 0x87,
  0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE3, 0xFE, 0x1F, 0xF1, 0xFE, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x1F, 0xF9, 0xFF, 0x0F, 0xF8, 0x7F, 0x87, 0xF8,
  0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xCF, 0xF8, 0x1F,
  0xE7, 0xFC, 0x1F, 0xF1, 0xFE, 0x0F, 0xF0, 0xFF, 0x9F, 0xF8, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x01,
  0xFB, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xF7, 0xF8, 0x07, 0xE7, 0xF8, 0x0F,
  0xE7, 0xF8, 0x0F, 0xC7, 0xF8, 0x1F, 0xC7, 0xF8, 0x3F, 0x8F, 0xF8, 0x3F,
  0x8F, 0xF0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x7C, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xF0,
  0xFF, 0x80, 0x10, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F,
  0xE0, 0x7F, 0x8F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x3F, 0xE0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xCF, 0x80, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x3F, 0xE7, 0xF9, 0xFF, 0x1F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0x0F, 0xF1, 0xFE,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xC7, 0xF8,
  0x7F, 0xC3, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x83, 0xFC, 0xFF, 0x83, 0xFC,
  0xFF, 0x83, 0xFC, 0xFF, 0x87, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x87, 0xF8,
  0x7F, 0x8F, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0xF9, 0xFE, 0x3F, 0xC3,
  0xF9, 0xFE, 0x0F, 0xE7, 0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0x83, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x1F, 0xE7, 0xF8, 0x7F, 0x9F, 0xF3, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F,
  0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x7F,
  0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xC0, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x83, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x7E, 0x00, 0x80, 0x00, 0x00, 0xF8, 0x03,
  0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x7E,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE,
  0x01, 0xF8, 0x07, 0xF0, 0x07, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xF8, 0x1F,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x70, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0x7F, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xF1, 0xFE, 0xFF, 0x8F, 0xF7, 0xFC,
  0x7F, 0xBF, 0xC3, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x01, 0xE0,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x3F,
  0x01, 0xE0, 0x7E, 0x07, 0xFE, 0x0F, 0x83, 0xE0, 0x7F, 0xF8, 0x7C, 0x3F,
  0x07, 0xFF, 0xE3, 0xE1, 0xF0, 0x7F, 0xFF, 0x1F, 0x1F, 0x87, 0xF1, 0xF0,
  0xF8, 0xF8, 0x3F, 0x0F, 0x87, 0xCF, 0xC3, 0xF0, 0xFC, 0x3E, 0x7E, 0x1F,
  0x87, 0xE1, 0xF3, 0xE1, 0xF8, 0x3E, 0x0F, 0x9F, 0x0F, 0xC1, 0xF0, 0x7D,
  0xF8, 0x7E, 0x1F, 0x83, 0xEF, 0x87, 0xE0, 0xFC, 0x1E, 0x7C, 0x3F, 0x07,
  0xC1, 0xF3, 0xE1, 0xF8, 0x3E, 0x0F, 0x9F, 0x0F, 0xC3, 0xF0, 0x7C, 0xF8,
  0x7E, 0x1F, 0x83, 0xC7, 0xC3, 0xF0, 0xF8, 0x3E, 0x7E, 0x1F, 0x8F, 0xC1,
  0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x1F, 0x87, 0xE7, 0xF1, 0xF0, 0x7C, 0x3F,
  0xFF, 0xFF, 0x83, 0xE0, 0xFF, 0xBF, 0xF8, 0x1F, 0x07, 0xF9, 0xFF, 0x80,
  0xF8, 0x1F, 0x87, 0xF8, 0x07, 0xC0, 0x10, 0x06, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x07, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFE,
  0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x83, 0xFC, 0x01, 0xFF,
  0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8,
  0xFF, 0x80, 0x0F, 0xF3, 0xFE, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F,
  0xF8, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x03,
  0xFE, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x83, 0xFE, 0x03, 0xFC,
  0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0xC7, 0xFC,
  0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xE7,
  0xFE, 0x1F, 0xF0, 0x3F, 0xE3, 0xFC, 0x03, 0xFC, 0xFF, 0x80, 0x7F, 0x9F,
  0xE0, 0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xDF, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x1F, 0xF3, 0xFC, 0x03, 0xFE, 0x7F, 0x80, 0x7F, 0xCF, 0xF0, 0x0F, 0xF1,
  0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xC3, 0xFF, 0x7F, 0xF0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0x83, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x1F,
  0xE0, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F,
  0xF0, 0x1F, 0xE1, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xE1, 0xFF, 0x03,
  0xFE, 0x1F, 0xE0, 0x3F, 0xE1, 0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x3F, 0xE3,
  0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xC3, 0xFE, 0x03, 0xFC, 0x3F, 0xC0,
  0x7F, 0xC3, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xFC, 0x0F, 0xF8,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xC7, 0xFE, 0x1F, 0xF8, 0x1F, 0xE1, 0xFF, 0x01, 0xFE, 0x1F, 0xE0,
  0x1F, 0xE3, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xF3, 0xFC, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x83, 0xFF, 0xC7, 0xF8, 0x3F, 0xFC, 0xFF, 0x87, 0xFF,
  0xCF, 0xF8, 0x7F, 0xFC, 0xFF, 0x87, 0xFF, 0xCF, 0xF8, 0x7F, 0xFC, 0xFF,
  0x80, 0x7F, 0xCF, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x0F,
  0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0x7F, 0x81, 0xFF, 0x87,
  0xFE, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFF,
  0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFE,
  0x07, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFE,
  0x07, 0xF8, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFC,
  0x0F, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xFC,
  0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0x0F, 0xF0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF0,
  0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0,
  0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xC0,
  0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F,
  0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xE3, 0xFE, 0x07, 0xFD, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFE,
  0x07, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0x03, 0xFF, 0x80, 0x7F,
  0x81, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x80, 0x1F,
  0xF0, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF, 0xC0, 0x07, 0xF8, 0xFF, 0xC0, 0x03,
  0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x1F,
  0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x81,
  0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F,
  0xEF, 0xC1, 0xFF, 0xF8, 0x0F, 0xEF, 0xC3, 0xFF, 0xF8, 0x1F, 0xEF, 0xC3,
  0xF7, 0xF8, 0x1F, 0xEF, 0xC7, 0xF7, 0xF8, 0x1F, 0xEF, 0xC7, 0xEF, 0xF0,
  0x1F, 0xEF, 0xC7, 0xEF, 0xF0, 0x1F, 0xEF, 0xCF, 0xEF, 0xF0, 0x3F, 0xEF,
  0xCF, 0xCF, 0xF0, 0x3F, 0xC7, 0xCF, 0xDF, 0xF0, 0x3F, 0xC7, 0xDF, 0x9F,
  0xF0, 0x3F, 0xC7, 0xDF, 0x9F, 0xE0, 0x3F, 0xC7, 0xFF, 0x1F, 0xE0, 0x3F,
  0xC7, 0xFF, 0x1F, 0xE0, 0x7F, 0xC7, 0xFF, 0x3F, 0xE0, 0x7F, 0xC7, 0xFE,
  0x3F, 0xE0, 0x7F, 0xC7, 0xFE, 0x3F, 0xC0, 0x7F, 0x87, 0xFC, 0x3F, 0xC0,
  0x7F, 0x87, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x7F, 0xC0, 0xFF, 0x87,
  0xF8, 0x7F, 0xC0, 0xFF, 0x83, 0xF8, 0x7F, 0xC0, 0xFF, 0x83, 0xF0, 0x7F,
  0x80, 0xFF, 0x03, 0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE,
  0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xFE,
  0x01, 0xFE, 0x07, 0xFF, 0x01, 0xFE, 0x07, 0xFF, 0x03, 0xFE, 0x07, 0xFF,
  0x03, 0xFE, 0x07, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0x83, 0xFC, 0x0F, 0xFF,
  0x83, 0xFC, 0x0F, 0xFF, 0x83, 0xFC, 0x0F, 0xFF, 0x87, 0xFC, 0x0F, 0xFF,
  0x87, 0xFC, 0x0F, 0xFF, 0xC7, 0xFC, 0x1F, 0xF7, 0xC7, 0xF8, 0x1F, 0xF7,
  0xC7, 0xF8, 0x1F, 0xF7, 0xC7, 0xF8, 0x1F, 0xE7, 0xCF, 0xF8, 0x1F, 0xE3,
  0xEF, 0xF8, 0x1F, 0xE3, 0xEF, 0xF8, 0x3F, 0xE3, 0xEF, 0xF0, 0x3F, 0xE3,
  0xEF, 0xF0, 0x3F, 0xE3, 0xFF, 0xF0, 0x3F, 0xC1, 0xFF, 0xF0, 0x3F, 0xC1,
  0xFF, 0xF0, 0x3F, 0xC1, 0xFF, 0xE0, 0x7F, 0xC1, 0xFF, 0xE0, 0x7F, 0xC0,
  0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0xE0, 0x7F, 0x80,
  0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80,
  0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xEF, 0xFE, 0x1F, 0xF8, 0x3F, 0xE1, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x1F,
  0xE3, 0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0x1F, 0xF3, 0xFC, 0x01, 0xFF, 0x7F,
  0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xF8, 0x01,
  0xFE, 0x7F, 0x80, 0x1F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF,
  0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFC, 0xFF, 0x00,
  0x3F, 0xCF, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x07, 0xF8,
  0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0x7F, 0x81, 0xFF, 0x07, 0xFE,
  0x7F, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF,
  0x80, 0xFF, 0x87, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03,
  0xFE, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xEF, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE1, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE3, 0xFE, 0x01, 0xFF,
  0x3F, 0xC0, 0x1F, 0xF3, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC,
  0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F,
  0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF,
  0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03,
  0xFC, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F,
  0xF8, 0x0F, 0xF8, 0x7F, 0x81, 0xFF, 0x07, 0xFE, 0x7F, 0xF0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0x81, 0xFF,
  0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF,
  0x80, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F,
  0xF0, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xC7, 0xFC, 0x03,
  0xFC, 0x7F, 0xC0, 0x3F, 0xC3, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3,
  0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xF8, 0x1F, 0xF0,
  0x7F, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF8, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xF3, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x03,
  0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x1F,
  0xE0, 0x7F, 0xC3, 0xFF, 0x3F, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE,
  0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80,
  0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F,
  0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0,
  0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F,
  0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFC, 0x0F, 0xF0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07,
  0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0x81, 0xFE, 0x01, 0xFE,
  0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x01,
  0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x0F, 0xFD, 0xFF, 0x00, 0x7F,
  0xCF, 0xF8, 0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x0F,
  0xF0, 0x1F, 0xF8, 0x7F, 0x80, 0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x1F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF,
  0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xC7, 0xFC, 0x01,
  0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x9F, 0xF0, 0x03, 0xFC,
  0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0x03,
  0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xC1, 0xFE, 0xFF, 0x07, 0xFC, 0x3F, 0xEF,
  0xF0, 0x7F, 0xC3, 0xFC, 0xFF, 0x0F, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0xC7,
  0xFC, 0xFF, 0x0F, 0xFC, 0x7F, 0x8F, 0xF1, 0xFF, 0xC7, 0xF8, 0xFF, 0x1F,
  0xFC, 0xFF, 0x8F, 0xF1, 0xFF, 0xCF, 0xF0, 0xFF, 0x3F, 0xFC, 0xFF, 0x0F,
  0xF3, 0xFF, 0xCF, 0xF0, 0xFF, 0x3F, 0xFD, 0xFE, 0x0F, 0xF7, 0xFF, 0xDF,
  0xE0, 0xFF, 0x7F, 0xFD, 0xFE, 0x0F, 0xF7, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFD, 0xFF, 0xF8, 0x0F, 0xFF, 0xDF, 0xFF,
  0x80, 0xFF, 0xFD, 0xFF, 0xF0, 0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0xFF, 0xF9,
  0xFF, 0xF0, 0x0F, 0xFF, 0x9F, 0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x0F,
  0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xFC,
  0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xC1,
  0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF,
  0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xF8, 0x3F,
  0xE0, 0x03, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0x9F,
  0xF0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x0F, 0xF7,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0xFF, 0xBF, 0xC0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x7F, 0xC7, 0xF8, 0x00,
  0x7F, 0xE3, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x80,
  0x3F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xEF, 0xF8, 0x07, 0xFE, 0x7F, 0x80, 0x7F, 0xC7, 0xF8, 0x0F, 0xFC, 0x7F,
  0x80, 0xFF, 0x87, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x03, 0xFC, 0x1F,
  0xE0, 0x3F, 0xC3, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xFC, 0x01,
  0xFC, 0x7F, 0x80, 0x1F, 0xCF, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x07, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x07, 0xEF, 0x80, 0xFD, 0xF0, 0x3F, 0x3F, 0x07, 0xE7, 0xE1, 0xF8,
  0xFC, 0x3F, 0x0F, 0x8F, 0xC1, 0xF1, 0xF8, 0x3E, 0x7E, 0x07, 0xEF, 0xC0,
  0xFC, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0x87, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0,
  0xFE, 0x07, 0xF0, 0x3F, 0x00, 0x04, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF,
  0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7,
  0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F,
  0xFF, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE,
  0x7F, 0xC7, 0xFB, 0xFE, 0x3F, 0xEF, 0xF8, 0xFF, 0xBF, 0xC3, 0xFC, 0xFF,
  0x0F, 0xF3, 0xFC, 0x7F, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC3, 0xFE, 0xFF, 0x07, 0xF3, 0xFC, 0x02, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x80,
  0x0F, 0xF7, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xF1, 0xFF, 0x1F, 0xE0, 0xFF,
  0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFF,
  0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE,
  0x7F, 0xC1, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFC, 0x7F, 0x83, 0xFC,
  0x7F, 0xC7, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFE, 0x7F, 0xE0, 0xFE, 0x3F, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xF8, 0xFF, 0x7F, 0x83, 0xFB,
  0xFC, 0x1F, 0xDF, 0xE0, 0xFE, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC3, 0xFD, 0xFC, 0x1F, 0xEF, 0xF0, 0xFE, 0x7F, 0x8F, 0xF3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x83, 0xFC, 0x03, 0xFC, 0xFF, 0x01,
  0xFF, 0x7F, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF,
  0x07, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x3F,
  0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFE, 0xFE, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xCF, 0xF8,
  0xFF, 0x3F, 0xC1, 0xFD, 0xFE, 0x07, 0xF7, 0xF8, 0x3F, 0xDF, 0xE0, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x83, 0xFF, 0x0F, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x07, 0xFE, 0x7F, 0x01, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xC7,
  0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F,
  0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF8, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F,
  0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF,
  0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0xC7, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x04, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xC0, 0x7F, 0xC0, 0x1E, 0x3F,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFB,
  0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0,
  0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0,
  0xFF, 0x1F, 0xE1, 0xFF, 0x3F, 0xE1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1,
  0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFE, 0x7F, 0xC3,
  0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83,
  0xFC, 0x7F, 0x87, 0xFC, 0xFF, 0x87, 0xF8, 0x01, 0xF8, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x0F,
  0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x0F,
  0xFE, 0x1F, 0xE1, 0xFF, 0x83, 0xFC, 0x7F, 0xE0, 0x7F, 0x9F, 0xF8, 0x1F,
  0xF3, 0xFE, 0x03, 0xFC, 0xFF, 0x80, 0x7F, 0xBF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xF7,
  0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFF, 0x03,
  0xFC, 0x3F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F,
  0xF8, 0x3F, 0xC1, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFC,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x01,
  0xFE, 0xFF, 0x0F, 0xF0, 0x3F, 0xFF, 0xF3, 0xFF, 0x07, 0xFF, 0xFE, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xE3, 0xFC,
  0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x0F, 0xF3,
  0xFC, 0x3F, 0xE1, 0xFE, 0x7F, 0x87, 0xF8, 0x3F, 0xCF, 0xF0, 0xFF, 0x0F,
  0xF9, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xCF, 0xF8, 0x7F,
  0x87, 0xF9, 0xFE, 0x1F, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC, 0x1F, 0xE7, 0xF8,
  0x7F, 0x87, 0xFC, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xE7,
  0xFC, 0x3F, 0xC3, 0xFC, 0xFF, 0x0F, 0xF8, 0x7F, 0x9F, 0xE1, 0xFE, 0x0F,
  0xF3, 0xFC, 0x3F, 0xC3, 0xFE, 0x7F, 0x87, 0xF8, 0x7F, 0x80, 0x00, 0x00,
  0x20, 0x07, 0xFB, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xF9, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0,
  0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE1, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xE1,
  0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC3,
  0xFE, 0x7F, 0xC3, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83,
  0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x87, 0xFC, 0xFF, 0x87, 0xF8, 0x00, 0x08,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xF1, 0xFE, 0x7F, 0xC3, 0xFC,
  0xFF, 0x03, 0xF9, 0xFE, 0x07, 0xF3, 0xFC, 0x1F, 0xEF, 0xF8, 0x3F, 0xDF,
  0xE0, 0x7F, 0xBF, 0xC0, 0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x03, 0xFD, 0xFE,
  0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xF1,
  0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xF1, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x0F, 0xF0, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xFC, 0x1F, 0xE1, 0xFE, 0x07, 0xF8,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFD,
  0xFF, 0x80, 0xFF, 0x3F, 0x80, 0x3F, 0xC3, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x03, 0xFC, 0x7F, 0x07,
  0xFE, 0xFF, 0x0F, 0xFE, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0x83, 0xFE, 0x7F, 0x83, 0xFC, 0x7F,
  0x83, 0xFC, 0xFF, 0x83, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF,
  0x07, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF,
  0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x03, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE1, 0xFF, 0x7F, 0xC7, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xF3, 0xF8, 0x3F, 0xCF, 0xF9, 0xFF,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x00, 0xC0, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC7, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xFE, 0x1F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x08, 0x00, 0x1F,
  0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE1, 0xFF, 0x3F,
  0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F,
  0xC3, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F,
  0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x87, 0xFC, 0xFF, 0x87, 0xF8, 0xFF,
  0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xEF, 0xE0, 0x02, 0x00, 0x00, 0xFF,
  0x83, 0xFE, 0xFF, 0x07, 0xF9, 0xFE, 0x1F, 0xF3, 0xFC, 0x3F, 0xC7, 0xF8,
  0x7F, 0x8F, 0xF1, 0xFF, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x9F,
  0xE0, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x01, 0xFD, 0xFE, 0x03, 0xFB, 0xFC,
  0x07, 0xF7, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x0F, 0xC3, 0xFF, 0xF8, 0x7F, 0x0F,
  0xEF, 0xE1, 0xFC, 0x7F, 0xBF, 0x87, 0xF1, 0xFE, 0xFE, 0x3F, 0xC7, 0xF3,
  0xF8, 0xFF, 0x3F, 0xCF, 0xE7, 0xFC, 0xFF, 0x3F, 0x9F, 0xF3, 0xF8, 0xFE,
  0x7F, 0xCF, 0xE3, 0xFB, 0xFF, 0x7F, 0x8F, 0xEF, 0xFD, 0xFC, 0x3F, 0xBF,
  0xF7, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xDF, 0xFE, 0x0F, 0xFF, 0x7F,
  0xF8, 0x3F, 0xFD, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0x9F, 0xFC,
  0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x03,
  0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xC1, 0xFE, 0x00, 0xFF,
  0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0xFF, 0x0F, 0xF8, 0x0F, 0xE1, 0xFE, 0x01, 0xFE, 0x7F,
  0xC0, 0x3F, 0xCF, 0xF0, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xEF,
  0xF0, 0x07, 0xF9, 0xFE, 0x01, 0xFF, 0x1F, 0xC0, 0x7F, 0xC3, 0xFC, 0x0F,
  0xF8, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC3, 0xFC,
  0x1F, 0xF0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC3, 0xFE, 0x0F, 0xF0, 0xFF, 0x03,
  0xFC, 0x7F, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0xCF, 0xF8, 0x0F, 0xF3, 0xFC,
  0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x7F, 0xC0, 0x1F, 0xDF, 0xE0, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78,
  0x00, 0x00, 0xC0, 0x00, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xE0, 0x3F, 0x3F,
  0xF0, 0x3E, 0x3F, 0xF8, 0x7E, 0x7F, 0xFC, 0x7E, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFC, 0x3F, 0xFC, 0xFC, 0x3F, 0xFC, 0xFC, 0x1F, 0xF8, 0xF8,
  0x0F, 0xF0, 0x00, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_BlackItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 15, 38, 13, 0, -37 },
  { 73, 17, 14, 16, 2, -39 },
  { 103, 26, 37, 26, 0, -37 },
  { 224, 25, 49, 26, 1, -43 },
  { 378, 25, 39, 32, 4, -38 },
  { 500, 27, 39, 30, 0, -38 },
  { 632, 9, 15, 8, 2, -39 },
  { 649, 16, 52, 16, 2, -41 },
  { 753, 16, 52, 16, -2, -41 },
  { 857, 22, 23, 23, 3, -37 },
  { 921, 22, 27, 23, 1, -31 },
  { 996, 12, 16, 14, -3, -6 },
  { 1020, 14, 7, 21, 4, -20 },
  { 1033, 9, 9, 15, 1, -8 },
  { 1044, 23, 40, 16, -4, -37 },
  { 1159, 23, 39, 26, 2, -38 },
  { 1272, 17, 37, 26, 5, -37 },
  { 1351, 25, 38, 26, 0, -38 },
  { 1470, 25, 39, 26, 0, -38 },
  { 1592, 24, 37, 26, 1, -37 },
  { 1703, 25, 38, 26, 1, -37 },
  { 1822, 22, 38, 26, 2, -37 },
  { 1927, 25, 37, 26, 2, -37 },
  { 2043, 24, 39, 26, 1, -38 },
  { 2160, 22, 38, 26, 3, -38 },
  { 2265, 13, 29, 15, 1, -28 },
  { 2313, 15, 38, 14, -2, -28 },
  { 2385, 21, 25, 23, 1, -28 },
  { 2451, 22, 18, 26, 2, -25 },
  { 2501, 21, 25, 23, 1, -28 },
  { 2567, 21, 39, 23, 3, -38 },
  { 2670, 37, 48, 39, 0, -36 },
  { 2892, 31, 37, 31, -3, -37 },
  { 3036, 28, 37, 29, 0, -37 },
  { 3166, 27, 39, 29, 2, -38 },
  { 3298, 28, 37, 28, 0, -37 },
  { 3428, 28, 37, 25, 0, -37 },
  { 3558, 27, 37, 24, 0, -37 },
  { 3683, 28, 39, 30, 2, -38 },
  { 3820, 32, 37, 31, 0, -37 },
  { 3968, 15, 37, 14, 0, -37 },
  { 4038, 26, 38, 25, 0, -37 },
  { 4162, 33, 37, 28, 0, -37 },
  { 4315, 22, 37, 24, 0, -37 },
  { 4417, 40, 37, 38, 0, -37 },
  { 4602, 32, 37, 31, 0, -37 },
  { 4750, 28, 39, 30, 2, -38 },
  { 4887, 29, 37, 29, 0, -37 },
  { 5022, 28, 45, 30, 2, -38 },
  { 5180, 28, 37, 29, 0, -37 },
  { 5310, 27, 39, 28, 1, -38 },
  { 5442, 27, 37, 28, 4, -37 },
  { 5567, 30, 38, 29, 1, -37 },
  { 5710, 29, 37, 30, 4, -37 },
  { 5845, 36, 37, 38, 4, -37 },
  { 6012, 33, 37, 28, -2, -37 },
  { 6165, 28, 37, 28, 4, -37 },
  { 6295, 30, 37, 27, -1, -37 },
  { 6434, 18, 52, 14, -1, -43 },
  { 6551, 14, 40, 19, 4, -37 },
  { 6621, 18, 52, 14, -3, -43 },
  { 6738, 19, 18, 20, 1, -37 },
  { 6781, 20, 6, 20, -3, 0 },
  { 6796, 12, 8, 17, 5, -39 },
  { 6808, 22, 29, 24, 0, -28 },
  { 6888, 24, 40, 25, 0, -39 },
  { 7008, 21, 29, 23, 1, -28 },
  { 7085, 26, 40, 25, 1, -39 },
  { 7215, 22, 29, 24, 1, -28 },
  { 7295, 19, 40, 17, 1, -40 },
  { 7390, 27, 39, 26, -1, -28 },
  { 7522, 24, 39, 25, -1, -39 },
  { 7639, 14, 38, 13, 0, -38 },
  { 7706, 20, 49, 13, -6, -38 },
  { 7829, 27, 39, 25, 0, -39 },
  { 7961, 15, 39, 13, 0, -39 },
  { 8035, 35, 28, 37, 0, -28 },
  { 8158, 24, 28, 25, -1, -28 },
  { 8242, 23, 29, 25, 1, -28 },
  { 8326, 26, 39, 25, -2, -28 },
  { 8453, 24, 39, 25, 1, -28 },
  { 8570, 19, 28, 17, 0, -28 },
  { 8637, 22, 29, 23, 0, -28 },
  { 8717, 15, 35, 16, 2, -34 },
  { 8783, 24, 28, 25, 1, -27 },
  { 8867, 23, 27, 23, 2, -27 },
  { 8945, 30, 27, 31, 3, -27 },
  { 9047, 27, 27, 23, -2, -27 },
  { 9139, 26, 38, 23, -1, -27 },
  { 9263, 24, 27, 23, -1, -27 },
  { 9344, 16, 50, 15, 1, -41 },
  { 9444, 11, 44, 13, 1, -37 },
  { 9505, 16, 50, 15, -2, -41 },
  { 9605, 24, 12, 27, 2, -21 },
};

const GFXfont RobotoCondensed_BlackItalic52pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic52pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic52pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOCONDENSED_BLACKITALIC52PT7B_H_
