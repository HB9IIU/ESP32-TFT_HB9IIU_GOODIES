#ifndef _ROBOTOCONDENSED_BLACKITALIC10PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0x21, 0xB0, 0x76, 0xA0, 0x29, 0x9E, 0xAF, 0x32, 0x80, 0x11,
  0x9E, 0xC3, 0x0B, 0x4E, 0x20, 0xC5, 0xB8, 0x47, 0x54, 0xC0, 0x33, 0xDC,
  0xDF, 0xE9, 0xE0, 0x54, 0x22, 0x44, 0x4C, 0xC4, 0x44, 0x48, 0x96, 0xD2,
  0x90, 0x23, 0xC8, 0xA0, 0x22, 0xF6, 0x60, 0x69, 0x00, 0xC0, 0x70, 0x10,
  0x84, 0x42, 0x21, 0x18, 0x33, 0xD6, 0xBD, 0x69, 0x80, 0x3D, 0xB4, 0x90,
  0x72, 0xC6, 0x66, 0x63, 0xC0, 0x72, 0xC6, 0x61, 0x69, 0xC0, 0x19, 0xCC,
  0xA7, 0x78, 0xC0, 0x7A, 0x1C, 0x21, 0x69, 0x80, 0x33, 0x1D, 0xBD, 0xE9,
  0xC0, 0x78, 0xC4, 0x62, 0x31, 0x00, 0x33, 0xD6, 0xED, 0x69, 0xC0, 0x6F,
  0xBB, 0xE6, 0xC0, 0x4C, 0x05, 0x80, 0x4C, 0x01, 0xB4, 0x1E, 0xE3, 0x78,
  0x3C, 0x47, 0x78, 0xEA, 0x26, 0xC8, 0x80, 0x1C, 0x45, 0x6F, 0x5A, 0xB5,
  0x6F, 0x60, 0x70, 0x11, 0xCE, 0xF5, 0xFF, 0x20, 0x7B, 0x52, 0xED, 0xEF,
  0xC0, 0x39, 0xA4, 0xF0, 0xCB, 0x67, 0x00, 0x73, 0xD2, 0x9D, 0xEF, 0xC0,
  0x7B, 0x10, 0xEC, 0x63, 0xC0, 0x7B, 0x10, 0xEC, 0x63, 0x00, 0x39, 0xB4,
  0x16, 0xCB, 0x67, 0x00, 0x6D, 0xB4, 0xDF, 0xCB, 0x2D, 0x80, 0x6D, 0x2D,
  0xB0, 0x18, 0xC6, 0x21, 0x79, 0x80, 0x6D, 0xE5, 0x1C, 0xF3, 0x6D, 0x80,
  0x66, 0x44, 0xCC, 0xF0, 0x67, 0x66, 0x6E, 0x6E, 0xEE, 0xD6, 0xD4, 0x6D,
  0xB6, 0xD7, 0xDB, 0x6D, 0x80, 0x39, 0xB4, 0xF3, 0xCB, 0x67, 0x00, 0x79,
  0xA4, 0xD6, 0xF3, 0x0C, 0x00, 0x39, 0xB4, 0xF3, 0xCB, 0x67, 0x06, 0x7B,
  0x52, 0xBF, 0x6B, 0x60, 0x3B, 0x58, 0x61, 0xED, 0xC0, 0xFB, 0x18, 0xC4,
  0x23, 0x00, 0x6D, 0xB4, 0x92, 0xDB, 0x67, 0x00, 0xDE, 0xF5, 0xEE, 0x73,
  0x00, 0xB7, 0x6A, 0xF7, 0xED, 0x9B, 0x36, 0x00, 0x6D, 0xE3, 0x8C, 0x73,
  0x4D, 0x80, 0xDE, 0xBC, 0xC4, 0x23, 0x00, 0x7C, 0x61, 0x0C, 0x63, 0x0F,
  0x80, 0x6D, 0xA5, 0xB6, 0xD8, 0xAF, 0xF5, 0x33, 0x32, 0x22, 0x66, 0x64,
  0x26, 0x5D, 0xF0, 0xD0, 0x75, 0x7F, 0xF0, 0x63, 0x10, 0xED, 0xEB, 0x56,
  0x7D, 0xCF, 0x60, 0x08, 0xC6, 0xFD, 0x6B, 0x5E, 0x76, 0xBD, 0xA7, 0x00,
  0x36, 0x6E, 0x44, 0xCC, 0x7E, 0xF5, 0xA7, 0x5B, 0x80, 0x64, 0x47, 0xDD,
  0xDF, 0x4C, 0x25, 0xB6, 0x23, 0x02, 0x26, 0x66, 0x4C, 0x63, 0x10, 0xBF,
  0x73, 0xDE, 0x6D, 0x25, 0xB6, 0x7E, 0xAF, 0x5E, 0xAF, 0x40, 0x72, 0xB5,
  0xAF, 0x00, 0x76, 0xB5, 0xA7, 0x00, 0x72, 0xF5, 0xAF, 0x42, 0x00, 0x7E,
  0xF5, 0xAF, 0x18, 0xC0, 0x76, 0xCC, 0xC0, 0x7D, 0x6B, 0xE0, 0x6F, 0xA5,
  0x90, 0x5A, 0xF5, 0xAF, 0x00, 0x5A, 0x9C, 0xC6, 0x00, 0xAF, 0xFD, 0xEB,
  0x00, 0x53, 0x98, 0xEF, 0x00, 0x5A, 0x9C, 0xC6, 0x23, 0x00, 0x73, 0x6C,
  0xF0, 0x2D, 0xA5, 0x16, 0xC8, 0x55, 0x6A, 0x49, 0x24, 0xD6, 0xD0, 0x6F,
  0x80,
};

const GFXglyph RobotoCondensed_BlackItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 7, 3, 0, -7 },
  { 4, 4, 3, 3, 0, -8 },
  { 6, 5, 7, 5, 0, -7 },
  { 11, 5, 9, 5, 0, -8 },
  { 17, 5, 7, 6, 1, -7 },
  { 22, 5, 7, 6, 0, -7 },
  { 27, 2, 3, 2, 0, -8 },
  { 28, 4, 10, 3, 0, -8 },
  { 33, 3, 10, 3, 0, -8 },
  { 37, 5, 4, 5, 0, -7 },
  { 40, 4, 5, 5, 0, -6 },
  { 43, 3, 3, 3, -1, -1 },
  { 45, 2, 1, 4, 1, -3 },
  { 46, 2, 2, 3, 0, -2 },
  { 47, 5, 8, 3, -1, -7 },
  { 52, 5, 7, 5, 0, -7 },
  { 57, 3, 7, 5, 1, -7 },
  { 60, 5, 7, 5, 0, -7 },
  { 65, 5, 7, 5, 0, -7 },
  { 70, 5, 7, 5, 0, -7 },
  { 75, 5, 7, 5, 0, -7 },
  { 80, 5, 7, 5, 0, -7 },
  { 85, 5, 7, 5, 0, -7 },
  { 90, 5, 7, 5, 0, -7 },
  { 95, 4, 7, 5, 1, -7 },
  { 99, 3, 6, 3, 0, -6 },
  { 102, 3, 8, 3, 0, -6 },
  { 105, 4, 4, 4, 0, -5 },
  { 107, 5, 3, 5, 0, -5 },
  { 109, 4, 4, 4, 0, -5 },
  { 111, 4, 7, 4, 1, -7 },
  { 115, 7, 9, 7, 0, -7 },
  { 123, 5, 7, 6, 0, -7 },
  { 128, 5, 7, 6, 0, -7 },
  { 133, 6, 7, 6, 0, -7 },
  { 139, 5, 7, 5, 0, -7 },
  { 144, 5, 7, 5, 0, -7 },
  { 149, 5, 7, 5, 0, -7 },
  { 154, 6, 7, 6, 0, -7 },
  { 160, 6, 7, 6, 0, -7 },
  { 166, 3, 7, 3, 0, -7 },
  { 169, 5, 7, 5, 0, -7 },
  { 174, 6, 7, 5, 0, -7 },
  { 180, 4, 7, 5, 0, -7 },
  { 184, 8, 7, 7, 0, -7 },
  { 191, 6, 7, 6, 0, -7 },
  { 197, 6, 7, 6, 0, -7 },
  { 203, 6, 7, 6, 0, -7 },
  { 209, 6, 8, 6, 0, -7 },
  { 215, 5, 7, 6, 0, -7 },
  { 220, 5, 7, 5, 0, -7 },
  { 225, 5, 7, 5, 1, -7 },
  { 230, 6, 7, 6, 0, -7 },
  { 236, 5, 7, 6, 1, -7 },
  { 241, 7, 7, 7, 1, -7 },
  { 248, 6, 7, 5, 0, -7 },
  { 254, 5, 7, 5, 1, -7 },
  { 259, 6, 7, 5, 0, -7 },
  { 265, 3, 10, 3, 0, -8 },
  { 269, 2, 8, 4, 1, -7 },
  { 271, 4, 10, 3, -1, -8 },
  { 276, 4, 4, 4, 0, -7 },
  { 278, 4, 1, 4, -1, 0 },
  { 279, 2, 2, 3, 1, -8 },
  { 280, 4, 5, 5, 0, -5 },
  { 283, 5, 8, 5, 0, -8 },
  { 288, 4, 5, 4, 0, -5 },
  { 291, 5, 8, 5, 0, -8 },
  { 296, 5, 5, 5, 0, -5 },
  { 300, 4, 8, 3, 0, -8 },
  { 304, 5, 7, 5, 0, -5 },
  { 309, 4, 8, 5, 0, -8 },
  { 313, 3, 8, 3, 0, -8 },
  { 316, 4, 10, 2, -1, -8 },
  { 321, 5, 8, 5, 0, -8 },
  { 326, 3, 8, 3, 0, -8 },
  { 329, 7, 5, 7, 0, -5 },
  { 334, 5, 5, 5, 0, -5 },
  { 338, 5, 5, 5, 0, -5 },
  { 342, 5, 7, 5, 0, -5 },
  { 347, 5, 7, 5, 0, -5 },
  { 352, 4, 5, 3, 0, -5 },
  { 355, 4, 5, 4, 0, -5 },
  { 358, 3, 7, 3, 0, -7 },
  { 361, 5, 5, 5, 0, -5 },
  { 365, 5, 5, 4, 0, -5 },
  { 369, 5, 5, 6, 1, -5 },
  { 373, 5, 5, 4, 0, -5 },
  { 377, 5, 7, 4, 0, -5 },
  { 382, 4, 5, 4, 0, -5 },
  { 385, 3, 10, 3, 0, -8 },
  { 389, 2, 8, 2, 0, -7 },
  { 391, 3, 10, 3, 0, -8 },
  { 395, 5, 2, 5, 0, -4 },
};

const GFXfont RobotoCondensed_BlackItalic10pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic10pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic10pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOCONDENSED_BLACKITALIC10PT7B_H_
