#ifndef _ROBOTOCONDENSED_BLACKITALIC33PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x00, 0x00, 0x07,
  0x81, 0xF0, 0xFC, 0x3F, 0x07, 0x80, 0x39, 0xE7, 0x3D, 0xE7, 0x3C, 0xE7,
  0x1C, 0xE7, 0x9C, 0xE3, 0x9C, 0xE3, 0x80, 0x00, 0xEF, 0x00, 0x77, 0x00,
  0x73, 0x80, 0x3B, 0xC0, 0x1D, 0xC0, 0x1C, 0xE0, 0x7F, 0xFE, 0x3F, 0xFE,
  0x3F, 0xFF, 0x03, 0x9C, 0x01, 0xDC, 0x01, 0xEE, 0x00, 0xE7, 0x00, 0x77,
  0x81, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x0E, 0xE0, 0x0E, 0x70, 0x07,
  0x78, 0x03, 0xB8, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x0F, 0x80, 0x7F, 0x81, 0xFF, 0x87, 0xFF, 0x0F, 0x9F, 0x3E,
  0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F,
  0x9F, 0x1F, 0xFE, 0x3F, 0xF8, 0x3F, 0xE0, 0x1F, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xF7, 0x8C, 0xE3,
  0x9C, 0xE7, 0xBC, 0xE7, 0xB8, 0xE7, 0x70, 0xFF, 0xF0, 0x7F, 0xE0, 0x3D,
  0xC0, 0x03, 0x80, 0x07, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x1D, 0xCE, 0x3D,
  0xCE, 0x39, 0xCE, 0x73, 0xCE, 0xF1, 0xCE, 0x21, 0xFE, 0x01, 0xFC, 0x00,
  0x78, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xFB, 0xE0,
  0x78, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0xF3, 0xFE, 0x79, 0xFF, 0x7D, 0xF7, 0xFE, 0xFB, 0xFE, 0xFC,
  0xFF, 0x7E, 0x7F, 0x3F, 0x1F, 0x8F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8,
  0x3E, 0x7E, 0x7B, 0xDD, 0xEF, 0x7B, 0x9C, 0xE0, 0x00, 0x40, 0x18, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x78, 0x07, 0x00, 0xE0, 0x08, 0x00, 0x04, 0x03, 0x80, 0xF0, 0x1C, 0x07,
  0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3C,
  0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x03, 0x80, 0x80, 0x00,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x63, 0x9F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xF8, 0x0F, 0x80, 0x7E, 0x03, 0x9C, 0x1E, 0x78, 0x70, 0xE0, 0x82,
  0x00, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x0F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x83, 0xE0, 0x0F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E,
  0x3C, 0x3C, 0x78, 0xF8, 0x30, 0x7F, 0xBF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF7, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE1, 0xF7, 0xC7, 0xC7, 0xCF, 0x8F, 0xBE,
  0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF1, 0xFB, 0xE3, 0xE7, 0xC7, 0xDF, 0x8F,
  0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0xF9, 0xF1, 0xF1, 0xF7, 0xE3, 0xFF, 0x87,
  0xFE, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x60, 0x7C, 0x3F, 0xBF, 0xE7,
  0xFC, 0xFF, 0x9D, 0xF4, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C,
  0x0F, 0x80, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x3F,
  0x3F, 0x1F, 0x3E, 0x3F, 0x3E, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7F, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC,
  0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x1F, 0x3F, 0x3F, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x03, 0xFE, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0xF8, 0x7E, 0xFC, 0x7C,
  0x7C, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x81, 0xFF, 0x03,
  0xFE, 0x0F, 0xF8, 0x3D, 0xF0, 0x7B, 0xE1, 0xE7, 0xC7, 0xCF, 0x9F, 0x3F,
  0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8,
  0xFF, 0xF1, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3D, 0xE0, 0xFF,
  0xE1, 0xFF, 0xE3, 0xFF, 0xC1, 0x8F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E,
  0xF8, 0xF9, 0xF1, 0xF3, 0xE7, 0xE7, 0xFF, 0x87, 0xFE, 0x07, 0xF8, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x07, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xE0, 0x7E,
  0x03, 0xF0, 0x0F, 0x80, 0x7F, 0xF1, 0xFF, 0xE7, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFF, 0xF1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE3, 0xF7, 0xCF, 0x9F,
  0xFE, 0x3F, 0xF0, 0xFF, 0x80, 0xF8, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F,
  0xFF, 0x3F, 0xFF, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF,
  0xF3, 0xF7, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x3F, 0x3E, 0x7C, 0x3F, 0xF8,
  0x3F, 0xC1, 0xFF, 0x87, 0xFF, 0x0F, 0x9F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8,
  0xF9, 0xF1, 0xF3, 0xE7, 0xE7, 0xFF, 0x87, 0xFF, 0x07, 0xFC, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x3F, 0xC1, 0xFF, 0x0F, 0xFE, 0x7E, 0xF9, 0xF1, 0xF7,
  0xC7, 0xFE, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0x8F, 0xFF, 0x3E, 0x7F, 0xF9,
  0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x1F, 0xF0,
  0x7F, 0x81, 0xF8, 0x07, 0x80, 0x00, 0x1E, 0x3F, 0x3F, 0x3E, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0xF8, 0xF8, 0xF8, 0x70,
  0x0F, 0x83, 0xE0, 0xFC, 0x3E, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC1,
  0xF0, 0x78, 0x3E, 0x0F, 0x01, 0x80, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0,
  0xFE, 0x0F, 0xF8, 0xFF, 0xC7, 0xFC, 0x1F, 0xC0, 0x7C, 0x01, 0xFC, 0x07,
  0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x08, 0x3F, 0xFC,
  0xFF, 0xF3, 0xFF, 0xDF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x7F, 0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0x10, 0x00, 0x70, 0x01, 0xF0, 0x07,
  0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0x01, 0xF8, 0x3F, 0xE3,
  0xFF, 0x1F, 0xF0, 0x7F, 0x01, 0xF0, 0x07, 0x00, 0x20, 0x00, 0x0F, 0xC1,
  0xFF, 0x0F, 0xFC, 0xFF, 0xFF, 0xCF, 0xFC, 0x7F, 0xE7, 0xE0, 0x3E, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xE0, 0x3C,
  0x07, 0xC0, 0x1C, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x0E, 0x1E, 0x0F, 0x0E,
  0x1C, 0x3F, 0xCE, 0x3C, 0x7F, 0xCE, 0x38, 0xFB, 0xCE, 0x38, 0xF3, 0xCE,
  0x79, 0xE3, 0x8E, 0x71, 0xE3, 0x8E, 0x71, 0xC7, 0x8E, 0x73, 0xC7, 0x8E,
  0xF3, 0xC7, 0x0E, 0xF3, 0xC7, 0x1C, 0xF3, 0xCF, 0x1C, 0xF3, 0xCF, 0x38,
  0xF3, 0xFF, 0xF8, 0xF1, 0xFF, 0xF0, 0x70, 0xE3, 0xC0, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3E, 0x0C, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x7E,
  0x7C, 0x0F, 0x8F, 0x83, 0xF1, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x9F, 0x81, 0xF3, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x80,
  0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x9F,
  0xC7, 0xC3, 0xF1, 0xF0, 0xFC, 0x7C, 0x3F, 0x3F, 0x1F, 0x8F, 0xFF, 0xE3,
  0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0x87, 0xC7, 0xE1, 0xF1, 0xF8,
  0x7C, 0x7C, 0x1F, 0x1F, 0x0F, 0xC7, 0xC7, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0,
  0x7F, 0xFE, 0x1F, 0x9F, 0x8F, 0xC3, 0xE3, 0xE0, 0xFD, 0xF8, 0x3F, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x7C, 0xF8, 0x3F, 0x3F, 0x0F, 0xC7, 0xEF, 0xE1,
  0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x03,
  0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xBF, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x3F, 0x0F, 0x8F, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E,
  0x3E, 0x1F, 0x8F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x7C, 0x7C, 0x3F, 0x1F,
  0x0F, 0xC7, 0xCF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3,
  0xFF, 0xE0, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xE1, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE,
  0x1F, 0x9F, 0x8F, 0xC3, 0xF3, 0xE0, 0x7D, 0xF8, 0x1F, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xC7, 0xF9, 0xF1, 0xFE, 0x7C, 0x7F, 0xBF, 0x3F, 0xEF, 0xC1,
  0xF3, 0xF0, 0x7C, 0xFC, 0x1F, 0x3F, 0x0F, 0xC7, 0xE7, 0xF1, 0xFF, 0xFC,
  0x3F, 0xFE, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x1F, 0x81, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF0, 0x3E, 0x1F, 0x03,
  0xE1, 0xF0, 0x3E, 0x3F, 0x07, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC3, 0xE0, 0x7C, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7C,
  0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F,
  0x81, 0xF8, 0xF8, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x87,
  0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE1,
  0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0xFC, 0xFC, 0x7C, 0x7C,
  0x3F, 0x7E, 0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x0F,
  0x83, 0xF0, 0x7C, 0x3F, 0x87, 0xE3, 0xF8, 0x3F, 0x1F, 0x81, 0xF9, 0xF8,
  0x0F, 0x9F, 0x80, 0x7C, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7E, 0x7C, 0x03, 0xE3, 0xF0, 0x1F, 0x1F,
  0x81, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xFC, 0x00,
  0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x3F, 0xC7,
  0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8,
  0x7F, 0x87, 0xFC, 0x3F, 0xC3, 0xFE, 0x3F, 0xE1, 0xFF, 0x1F, 0x71, 0xFF,
  0x0F, 0xB8, 0xFF, 0x87, 0xDC, 0xF7, 0xC3, 0xEE, 0x7B, 0xE1, 0xF7, 0xBD,
  0xF1, 0xFB, 0xFD, 0xF8, 0xF9, 0xFE, 0xF8, 0x7C, 0xFE, 0x7C, 0x3E, 0x7F,
  0x3E, 0x1F, 0x3F, 0x3F, 0x1F, 0x9F, 0x9F, 0x8F, 0xC7, 0x8F, 0xC7, 0xE3,
  0xC7, 0xC3, 0xE1, 0xE3, 0xE0, 0x0F, 0x81, 0xF0, 0xFC, 0x1F, 0x1F, 0xC1,
  0xF1, 0xFC, 0x3F, 0x1F, 0xC3, 0xF1, 0xFC, 0x3E, 0x1F, 0xE3, 0xE1, 0xFE,
  0x3E, 0x3F, 0xE7, 0xE3, 0xFE, 0x7E, 0x3E, 0xF7, 0xC3, 0xEF, 0x7C, 0x3E,
  0x77, 0xC3, 0xE7, 0x7C, 0x7E, 0x7F, 0xC7, 0xE7, 0xFC, 0x7C, 0x3F, 0x87,
  0xC3, 0xF8, 0x7C, 0x3F, 0x8F, 0xC3, 0xF8, 0xFC, 0x3F, 0x8F, 0xC1, 0xF8,
  0xF8, 0x1F, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE,
  0x1F, 0x9F, 0x8F, 0xC3, 0xF3, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF,
  0x03, 0xF7, 0xC0, 0xFD, 0xF0, 0x3E, 0xFC, 0x0F, 0xBF, 0x03, 0xEF, 0xC1,
  0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0x3F, 0x0F, 0xC7, 0xE7, 0xE1, 0xFF, 0xF8,
  0x3F, 0xFC, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x8F, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C,
  0x1F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xE3, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF,
  0x0F, 0xFF, 0x87, 0xFF, 0x81, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x9F, 0x8F, 0xC3,
  0xF3, 0xE0, 0xFD, 0xF8, 0x1F, 0x7E, 0x0F, 0xDF, 0x03, 0xF7, 0xC0, 0xFD,
  0xF0, 0x3E, 0xFC, 0x0F, 0xBF, 0x03, 0xEF, 0xC0, 0xFB, 0xF0, 0x7E, 0xFC,
  0x1F, 0x3F, 0x0F, 0xC7, 0xE7, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x01, 0x00,
  0x0F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x8F, 0xC7,
  0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xE3, 0xF3,
  0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xC1, 0xFB, 0xF0,
  0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x3E, 0x3F,
  0x0F, 0xCF, 0x83, 0xF0, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0xE3, 0xFB, 0xF1, 0xF8, 0xFC, 0xF8, 0x7E, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x01, 0xF9,
  0xF0, 0x7C, 0xF8, 0x7E, 0x7C, 0x3F, 0x3F, 0x3F, 0x0F, 0xFF, 0x87, 0xFF,
  0x81, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF,
  0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x07, 0xC7, 0xC1, 0xF3, 0xF0,
  0x7C, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E,
  0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xC1, 0xF9, 0xF0, 0x7C, 0x7C, 0x1F, 0x3F,
  0x07, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xF8, 0x3E, 0x3F, 0x0F, 0x8F, 0xEF,
  0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x0F,
  0xEF, 0x81, 0xF9, 0xF0, 0x3F, 0x3E, 0x0F, 0xC7, 0xC1, 0xF8, 0xF8, 0x3E,
  0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3E, 0x0F, 0xCF, 0xC0, 0xF9, 0xF0,
  0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0xF8, 0x7F, 0xE3, 0xE1, 0xFF, 0x8F,
  0x8F, 0xFE, 0x7E, 0x3E, 0xF9, 0xF8, 0xFB, 0xE7, 0xE7, 0xEF, 0xBF, 0x9F,
  0x3E, 0xFE, 0x7C, 0xFB, 0xFB, 0xF3, 0xFF, 0xEF, 0x8F, 0xFF, 0xBE, 0x3F,
  0xFE, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xF7, 0xFC, 0x3F, 0xDF,
  0xE0, 0xFF, 0x7F, 0x83, 0xF9, 0xFE, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0,
  0xFC, 0x7F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xC3, 0xF8,
  0x7E, 0x1F, 0x83, 0xF1, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0xFC, 0x03, 0xE7,
  0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0xFD, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E,
  0x3E, 0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0xC3, 0xF0, 0x7E, 0x00, 0xF8, 0x1F,
  0xFC, 0x1F, 0xBF, 0x0F, 0xDF, 0x8F, 0xC7, 0xC7, 0xC3, 0xE7, 0xE1, 0xF3,
  0xE0, 0xFB, 0xF0, 0x3D, 0xF0, 0x1E, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x07, 0xF0, 0x7F,
  0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x00, 0xFC,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xFC,
  0x7E, 0x1F, 0x0F, 0x80, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07,
  0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0xFC,
  0x0F, 0xC1, 0xFE, 0x1D, 0xE3, 0xDE, 0x38, 0xE7, 0x8E, 0x78, 0xEF, 0x0E,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFD, 0xFF, 0xE0, 0x7C, 0x7C, 0x3E, 0x1E, 0x0F,
  0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F, 0xFF, 0x3E, 0x7C, 0xF9, 0xF0, 0x07,
  0xC3, 0xFF, 0x3F, 0xF9, 0xFF, 0xEF, 0xCF, 0xBE, 0x3E, 0xF9, 0xFB, 0xFF,
  0xEF, 0xFF, 0x9F, 0xFE, 0x3C, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xF8, 0x7F,
  0xF8, 0xFF, 0xF1, 0xFF, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0xBF, 0x1F,
  0x7C, 0x3E, 0xF8, 0x7D, 0xF1, 0xFB, 0xE3, 0xEF, 0xC7, 0xDF, 0xFF, 0xBF,
  0xFE, 0x7F, 0xF8, 0xFB, 0xE0, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F, 0xFF,
  0x3E, 0x7D, 0xF1, 0xF7, 0xC7, 0xDF, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xCF,
  0x9E, 0x3E, 0x7C, 0xF9, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x07, 0xBF, 0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF,
  0xC7, 0xE7, 0xE3, 0xE1, 0xF1, 0xF1, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E,
  0x3E, 0x3F, 0x1F, 0x1F, 0x0F, 0x87, 0xCF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0,
  0x7F, 0xF0, 0x1E, 0xF8, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE,
  0x7C, 0x7F, 0xF1, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x80,
  0x3E, 0x00, 0xFC, 0xE3, 0xFF, 0x87, 0xFF, 0x0F, 0xF8, 0x1F, 0x80, 0x01,
  0xF0, 0x7F, 0x0F, 0xF0, 0xFE, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x7F,
  0xCF, 0xFC, 0xFF, 0xCF, 0xFC, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x00, 0x07, 0xDF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x3E, 0x3E, 0x7E,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7E, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x61, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xF3,
  0xE7, 0xE7, 0xC7, 0xDF, 0x8F, 0xBE, 0x3F, 0x7C, 0x7C, 0xF8, 0xF9, 0xF1,
  0xF7, 0xE3, 0xEF, 0xCF, 0xDF, 0x1F, 0xBE, 0x3E, 0x7C, 0x7C, 0xF8, 0xF8,
  0x0F, 0x07, 0xC7, 0xE1, 0xF0, 0x70, 0x00, 0x00, 0x3E, 0x1F, 0x0F, 0x8F,
  0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC7,
  0xE3, 0xE1, 0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x3F, 0x9F, 0x9F, 0x8F, 0x9F, 0x87, 0xDF, 0x83, 0xFF, 0x81, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x0F, 0xDF, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF8, 0xF8, 0xFC, 0x00,
  0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F,
  0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE3, 0xF1, 0xF0, 0xF8, 0x00, 0x1F, 0x78, 0xF8, 0x7F, 0xF7, 0xF3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3E, 0x7E, 0x7C, 0xF9, 0xF9, 0xF3, 0xE7, 0xE7,
  0xDF, 0x9F, 0x1F, 0x7C, 0x7C, 0x7D, 0xF1, 0xF1, 0xF7, 0xC7, 0xCF, 0xDF,
  0x3F, 0x3E, 0x7C, 0xFC, 0xFB, 0xF3, 0xE3, 0xEF, 0x8F, 0x8F, 0xBE, 0x3E,
  0x3E, 0xF8, 0xF9, 0xF8, 0x3E, 0x78, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xF3,
  0xE7, 0xE7, 0xC7, 0xDF, 0x8F, 0xBE, 0x3F, 0x7C, 0x7C, 0xF8, 0xF9, 0xF1,
  0xF3, 0xE3, 0xEF, 0xCF, 0xDF, 0x1F, 0xBE, 0x3E, 0x7C, 0x7C, 0xF8, 0xF8,
  0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xE7, 0xEF, 0xC7, 0xDF,
  0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0xFD, 0xF1, 0xF3, 0xE3, 0xE7, 0xCF,
  0xCF, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xC0, 0x0F, 0xFC, 0x1F, 0xFE,
  0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0x3F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F, 0x1F,
  0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7F, 0xFE,
  0x7F, 0xFC, 0x7F, 0xF8, 0x7D, 0xF0, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0x9F, 0x1F, 0xDF,
  0x3F, 0xFE, 0x3F, 0xFE, 0x7E, 0x7E, 0x7C, 0x3E, 0x7C, 0x7E, 0x7C, 0x7E,
  0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0x7C, 0xF8, 0x7C, 0x7C, 0xFC, 0x7F, 0xF8,
  0x7F, 0xF8, 0x3F, 0xF8, 0x1E, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x1E, 0xF3, 0xFF, 0x3F,
  0xF3, 0xFE, 0x3F, 0xE3, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xE0,
  0x7F, 0xC3, 0xFF, 0x8F, 0xFF, 0x3E, 0x7C, 0xF1, 0xF3, 0xE0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xBE, 0x3E, 0xF8, 0xFB, 0xFF, 0xC7, 0xFF,
  0x0F, 0xF8, 0x1F, 0x80, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x1F, 0xFF,
  0xFB, 0xFE, 0xFF, 0x8F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x7E, 0x0F, 0x80, 0x3E, 0x3E, 0xFC, 0xFD,
  0xF1, 0xFB, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0xBF, 0x1F, 0x7C, 0x7E, 0xF8,
  0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x9F, 0x9F, 0xFF, 0x3F, 0xFC,
  0x3F, 0xF8, 0x3D, 0xF0, 0xF8, 0xFF, 0xE3, 0xEF, 0x9F, 0xBE, 0x7C, 0xF9,
  0xF3, 0xEF, 0x8F, 0xBE, 0x3E, 0xF8, 0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x00, 0xF9, 0xE3,
  0xFF, 0x3C, 0xFB, 0xE7, 0x9F, 0x79, 0xF3, 0xEF, 0x3E, 0x79, 0xEF, 0xDF,
  0x3D, 0xFB, 0xE7, 0xBF, 0x78, 0xFF, 0xFF, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8,
  0x7F, 0x7F, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3E, 0x3F, 0x07, 0xC7, 0xC0,
  0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x0F, 0x9F, 0x83, 0xCF, 0x81, 0xFF, 0xC0,
  0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x81, 0xF7, 0xC1, 0xFB, 0xE0, 0xF9,
  0xF0, 0xFC, 0x7C, 0x00, 0x1F, 0x1F, 0x8F, 0x8F, 0x87, 0xCF, 0xC3, 0xE7,
  0xE1, 0xF3, 0xE0, 0xFB, 0xF0, 0x7D, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x07,
  0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F,
  0xFE, 0x1F, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xF8, 0x7F,
  0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0x80, 0xE0, 0x78, 0x3E, 0x0F, 0x07,
  0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x0F, 0xC3,
  0xE0, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8,
  0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0x60, 0x07, 0x07, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x70, 0x70, 0x60,
  0x04, 0x03, 0x80, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x07, 0xC3, 0xF1, 0xF0,
  0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x78,
  0x3E, 0x0F, 0x01, 0x00, 0x1E, 0x00, 0x7E, 0x1D, 0xFE, 0x7B, 0xFC, 0xFF,
  0xBF, 0xFE, 0x3F, 0xBC, 0x7E, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_BlackItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 23, 8, 0, -23 },
  { 30, 11, 9, 10, 1, -25 },
  { 43, 17, 23, 16, 0, -23 },
  { 92, 15, 29, 16, 1, -26 },
  { 147, 16, 23, 21, 3, -23 },
  { 193, 17, 23, 19, 0, -23 },
  { 242, 5, 9, 5, 2, -25 },
  { 248, 11, 33, 10, 1, -26 },
  { 294, 10, 33, 10, -1, -26 },
  { 336, 14, 14, 15, 2, -23 },
  { 361, 14, 17, 15, 1, -20 },
  { 391, 8, 10, 9, -2, -4 },
  { 401, 9, 4, 13, 2, -12 },
  { 406, 5, 5, 10, 1, -5 },
  { 410, 14, 25, 10, -2, -23 },
  { 454, 15, 23, 16, 1, -23 },
  { 498, 11, 23, 16, 3, -23 },
  { 530, 16, 23, 16, 0, -23 },
  { 576, 16, 23, 16, 0, -23 },
  { 622, 15, 23, 16, 1, -23 },
  { 666, 15, 23, 16, 1, -23 },
  { 710, 14, 23, 16, 1, -23 },
  { 751, 16, 23, 16, 1, -23 },
  { 797, 15, 23, 16, 1, -23 },
  { 841, 14, 23, 16, 2, -23 },
  { 882, 8, 18, 10, 1, -18 },
  { 900, 10, 24, 9, -1, -18 },
  { 930, 14, 16, 14, 0, -18 },
  { 958, 14, 11, 17, 1, -16 },
  { 978, 14, 16, 14, 0, -18 },
  { 1006, 13, 23, 15, 2, -23 },
  { 1044, 24, 30, 25, 0, -23 },
  { 1134, 19, 23, 19, -2, -23 },
  { 1189, 18, 23, 18, 0, -23 },
  { 1241, 18, 23, 18, 1, -23 },
  { 1293, 18, 23, 18, 0, -23 },
  { 1345, 17, 23, 16, 0, -23 },
  { 1394, 17, 23, 15, 0, -23 },
  { 1443, 18, 23, 19, 1, -23 },
  { 1495, 20, 23, 20, 0, -23 },
  { 1553, 10, 23, 9, 0, -23 },
  { 1582, 17, 23, 16, 0, -23 },
  { 1631, 21, 23, 18, 0, -23 },
  { 1692, 14, 23, 15, 0, -23 },
  { 1733, 25, 23, 24, 0, -23 },
  { 1805, 20, 23, 19, 0, -23 },
  { 1863, 18, 23, 19, 1, -23 },
  { 1915, 18, 23, 18, 0, -23 },
  { 1967, 18, 27, 19, 1, -23 },
  { 2028, 18, 23, 18, 0, -23 },
  { 2080, 17, 23, 18, 1, -23 },
  { 2129, 17, 23, 18, 2, -23 },
  { 2178, 18, 23, 19, 1, -23 },
  { 2230, 19, 23, 19, 2, -23 },
  { 2285, 22, 23, 24, 3, -23 },
  { 2349, 21, 23, 18, -1, -23 },
  { 2410, 17, 23, 18, 3, -23 },
  { 2459, 20, 23, 17, -1, -23 },
  { 2517, 12, 33, 9, -1, -27 },
  { 2567, 9, 25, 12, 2, -23 },
  { 2596, 12, 33, 9, -2, -27 },
  { 2646, 12, 12, 13, 1, -23 },
  { 2664, 13, 4, 13, -2, 0 },
  { 2671, 8, 5, 11, 3, -25 },
  { 2676, 14, 17, 15, 0, -17 },
  { 2706, 15, 25, 16, 0, -25 },
  { 2753, 14, 17, 15, 0, -17 },
  { 2783, 17, 25, 16, 0, -25 },
  { 2837, 14, 17, 15, 1, -17 },
  { 2867, 12, 25, 11, 1, -25 },
  { 2905, 16, 24, 16, 0, -17 },
  { 2953, 15, 25, 16, 0, -25 },
  { 3000, 9, 24, 8, 0, -24 },
  { 3027, 13, 31, 8, -4, -24 },
  { 3078, 17, 25, 16, 0, -25 },
  { 3132, 9, 25, 8, 0, -25 },
  { 3161, 22, 17, 24, 0, -17 },
  { 3208, 15, 17, 16, 0, -17 },
  { 3240, 15, 17, 16, 0, -17 },
  { 3272, 16, 24, 16, -1, -17 },
  { 3320, 16, 24, 16, 0, -17 },
  { 3368, 12, 17, 11, 0, -17 },
  { 3394, 14, 17, 15, 0, -17 },
  { 3424, 10, 22, 10, 1, -22 },
  { 3452, 15, 17, 16, 1, -17 },
  { 3484, 14, 17, 15, 2, -17 },
  { 3514, 19, 17, 20, 2, -17 },
  { 3555, 17, 17, 15, -1, -17 },
  { 3592, 17, 24, 15, -1, -17 },
  { 3643, 16, 17, 15, -1, -17 },
  { 3677, 10, 32, 9, 1, -26 },
  { 3717, 8, 27, 8, 0, -23 },
  { 3744, 10, 32, 9, -1, -26 },
  { 3784, 15, 8, 17, 1, -14 },
};

const GFXfont RobotoCondensed_BlackItalic33pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic33pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic33pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _ROBOTOCONDENSED_BLACKITALIC33PT7B_H_
