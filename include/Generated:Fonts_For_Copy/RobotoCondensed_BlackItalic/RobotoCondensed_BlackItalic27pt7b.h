#ifndef _ROBOTOCONDENSED_BLACKITALIC27PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x38, 0x38, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0x70, 0x73, 0xBB, 0x9D, 0xCC,
  0xEE, 0x77, 0x33, 0x98, 0x03, 0xB8, 0x0E, 0xC0, 0x33, 0x01, 0xDC, 0x07,
  0x60, 0x19, 0x83, 0xFF, 0x8F, 0xFE, 0x0C, 0xC0, 0x37, 0x01, 0xDC, 0x3F,
  0xFC, 0xFF, 0xE0, 0xEE, 0x03, 0xB0, 0x0C, 0xC0, 0x77, 0x01, 0xD8, 0x06,
  0x60, 0x00, 0x01, 0x80, 0x18, 0x01, 0x80, 0x7C, 0x1F, 0xE1, 0xFF, 0x3F,
  0xF3, 0xCF, 0x3C, 0xF3, 0xC0, 0x3C, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03,
  0xE0, 0x1E, 0xF1, 0xEF, 0x3E, 0xFB, 0xCF, 0xFC, 0x7F, 0x81, 0xF0, 0x0C,
  0x01, 0x80, 0x18, 0x00, 0x3C, 0x03, 0xF0, 0x1D, 0xCD, 0xCE, 0x6E, 0x77,
  0x73, 0xF1, 0xBB, 0x0F, 0xF8, 0x3F, 0x80, 0x38, 0x01, 0xBC, 0x1F, 0xF1,
  0xFB, 0x8D, 0xDC, 0xEE, 0xEE, 0x67, 0x63, 0xB8, 0x1F, 0x80, 0x78, 0x03,
  0xC0, 0x1F, 0x80, 0xFF, 0x07, 0xFC, 0x1E, 0x70, 0x7B, 0xC1, 0xEE, 0x07,
  0xF8, 0x0F, 0xC0, 0x7C, 0x73, 0xFB, 0xDF, 0xFF, 0x7B, 0xFB, 0xEF, 0xEF,
  0x9F, 0xBE, 0x7C, 0x7F, 0xF1, 0xFF, 0xE1, 0xE7, 0x80, 0x7B, 0x9C, 0xE7,
  0x39, 0x9C, 0x01, 0x01, 0x81, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x38,
  0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x04, 0x00, 0x08, 0x06, 0x03,
  0x81, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0,
  0xF0, 0x70, 0x20, 0x00, 0x03, 0x80, 0x30, 0x03, 0x06, 0x33, 0x7F, 0xF7,
  0xFF, 0x0F, 0x81, 0xF0, 0x3F, 0x87, 0xB8, 0x71, 0xC2, 0x10, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xC0,
  0x78, 0x0E, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0xE3, 0x8E, 0x79, 0xCF, 0x38,
  0x40, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0xF7, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70,
  0x07, 0x00, 0xE0, 0x00, 0x07, 0x81, 0xFE, 0x1F, 0xE3, 0xDF, 0x3C, 0xF7,
  0x8F, 0x78, 0xF7, 0x8F, 0x78, 0xFF, 0x9F, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF,
  0x1E, 0xF3, 0xCF, 0xBC, 0x7F, 0x87, 0xF8, 0x1E, 0x00, 0x01, 0x0F, 0x7F,
  0xFF, 0xFF, 0xDF, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x7C, 0x7C, 0x78, 0x07, 0xC0, 0x7F, 0x87, 0xFC, 0x7D, 0xF3, 0xC7,
  0x9E, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xE7, 0xFF, 0x3F, 0xF8, 0x07,
  0xC0, 0x7F, 0x87, 0xFE, 0x7D, 0xF3, 0xC7, 0x80, 0x3C, 0x03, 0xE0, 0x3E,
  0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x01, 0xE0, 0x0F, 0x78, 0x7B, 0xE7, 0xCF,
  0xFC, 0x7F, 0xE1, 0xFE, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x07,
  0xE0, 0x3F, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x1D, 0xF1, 0xEF, 0x0E, 0x78,
  0xF3, 0xC7, 0xFF, 0x3F, 0xFB, 0xFF, 0xC0, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xFF,
  0x07, 0xFC, 0x3F, 0xE0, 0xCF, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x7C, 0x79,
  0xE7, 0xCF, 0xFC, 0x7F, 0xC1, 0xFE, 0x07, 0xC0, 0x01, 0xE0, 0xFC, 0x3F,
  0x8F, 0xE3, 0xE0, 0x78, 0x1E, 0xE3, 0xFE, 0xFF, 0xFF, 0x7F, 0xC7, 0xF8,
  0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0xDE, 0x7F, 0xCF, 0xF0, 0x78, 0x00, 0x7F,
  0xFB, 0xFF, 0xDF, 0xFE, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78,
  0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0xFF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xDE, 0x1F, 0xE3, 0xF8, 0x7F, 0xCF, 0x9C,
  0xF1, 0xEF, 0x1E, 0xF3, 0xEF, 0xFC, 0xFF, 0xC7, 0xF8, 0x3E, 0x00, 0x0F,
  0x07, 0xF1, 0xFF, 0x3F, 0xEF, 0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF3, 0xFE,
  0x7F, 0xFF, 0x3F, 0xE3, 0xFC, 0x0F, 0x03, 0xE3, 0xF8, 0x7E, 0x1F, 0x83,
  0xC0, 0x00, 0x00, 0xF7, 0xDF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3,
  0xCF, 0x38, 0x00, 0x0F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x70, 0xF0, 0x60,
  0x00, 0x20, 0x1C, 0x0F, 0x87, 0xF3, 0xFC, 0xFE, 0x1E, 0x03, 0xF0, 0x7F,
  0x83, 0xF8, 0x1F, 0x01, 0xC0, 0x08, 0x7F, 0xE7, 0xFE, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xEF, 0xFC, 0xFF, 0xC0, 0x30, 0x07, 0x00, 0xF8,
  0x1F, 0xC1, 0xFE, 0x0F, 0xC0, 0xF8, 0x7F, 0x3F, 0xCF, 0xE1, 0xF0, 0x38,
  0x08, 0x00, 0x1F, 0x1F, 0xE7, 0xFF, 0xFF, 0xF3, 0xFC, 0xF0, 0x7C, 0x3E,
  0x1F, 0x07, 0x83, 0xC0, 0xF0, 0x38, 0x00, 0x00, 0x01, 0xE0, 0xF8, 0x3E,
  0x07, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0F, 0x0E, 0x03, 0x80, 0xE0,
  0xE0, 0x0C, 0x38, 0x01, 0xC7, 0x1E, 0x19, 0xC7, 0xF3, 0x39, 0xFE, 0x6E,
  0x79, 0xCD, 0xCE, 0x71, 0xB9, 0xCE, 0x76, 0x71, 0xCF, 0xCE, 0x39, 0xF9,
  0xCE, 0x37, 0x39, 0xCE, 0xE7, 0xF9, 0x9C, 0x7B, 0xF3, 0x8E, 0x38, 0x30,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7F, 0x80, 0xFF, 0x03, 0xDE, 0x07, 0xBC, 0x1E, 0x78, 0x3C, 0xF0, 0xFF,
  0xE1, 0xFF, 0xC7, 0xFF, 0xCF, 0xFF, 0xBE, 0x1F, 0x7C, 0x1F, 0xF0, 0x3F,
  0xE0, 0x78, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE3, 0xE3, 0xE7,
  0xC7, 0xCF, 0x8F, 0x1E, 0x3E, 0x3F, 0xF8, 0x7F, 0xC1, 0xFF, 0xE3, 0xE3,
  0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC3,
  0xFF, 0x00, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFF, 0x3C, 0x3D, 0xE0,
  0xF7, 0x83, 0xDE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x7B, 0xC3, 0xEF, 0x0F, 0x3F, 0xFC, 0x7F, 0xE0, 0xFF, 0x01, 0xF8, 0x00,
  0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x87, 0xFF, 0x3E, 0x3C, 0xF8, 0xF3, 0xC3,
  0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF7, 0xC7, 0xDF, 0x1F, 0x78, 0x79, 0xE1,
  0xE7, 0x8F, 0xBF, 0xFC, 0xFF, 0xE3, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xFC,
  0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x3F, 0xF0, 0xFF, 0xC7, 0xFE, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xF1,
  0xFF, 0x87, 0xFE, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xC7, 0xFE, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F,
  0xFF, 0x3C, 0x3D, 0xF0, 0xF7, 0x83, 0xDE, 0x00, 0x78, 0x03, 0xE7, 0xFF,
  0x9F, 0xFE, 0x7E, 0xF0, 0x7B, 0xC1, 0xEF, 0x8F, 0xBF, 0xFE, 0x7F, 0xF8,
  0xFF, 0xC1, 0xF8, 0x00, 0x1F, 0x0F, 0x8F, 0x07, 0x87, 0x83, 0xC3, 0xC1,
  0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF0, 0x7C, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x1F, 0xFF, 0x8F, 0x87, 0xC7, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF1,
  0xF0, 0x78, 0xF8, 0x7C, 0x7C, 0x3E, 0x3C, 0x1E, 0x00, 0x1F, 0x1F, 0x1E,
  0x1E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x7C, 0x7C, 0x78, 0x78,
  0x78, 0x78, 0xF8, 0xF8, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE3, 0xE7, 0x8F, 0x1E, 0x3F, 0xF8, 0x7F, 0xC1, 0xFE, 0x01,
  0xF0, 0x00, 0x1F, 0x1F, 0x8F, 0x1F, 0x87, 0x8F, 0x83, 0xCF, 0x83, 0xEF,
  0x81, 0xF7, 0xC0, 0xF7, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xEF, 0x81, 0xE7, 0xC1, 0xF1, 0xE0,
  0xF8, 0xF8, 0x7C, 0x7C, 0x3C, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07,
  0x80, 0xF0, 0x1E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x81,
  0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F,
  0xC3, 0xF8, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x9F, 0xE1, 0xFC, 0xEF,
  0x1F, 0xE7, 0xF8, 0xF7, 0x77, 0xC7, 0x9B, 0xBC, 0x3C, 0xFD, 0xE1, 0xE7,
  0xCF, 0x1F, 0x3E, 0xF8, 0xF9, 0xE7, 0xC7, 0xCF, 0x3E, 0x3C, 0x71, 0xE0,
  0x1F, 0x0F, 0x8F, 0x87, 0x87, 0xC3, 0xC3, 0xE1, 0xE3, 0xF9, 0xF1, 0xFC,
  0xF8, 0xFE, 0x7C, 0x7F, 0x3C, 0x3D, 0x9E, 0x1E, 0xEF, 0x1F, 0x7F, 0x8F,
  0xBF, 0xC7, 0x8F, 0xC3, 0xC7, 0xE1, 0xE3, 0xF1, 0xF1, 0xF8, 0xF8, 0xFC,
  0x7C, 0x3E, 0x3C, 0x1E, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF,
  0xE3, 0xC3, 0xCF, 0x87, 0x9E, 0x0F, 0x3C, 0x1E, 0xF8, 0x3D, 0xF0, 0x7B,
  0xE1, 0xF7, 0x83, 0xEF, 0x07, 0xDE, 0x0F, 0x3E, 0x3E, 0x3F, 0xF8, 0x7F,
  0xE0, 0x7F, 0x80, 0x7E, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF,
  0xE3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9E, 0x1F, 0x3C, 0x3C, 0x7F, 0xF9,
  0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF,
  0xE3, 0xC3, 0xCF, 0x87, 0x9E, 0x0F, 0x3C, 0x1E, 0xF8, 0x3D, 0xF0, 0x7B,
  0xE0, 0xF7, 0x83, 0xEF, 0x07, 0xDE, 0x0F, 0x3E, 0x3E, 0x3F, 0xF8, 0x7F,
  0xF0, 0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x10,
  0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE3, 0xE3, 0xE7, 0xC7,
  0xCF, 0x8F, 0x9E, 0x1E, 0x3F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC3, 0xFF, 0x07,
  0x9E, 0x0F, 0x3E, 0x1E, 0x7C, 0x3C, 0x78, 0xF8, 0xF1, 0xF1, 0xF3, 0xC3,
  0xE0, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE3, 0xE3, 0xC7, 0xC7,
  0xCF, 0x80, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xCF,
  0x87, 0x8F, 0x0F, 0x1E, 0x3E, 0x3F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0x3E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x0F, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3E,
  0x3E, 0x78, 0x7C, 0xF0, 0xF1, 0xE1, 0xE7, 0xC3, 0xCF, 0x8F, 0x9E, 0x1F,
  0x3C, 0x3E, 0x78, 0x78, 0xF0, 0xF3, 0xE1, 0xE7, 0xC7, 0xCF, 0x0F, 0x9E,
  0x1E, 0x3C, 0x3C, 0x7F, 0xF8, 0x7F, 0xE0, 0xFF, 0x80, 0x7E, 0x00, 0xF8,
  0x3F, 0xF0, 0xFB, 0xE1, 0xF7, 0xC3, 0xEF, 0x8F, 0x8F, 0x1F, 0x1E, 0x3C,
  0x3C, 0xF8, 0x79, 0xE0, 0xF3, 0xC1, 0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x0F,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF1,
  0xE3, 0xFE, 0x3C, 0x7B, 0xC7, 0x8F, 0x79, 0xF3, 0xEF, 0x3E, 0x79, 0xE7,
  0xCF, 0x3D, 0xFB, 0xE7, 0xBF, 0x78, 0xF7, 0xEF, 0x1F, 0xFD, 0xE3, 0xFF,
  0xF8, 0x7F, 0x7F, 0x0F, 0xEF, 0xE1, 0xFD, 0xF8, 0x3F, 0x3F, 0x07, 0xE7,
  0xE0, 0xFC, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0x87,
  0x8F, 0x83, 0xC7, 0xC1, 0xF7, 0xC0, 0xFB, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0x79, 0xE0, 0x7C, 0xF0, 0x7C, 0x78, 0x3E, 0x3E, 0x3E,
  0x1F, 0x00, 0xF8, 0x7F, 0xE1, 0xF7, 0x8F, 0x9E, 0x3C, 0x79, 0xF1, 0xE7,
  0x83, 0xBE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x1F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x3F, 0xFC, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC0,
  0x0F, 0xC3, 0xF0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1,
  0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x0F, 0xC0, 0xF1, 0xE3,
  0xC7, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xF3, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x7C, 0xF8, 0xF1, 0xE0, 0x07, 0xC3, 0xF0, 0xFC, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0,
  0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C,
  0x1F, 0x07, 0xC0, 0x0F, 0x07, 0x87, 0xC3, 0xE3, 0xB1, 0xDD, 0xEE, 0xE7,
  0xF3, 0xF1, 0xC0, 0x7F, 0xEF, 0xFB, 0xFF, 0x00, 0xF1, 0xE3, 0x8F, 0x0F,
  0x81, 0xFE, 0x3F, 0xE3, 0xDE, 0x7D, 0xE0, 0x1E, 0x1F, 0xE7, 0xFE, 0x7D,
  0xEF, 0xBE, 0xF3, 0xEF, 0x3C, 0xFF, 0xC7, 0xFC, 0x3B, 0xC0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3D, 0xC3, 0xFE, 0x3F, 0xF3,
  0xDF, 0x3C, 0xF7, 0xCF, 0x78, 0xF7, 0x8F, 0x78, 0xF7, 0x8F, 0x79, 0xFF,
  0xDE, 0xFF, 0xEF, 0xFC, 0xF7, 0x80, 0x0F, 0x81, 0xFC, 0x3F, 0xE3, 0xDE,
  0x78, 0xF7, 0x8F, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF1, 0xE7, 0xBC,
  0x7F, 0xC3, 0xF8, 0x1F, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0xF7, 0x8F, 0xFE, 0x3F, 0xF9, 0xF7, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE7, 0xCF, 0x9F, 0x3E, 0x78, 0xF9, 0xE1, 0xEF,
  0x87, 0xFE, 0x1F, 0xF8, 0x3D, 0xE0, 0x07, 0xC1, 0xFE, 0x3F, 0xE3, 0xDF,
  0x78, 0xF7, 0x8F, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0x80, 0x78, 0x07, 0xDC,
  0x7F, 0xC3, 0xFC, 0x1F, 0x80, 0x07, 0x83, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F,
  0x0F, 0xF3, 0xFC, 0xFF, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x83,
  0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x78, 0xFF, 0xCF,
  0xFE, 0xFF, 0xF7, 0x8F, 0xBC, 0x79, 0xE3, 0xCF, 0x1E, 0xF8, 0xF7, 0xCF,
  0xBE, 0x7C, 0xFB, 0xC7, 0xFE, 0x3F, 0xF0, 0x77, 0x80, 0x7C, 0x67, 0xC7,
  0xFE, 0x3F, 0xE0, 0xFC, 0x00, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E,
  0x03, 0xC0, 0x3D, 0xE3, 0xFE, 0x3F, 0xF3, 0xDF, 0x7C, 0xF7, 0x8F, 0x78,
  0xF7, 0x9F, 0x79, 0xF7, 0x9E, 0xF9, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF3,
  0xE0, 0x1E, 0x3C, 0x78, 0x70, 0x00, 0x0F, 0x9E, 0x3C, 0x78, 0xF3, 0xE7,
  0xCF, 0x1E, 0x3C, 0x78, 0xF3, 0xE7, 0x8F, 0x00, 0x03, 0xC0, 0xF0, 0x3C,
  0x07, 0x00, 0x00, 0x00, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F,
  0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x8B,
  0xE3, 0xF0, 0xFC, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xF8, 0x03, 0xCF, 0xCF, 0x3E, 0x3D, 0xF0, 0xFF, 0x83, 0xFC,
  0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7B, 0xC3, 0xEF,
  0x8F, 0x3E, 0x3C, 0x78, 0xF1, 0xE0, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x78,
  0xF8, 0xF0, 0xF0, 0x3D, 0xE7, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0xF7, 0xEF,
  0x3C, 0xF3, 0xDF, 0x3C, 0xF7, 0x9F, 0x3D, 0xE7, 0xCF, 0x79, 0xE3, 0xDE,
  0x79, 0xF7, 0x9E, 0x7F, 0xE7, 0x9E, 0xF1, 0xE7, 0xBC, 0xF9, 0xEF, 0x3E,
  0x78, 0x3D, 0xE3, 0xFF, 0x3F, 0xF3, 0xDF, 0x7C, 0xF7, 0x8F, 0x78, 0xF7,
  0x9F, 0x79, 0xF7, 0x9E, 0xF9, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF3, 0xE0,
  0x07, 0xC1, 0xFE, 0x3F, 0xE3, 0xDF, 0x78, 0xF7, 0x8F, 0x78, 0xF7, 0x8F,
  0xF8, 0xFF, 0x8F, 0x79, 0xE7, 0xBE, 0x7F, 0xC3, 0xFC, 0x1F, 0x00, 0x1E,
  0xE0, 0xFF, 0x87, 0xFE, 0x3F, 0xF3, 0xE7, 0x9F, 0x3C, 0xF1, 0xE7, 0x8F,
  0x3C, 0x79, 0xE3, 0xDF, 0x3E, 0xFD, 0xE7, 0xFF, 0x3F, 0xF1, 0xEF, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x79, 0xFB, 0xCF,
  0xFE, 0xFB, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xCF, 0x3E, 0xF9, 0xE7, 0xCF,
  0x3C, 0x78, 0xF7, 0xC7, 0xFE, 0x3F, 0xF0, 0xFF, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x3D, 0xCF, 0xE3, 0xF8, 0xFE, 0x7E, 0x1F,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x00,
  0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0xDE, 0x79, 0xF7, 0xC0, 0x3F, 0x03, 0xF8,
  0x0F, 0xC0, 0x7C, 0xF3, 0xCF, 0x3C, 0xFF, 0xC7, 0xF8, 0x1E, 0x00, 0x3E,
  0x3C, 0x3C, 0xFF, 0xFF, 0xFE, 0x7C, 0x78, 0x78, 0x78, 0x78, 0xF8, 0xF0,
  0xF0, 0xFC, 0xFC, 0x7C, 0x3C, 0x3C, 0x79, 0xE3, 0xCF, 0x3E, 0x79, 0xE7,
  0xCF, 0x3C, 0x79, 0xE3, 0xCF, 0x1E, 0x79, 0xF3, 0xCF, 0x9E, 0x78, 0xF7,
  0xC7, 0xFE, 0x3F, 0xF0, 0xF7, 0x80, 0xF9, 0xFF, 0x9E, 0xF9, 0xE7, 0xBE,
  0x7B, 0xC7, 0xBC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x07, 0xE0,
  0x7E, 0x03, 0xE0, 0x3C, 0x00, 0x71, 0xCF, 0x73, 0xCF, 0x73, 0xDE, 0x77,
  0xDE, 0x77, 0xDE, 0x77, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x7D,
  0xF8, 0x7D, 0xF8, 0x7D, 0xF0, 0x79, 0xF0, 0x79, 0xF0, 0x71, 0xE0, 0x1E,
  0x7C, 0x79, 0xE1, 0xEF, 0x07, 0xBC, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03,
  0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0x78, 0x7D, 0xE1, 0xE7, 0x8F,
  0x9E, 0x00, 0x7C, 0xFB, 0xE7, 0xCF, 0x3C, 0x7B, 0xE3, 0xDE, 0x1F, 0xF0,
  0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xC0, 0x00, 0x3F,
  0xF3, 0xFF, 0x3F, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E,
  0x03, 0xE0, 0x7C, 0x07, 0x80, 0xFF, 0xCF, 0xFC, 0xFF, 0xC0, 0x01, 0x03,
  0x81, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x07, 0x87,
  0x83, 0x83, 0xC0, 0xF0, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0x70, 0x38, 0x0C, 0x00, 0x0C, 0x30, 0xC7, 0x1C, 0x61, 0x86, 0x18, 0xE3,
  0x8E, 0x30, 0xC3, 0x0C, 0x71, 0xC6, 0x18, 0x61, 0x8E, 0x00, 0x08, 0x0E,
  0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x07, 0x0F,
  0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0xF0, 0xE0, 0x40,
  0x3C, 0x77, 0xE7, 0xFF, 0xFF, 0xFF, 0xE7, 0xE0, 0x1C,
};

const GFXglyph RobotoCondensed_BlackItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 19, 7, 0, -19 },
  { 20, 9, 7, 8, 1, -20 },
  { 28, 14, 19, 13, 0, -19 },
  { 62, 12, 25, 13, 1, -22 },
  { 100, 13, 19, 17, 2, -19 },
  { 131, 14, 19, 16, 0, -19 },
  { 165, 5, 8, 4, 1, -20 },
  { 170, 9, 27, 9, 1, -21 },
  { 201, 9, 27, 8, -1, -21 },
  { 232, 12, 12, 12, 1, -19 },
  { 250, 11, 14, 12, 1, -16 },
  { 270, 6, 9, 7, -1, -3 },
  { 277, 7, 3, 11, 2, -10 },
  { 280, 5, 5, 8, 0, -5 },
  { 284, 12, 21, 8, -2, -19 },
  { 316, 12, 19, 13, 1, -19 },
  { 345, 8, 19, 13, 3, -19 },
  { 364, 13, 19, 13, 0, -19 },
  { 395, 13, 19, 13, 0, -19 },
  { 426, 13, 19, 13, 0, -19 },
  { 457, 13, 19, 13, 0, -19 },
  { 488, 11, 19, 13, 1, -19 },
  { 515, 13, 19, 13, 1, -19 },
  { 546, 12, 19, 13, 1, -19 },
  { 575, 11, 19, 13, 2, -19 },
  { 602, 6, 16, 8, 1, -16 },
  { 614, 8, 22, 7, -1, -16 },
  { 636, 11, 13, 12, 0, -15 },
  { 654, 12, 9, 14, 1, -13 },
  { 668, 11, 13, 12, 0, -14 },
  { 686, 10, 19, 12, 2, -19 },
  { 710, 19, 25, 20, 0, -19 },
  { 770, 15, 19, 16, -1, -19 },
  { 806, 15, 19, 15, 0, -19 },
  { 842, 14, 19, 15, 1, -19 },
  { 876, 14, 19, 15, 0, -19 },
  { 910, 14, 19, 13, 0, -19 },
  { 944, 14, 19, 12, 0, -19 },
  { 978, 14, 19, 15, 1, -19 },
  { 1012, 17, 19, 16, 0, -19 },
  { 1053, 8, 19, 7, 0, -19 },
  { 1072, 14, 19, 13, 0, -19 },
  { 1106, 17, 19, 15, 0, -19 },
  { 1147, 11, 19, 13, 0, -19 },
  { 1174, 21, 19, 20, 0, -19 },
  { 1224, 17, 19, 16, 0, -19 },
  { 1265, 15, 19, 16, 1, -19 },
  { 1301, 15, 19, 15, 0, -19 },
  { 1337, 15, 23, 16, 1, -19 },
  { 1381, 15, 19, 15, 0, -19 },
  { 1417, 15, 19, 14, 0, -19 },
  { 1453, 14, 19, 15, 2, -19 },
  { 1487, 15, 19, 15, 1, -19 },
  { 1523, 15, 19, 15, 2, -19 },
  { 1559, 19, 19, 19, 2, -19 },
  { 1605, 17, 19, 15, -1, -19 },
  { 1646, 14, 19, 14, 2, -19 },
  { 1680, 15, 19, 14, 0, -19 },
  { 1716, 10, 27, 7, -1, -22 },
  { 1750, 7, 21, 10, 2, -19 },
  { 1769, 10, 27, 7, -2, -22 },
  { 1803, 9, 10, 11, 1, -19 },
  { 1815, 11, 3, 10, -2, 0 },
  { 1820, 6, 4, 9, 3, -20 },
  { 1823, 12, 15, 12, 0, -15 },
  { 1846, 12, 21, 13, 0, -21 },
  { 1878, 12, 15, 12, 0, -15 },
  { 1901, 14, 21, 13, 0, -21 },
  { 1938, 12, 15, 13, 0, -15 },
  { 1961, 10, 21, 9, 1, -21 },
  { 1988, 13, 20, 13, 0, -15 },
  { 2021, 12, 21, 13, 0, -21 },
  { 2053, 7, 21, 7, 0, -21 },
  { 2072, 10, 26, 7, -3, -21 },
  { 2105, 14, 21, 13, 0, -21 },
  { 2142, 8, 21, 7, 0, -21 },
  { 2163, 18, 15, 19, 0, -15 },
  { 2197, 12, 15, 13, 0, -15 },
  { 2220, 12, 15, 13, 0, -15 },
  { 2243, 13, 20, 13, -1, -15 },
  { 2276, 13, 20, 13, 0, -15 },
  { 2309, 10, 15, 9, 0, -15 },
  { 2328, 12, 15, 12, 0, -15 },
  { 2351, 8, 18, 8, 1, -18 },
  { 2369, 13, 15, 13, 0, -15 },
  { 2394, 12, 15, 12, 1, -15 },
  { 2417, 16, 15, 16, 1, -15 },
  { 2447, 14, 15, 12, -1, -15 },
  { 2474, 13, 20, 12, 0, -15 },
  { 2507, 12, 15, 12, 0, -15 },
  { 2530, 9, 26, 8, 0, -21 },
  { 2560, 6, 23, 7, 0, -19 },
  { 2578, 8, 26, 8, -1, -21 },
  { 2604, 12, 6, 14, 1, -11 },
};

const GFXfont RobotoCondensed_BlackItalic27pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic27pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic27pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOCONDENSED_BLACKITALIC27PT7B_H_
