#ifndef _ROBOTOCONDENSED_BLACKITALIC43PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x07, 0xE0, 0x7F, 0x0F, 0xF0, 0x7E, 0x07, 0xE0, 0x3C, 0x00,
  0x7C, 0x7B, 0xE7, 0xDF, 0x3E, 0xF9, 0xF7, 0xCF, 0xBC, 0x79, 0xE3, 0xDF,
  0x1E, 0xF9, 0xF7, 0x8F, 0x3C, 0x79, 0xE3, 0xC0, 0x00, 0x3C, 0xF0, 0x00,
  0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7,
  0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x0F, 0x3C, 0x00, 0x3C,
  0xF0, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x07, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0xF3, 0xC0, 0x07,
  0x9E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0x3C,
  0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0x7F, 0x0F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0x7E, 0x1F, 0x87, 0xF3,
  0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x07,
  0xF0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x08, 0xF9, 0xE1,
  0xEF, 0x1E, 0x1E, 0xF1, 0xE3, 0xCF, 0x1E, 0x7C, 0xF1, 0xE7, 0x8F, 0x3E,
  0xF0, 0xFF, 0xFF, 0x07, 0xFD, 0xE0, 0x7F, 0xBC, 0x01, 0xF7, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0xF8, 0x03, 0xDF, 0xE0,
  0x7B, 0xFE, 0x0F, 0xFF, 0xF0, 0xF7, 0xCF, 0x1E, 0x78, 0xF3, 0xEF, 0x8F,
  0x3C, 0xF8, 0xF7, 0x8F, 0x9F, 0xF0, 0xF9, 0xF3, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFE, 0xFC, 0x01,
  0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F,
  0xBF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x3F, 0x0F, 0xFC, 0x7C, 0x3F, 0xFC, 0xF8, 0xFF, 0xFB,
  0xF3, 0xFB, 0xFF, 0xE7, 0xF7, 0xFF, 0x8F, 0xE7, 0xFF, 0x3F, 0x8F, 0xFE,
  0x7F, 0x0F, 0xF8, 0x7E, 0x1F, 0xF0, 0xFE, 0x7F, 0xC1, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF, 0x7F, 0x01, 0xF8, 0xFF, 0x00,
  0x3E, 0x7C, 0xFB, 0xE7, 0xCF, 0x9F, 0x3C, 0x79, 0xF3, 0xE7, 0x80, 0x00,
  0x10, 0x01, 0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x01, 0x00, 0x01, 0x00, 0x06,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x01, 0xC0, 0x04, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x61, 0xE1, 0x9F, 0x3C, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3E, 0xF0, 0x0F, 0xCF,
  0x03, 0xF1, 0xF0, 0x7C, 0x1E, 0x03, 0x03, 0x80, 0x00, 0x40, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x0F, 0x87, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x7E, 0x3E, 0x3F,
  0x1F, 0x1F, 0x8F, 0x81, 0x80, 0x7F, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF,
  0xE0, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xCE, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE,
  0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xBF, 0x8F, 0xE3, 0xF1, 0xF8, 0x7E,
  0x3F, 0x0F, 0xEF, 0xE1, 0xFD, 0xFC, 0x3F, 0xBF, 0x87, 0xF7, 0xE0, 0xFF,
  0xFC, 0x1F, 0xBF, 0x83, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F, 0xDF, 0xC3, 0xFB,
  0xF0, 0x7F, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x7F, 0x3F, 0x0F, 0xE7,
  0xE1, 0xF8, 0xFC, 0x7F, 0x1F, 0xDF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03,
  0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x18, 0x03, 0xC0, 0xFE,
  0x3F, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF6, 0x3F, 0x81,
  0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E,
  0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xFB, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFC, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFB, 0xF8,
  0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0x7E,
  0x1F, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7D, 0xFC,
  0x07, 0xDF, 0xC0, 0xF9, 0xF8, 0x1F, 0x9F, 0x81, 0xF3, 0xF8, 0x3F, 0x3F,
  0x87, 0xE3, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x7C, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F,
  0xFF, 0x81, 0xF1, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0xFC, 0x1F, 0xCF, 0xE1, 0xF8,
  0xFE, 0x3F, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC,
  0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF8, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFC, 0xFE, 0x7F, 0x0F, 0xEF, 0xE1,
  0xFD, 0xF8, 0x3F, 0xBF, 0x07, 0xF7, 0xE0, 0xFE, 0xFC, 0x1F, 0xDF, 0x83,
  0xF3, 0xF0, 0xFE, 0x7E, 0x1F, 0xCF, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF,
  0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xFC, 0xFE,
  0x0F, 0xDF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFF,
  0x03, 0xFF, 0xF8, 0x7F, 0x1F, 0x87, 0xF1, 0xF8, 0xFE, 0x1F, 0xCF, 0xE1,
  0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x3F, 0x8F, 0xF7, 0xF8, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F,
  0xEF, 0xE7, 0xF1, 0xF9, 0xF8, 0x7E, 0xFE, 0x1F, 0xBF, 0x87, 0xEF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xBF, 0x8F, 0xEF, 0xE3, 0xFB, 0xF8, 0xFE,
  0xFF, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xFE, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x87,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x87, 0xE0, 0xF0, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x01, 0xC0, 0x03, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF8, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0xF0, 0x0F,
  0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x3E,
  0x00, 0x07, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x9F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8,
  0xFF, 0xFF, 0x00, 0x08, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0xE3, 0xFF,
  0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0x01, 0xC0, 0x00,
  0x40, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xF7, 0xFB, 0xFB, 0xF8, 0xFD, 0xFC, 0x7E, 0xFC, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x03, 0xF0, 0x78,
  0x3E, 0x0F, 0xF8, 0xF0, 0x78, 0x3F, 0xF8, 0xE1, 0xF0, 0xFF, 0xF1, 0xE3,
  0xC3, 0xE3, 0xC3, 0xCF, 0x8F, 0x87, 0x87, 0x9E, 0x1F, 0x1F, 0x0F, 0x3C,
  0x7C, 0x3E, 0x3C, 0xF8, 0xF8, 0x78, 0x79, 0xF1, 0xF0, 0xF0, 0xF3, 0xC7,
  0xE3, 0xE1, 0xE7, 0x8F, 0x87, 0xC3, 0xCF, 0x1F, 0x0F, 0x07, 0x1E, 0x3E,
  0x1E, 0x1E, 0x7C, 0x7C, 0x7C, 0x3C, 0xF8, 0xF8, 0xF8, 0xF1, 0xF1, 0xF3,
  0xF1, 0xE3, 0xE3, 0xFF, 0xFF, 0x87, 0xC3, 0xFF, 0xFE, 0x07, 0x87, 0xF3,
  0xF8, 0x0F, 0x07, 0xC3, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x06, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF,
  0xC0, 0x07, 0xF7, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xF8,
  0x7E, 0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x1F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE7,
  0xF8, 0x07, 0xF3, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFE, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F,
  0xC1, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xF1, 0xFC, 0x3F, 0xC3, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0x8F, 0xE0, 0x7F,
  0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x07, 0xF8, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xF8, 0x3F, 0x8F,
  0xE0, 0x7F, 0x1F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x3F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0xFE, 0x3F, 0x03, 0xFC,
  0x7F, 0x07, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x3F,
  0xC1, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8,
  0x3F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03,
  0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0x7F,
  0x1F, 0xC0, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xF0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0x81,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0, 0x3F, 0x1F, 0xC0,
  0x7E, 0x7F, 0x00, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC3, 0xFF, 0xBF, 0x87, 0xFE, 0x7F, 0x0F, 0xFC,
  0xFE, 0x3F, 0xF9, 0xFC, 0x7F, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0xCF,
  0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x07, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8,
  0x1F, 0xC0, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x83,
  0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F,
  0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8,
  0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0,
  0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0x80,
  0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F,
  0xC1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F,
  0x87, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0x81, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xE0, 0xFE, 0x0F, 0xF8, 0x1F, 0xC3,
  0xFE, 0x07, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xF0, 0x1F, 0xC3, 0xFC, 0x03,
  0xF8, 0xFF, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xE7, 0xF8, 0x03, 0xFD, 0xFE,
  0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xBF, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x07,
  0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x00,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x07, 0xFC,
  0x01, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0xC0, 0xFF,
  0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xC1,
  0xFB, 0xE1, 0xFF, 0xE0, 0xFD, 0xF1, 0xFF, 0xE0, 0x7E, 0xF8, 0xFB, 0xF0,
  0x7F, 0x7C, 0xFF, 0xF8, 0x3F, 0xBE, 0x7D, 0xFC, 0x1F, 0xDF, 0x3E, 0xFE,
  0x0F, 0xEF, 0xBE, 0x7F, 0x07, 0xF7, 0xDF, 0x3F, 0x03, 0xF1, 0xEF, 0xBF,
  0x83, 0xF8, 0xFF, 0x9F, 0xC1, 0xFC, 0x7F, 0xCF, 0xE0, 0xFE, 0x3F, 0xC7,
  0xF0, 0x7F, 0x1F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF1,
  0xFC, 0x1F, 0xC3, 0xF8, 0xFE, 0x0F, 0xE1, 0xF8, 0x7F, 0x07, 0xF0, 0xFC,
  0x3F, 0x83, 0xF8, 0x7C, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03,
  0xF8, 0x1F, 0xE0, 0x7F, 0x07, 0xFC, 0x0F, 0xE0, 0xFF, 0x81, 0xFC, 0x1F,
  0xF0, 0x3F, 0x83, 0xFE, 0x0F, 0xE0, 0x7F, 0xE1, 0xFC, 0x0F, 0xFC, 0x3F,
  0x83, 0xFF, 0x87, 0xF0, 0x7F, 0xF0, 0xFE, 0x0F, 0xFE, 0x1F, 0xC1, 0xFF,
  0xE7, 0xF0, 0x3F, 0xBC, 0xFE, 0x07, 0xF7, 0x9F, 0xC1, 0xFE, 0xF3, 0xF8,
  0x3F, 0x9F, 0x7F, 0x07, 0xF3, 0xEF, 0xE0, 0xFE, 0x3F, 0xF8, 0x1F, 0xC7,
  0xFF, 0x03, 0xF8, 0xFF, 0xE0, 0xFE, 0x1F, 0xFC, 0x1F, 0xC1, 0xFF, 0x83,
  0xF8, 0x3F, 0xF0, 0x7F, 0x07, 0xFC, 0x0F, 0xE0, 0xFF, 0x81, 0xFC, 0x1F,
  0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F,
  0x80, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xE0, 0xFE,
  0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x7F,
  0x3F, 0x80, 0xFF, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFE,
  0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7F, 0x03, 0xF8,
  0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0xFE,
  0x1F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7E,
  0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0xFF,
  0x7F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC,
  0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF8,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01, 0x00,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x1F, 0xC1, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x3F, 0x9F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xE0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0,
  0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF1, 0xFE, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F,
  0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0,
  0x7F, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81,
  0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x81,
  0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03,
  0xF8, 0x7F, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0x7F, 0x01,
  0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x07,
  0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F,
  0xE0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x3F,
  0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x0F, 0xC1, 0xFD, 0xF8,
  0x3F, 0x07, 0xF7, 0xE1, 0xFC, 0x3F, 0x9F, 0x87, 0xF0, 0xFE, 0x7E, 0x1F,
  0xC3, 0xF9, 0xF8, 0xFF, 0x1F, 0xC7, 0xE3, 0xFC, 0x7F, 0x1F, 0x8F, 0xF1,
  0xFC, 0x7E, 0x7F, 0xC7, 0xE1, 0xF9, 0xFF, 0x3F, 0x87, 0xE7, 0xFC, 0xFE,
  0x1F, 0xBF, 0xF3, 0xF8, 0x7E, 0xFF, 0xDF, 0xC1, 0xFB, 0xFF, 0x7F, 0x07,
  0xEF, 0xFD, 0xFC, 0x1F, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xDF, 0xFE, 0x07, 0xFF, 0x7F, 0xF0, 0x1F, 0xFD, 0xFF, 0xC0, 0x7F, 0xE7,
  0xFF, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xF1, 0xFF,
  0x80, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0xC0,
  0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x07,
  0xF0, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0xF0, 0x3F, 0x81, 0xFE, 0x03,
  0xFC, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC7,
  0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0xFE, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xF3, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x1F,
  0xE1, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0xC1, 0xFC, 0x07, 0xF8, 0x1F,
  0xE0, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0xFE, 0x03, 0xF9, 0xFC,
  0x0F, 0xF3, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0x87, 0xE0, 0xFE, 0x0F, 0xC3,
  0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x9F, 0xC0, 0x3F, 0x3F, 0x80, 0x7E, 0x7E,
  0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0,
  0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x1F, 0xC3,
  0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x1F, 0x83, 0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0x7E, 0x0F,
  0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE0, 0xFC, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x81, 0xEF, 0x07, 0xDE, 0x0F, 0x3C, 0x3E, 0x78,
  0xF8, 0xF9, 0xF1, 0xF7, 0xE3, 0xEF, 0x87, 0xFF, 0x07, 0x80, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF0, 0x7F, 0x1F, 0xC3,
  0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7C, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F,
  0xCF, 0xEF, 0xE3, 0xFB, 0xF8, 0xFE, 0xFE, 0x3F, 0xBF, 0x9F, 0xEF, 0xFF,
  0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xEF, 0xC1, 0xF3, 0xF8, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFD, 0xF0, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xCF, 0xE1,
  0xF8, 0x7F, 0x3F, 0x87, 0xF3, 0xF8, 0x7F, 0x3F, 0x87, 0xF3, 0xF8, 0x7E,
  0x3F, 0x07, 0xE7, 0xF0, 0x7E, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F,
  0xE7, 0xF0, 0xFC, 0x7F, 0xBF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xDF,
  0xF8, 0xFD, 0xFE, 0x0F, 0xC7, 0xC0, 0x01, 0xF8, 0x01, 0xFF, 0x81, 0xFF,
  0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0xEF, 0xE7, 0xF1, 0xF9, 0xF8, 0x7E,
  0xFE, 0x1F, 0xBF, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x7F, 0x3F, 0xBF, 0x8F, 0xFF,
  0xE1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x3F,
  0x83, 0xFD, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFE,
  0xFF, 0x8F, 0xE1, 0xFC, 0x7E, 0x0F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF1,
  0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x87,
  0xF0, 0xFC, 0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0xDF, 0xE1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFE, 0xFC, 0x03, 0xE7, 0xE0, 0x01, 0xFC,
  0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xE7, 0xF7,
  0xF0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x04,
  0x3F, 0xEF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFE,
  0x07, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xF1, 0xF8, 0x3F, 0xCF, 0xC3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xE7, 0xF8, 0xFE, 0x1F,
  0xC7, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xF8, 0xFE,
  0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x07, 0xF1, 0xF8, 0x3F, 0x8F, 0xC1, 0xFC,
  0x7F, 0x0F, 0xC3, 0xFD, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x81,
  0x03, 0xFC, 0x1E, 0x3F, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x01, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xEF, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7F, 0x3F, 0x87, 0xF3, 0xF8,
  0x7F, 0x3F, 0x87, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xE3, 0xF0, 0xFE, 0x7F,
  0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0xCF,
  0xE1, 0xFC, 0x03, 0xC0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F,
  0xC1, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF0, 0x3F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0x00, 0x0E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xF1, 0xFC, 0x7F,
  0x87, 0xF3, 0xFC, 0x1F, 0xDF, 0xE0, 0x7F, 0x7F, 0x81, 0xFB, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x01, 0xFC, 0xFC, 0x07, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE,
  0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xF0, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x83,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x0F, 0xCF,
  0x83, 0xE0, 0xFF, 0xFE, 0x7F, 0x87, 0xFF, 0xF7, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xEF, 0xFD, 0xFC, 0xFE, 0x3F, 0x8F, 0xE7,
  0xF1, 0xFC, 0x7F, 0x3F, 0x8F, 0xE3, 0xF9, 0xFC, 0x7F, 0x1F, 0xCF, 0xE3,
  0xF8, 0xFE, 0x7E, 0x1F, 0x87, 0xF7, 0xF0, 0xFC, 0x3F, 0x3F, 0x8F, 0xE1,
  0xF9, 0xFC, 0x7F, 0x1F, 0xCF, 0xE3, 0xF8, 0xFE, 0x7F, 0x1F, 0xC7, 0xF3,
  0xF0, 0xFC, 0x3F, 0xBF, 0x87, 0xE1, 0xF9, 0xFC, 0x7F, 0x0F, 0xCF, 0xE3,
  0xF8, 0xFE, 0x7F, 0x1F, 0xC7, 0xF3, 0xF0, 0xFE, 0x3F, 0x80, 0x0F, 0xE7,
  0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0x87, 0xF3, 0xF8, 0x7F, 0x3F, 0x87, 0xF3, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3,
  0xF0, 0xFE, 0x3F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFC,
  0x7F, 0x1F, 0xC7, 0xE1, 0xFC, 0x7E, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFF,
  0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0x7F, 0x9F, 0xC3,
  0xF3, 0xF0, 0x7E, 0xFE, 0x0F, 0xDF, 0xC1, 0xFB, 0xF8, 0x3F, 0x7F, 0x0F,
  0xEF, 0xE1, 0xFD, 0xF8, 0x3F, 0xBF, 0x07, 0xF7, 0xE0, 0xFC, 0xFC, 0x3F,
  0x9F, 0xEF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF0,
  0x01, 0xF8, 0x00, 0x07, 0xF7, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xEF, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF0, 0x7F, 0xBF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x03, 0xF1, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0xFF, 0x7E,
  0x1F, 0xF7, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFB, 0xFE, 0x7F, 0x0F,
  0xC7, 0xE0, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1,
  0xFC, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x8F, 0xC3, 0xF8, 0xFC,
  0x3F, 0x8F, 0xE7, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF0, 0x1F, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x1F, 0xDE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF,
  0xE3, 0xFF, 0xCF, 0xFF, 0x9F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x01,
  0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xCF, 0xE3,
  0xF3, 0xF0, 0xFC, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF3, 0xF0, 0xFE, 0xFC,
  0x3F, 0xBF, 0x0F, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFE,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x3F,
  0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xF7, 0xFF, 0x87, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x01, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x1F,
  0x00, 0x3F, 0x87, 0xF3, 0xF8, 0x7F, 0x3F, 0x87, 0xE3, 0xF8, 0xFE, 0x3F,
  0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xC7,
  0xF1, 0xFC, 0x7E, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xF8,
  0xFE, 0x1F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xF7, 0xF8, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFB, 0xF0, 0x1F, 0x3F, 0x00, 0xFE,
  0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0xFF, 0x7F, 0x1F, 0xCF, 0xE3, 0xF8, 0xFC,
  0xFE, 0x1F, 0x9F, 0xC3, 0xF3, 0xF0, 0x7E, 0xFE, 0x0F, 0xDF, 0xC1, 0xFB,
  0xF0, 0x3F, 0x7E, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x3E, 0x1F, 0xFF, 0x1F, 0x1F,
  0xFF, 0x9F, 0x8F, 0xDF, 0x8F, 0xC7, 0xEF, 0xC7, 0xE7, 0xF7, 0xE7, 0xF3,
  0xF3, 0xF3, 0xF9, 0xF9, 0xF9, 0xFC, 0xFC, 0x7D, 0xFE, 0xFC, 0x3E, 0xFF,
  0x7E, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF, 0xFF, 0x07, 0xFD, 0xFF, 0x83, 0xFE,
  0xFF, 0xC1, 0xFF, 0x7F, 0xC0, 0xFF, 0x3F, 0xE0, 0x7F, 0x9F, 0xE0, 0x3F,
  0x8F, 0xF0, 0x1F, 0xC7, 0xF8, 0x0F, 0xE3, 0xF8, 0x07, 0xE1, 0xFC, 0x03,
  0xF0, 0xFE, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xFC, 0x1F, 0x8F, 0xF0,
  0x7F, 0x3F, 0x81, 0xFD, 0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0xDF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0x7E, 0x01, 0xFD, 0xFC, 0x0F, 0xE7,
  0xF0, 0x3F, 0x8F, 0xC1, 0xFC, 0x3F, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3,
  0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0,
  0x3F, 0x3F, 0xC0, 0xFC, 0xFE, 0x03, 0xF3, 0xF8, 0x0F, 0xDF, 0xC0, 0x3F,
  0x7F, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x00,
  0x00, 0x10, 0x03, 0x80, 0x3C, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x80,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7C, 0x03,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x20, 0x00, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70,
  0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0E, 0x00, 0x02, 0x00, 0x1C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFE, 0x03, 0xF0,
  0x0F, 0x01, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x06, 0x00, 0x00,
  0x0F, 0x80, 0x01, 0xFC, 0x1F, 0x3F, 0xE1, 0xF3, 0xFF, 0x1F, 0x7F, 0xFB,
  0xF7, 0xEF, 0xFE, 0x7C, 0x7F, 0xEF, 0x87, 0xFC, 0xF8, 0x3F, 0x80, 0x00,
  0xF0,
};

const GFXglyph RobotoCondensed_BlackItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 12, 31, 11, 0, -31 },
  { 48, 13, 12, 13, 2, -32 },
  { 68, 22, 31, 21, 0, -31 },
  { 154, 20, 39, 21, 1, -35 },
  { 252, 20, 31, 27, 4, -31 },
  { 330, 23, 31, 25, 0, -31 },
  { 420, 7, 12, 6, 2, -32 },
  { 431, 13, 43, 14, 2, -34 },
  { 501, 14, 43, 13, -2, -34 },
  { 577, 19, 19, 19, 2, -31 },
  { 623, 18, 22, 19, 1, -25 },
  { 673, 9, 14, 11, -2, -5 },
  { 689, 12, 5, 18, 3, -15 },
  { 697, 7, 7, 13, 1, -7 },
  { 704, 19, 34, 13, -3, -31 },
  { 785, 19, 31, 21, 2, -31 },
  { 859, 13, 31, 21, 5, -31 },
  { 910, 21, 31, 21, 0, -31 },
  { 992, 21, 31, 21, 0, -31 },
  { 1074, 20, 31, 21, 1, -31 },
  { 1152, 20, 31, 21, 1, -31 },
  { 1230, 19, 31, 21, 1, -31 },
  { 1304, 21, 31, 21, 1, -31 },
  { 1386, 20, 31, 21, 1, -31 },
  { 1464, 18, 31, 21, 3, -31 },
  { 1534, 10, 24, 12, 1, -24 },
  { 1564, 13, 33, 12, -2, -24 },
  { 1618, 17, 20, 19, 1, -23 },
  { 1661, 19, 14, 22, 1, -20 },
  { 1695, 18, 21, 19, 0, -23 },
  { 1743, 17, 31, 19, 3, -31 },
  { 1809, 31, 40, 32, 0, -30 },
  { 1964, 25, 31, 25, -2, -31 },
  { 2061, 23, 31, 24, 0, -31 },
  { 2151, 23, 31, 24, 1, -31 },
  { 2241, 23, 31, 23, 0, -31 },
  { 2331, 23, 31, 20, 0, -31 },
  { 2421, 22, 31, 20, 0, -31 },
  { 2507, 23, 31, 25, 1, -31 },
  { 2597, 27, 31, 25, 0, -31 },
  { 2702, 12, 31, 12, 0, -31 },
  { 2749, 22, 31, 21, 0, -31 },
  { 2835, 27, 31, 23, 0, -31 },
  { 2940, 18, 31, 20, 0, -31 },
  { 3010, 33, 31, 32, 0, -31 },
  { 3138, 27, 31, 25, 0, -31 },
  { 3243, 24, 31, 25, 1, -31 },
  { 3336, 24, 31, 24, 0, -31 },
  { 3429, 24, 37, 25, 1, -31 },
  { 3540, 24, 31, 24, 0, -31 },
  { 3633, 22, 31, 23, 1, -31 },
  { 3719, 22, 31, 23, 3, -31 },
  { 3805, 24, 31, 24, 1, -31 },
  { 3898, 24, 31, 24, 3, -31 },
  { 3991, 30, 31, 31, 3, -31 },
  { 4108, 28, 31, 24, -2, -31 },
  { 4217, 23, 31, 23, 3, -31 },
  { 4307, 25, 31, 22, -1, -31 },
  { 4404, 15, 43, 11, -1, -36 },
  { 4485, 11, 34, 16, 3, -31 },
  { 4532, 15, 43, 11, -2, -36 },
  { 4613, 15, 15, 17, 1, -31 },
  { 4642, 17, 5, 17, -3, 0 },
  { 4653, 10, 7, 14, 4, -33 },
  { 4662, 18, 23, 19, 0, -23 },
  { 4714, 20, 32, 21, 0, -32 },
  { 4794, 18, 23, 19, 1, -23 },
  { 4846, 21, 32, 21, 1, -32 },
  { 4930, 18, 23, 20, 1, -23 },
  { 4982, 16, 32, 14, 1, -32 },
  { 5046, 21, 32, 21, 0, -23 },
  { 5130, 20, 32, 21, -1, -32 },
  { 5210, 12, 32, 11, 0, -32 },
  { 5258, 17, 41, 11, -5, -32 },
  { 5346, 22, 32, 20, 0, -32 },
  { 5434, 12, 32, 11, 0, -32 },
  { 5482, 29, 23, 31, 0, -23 },
  { 5566, 20, 23, 21, -1, -23 },
  { 5624, 19, 23, 21, 1, -23 },
  { 5679, 22, 32, 21, -2, -23 },
  { 5767, 20, 32, 21, 1, -23 },
  { 5847, 15, 23, 14, 0, -23 },
  { 5891, 18, 23, 19, 0, -23 },
  { 5943, 13, 28, 13, 1, -28 },
  { 5989, 20, 23, 21, 1, -23 },
  { 6047, 19, 23, 19, 2, -23 },
  { 6102, 25, 23, 26, 2, -23 },
  { 6174, 22, 23, 19, -2, -23 },
  { 6238, 22, 32, 19, -1, -23 },
  { 6326, 20, 23, 19, -1, -23 },
  { 6384, 13, 42, 12, 1, -34 },
  { 6453, 9, 37, 11, 1, -31 },
  { 6495, 13, 42, 12, -1, -34 },
  { 6564, 20, 10, 23, 1, -18 },
};

const GFXfont RobotoCondensed_BlackItalic43pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic43pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic43pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOCONDENSED_BLACKITALIC43PT7B_H_
