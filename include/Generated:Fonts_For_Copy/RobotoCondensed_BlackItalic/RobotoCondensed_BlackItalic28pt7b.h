#ifndef _ROBOTOCONDENSED_BLACKITALIC28PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x38, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF8, 0x70, 0x73, 0xB9, 0xDC,
  0xEE, 0xE7, 0x77, 0x3B, 0x9D, 0xCC, 0x01, 0x98, 0x0E, 0xE0, 0x3B, 0x80,
  0xCC, 0x07, 0x70, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x0E, 0xE0, 0x3B, 0x00,
  0xDC, 0x07, 0x70, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x0E, 0xE0, 0x33, 0x01,
  0xDC, 0x07, 0x70, 0x1D, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x0F, 0x80,
  0xFE, 0x0F, 0xF8, 0xFF, 0xC7, 0x9F, 0x3C, 0xF9, 0xE0, 0x0F, 0x00, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0x79,
  0xFF, 0xC7, 0xFC, 0x3F, 0xC0, 0x7C, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x00,
  0x1C, 0x01, 0xF8, 0x07, 0x71, 0x1D, 0xCE, 0xE7, 0x33, 0x9D, 0xC7, 0xFE,
  0x1F, 0xF0, 0x3D, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xBC, 0x0F, 0xF8, 0x7F,
  0xE1, 0xB9, 0xCE, 0xE7, 0x73, 0x9C, 0x8E, 0xE0, 0x1F, 0x80, 0x3C, 0x03,
  0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC1, 0xE7, 0x83, 0xCE, 0x07, 0xBC,
  0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0x00, 0xFE, 0x79, 0xFE, 0xF7, 0xBF, 0xDF,
  0x7F, 0xBE, 0x7F, 0x7C, 0xFC, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFB,
  0xE0, 0x7B, 0xDC, 0xE7, 0x39, 0x9C, 0x01, 0x01, 0xC1, 0xE1, 0xE0, 0xE0,
  0xE0, 0x70, 0x78, 0x38, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x1C, 0x06,
  0x02, 0x00, 0x08, 0x06, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1,
  0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x78, 0x38, 0x10, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0xC6, 0x27, 0xBF, 0x3F, 0xFC, 0x3F, 0x01, 0xE0, 0x3F,
  0x83, 0xCE, 0x1C, 0x70, 0x01, 0x00, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xC0, 0x78, 0x0F, 0x03, 0xE0,
  0x78, 0x00, 0x1E, 0x3C, 0x70, 0xE3, 0xC7, 0x9E, 0x38, 0x20, 0xFF, 0xFE,
  0xFE, 0xFE, 0x33, 0xDE, 0xF7, 0x80, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xF0,
  0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0x07, 0xC0, 0xFE, 0x1F, 0xF3, 0xFF, 0x3C, 0xF7, 0xCF,
  0x78, 0xF7, 0x8F, 0x78, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0xF1, 0xFF, 0x1E,
  0xF1, 0xEF, 0x1E, 0xFF, 0xC7, 0xFC, 0x7F, 0x81, 0xE0, 0x01, 0x87, 0xCF,
  0xDF, 0xEF, 0xF7, 0x78, 0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE1,
  0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0x3F, 0xC1,
  0xFF, 0x87, 0xFE, 0x3E, 0x78, 0xF1, 0xE3, 0xC7, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80,
  0x7F, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x03, 0xE0, 0x3F, 0xC1, 0xFF,
  0x8F, 0xFE, 0x3E, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x7E, 0x07, 0xF0, 0x1F,
  0x00, 0x7E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xCF, 0x8F, 0x3E, 0x7C, 0x7F,
  0xF1, 0xFF, 0x83, 0xFC, 0x07, 0xC0, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x80,
  0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x0E, 0xF0, 0x7F, 0xC3,
  0xDF, 0x0E, 0x7C, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x1F, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0xC7, 0xFE,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0xCF,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xCF, 0x8F, 0x1E, 0x3C, 0x7F, 0xF1, 0xFF,
  0x83, 0xFC, 0x03, 0xC0, 0x01, 0xE0, 0x7E, 0x0F, 0xE1, 0xFE, 0x3F, 0x03,
  0xE0, 0x7C, 0x07, 0xBC, 0x7F, 0xEF, 0xFE, 0xFF, 0xFF, 0x9F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1E, 0xFF, 0xE7, 0xFC, 0x3F, 0x81, 0xF0, 0x3F, 0xFD,
  0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0xFF,
  0x07, 0xFC, 0x7F, 0xE3, 0xCF, 0x9E, 0x78, 0xF3, 0xC7, 0xFE, 0x1F, 0xE1,
  0xFC, 0x1F, 0xF1, 0xF3, 0xCF, 0x1E, 0x78, 0xF3, 0xC7, 0x9E, 0x7C, 0xFF,
  0xE7, 0xFE, 0x1F, 0xE0, 0x7E, 0x00, 0x0F, 0x83, 0xF8, 0xFF, 0x3F, 0xF7,
  0x9F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xEF, 0xFF, 0xF7, 0xFC,
  0x7F, 0x81, 0xF0, 0x7C, 0x7F, 0x0F, 0xC1, 0xF0, 0x38, 0x00, 0x18, 0xF7,
  0xCF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x18, 0xF3, 0xEF, 0x1C, 0x06, 0x0F,
  0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0x60, 0x00, 0x10, 0x0F, 0x03,
  0xE0, 0xFE, 0x3F, 0xC7, 0xF0, 0x78, 0x07, 0xE0, 0x7F, 0x81, 0xFC, 0x07,
  0xC0, 0x1C, 0x00, 0x40, 0x3F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xC0, 0x10, 0x03, 0x80,
  0x3E, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xF0, 0x3E, 0x1F, 0xE7, 0xFC,
  0x7F, 0x07, 0xC0, 0x60, 0x08, 0x00, 0x1F, 0x07, 0xF1, 0xFF, 0x7F, 0xEF,
  0x3F, 0xE7, 0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x03, 0xC0,
  0x78, 0x00, 0x01, 0x80, 0x78, 0x1F, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0xF8, 0x03, 0xE3, 0xC0, 0x78, 0x0E, 0x0E, 0x00, 0x61, 0xE0,
  0x06, 0x1C, 0x3C, 0x73, 0x8F, 0xF7, 0x39, 0xFE, 0x77, 0x1C, 0xE7, 0x73,
  0x8E, 0x77, 0x38, 0xE7, 0x67, 0x9C, 0x7E, 0x79, 0xC6, 0xE7, 0x1C, 0xEE,
  0x73, 0xCC, 0xE7, 0xFD, 0xCE, 0x3F, 0xF8, 0xE3, 0xCF, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xBC, 0x07, 0xBE, 0x0F, 0x1E, 0x0F,
  0x1E, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x7C, 0x1E, 0x7C,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF8, 0xFF,
  0xF1, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x3E, 0x3F, 0xFC, 0x7F, 0xE0,
  0xFF, 0xE3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9E, 0x1F, 0x3C, 0x3E, 0xFF,
  0xF9, 0xFF, 0xF3, 0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x7F,
  0xF1, 0xFF, 0xE3, 0xC3, 0xCF, 0x87, 0xDE, 0x0F, 0xBC, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x0F, 0x3C, 0x1E, 0x7C,
  0x7C, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x1F, 0xE0, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xE1, 0xE3, 0xC7, 0xC7, 0xCF, 0x8F, 0x9F, 0x1F,
  0x3C, 0x3E, 0x78, 0x7C, 0xF0, 0xF3, 0xE1, 0xE7, 0xC7, 0xCF, 0x8F, 0x9E,
  0x1F, 0x3C, 0x7C, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x00, 0x1F,
  0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE1, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x87, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF,
  0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x1F, 0xFC, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xE3, 0xEF, 0x83, 0xDF,
  0x07, 0xBC, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE7, 0xF7, 0xCF, 0xEF, 0x9F,
  0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3C, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0,
  0xFE, 0x00, 0x1F, 0x07, 0x8F, 0x87, 0xC7, 0x83, 0xE3, 0xC1, 0xF1, 0xE0,
  0xF9, 0xF0, 0x78, 0xF8, 0x3C, 0x7C, 0x3E, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xC1, 0xE3, 0xE1, 0xF1, 0xE0, 0xF8, 0xF0, 0x7C,
  0xF8, 0x3C, 0x7C, 0x1E, 0x3E, 0x0F, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x7C, 0x7C, 0x7C,
  0x78, 0x78, 0x78, 0xF8, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0xCF, 0x9F, 0x3E, 0x78, 0xFF, 0xE1, 0xFF,
  0x07, 0xF8, 0x07, 0xC0, 0x1F, 0x1F, 0x87, 0xC7, 0xC1, 0xE3, 0xF0, 0x78,
  0xF8, 0x1E, 0x7C, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xDF, 0x01, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE1,
  0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0x1F, 0x81, 0xF8, 0xFC, 0x0F,
  0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xF1, 0xF8, 0x3F, 0x9F, 0xC3, 0xF8, 0xFF,
  0x1F, 0xC7, 0xF9, 0xFE, 0x3F, 0xCE, 0xF1, 0xEE, 0x7F, 0x8F, 0x77, 0xFC,
  0xFB, 0xBB, 0xC7, 0xDF, 0xDE, 0x3C, 0xFD, 0xF1, 0xE7, 0xEF, 0x8F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xC7, 0xCF, 0x9E, 0x3E, 0x78, 0xF1, 0xF3, 0xCF, 0x80,
  0x1F, 0x07, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xF1, 0xF1, 0xF8, 0xF1, 0xFC,
  0x78, 0xFE, 0x3C, 0x7F, 0x3E, 0x3D, 0xDF, 0x1E, 0xEF, 0x8F, 0x77, 0x8F,
  0x9B, 0xC7, 0xCF, 0xE3, 0xE7, 0xF1, 0xE3, 0xF8, 0xF1, 0xFC, 0xF8, 0x7C,
  0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0xF0, 0x7F,
  0xF1, 0xFF, 0xE3, 0xE3, 0xEF, 0x87, 0xDF, 0x0F, 0xBC, 0x1F, 0x78, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xEF, 0x83, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C,
  0x7C, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x1F, 0xF0, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFE, 0x1E, 0x1E, 0x3E, 0x1E, 0x3E, 0x1E, 0x3E,
  0x1E, 0x3C, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xE0, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xE3, 0xEF, 0x87,
  0xDF, 0x0F, 0xBC, 0x1F, 0x78, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xEF,
  0x83, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x7C, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF,
  0x80, 0x7F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x20, 0x1F, 0xF0,
  0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF1, 0xE1, 0xE7, 0xC3, 0xCF, 0x87, 0x9F,
  0x1F, 0x3C, 0x3E, 0x7F, 0xF8, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0x0F, 0xBE,
  0x1E, 0x7C, 0x3C, 0x78, 0x78, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xC0,
  0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF1, 0xF3, 0xE7, 0xC3, 0xC7,
  0x80, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F,
  0x8F, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x7F, 0xF8, 0x7F, 0xE0, 0x7F, 0x80,
  0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3E, 0x1E, 0x7C, 0x3C, 0xF0, 0xF9, 0xE1, 0xF3, 0xC3, 0xEF, 0x87,
  0x9F, 0x0F, 0x3E, 0x1E, 0x78, 0x7C, 0xF0, 0xFB, 0xE1, 0xF7, 0xC3, 0xCF,
  0x87, 0x9F, 0x0F, 0x3E, 0x3E, 0x7C, 0x7C, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF,
  0x80, 0xFC, 0x00, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0x78,
  0x7C, 0x78, 0xF8, 0x78, 0xF8, 0x78, 0xF0, 0x79, 0xF0, 0x79, 0xF0, 0x79,
  0xE0, 0x7B, 0xE0, 0x7B, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0xF8, 0xF1, 0xEF, 0x9F, 0x1E,
  0xF9, 0xF3, 0xEF, 0x9F, 0x3E, 0xFB, 0xF3, 0xCF, 0xBF, 0x7C, 0xFB, 0xF7,
  0xCF, 0xFF, 0x78, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFC,
  0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0x8F, 0x80, 0x1F, 0x0F, 0xC3,
  0xC3, 0xE0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0xBE, 0x01, 0xEF, 0x80, 0x7F,
  0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x0F, 0xF8, 0x03, 0xDE, 0x01, 0xF7, 0x80, 0xF9, 0xE0, 0x3E, 0x7C, 0x1F,
  0x1F, 0x07, 0xC7, 0xC3, 0xF0, 0xF8, 0xF8, 0x3E, 0xF0, 0xF9, 0xE1, 0xF3,
  0xC7, 0xC7, 0x8F, 0x0F, 0xBE, 0x0F, 0x78, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x80, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0x87, 0xFF,
  0xC7, 0xFF, 0xC3, 0xFF, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xFF, 0x00, 0x07, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x03, 0xC0, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1F, 0x07,
  0xC3, 0xF0, 0xF1, 0xF3, 0xE7, 0xC7, 0x8F, 0x1E, 0x3C, 0x7C, 0xF9, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1F, 0x3E, 0x7C, 0x78, 0xF1, 0xE3, 0xC0, 0x07, 0xC1,
  0xF0, 0xFC, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E,
  0x07, 0x83, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0xC3, 0xF0, 0x07, 0x03, 0xC0,
  0xF0, 0x7E, 0x1F, 0x8E, 0xE3, 0xB9, 0xCE, 0xF3, 0xB8, 0xF0, 0x7F, 0xEF,
  0xFF, 0xFF, 0x80, 0xF9, 0xE3, 0xC7, 0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0xDF,
  0x7D, 0xF0, 0x1F, 0x1F, 0xF3, 0xFE, 0x7D, 0xEF, 0x9E, 0xF1, 0xEF, 0x3E,
  0xFF, 0xE7, 0xFE, 0x3B, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xFF, 0x87, 0xFE, 0x3F, 0xF1, 0xFF, 0xCF, 0x3E, 0xF9,
  0xF7, 0xCF, 0xBC, 0x7D, 0xE3, 0xCF, 0x1E, 0x78, 0xF7, 0xFF, 0xBF, 0xF9,
  0xFF, 0xCF, 0x78, 0x00, 0x07, 0xC1, 0xFE, 0x3F, 0xE3, 0xFF, 0x78, 0xF7,
  0x8F, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x9E, 0xF9, 0xE7, 0xFE, 0x7F, 0xC3,
  0xF8, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0xF7, 0x87, 0xFE, 0x3F, 0xF9, 0xFF, 0xE7, 0xCF, 0x9E, 0x3C,
  0x78, 0xF1, 0xE3, 0xCF, 0x8F, 0x3E, 0x7C, 0xF9, 0xF1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x3D, 0xE0, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0x7F, 0xE7, 0xCF,
  0x3C, 0x79, 0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xC0, 0x1E, 0x10, 0xFF, 0x87,
  0xFE, 0x1F, 0xF0, 0x3E, 0x00, 0x07, 0xC3, 0xF1, 0xFC, 0x7F, 0x3E, 0x0F,
  0x8F, 0xFB, 0xFC, 0xFF, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x3C, 0x7F, 0xF3,
  0xFF, 0x8F, 0xFE, 0x7C, 0x79, 0xE3, 0xE7, 0x8F, 0x9E, 0x3E, 0xF8, 0xF3,
  0xE3, 0xCF, 0x8F, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC1, 0xFE, 0x00, 0x78,
  0x03, 0xE1, 0x9F, 0x8F, 0xFC, 0x3F, 0xE0, 0x7E, 0x00, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0x87, 0xFE, 0x3F, 0xF1,
  0xFF, 0x9F, 0x3E, 0xF9, 0xF7, 0x8F, 0x3C, 0x79, 0xE3, 0xCF, 0x3E, 0xF9,
  0xF7, 0xCF, 0xBC, 0x79, 0xE3, 0xCF, 0x1E, 0x00, 0x00, 0x1E, 0x1F, 0x1F,
  0x0E, 0x00, 0x00, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x7C, 0x78,
  0x78, 0x78, 0x78, 0xF8, 0xF8, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x81, 0xF0,
  0x1C, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x78, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x9F, 0x1E, 0x7C,
  0x3D, 0xF0, 0x7B, 0xE0, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7B, 0xE1, 0xF7, 0xC3, 0xE7, 0x87, 0x8F, 0x8F, 0x1F,
  0x00, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C,
  0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0xF8, 0xF8, 0xF0, 0x3D, 0xE3,
  0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xCF, 0x1E, 0xF9, 0xE3,
  0xDF, 0x3C, 0xFB, 0xC7, 0x9F, 0x79, 0xF3, 0xCF, 0x3E, 0x79, 0xE7, 0xCF,
  0x7C, 0xF1, 0xEF, 0x9E, 0x7D, 0xE3, 0xCF, 0xBC, 0xF9, 0xE0, 0x3D, 0xE1,
  0xFF, 0x8F, 0xFC, 0x7F, 0xF7, 0xCF, 0xBE, 0x7D, 0xE3, 0xCF, 0x1E, 0x78,
  0xF3, 0xCF, 0xBE, 0x7D, 0xF3, 0xEF, 0x1E, 0x78, 0xF3, 0xC7, 0x80, 0x07,
  0xC0, 0xFF, 0x0F, 0xFC, 0x7F, 0xE7, 0xCF, 0xBC, 0x7D, 0xE3, 0xEF, 0x1F,
  0xF8, 0xF7, 0xC7, 0x9E, 0x3C, 0xFF, 0xC7, 0xFE, 0x1F, 0xE0, 0x7C, 0x00,
  0x1E, 0xF0, 0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x1E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x1F, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x9F, 0xFE, 0x7F, 0xF1, 0xFF,
  0xC7, 0xBC, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x00, 0x0F, 0x78, 0xFF, 0xCF, 0xFE, 0xFF, 0xF7, 0xCF, 0xBC, 0x79, 0xE3,
  0xCF, 0x1E, 0xF8, 0xF7, 0xCF, 0xBE, 0x7C, 0xFF, 0xC7, 0xFE, 0x3F, 0xF0,
  0xF7, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0x3D, 0xCF, 0xF3, 0xFC, 0xFF, 0x3E, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E,
  0x07, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x00, 0x0F, 0x81, 0xFE, 0x3F, 0xE7,
  0xCF, 0x78, 0xF7, 0xC0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0x3E, 0xF1, 0xEF,
  0x3E, 0xFF, 0xC7, 0xF8, 0x1F, 0x00, 0x3E, 0x3E, 0x3C, 0xFF, 0xFF, 0xFF,
  0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0xF8, 0xF8, 0xFC, 0xFC, 0x7C, 0x3C,
  0x7C, 0xF3, 0xC7, 0x9E, 0x3C, 0xF1, 0xEF, 0x9F, 0x7C, 0xFB, 0xE7, 0x9E,
  0x3C, 0xF1, 0xE7, 0x9F, 0x3C, 0xF9, 0xFF, 0xCF, 0xFC, 0x7F, 0xE1, 0xEF,
  0x00, 0xF9, 0xFF, 0x9F, 0x79, 0xE7, 0xBE, 0x7B, 0xE7, 0xBC, 0x7B, 0xC7,
  0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x07, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x00,
  0xF3, 0x9F, 0xF7, 0x9E, 0xF7, 0x9E, 0xE7, 0xBE, 0xEF, 0xBC, 0xEF, 0xBC,
  0xEF, 0xB8, 0xFD, 0xF8, 0xFD, 0xF8, 0xFD, 0xF0, 0xF9, 0xF0, 0xF9, 0xF0,
  0xF1, 0xE0, 0xF1, 0xE0, 0xF1, 0xE0, 0x1E, 0x7C, 0x79, 0xE1, 0xEF, 0x87,
  0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x83,
  0xFE, 0x0F, 0x78, 0x7D, 0xE1, 0xE7, 0xCF, 0x9F, 0x00, 0x3E, 0x3C, 0x7C,
  0xF8, 0x79, 0xF0, 0xF7, 0xC1, 0xEF, 0x83, 0xDE, 0x07, 0xFC, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x00,
  0x00, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xC0, 0x3E, 0x03, 0xE0, 0x3E,
  0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xFF, 0xCF, 0xFC, 0x7F, 0xE3,
  0xFF, 0x00, 0x01, 0x01, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x07, 0x87, 0x83, 0x81, 0xE0, 0xF0, 0x38, 0x1C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x1C, 0x02, 0x00, 0x0C, 0x18, 0x30,
  0x61, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x87, 0x0C, 0x18, 0x30,
  0xE1, 0xC3, 0x86, 0x0C, 0x18, 0x70, 0x08, 0x07, 0x03, 0x81, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xE0, 0x78, 0x38, 0x3C, 0x3C,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0xF0, 0x70, 0x10,
  0x00, 0x3C, 0x3B, 0xF3, 0xFF, 0xFD, 0xFF, 0xEE, 0x3E, 0x00, 0xE0,
};

const GFXglyph RobotoCondensed_BlackItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 20, 7, 0, -20 },
  { 21, 9, 8, 9, 1, -21 },
  { 30, 14, 20, 14, 0, -20 },
  { 65, 13, 26, 14, 1, -23 },
  { 108, 14, 20, 17, 2, -20 },
  { 143, 15, 20, 16, 0, -20 },
  { 181, 5, 8, 4, 1, -21 },
  { 186, 9, 28, 9, 1, -22 },
  { 218, 9, 28, 9, -1, -22 },
  { 250, 13, 12, 13, 1, -20 },
  { 270, 11, 14, 13, 1, -16 },
  { 290, 7, 9, 7, -2, -3 },
  { 298, 8, 4, 11, 2, -11 },
  { 302, 5, 5, 8, 0, -5 },
  { 306, 12, 22, 8, -2, -20 },
  { 339, 12, 20, 14, 1, -20 },
  { 369, 9, 20, 14, 3, -20 },
  { 392, 14, 20, 14, 0, -20 },
  { 427, 14, 20, 14, 0, -20 },
  { 462, 14, 20, 14, 0, -20 },
  { 497, 14, 20, 14, 0, -20 },
  { 532, 12, 20, 14, 1, -20 },
  { 562, 14, 20, 14, 1, -20 },
  { 597, 13, 20, 14, 1, -20 },
  { 630, 11, 20, 14, 2, -20 },
  { 658, 6, 16, 8, 1, -16 },
  { 670, 8, 22, 8, -1, -16 },
  { 692, 12, 13, 12, 0, -15 },
  { 712, 12, 11, 14, 1, -14 },
  { 729, 12, 14, 12, 0, -15 },
  { 750, 11, 20, 12, 2, -20 },
  { 778, 20, 25, 21, 0, -19 },
  { 841, 16, 20, 16, -1, -20 },
  { 881, 15, 20, 15, 0, -20 },
  { 919, 15, 20, 16, 1, -20 },
  { 957, 15, 20, 15, 0, -20 },
  { 995, 15, 20, 13, 0, -20 },
  { 1033, 14, 20, 13, 0, -20 },
  { 1068, 15, 20, 16, 1, -20 },
  { 1106, 17, 20, 17, 0, -20 },
  { 1149, 8, 20, 8, 0, -20 },
  { 1169, 14, 20, 13, 0, -20 },
  { 1204, 18, 20, 15, 0, -20 },
  { 1249, 12, 20, 13, 0, -20 },
  { 1279, 21, 20, 21, 0, -20 },
  { 1332, 17, 20, 17, 0, -20 },
  { 1375, 15, 20, 16, 1, -20 },
  { 1413, 16, 20, 16, 0, -20 },
  { 1453, 15, 24, 16, 1, -20 },
  { 1498, 15, 20, 15, 0, -20 },
  { 1536, 15, 20, 15, 0, -20 },
  { 1574, 14, 20, 15, 2, -20 },
  { 1609, 15, 20, 16, 1, -20 },
  { 1647, 16, 20, 16, 2, -20 },
  { 1687, 20, 20, 20, 2, -20 },
  { 1737, 18, 20, 15, -1, -20 },
  { 1782, 15, 20, 15, 2, -20 },
  { 1820, 17, 20, 15, -1, -20 },
  { 1863, 10, 28, 7, -1, -23 },
  { 1898, 7, 22, 10, 2, -20 },
  { 1918, 10, 28, 7, -2, -23 },
  { 1953, 10, 10, 11, 1, -20 },
  { 1966, 11, 3, 11, -2, 0 },
  { 1971, 6, 4, 9, 3, -21 },
  { 1974, 12, 15, 13, 0, -15 },
  { 1997, 13, 21, 13, 0, -21 },
  { 2032, 12, 15, 12, 0, -15 },
  { 2055, 14, 21, 13, 0, -21 },
  { 2092, 13, 15, 13, 0, -15 },
  { 2117, 10, 21, 9, 1, -21 },
  { 2144, 14, 21, 14, 0, -15 },
  { 2181, 13, 21, 13, 0, -21 },
  { 2216, 8, 22, 7, 0, -22 },
  { 2238, 11, 28, 7, -3, -22 },
  { 2277, 15, 21, 13, 0, -21 },
  { 2317, 8, 21, 7, 0, -21 },
  { 2338, 19, 15, 20, 0, -15 },
  { 2374, 13, 15, 13, 0, -15 },
  { 2399, 13, 15, 13, 0, -15 },
  { 2424, 14, 21, 13, -1, -15 },
  { 2461, 13, 21, 13, 0, -15 },
  { 2496, 10, 15, 9, 0, -15 },
  { 2515, 12, 15, 12, 0, -15 },
  { 2538, 8, 18, 8, 1, -18 },
  { 2556, 13, 15, 13, 1, -15 },
  { 2581, 12, 15, 13, 1, -15 },
  { 2604, 16, 15, 17, 2, -15 },
  { 2634, 14, 15, 12, -1, -15 },
  { 2661, 15, 21, 13, -1, -15 },
  { 2701, 13, 15, 12, 0, -15 },
  { 2726, 9, 27, 8, 0, -22 },
  { 2757, 7, 24, 7, 0, -20 },
  { 2778, 9, 27, 8, -1, -22 },
  { 2809, 13, 6, 15, 1, -11 },
};

const GFXfont RobotoCondensed_BlackItalic28pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic28pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic28pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOCONDENSED_BLACKITALIC28PT7B_H_
