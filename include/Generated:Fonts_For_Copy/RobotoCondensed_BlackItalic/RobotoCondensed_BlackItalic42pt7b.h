#ifndef _ROBOTOCONDENSED_BLACKITALIC42PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x03, 0xC0, 0x7C, 0xFB,
  0xE7, 0xDF, 0x3E, 0xF9, 0xF7, 0x8F, 0x3C, 0x79, 0xE3, 0xDF, 0x3E, 0xF1,
  0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xC0, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80,
  0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x39, 0xE0, 0x03, 0xCF,
  0x00, 0x1E, 0x78, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF0, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0xF3, 0xC0,
  0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE0, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x01,
  0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0x9E, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0,
  0xFE, 0xFE, 0x1F, 0xC7, 0xE1, 0xFC, 0x7E, 0x1F, 0xC7, 0xF1, 0xF8, 0x7F,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0xFE, 0x1F, 0x8F, 0xE1, 0xF8, 0xFE, 0x1F, 0x8F, 0xE3, 0xF8, 0x7F,
  0x3F, 0x87, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x7F, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x1F, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0xF9, 0xE1,
  0xCF, 0x1E, 0x3C, 0xF1, 0xE7, 0xCF, 0x1E, 0x78, 0xF3, 0xEF, 0x0F, 0x3F,
  0xF0, 0xFF, 0xDE, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xE7, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xEF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0x79, 0xE1, 0xEF, 0x9E, 0x3C, 0xF1, 0xE3, 0xCF, 0x1E,
  0x78, 0xF1, 0xEF, 0x0F, 0x1E, 0x30, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xDF, 0x80, 0x7E, 0x7E, 0x01, 0xF1,
  0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x1F, 0x1F,
  0xFC, 0xFC, 0xFF, 0xFB, 0xF7, 0xFF, 0xEF, 0x9F, 0xDF, 0xFE, 0x7E, 0x7F,
  0xFB, 0xF8, 0xFF, 0xCF, 0xE3, 0xFF, 0x3F, 0x87, 0xF8, 0x7F, 0x3F, 0xE1,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFB, 0xF8, 0x1F,
  0x8F, 0xE0, 0x3E, 0x79, 0xF3, 0xE7, 0xCF, 0x9E, 0x3C, 0x79, 0xF3, 0xE7,
  0x80, 0x00, 0x10, 0x03, 0x80, 0x3E, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F,
  0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0E, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x06, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x07,
  0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x70, 0x01, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x1C,
  0x3C, 0x77, 0xCE, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xC1, 0xFF, 0x80, 0x3E,
  0x00, 0x3F, 0xC0, 0x1F, 0x78, 0x0F, 0xDE, 0x07, 0xE3, 0xC1, 0xF0, 0xF8,
  0x38, 0x1C, 0x00, 0x04, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x7F,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xE0, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x0F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF0, 0xF8, 0xFC, 0x7C, 0x7E, 0x3E, 0x3F, 0x1F, 0x03, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x39, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0x00,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE,
  0x1F, 0xFF, 0x87, 0xE7, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x7F, 0x0F, 0xDF,
  0xC3, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0xFE,
  0xFC, 0x3F, 0xBF, 0x0F, 0xCF, 0xC3, 0xF3, 0xF1, 0xFC, 0xFE, 0xFE, 0x3F,
  0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x00,
  0x0C, 0x01, 0xF0, 0x3F, 0x83, 0xFE, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F,
  0xFE, 0x7B, 0xF1, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0x87, 0xF1, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFE, 0x7F, 0x1F, 0xC3,
  0xF1, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0xFE, 0xFE, 0x0F, 0xC7, 0xE1, 0xFC, 0x7F, 0x3F, 0xC7, 0xFF, 0xF8,
  0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE,
  0x03, 0xEF, 0xC0, 0x7D, 0xF8, 0x1F, 0x7F, 0x07, 0xEF, 0xE0, 0xF9, 0xFC,
  0x3F, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x7C, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x81,
  0xE1, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xCF, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xE3, 0xF8, 0xFF, 0x7F,
  0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0x80, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xFB, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFE,
  0x7F, 0x7F, 0x1F, 0xDF, 0x83, 0xF7, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F,
  0xDF, 0x87, 0xF7, 0xE1, 0xFD, 0xF8, 0x7E, 0x7F, 0x7F, 0x8F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xDF, 0xC7, 0xF1, 0xF8, 0xFE, 0x3F, 0x1F,
  0x87, 0xE3, 0xF1, 0xFC, 0x7E, 0x3F, 0x8F, 0xEF, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xE3, 0xF1, 0xF8,
  0x7E, 0x7F, 0x0F, 0xCF, 0xE1, 0xF9, 0xFC, 0x3F, 0x3F, 0x8F, 0xE7, 0xF1,
  0xFC, 0xFE, 0x7F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF,
  0x80, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x03, 0xFE, 0x07, 0xFF, 0x83, 0xFF,
  0xE3, 0xFF, 0xF3, 0xF9, 0xF9, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xEF, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0xE1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x83,
  0x80, 0x01, 0xE0, 0x1F, 0x80, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xF8, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xC0,
  0x7C, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x0F,
  0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F,
  0x80, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0,
  0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x01, 0x00, 0x1F,
  0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF1, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x03,
  0x80, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x07, 0xF8, 0x0F, 0xFE,
  0x0F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0x00, 0x1F,
  0x00, 0x07, 0x00, 0x01, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xFE, 0x07, 0xFF,
  0x87, 0xFF, 0xE3, 0xFF, 0xFB, 0xF9, 0xFD, 0xFC, 0xFE, 0xFC, 0x7F, 0x7E,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFC, 0x01, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x3E, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x78, 0x3E, 0x07, 0xC0, 0xE0,
  0xF0, 0x7F, 0xC3, 0xC7, 0xC3, 0xFF, 0x8F, 0x1E, 0x1F, 0xFE, 0x3C, 0xF8,
  0x7C, 0xF8, 0xF3, 0xC3, 0xE3, 0xE3, 0xCF, 0x1F, 0x0F, 0x0F, 0x7C, 0x7C,
  0x3C, 0x3D, 0xE1, 0xF1, 0xF0, 0xF7, 0x8F, 0x87, 0xC7, 0x9E, 0x3E, 0x1E,
  0x1E, 0x78, 0xF8, 0x78, 0x7B, 0xE3, 0xE3, 0xE1, 0xEF, 0x8F, 0x8F, 0x8F,
  0x3E, 0x3E, 0x3C, 0x3C, 0xF8, 0xF9, 0xF1, 0xE3, 0xE3, 0xFF, 0xFF, 0x8F,
  0x8F, 0xF7, 0xFC, 0x1E, 0x1F, 0xDF, 0xE0, 0x78, 0x3C, 0x3E, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x03, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFE,
  0x03, 0xF0, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xC0, 0x7F,
  0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0x87,
  0xF0, 0x7F, 0x0F, 0xC0, 0xFE, 0x3F, 0x81, 0xF8, 0x7F, 0x07, 0xF0, 0xFE,
  0x1F, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xE1, 0xF8, 0x1F,
  0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC1, 0xFE, 0x3F, 0x83, 0xF8,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87,
  0xF0, 0x7F, 0x0F, 0xE0, 0x7E, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFE,
  0x03, 0xF9, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC,
  0x3F, 0x87, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xFC, 0x7F, 0x07,
  0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF3,
  0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8,
  0x3F, 0x8F, 0xC0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F,
  0x1F, 0xC3, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87,
  0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC3,
  0xFF, 0x3F, 0x8F, 0xFE, 0x7F, 0x1F, 0xFC, 0xFE, 0x3F, 0xF9, 0xFC, 0x7F,
  0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x8F, 0xC0, 0x7F, 0x1F, 0xC0, 0xFE,
  0x3F, 0x83, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x1F,
  0xC1, 0xFC, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xE0,
  0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F,
  0xC0, 0x3F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFC,
  0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1,
  0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F,
  0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x00, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F,
  0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x80,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0xC1, 0xFC, 0x1F, 0xE0, 0x7E, 0x0F,
  0xF0, 0x3F, 0x87, 0xFC, 0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0xFF, 0x00, 0xFE,
  0x3F, 0x80, 0x3F, 0x9F, 0xE0, 0x0F, 0xCF, 0xF0, 0x07, 0xF3, 0xF8, 0x01,
  0xFD, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xDF, 0xC0, 0x1F,
  0xE7, 0xF0, 0x07, 0xF1, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0,
  0x1F, 0x83, 0xF8, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x01,
  0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03,
  0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x0F,
  0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xBC, 0x3F, 0xFC, 0x1F, 0xBC, 0x3F,
  0xFC, 0x1F, 0xBC, 0x3F, 0xFC, 0x3F, 0xBC, 0x7D, 0xF8, 0x3F, 0xBE, 0x7D,
  0xF8, 0x3F, 0xBE, 0xFD, 0xF8, 0x3F, 0xBE, 0xFB, 0xF8, 0x3F, 0x3E, 0xFB,
  0xF8, 0x3F, 0x3F, 0xF3, 0xF8, 0x7F, 0x3F, 0xF3, 0xF0, 0x7F, 0x3F, 0xE7,
  0xF0, 0x7F, 0x3F, 0xE7, 0xF0, 0x7F, 0x1F, 0xE7, 0xF0, 0x7F, 0x1F, 0xC7,
  0xF0, 0x7E, 0x1F, 0xC7, 0xF0, 0xFE, 0x1F, 0x87, 0xE0, 0xFE, 0x1F, 0x8F,
  0xE0, 0xFE, 0x1F, 0x0F, 0xE0, 0xFE, 0x1F, 0x0F, 0xE0, 0x07, 0xF0, 0x1F,
  0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xF8,
  0x3F, 0x83, 0xFE, 0x0F, 0xE0, 0xFF, 0x83, 0xF8, 0x3F, 0xE0, 0xFE, 0x0F,
  0xFC, 0x3F, 0x07, 0xFF, 0x1F, 0xC1, 0xFF, 0xC7, 0xF0, 0x7F, 0xF1, 0xFC,
  0x1F, 0xFC, 0x7F, 0x07, 0xFF, 0x9F, 0xC3, 0xF9, 0xE7, 0xE0, 0xFE, 0x7B,
  0xF8, 0x3F, 0x9E, 0xFE, 0x0F, 0xE7, 0xBF, 0x83, 0xF8, 0xFF, 0xE0, 0xFE,
  0x3F, 0xF8, 0x7F, 0x0F, 0xFC, 0x1F, 0xC3, 0xFF, 0x07, 0xF0, 0xFF, 0xC1,
  0xFC, 0x1F, 0xF0, 0x7F, 0x07, 0xFC, 0x1F, 0x81, 0xFE, 0x0F, 0xE0, 0x7F,
  0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0x7F, 0x3F, 0x80,
  0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF7, 0xF0, 0x0F,
  0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0xFE, 0x7F, 0x01, 0xFC,
  0xFE, 0x03, 0xF9, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xE7, 0xE0, 0x1F, 0x8F,
  0xC0, 0x7F, 0x1F, 0x80, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0x87, 0xF0,
  0x7F, 0x0F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07,
  0xF1, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xF8,
  0x7F, 0x0F, 0xE0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03,
  0xF9, 0xFC, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F,
  0xBF, 0x80, 0x7E, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3,
  0xF0, 0x0F, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F,
  0x83, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x04, 0x00, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xC0, 0xFE,
  0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFC, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3,
  0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xF0, 0x7F, 0x0F, 0xE0, 0xFC, 0x1F,
  0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x8F, 0xE0, 0xFF, 0x1F, 0xC0, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x7F, 0xDF, 0xE1, 0xFC, 0x1F, 0x87, 0xF0, 0x7F, 0x1F,
  0xC1, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8,
  0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0xBF, 0xE1, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x7F, 0x0F, 0xE0, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F,
  0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F,
  0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F,
  0x81, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F,
  0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0xFE,
  0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF,
  0x01, 0xFC, 0xFF, 0x03, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x7F,
  0x07, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F,
  0x1F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F,
  0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x0F, 0xC3, 0xFF, 0xF0, 0xFE, 0x1F, 0xFF, 0x87, 0xF0, 0xFF, 0xFC, 0x3F,
  0x8F, 0xEF, 0xE3, 0xFC, 0x7F, 0x7F, 0x1F, 0xE3, 0xFB, 0xF8, 0xFF, 0x1F,
  0x9F, 0xCF, 0xF9, 0xFC, 0xFE, 0x7F, 0xCF, 0xE7, 0xF3, 0xFE, 0x7E, 0x1F,
  0xBF, 0xF7, 0xF0, 0xFD, 0xFF, 0xBF, 0x87, 0xEF, 0xFD, 0xF8, 0x3F, 0xFF,
  0xEF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xDF, 0xFC, 0x07,
  0xFE, 0xFF, 0xE0, 0x3F, 0xF3, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8,
  0xFF, 0x80, 0x7F, 0xC7, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE,
  0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0xFF, 0x01, 0xFC,
  0x1F, 0xC0, 0x1F, 0xC7, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x3F, 0xC0,
  0x0F, 0xE7, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xF7, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0x9F, 0xC0, 0x1F, 0xE3, 0xF8,
  0x03, 0xFC, 0x7F, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0xFE, 0x07, 0xF8,
  0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFD, 0xFC, 0x0F, 0xF7,
  0xF0, 0x3F, 0x9F, 0xC1, 0xFE, 0x7F, 0x07, 0xF0, 0xFC, 0x3F, 0x83, 0xF0,
  0xFE, 0x0F, 0xC7, 0xF0, 0x3F, 0x1F, 0xC0, 0xFE, 0xFE, 0x01, 0xFB, 0xF8,
  0x07, 0xEF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x0F, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFF, 0x07,
  0xDE, 0x1F, 0x3C, 0x3E, 0x78, 0xF8, 0xF1, 0xF1, 0xE7, 0xC3, 0xEF, 0x87,
  0xFF, 0x0F, 0x80, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xEF,
  0xFF, 0xF0, 0x7E, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x01, 0xFC,
  0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xCF, 0xE7, 0xF3,
  0xF9, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF,
  0xFE, 0x7F, 0xFF, 0xBF, 0xCF, 0xEF, 0xE3, 0xFB, 0xF8, 0xFC, 0xFE, 0x7F,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xCF, 0xC0,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x7C, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xF9,
  0xFE, 0x7F, 0x3F, 0x87, 0xE7, 0xF0, 0xFC, 0xFE, 0x1F, 0x9F, 0x87, 0xF3,
  0xF0, 0xFE, 0xFE, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0x7E, 0x7F, 0x0F, 0xCF,
  0xC1, 0xF9, 0xFC, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFB, 0xFE, 0x3F,
  0x7F, 0x87, 0xE7, 0xE0, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x87, 0xFF,
  0xE3, 0xFF, 0xF3, 0xF9, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0xFD,
  0xF8, 0xFE, 0xFE, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xF3, 0xF8, 0x1F, 0xDF, 0xC1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xE3, 0xF8, 0x7E, 0x1F, 0xC7,
  0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x1F,
  0xC3, 0xF0, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x87, 0xE1, 0xF8, 0x3F,
  0x9F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x03, 0xEF, 0xC0, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE,
  0x3F, 0xFF, 0x9F, 0xE7, 0xE7, 0xF0, 0xFD, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x10, 0xFF, 0x3C, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8,
  0x1F, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE1, 0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x81,
  0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0x0F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xF3, 0xF8, 0x3F, 0xDF, 0x83, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xE7, 0xF8, 0xFE, 0x1F, 0xC7,
  0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFC, 0x1F,
  0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0x7F,
  0x3F, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8,
  0x07, 0xDF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0x87,
  0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xEF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFE, 0xFF, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0x87, 0xF1, 0xF8, 0x7F, 0x3F, 0x87, 0xE3, 0xF8, 0x7E, 0x3F, 0x8F,
  0xE3, 0xF0, 0xFE, 0x3F, 0x0F, 0xE3, 0xF0, 0xFE, 0x7F, 0x0F, 0xC7, 0xF0,
  0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xFC, 0x7E, 0x1F, 0xCF, 0xE1, 0xFC, 0x01,
  0xC0, 0x7E, 0x07, 0xE0, 0xFF, 0x07, 0xE0, 0x7E, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x0E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF8,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x87, 0xF3, 0xFE, 0x1F, 0xCF, 0xF0, 0x7E,
  0x7F, 0x81, 0xFB, 0xFC, 0x0F, 0xEF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFD, 0xFC, 0x07, 0xE3,
  0xF0, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xC3, 0xFC,
  0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xF0,
  0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0x1F, 0xDF, 0x07, 0xC0, 0xFF, 0xFE, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xE7, 0xF9,
  0xF8, 0xFE, 0x3F, 0x8F, 0xC7, 0xF1, 0xFC, 0x7E, 0x3F, 0x8F, 0xC3, 0xF1,
  0xF8, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xFC, 0x7E, 0x3F, 0x8F, 0xE7, 0xF1,
  0xFC, 0x7F, 0x3F, 0x8F, 0xE3, 0xF9, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF0,
  0xFC, 0x7E, 0x1F, 0x8F, 0xE7, 0xF1, 0xFC, 0x7F, 0x3F, 0x8F, 0xE3, 0xF9,
  0xFC, 0x7F, 0x1F, 0xCF, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xE0, 0x0F,
  0xCF, 0x80, 0xFD, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF1,
  0xFE, 0xFF, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xF1, 0xF8, 0x7F,
  0x3F, 0x87, 0xE3, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F,
  0xE3, 0xF0, 0xFE, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1,
  0xFC, 0x7E, 0x1F, 0xC7, 0xE1, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF,
  0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xE7, 0xF7, 0xF1, 0xFD, 0xF8, 0x3F,
  0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0xFE, 0xFE, 0x7F, 0x3F, 0xFF, 0xC7, 0xFF,
  0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xF7, 0xC0, 0x3F,
  0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xF9, 0xFC,
  0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0,
  0xFE, 0x1F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xF8, 0x7F, 0x0F, 0xC3,
  0xF0, 0xFE, 0x1F, 0xCF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0x83, 0xFF, 0xF8, 0x1F, 0x9F, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xC7, 0xE1, 0xFE, 0xFC, 0x7F,
  0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFC, 0xFE, 0x3F, 0x9F, 0x87, 0xF7, 0xF0,
  0xFE, 0xFE, 0x1F, 0xDF, 0xC3, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC3,
  0xF9, 0xF8, 0x7F, 0x3F, 0x0F, 0xE7, 0xE1, 0xF8, 0xFE, 0x7F, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x3E, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xDE, 0x3F, 0x7C,
  0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x1F, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F,
  0xFF, 0xCF, 0xC7, 0xF3, 0xF1, 0xFC, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF3,
  0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F,
  0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x81, 0xFC,
  0x0F, 0xE1, 0xFF, 0xEF, 0xFE, 0x7F, 0xF3, 0xFF, 0xBF, 0xFC, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xFD, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x0F, 0xE0,
  0x3F, 0x00, 0x3F, 0x87, 0xE7, 0xF1, 0xFC, 0xFC, 0x3F, 0x9F, 0x87, 0xF3,
  0xF0, 0xFE, 0xFE, 0x1F, 0x9F, 0xC3, 0xF3, 0xF8, 0xFE, 0x7E, 0x1F, 0xCF,
  0xC3, 0xF9, 0xF8, 0x7E, 0x7F, 0x0F, 0xCF, 0xE3, 0xF9, 0xFC, 0x7F, 0x3F,
  0x0F, 0xE7, 0xE1, 0xFC, 0xFE, 0x7F, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0xFF, 0xF0, 0x3E, 0xFE, 0x00, 0xFE, 0x1F, 0xFF, 0x8F, 0xEF,
  0xE3, 0xFB, 0xF8, 0xFE, 0xFE, 0x7F, 0x1F, 0x9F, 0xC7, 0xE7, 0xE1, 0xFB,
  0xF8, 0x7E, 0xFE, 0x1F, 0xBF, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0xFC, 0x3E, 0x3F,
  0x7E, 0x3F, 0x1F, 0xBF, 0x1F, 0x8F, 0xDF, 0x8F, 0xCF, 0xCF, 0xCF, 0xE7,
  0xE7, 0xE7, 0xF3, 0xF3, 0xF3, 0xFB, 0xF1, 0xFB, 0xFD, 0xF8, 0xFD, 0xFE,
  0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFB, 0xFF, 0x07, 0xFD,
  0xFF, 0x03, 0xFC, 0xFF, 0x81, 0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0x7F,
  0x1F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xC3, 0xF8, 0x07,
  0xE1, 0xF8, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x1F, 0x8F, 0xE0,
  0x7E, 0x3F, 0x01, 0xFD, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x7F, 0x7E, 0x03, 0xF9, 0xFC, 0x0F, 0xE7,
  0xF0, 0x7F, 0x0F, 0xC1, 0xFC, 0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F,
  0xC7, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0xFE, 0x07, 0xE7, 0xF0, 0x3F,
  0x3F, 0x81, 0xFB, 0xF8, 0x0F, 0xDF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0,
  0x00, 0x30, 0x0F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x3F, 0x0F, 0xF0, 0xFE, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x1C, 0x00, 0x40,
  0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x03,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1C, 0x00, 0x02, 0x00, 0x38, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x03,
  0xF0, 0x7F, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xFC,
  0x0F, 0x80, 0xF0, 0x0C, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x1F, 0x3F, 0xE1,
  0xF3, 0xFE, 0x3E, 0x7F, 0xF3, 0xE7, 0xCF, 0xFE, 0x78, 0x7F, 0xCF, 0x87,
  0xFC, 0xF8, 0x3F, 0x80, 0x01, 0xF0,
};

const GFXglyph RobotoCondensed_BlackItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 12, 30, 11, 0, -30 },
  { 46, 13, 12, 13, 2, -32 },
  { 66, 21, 30, 21, 0, -30 },
  { 145, 20, 38, 21, 1, -34 },
  { 240, 20, 30, 26, 4, -30 },
  { 315, 22, 30, 24, 0, -30 },
  { 398, 7, 12, 6, 2, -32 },
  { 409, 13, 42, 13, 2, -33 },
  { 478, 14, 42, 13, -2, -33 },
  { 552, 18, 18, 19, 2, -30 },
  { 593, 18, 22, 19, 1, -25 },
  { 643, 9, 13, 11, -2, -5 },
  { 658, 11, 5, 17, 3, -15 },
  { 665, 7, 7, 12, 1, -7 },
  { 672, 18, 33, 13, -3, -30 },
  { 747, 18, 30, 21, 2, -30 },
  { 815, 14, 30, 21, 4, -30 },
  { 868, 20, 30, 21, 0, -30 },
  { 943, 20, 30, 21, 0, -30 },
  { 1018, 19, 30, 21, 1, -30 },
  { 1090, 20, 30, 21, 1, -30 },
  { 1165, 18, 30, 21, 1, -30 },
  { 1233, 21, 30, 21, 1, -30 },
  { 1312, 19, 30, 21, 1, -30 },
  { 1384, 17, 30, 21, 3, -30 },
  { 1448, 10, 23, 12, 1, -23 },
  { 1477, 13, 31, 12, -2, -23 },
  { 1528, 17, 20, 18, 1, -23 },
  { 1571, 19, 14, 21, 1, -20 },
  { 1605, 18, 20, 18, 0, -22 },
  { 1650, 17, 30, 19, 2, -30 },
  { 1714, 30, 38, 31, 0, -29 },
  { 1857, 24, 30, 25, -2, -30 },
  { 1947, 23, 30, 23, 0, -30 },
  { 2034, 23, 30, 23, 1, -30 },
  { 2121, 22, 30, 23, 0, -30 },
  { 2204, 22, 30, 20, 0, -30 },
  { 2287, 22, 30, 19, 0, -30 },
  { 2370, 23, 30, 24, 1, -30 },
  { 2457, 26, 30, 25, 0, -30 },
  { 2555, 12, 30, 11, 0, -30 },
  { 2600, 21, 30, 20, 0, -30 },
  { 2679, 26, 30, 23, 0, -30 },
  { 2777, 17, 30, 20, 0, -30 },
  { 2841, 32, 30, 31, 0, -30 },
  { 2961, 26, 30, 25, 0, -30 },
  { 3059, 23, 30, 25, 1, -30 },
  { 3146, 23, 30, 23, 0, -30 },
  { 3233, 23, 35, 25, 1, -30 },
  { 3334, 23, 30, 23, 0, -30 },
  { 3421, 22, 30, 22, 1, -30 },
  { 3504, 22, 30, 23, 3, -30 },
  { 3587, 24, 30, 24, 1, -30 },
  { 3677, 24, 30, 24, 3, -30 },
  { 3767, 29, 30, 30, 3, -30 },
  { 3876, 27, 30, 23, -2, -30 },
  { 3978, 22, 30, 23, 3, -30 },
  { 4061, 25, 30, 22, -1, -30 },
  { 4155, 15, 42, 11, -1, -35 },
  { 4234, 11, 33, 16, 3, -30 },
  { 4280, 14, 42, 11, -2, -35 },
  { 4354, 15, 15, 16, 1, -30 },
  { 4383, 17, 5, 16, -3, 0 },
  { 4394, 10, 6, 14, 4, -31 },
  { 4402, 18, 22, 19, 0, -22 },
  { 4452, 19, 32, 20, 0, -32 },
  { 4528, 17, 22, 19, 1, -22 },
  { 4575, 21, 32, 20, 1, -32 },
  { 4659, 18, 22, 20, 1, -22 },
  { 4709, 15, 32, 14, 1, -32 },
  { 4769, 21, 31, 21, 0, -22 },
  { 4851, 20, 32, 20, -1, -32 },
  { 4931, 12, 31, 11, 0, -31 },
  { 4978, 17, 40, 10, -5, -31 },
  { 5063, 22, 32, 20, 0, -32 },
  { 5151, 12, 32, 11, 0, -32 },
  { 5199, 29, 22, 30, 0, -22 },
  { 5279, 20, 22, 20, -1, -22 },
  { 5334, 18, 22, 20, 1, -22 },
  { 5384, 21, 31, 20, -2, -22 },
  { 5466, 19, 31, 20, 1, -22 },
  { 5540, 15, 22, 14, 0, -22 },
  { 5582, 18, 22, 18, 0, -22 },
  { 5632, 13, 28, 13, 1, -28 },
  { 5678, 19, 22, 20, 1, -22 },
  { 5731, 18, 22, 19, 2, -22 },
  { 5781, 25, 22, 25, 2, -22 },
  { 5850, 22, 22, 19, -2, -22 },
  { 5911, 21, 31, 19, -1, -22 },
  { 5993, 20, 22, 19, -1, -22 },
  { 6048, 12, 40, 12, 1, -33 },
  { 6108, 9, 36, 10, 1, -30 },
  { 6149, 12, 40, 12, -1, -33 },
  { 6209, 20, 10, 22, 1, -18 },
};

const GFXfont RobotoCondensed_BlackItalic42pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic42pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic42pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOCONDENSED_BLACKITALIC42PT7B_H_
