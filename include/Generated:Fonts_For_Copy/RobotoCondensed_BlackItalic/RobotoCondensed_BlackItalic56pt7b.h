#ifndef _ROBOTOCONDENSED_BLACKITALIC56PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x8F, 0xCF, 0xE3, 0xF3, 0xF0, 0xFC, 0xFC, 0x7F, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xF8, 0x7E, 0x7E, 0x1F, 0x1F, 0x87, 0xC7, 0xE3, 0xF1,
  0xF0, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0xC3, 0xE3, 0xE0, 0xF8, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C,
  0xFC, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x9F, 0x80,
  0x01, 0xF9, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x3F,
  0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0xFC, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xF9, 0xF0,
  0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0xF8, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x1F, 0x1F,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x3E, 0x3E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x3F, 0xE1,
  0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x87,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x87, 0xF8, 0x1F, 0xE0,
  0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x81, 0x8F, 0xE7, 0xE0, 0xF3, 0xF0, 0xF8, 0x3E, 0xFC, 0x7E, 0x1F, 0xBF,
  0x1F, 0x8F, 0xCF, 0xC7, 0xE3, 0xE3, 0xE1, 0xF9, 0xF0, 0xF8, 0x7E, 0xFC,
  0x3F, 0x3F, 0x7E, 0x0F, 0xFF, 0xDF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFD, 0xF0, 0x01, 0xFE, 0xFC, 0x00, 0x0C, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF7, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0x7F, 0xFC, 0x0F, 0xFF,
  0xBF, 0x07, 0xEF, 0xC7, 0xC1, 0xF7, 0xE1, 0xF0, 0xFD, 0xF8, 0x7C, 0x7E,
  0x7E, 0x1F, 0x1F, 0x1F, 0x87, 0xCF, 0x87, 0xE3, 0xF7, 0xE1, 0xF8, 0xFF,
  0xF0, 0x7E, 0x3F, 0x38, 0x0F, 0xDF, 0x82, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00,
  0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE,
  0x3F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE1, 0xFC, 0x3F, 0xFF, 0x0F, 0xE1, 0xFF,
  0xFC, 0x7F, 0x1F, 0xFF, 0xE7, 0xF9, 0xFF, 0xFF, 0xBF, 0xCF, 0xF7, 0xFF,
  0xFC, 0xFF, 0x9F, 0xFF, 0xE7, 0xFC, 0xFF, 0xFF, 0x3F, 0xE3, 0xFF, 0xF1,
  0xFF, 0x0F, 0xFF, 0x8F, 0xF8, 0x7F, 0xFC, 0x7F, 0xC1, 0xFF, 0xC3, 0xFE,
  0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xF7, 0xFE,
  0x03, 0xFF, 0x1F, 0xF0, 0x01, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x9F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF0, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x20, 0x1E, 0x00, 0x38,
  0x1E, 0x0E, 0x7E, 0x3E, 0x3F, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xEF, 0x80, 0x1F, 0xCF, 0x80, 0x3F,
  0x8F, 0xC0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x0C,
  0x03, 0x80, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFF,
  0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xC0, 0x7C, 0x00,
  0xC0, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xDF,
  0xFF, 0xBF, 0xFF, 0x00, 0x1E, 0x1F, 0xC7, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFE, 0x3F, 0x02, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF,
  0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF3, 0xFE, 0x07,
  0xF9, 0xFF, 0x07, 0xFC, 0xFF, 0x83, 0xFE, 0x7F, 0x81, 0xFF, 0x3F, 0xC0,
  0xFF, 0xBF, 0xE0, 0x7F, 0xDF, 0xF0, 0x3F, 0xEF, 0xF8, 0x1F, 0xE7, 0xFC,
  0x1F, 0xF3, 0xFE, 0x0F, 0xF9, 0xFE, 0x07, 0xFD, 0xFF, 0x03, 0xFE, 0xFF,
  0x81, 0xFF, 0x7F, 0xC0, 0xFF, 0x3F, 0xE0, 0x7F, 0x9F, 0xF0, 0x7F, 0xCF,
  0xF8, 0x3F, 0xE7, 0xF8, 0x1F, 0xF3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8,
  0xFF, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x01,
  0xF0, 0x03, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF9,
  0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0xE7, 0xFC, 0xC1,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xFC,
  0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x3F, 0xE0,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x0F, 0xFC, 0x7F, 0xC1, 0xFF,
  0x0F, 0xF8, 0x7F, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xDF, 0xF0, 0x07, 0xF7, 0xF8, 0x03,
  0xFB, 0xFE, 0x00, 0xFE, 0xFF, 0x80, 0x7F, 0x3F, 0xE0, 0x1F, 0xCF, 0xF8,
  0x0F, 0xE3, 0xFE, 0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x7F, 0xC0, 0xFF, 0x1F,
  0xF0, 0x7F, 0x87, 0xFC, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF9, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x03, 0xFE, 0x7F, 0xE0, 0x07, 0x83, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF1, 0xFF, 0x03, 0xFC, 0x3F, 0xE0,
  0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xE7, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xE3, 0xFE, 0x7F, 0xC3, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x83, 0xFE,
  0x7F, 0x87, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x00, 0x20, 0x00, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFC, 0x7F, 0xC1,
  0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F,
  0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x1F, 0xE3, 0xFE, 0x07, 0xF8,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x3F, 0xE3, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xFC, 0x1F, 0xE1, 0xFF, 0x07,
  0xF8, 0x7F, 0x81, 0xFE, 0x3F, 0xE0, 0x7F, 0x8F, 0xF8, 0x1F, 0xE3, 0xFE,
  0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x1F, 0xF1, 0xFF, 0x87, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x7F, 0xC3,
  0xFC, 0xFF, 0x87, 0xF9, 0xFE, 0x0F, 0xF7, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xF7, 0xFC, 0x3F, 0xEF, 0xF8, 0x7F, 0xDF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xFF,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x1F,
  0xC0, 0x7F, 0x83, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x81, 0xFE, 0x03,
  0xF0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x0F, 0xE0, 0x7F, 0x83, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1,
  0xFE, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFE,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0x08, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x7F,
  0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x7F, 0xC7, 0xFD, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x80, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x03, 0xF8, 0x07, 0xE0,
  0x3E, 0x03, 0xF0, 0x1F, 0xF8, 0x3E, 0x07, 0xE0, 0x7F, 0xFC, 0x3E, 0x07,
  0xE0, 0xFF, 0xFE, 0x1F, 0x0F, 0xC1, 0xFF, 0xFE, 0x1F, 0x0F, 0xC1, 0xFC,
  0x7E, 0x1F, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0x1F, 0x87, 0xF0, 0xFC, 0x1F,
  0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x3F, 0x0F,
  0xE0, 0xF8, 0x1F, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x3E, 0x1F, 0xC1, 0xF8,
  0x3F, 0x7E, 0x1F, 0xC1, 0xF8, 0x3E, 0x7E, 0x1F, 0xC1, 0xF8, 0x3E, 0x7E,
  0x1F, 0x83, 0xF0, 0x3E, 0x7E, 0x1F, 0x83, 0xF0, 0x3E, 0x7C, 0x3F, 0x83,
  0xF0, 0x7C, 0x7C, 0x3F, 0x83, 0xF0, 0x7C, 0x7C, 0x3F, 0x87, 0xE0, 0x7C,
  0x7C, 0x3F, 0x87, 0xE0, 0xF8, 0x7C, 0x3F, 0x87, 0xE0, 0xF8, 0x7C, 0x1F,
  0x8F, 0xE1, 0xF0, 0x7C, 0x1F, 0xFF, 0xF3, 0xF0, 0x7C, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7C, 0x0F, 0xFF, 0xFF, 0xC0, 0x7C, 0x0F, 0xF9, 0xFF, 0x80, 0x7E,
  0x07, 0xF0, 0xFF, 0x00, 0x7E, 0x00, 0x80, 0x18, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0x00, 0x00, 0x0F, 0xFC,
  0x1F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x3F,
  0xDF, 0xC0, 0x00, 0x3F, 0xEF, 0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F,
  0xF3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x07,
  0xFC, 0x7F, 0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFE, 0x1F, 0xE0, 0x03,
  0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x00, 0xFF,
  0x87, 0xFE, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x1F,
  0xF3, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0xC0, 0x03,
  0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F,
  0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x0F, 0xFC,
  0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0xC3, 0xFE, 0x07,
  0xFE, 0x0F, 0xF8, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0xFF,
  0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0,
  0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F,
  0xF8, 0x7F, 0xC1, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF,
  0x87, 0xFC, 0x01, 0xFE, 0x3F, 0xE0, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xF3,
  0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x8F,
  0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0xC1, 0xFF,
  0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0x1F, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x3F, 0xE0,
  0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0xC3, 0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x0F,
  0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x03, 0xFE,
  0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x87,
  0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE,
  0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x81,
  0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC7, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE1,
  0xFF, 0x80, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0xFF,
  0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x7F,
  0xFE, 0x7F, 0xC1, 0xFF, 0xF9, 0xFF, 0x07, 0xFF, 0xC7, 0xFC, 0x3F, 0xFF,
  0x3F, 0xF0, 0xFF, 0xFC, 0xFF, 0xC3, 0xFF, 0xF3, 0xFE, 0x0F, 0xFF, 0xCF,
  0xF8, 0x03, 0xFF, 0x3F, 0xE0, 0x0F, 0xFC, 0xFF, 0x80, 0x3F, 0xE3, 0xFE,
  0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0,
  0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F,
  0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF,
  0xC0, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F,
  0xF0, 0x07, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0x8F, 0xFE, 0x00, 0x1F,
  0xF1, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xCF, 0xFC, 0x00,
  0x1F, 0xF3, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFC, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xC3,
  0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x7F, 0xBF, 0x07, 0xFF, 0xF8, 0x0F, 0xF7, 0xE0, 0xFF, 0xFF,
  0x01, 0xFE, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xDF, 0x87, 0xF7, 0xF8, 0x0F,
  0xFB, 0xF0, 0xFE, 0xFF, 0x01, 0xFF, 0x7E, 0x1F, 0xBF, 0xE0, 0x3F, 0xEF,
  0xC7, 0xF7, 0xFC, 0x07, 0xFD, 0xF8, 0xFC, 0xFF, 0x80, 0xFF, 0x3F, 0xBF,
  0x9F, 0xF0, 0x3F, 0xE3, 0xF7, 0xF3, 0xFC, 0x07, 0xFC, 0x7E, 0xFC, 0xFF,
  0x80, 0xFF, 0x8F, 0xFF, 0x9F, 0xF0, 0x1F, 0xF1, 0xFF, 0xE3, 0xFE, 0x03,
  0xFE, 0x3F, 0xFC, 0x7F, 0xC0, 0x7F, 0xC7, 0xFF, 0x1F, 0xF8, 0x1F, 0xF8,
  0xFF, 0xE3, 0xFE, 0x03, 0xFE, 0x1F, 0xFC, 0x7F, 0xC0, 0x7F, 0xC3, 0xFF,
  0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x3F,
  0xE0, 0x3F, 0xE1, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xC1, 0xFF, 0x01,
  0xFF, 0x03, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0x07, 0xFC, 0x07, 0xFC,
  0x0F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x0F,
  0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xF8,
  0x07, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F,
  0xFC, 0x07, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xF0,
  0x1F, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F,
  0xF0, 0x1F, 0xFF, 0xC3, 0xFE, 0x03, 0xFF, 0xF8, 0x7F, 0xC0, 0x7F, 0xFF,
  0x0F, 0xF8, 0x0F, 0xFB, 0xE1, 0xFF, 0x01, 0xFF, 0x7C, 0x7F, 0xE0, 0x7F,
  0xEF, 0xCF, 0xF8, 0x0F, 0xF9, 0xF9, 0xFF, 0x01, 0xFF, 0x1F, 0x3F, 0xE0,
  0x3F, 0xE3, 0xE7, 0xFC, 0x07, 0xFC, 0x7C, 0xFF, 0x80, 0xFF, 0x8F, 0xFF,
  0xE0, 0x3F, 0xF1, 0xFF, 0xFC, 0x07, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0x83,
  0xFF, 0xF0, 0x1F, 0xF0, 0x7F, 0xFE, 0x03, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F,
  0xC1, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xC0, 0x7F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F,
  0xE1, 0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFF, 0x3F, 0xF0, 0x07, 0xFC,
  0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x7F,
  0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0xFF, 0xDF, 0xF0,
  0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xEF, 0xFC, 0x00,
  0xFF, 0xBF, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x7F,
  0xEF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF3,
  0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F,
  0xC0, 0x7F, 0xC1, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC,
  0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0,
  0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x87,
  0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x7F,
  0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0,
  0x3F, 0xE1, 0xFF, 0x80, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x3F, 0xF0, 0x07,
  0xFC, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF,
  0x7F, 0xE0, 0x07, 0xFD, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0xDF,
  0xF0, 0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xEF, 0xFC,
  0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFE, 0xFF, 0xC0, 0x0F, 0xFB, 0xFE, 0x00,
  0x7F, 0xEF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x1F,
  0xF3, 0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF8,
  0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F,
  0xC0, 0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC,
  0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE1,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0x1F, 0xF8,
  0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0,
  0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01,
  0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F,
  0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC3,
  0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3,
  0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0xC3, 0xFE,
  0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x03,
  0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F,
  0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x01, 0xFF,
  0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0,
  0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x00, 0xFF, 0x87,
  0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x80, 0x7F, 0xC3, 0xFF,
  0x01, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x80,
  0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07,
  0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xC0, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xF7,
  0xFE, 0x00, 0x7F, 0xE7, 0xFC, 0x01, 0xFF, 0x8F, 0xF8, 0x03, 0xFF, 0x1F,
  0xF0, 0x07, 0xFE, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF,
  0x80, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0,
  0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x8F,
  0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0xFF,
  0x80, 0x07, 0xF9, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xEF, 0xF8,
  0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0x01, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xE0,
  0xFF, 0xBF, 0xC0, 0xFF, 0x83, 0xFE, 0xFF, 0x07, 0xFE, 0x0F, 0xFB, 0xFC,
  0x1F, 0xF8, 0x7F, 0xCF, 0xF0, 0x7F, 0xE1, 0xFF, 0x3F, 0xC3, 0xFF, 0x87,
  0xFC, 0xFF, 0x0F, 0xFE, 0x3F, 0xF3, 0xFC, 0x3F, 0xF8, 0xFF, 0x8F, 0xF1,
  0xFF, 0xE3, 0xFE, 0x3F, 0xC7, 0xFF, 0x8F, 0xF8, 0xFF, 0x1F, 0xFE, 0x7F,
  0xC3, 0xFC, 0xFF, 0xF9, 0xFF, 0x0F, 0xF3, 0xFF, 0xE7, 0xFC, 0x3F, 0xCF,
  0xFF, 0xBF, 0xE0, 0xFF, 0x7F, 0xFE, 0xFF, 0x83, 0xFD, 0xFF, 0xFB, 0xFE,
  0x0F, 0xF7, 0xFF, 0xEF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xBF, 0xFF, 0x80, 0xFF, 0xFE, 0xFF, 0xFC, 0x03, 0xFF, 0xF3,
  0xFF, 0xF0, 0x0F, 0xFF, 0xCF, 0xFF, 0xC0, 0x3F, 0xFF, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0xFF, 0xF8, 0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x0F, 0xFF, 0x8F,
  0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x03,
  0xFF, 0xC3, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F,
  0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xF8,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xC7,
  0xFE, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x03,
  0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xF3, 0xFC, 0x00,
  0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x0F, 0xFC, 0x3F,
  0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF,
  0x81, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F,
  0xFD, 0xFF, 0x00, 0x7F, 0xE7, 0xFC, 0x01, 0xFF, 0x9F, 0xF0, 0x0F, 0xFC,
  0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0x87, 0xFE, 0x01, 0xFE,
  0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE3, 0xFE, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0xFF, 0x7F, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F,
  0x7E, 0x07, 0xF7, 0xE0, 0x7E, 0x7E, 0x0F, 0xE7, 0xE0, 0xFC, 0x7E, 0x1F,
  0xC3, 0xE1, 0xF8, 0x3F, 0x3F, 0x83, 0xF3, 0xF8, 0x3F, 0x7F, 0x03, 0xF7,
  0xF0, 0x3F, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x80, 0xFF, 0x83,
  0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xE3, 0xFC, 0x7F, 0xC7,
  0xFC, 0xFF, 0x87, 0xFC, 0xFF, 0x87, 0xFC, 0xFF, 0x87, 0xFC, 0xFF, 0x87,
  0xFC, 0xFF, 0x8F, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0x7F, 0xF7, 0xF8, 0x3F, 0xF7, 0xF8, 0x0F, 0xE7, 0xFC, 0x01, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xF0, 0x7F, 0x87, 0xFC, 0x1F,
  0xF1, 0xFF, 0x07, 0xFC, 0x7F, 0xC1, 0xFE, 0x1F, 0xE0, 0x7F, 0x8F, 0xF8,
  0x1F, 0xE3, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F,
  0xF0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFC, 0x7F, 0xC0, 0xFF,
  0x1F, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFD, 0xFF, 0xE0, 0xFF,
  0x3F, 0xF0, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xE1, 0xFE, 0x7F,
  0x83, 0xFD, 0xFF, 0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x9F, 0xE0, 0xFF,
  0x3F, 0xC1, 0xFE, 0x7F, 0x87, 0xFC, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0x07, 0xFC, 0x01,
  0xFE, 0x7F, 0xC0, 0x7F, 0xF7, 0xFC, 0x0F, 0xFF, 0x7F, 0x81, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83,
  0xFE, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x81,
  0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0,
  0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xF7, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x3F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x7F, 0xC0, 0xFF, 0x7F, 0xC0, 0xFF,
  0x7F, 0xC0, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x40, 0x7F, 0xC0, 0xE0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07, 0xFC, 0xFF,
  0x00, 0xFF, 0xEF, 0xF0, 0x1F, 0xFE, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F,
  0xE0, 0x3F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07,
  0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3,
  0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x02, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x1C, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFD, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x7F,
  0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F,
  0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC,
  0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0xC7,
  0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0xFF,
  0x80, 0x00, 0xF8, 0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x83, 0xFF, 0x87, 0xFC, 0x3F,
  0xF8, 0x3F, 0xE3, 0xFF, 0x81, 0xFF, 0x1F, 0xF8, 0x0F, 0xF9, 0xFF, 0x80,
  0x7F, 0xDF, 0xFC, 0x03, 0xFC, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xEF, 0xF8, 0x03, 0xFE, 0x7F,
  0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0,
  0x7F, 0xC3, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x83, 0xFF, 0x07, 0xF8, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE7, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xE3, 0xFF, 0x03, 0xFF, 0xFF,
  0xDF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0xFF,
  0x87, 0xFC, 0x7F, 0xC3, 0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC7,
  0xFC, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x7F, 0x83, 0xFC,
  0x1F, 0xF3, 0xFE, 0x1F, 0xF0, 0x7F, 0xCF, 0xF8, 0x7F, 0xC3, 0xFE, 0x3F,
  0xE1, 0xFF, 0x0F, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xE3, 0xFC, 0x1F, 0xF0,
  0xFF, 0x8F, 0xF0, 0x7F, 0x83, 0xFE, 0x7F, 0xC3, 0xFE, 0x0F, 0xF9, 0xFF,
  0x0F, 0xF8, 0x3F, 0xC7, 0xFC, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x87,
  0xFC, 0x7F, 0x83, 0xFE, 0x1F, 0xF1, 0xFE, 0x0F, 0xF0, 0x7F, 0xCF, 0xF8,
  0x3F, 0xC1, 0xFF, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0xFF, 0x87, 0xFC, 0x3F,
  0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0x8F, 0xF0, 0x7F, 0xC3, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F,
  0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xFC,
  0x7F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F,
  0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xC3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0xC7,
  0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFE, 0x3F, 0xE0, 0xFF,
  0x8F, 0xF8, 0x3F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x3F, 0xE1, 0xFF, 0x3F, 0xC0, 0xFF, 0x7F, 0xC0,
  0xFF, 0x7F, 0xC0, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x83,
  0xFE, 0xFF, 0x87, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFC, 0x1F, 0xE0,
  0x7F, 0xC1, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xF8,
  0x1F, 0xF0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF,
  0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFE, 0xFF,
  0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xFC, 0x18, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F,
  0x8F, 0xF0, 0x7F, 0xF3, 0xFC, 0x3F, 0xFD, 0xFE, 0x1F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xE1, 0xFF,
  0x9F, 0xF0, 0x3F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFE, 0x07, 0xFC, 0x7F, 0x81,
  0xFF, 0x3F, 0xE0, 0x7F, 0xCF, 0xF8, 0x1F, 0xE3, 0xFE, 0x0F, 0xF8, 0xFF,
  0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE3, 0xFC, 0x0F, 0xF8,
  0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F,
  0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0xFF, 0x80,
  0x06, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xEF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xF1, 0xFF, 0x1F, 0xE1,
  0xFF, 0x1F, 0xE1, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x0F,
  0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE,
  0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0,
  0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xF0,
  0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x01, 0x00, 0x1F, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xFC,
  0x7F, 0xC1, 0xFF, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F,
  0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xC3, 0xFC,
  0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0xC7,
  0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFE, 0x1F, 0xE0, 0xFF,
  0x8F, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xE0,
  0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x07, 0xF9, 0xFE, 0x00, 0x10, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0xFF, 0x83,
  0xFE, 0xFF, 0x87, 0xFE, 0xFF, 0x87, 0xFC, 0xFF, 0x87, 0xFC, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0xF0, 0x7F, 0x9F,
  0xF0, 0x7F, 0x9F, 0xE0, 0x7F, 0x9F, 0xE0, 0x7F, 0xBF, 0xE0, 0x7F, 0xBF,
  0xC0, 0x7F, 0xBF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x07, 0xE0, 0xFF, 0x7F, 0x83, 0xF0, 0x7F, 0xBF, 0xC3, 0xF8,
  0x7F, 0xDF, 0xE1, 0xFC, 0x3F, 0xCF, 0xF1, 0xFE, 0x1F, 0xE7, 0xF8, 0xFF,
  0x1F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x7F, 0xC7, 0xF8, 0xFF, 0x3F,
  0xE3, 0xFC, 0x7F, 0x9F, 0xF3, 0xFC, 0x3F, 0xDF, 0xFD, 0xFE, 0x1F, 0xEF,
  0xFE, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFB,
  0xFF, 0xFF, 0x81, 0xFF, 0xF7, 0xFF, 0xC0, 0xFF, 0xFB, 0xFF, 0xE0, 0x7F,
  0xFD, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xF0, 0x1F, 0xFE, 0x7F, 0xF8, 0x0F,
  0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0x8F, 0xFE, 0x01,
  0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80,
  0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xE1, 0xFF,
  0x80, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0xFF, 0xC0, 0x3F, 0xE7, 0xFC, 0x00,
  0xFF, 0x7F, 0xC0, 0x07, 0xFB, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFD, 0xFE,
  0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xF3, 0xFE, 0x01,
  0xFF, 0x9F, 0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0xC3, 0xFC, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0x83,
  0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x7F, 0xC0,
  0xFF, 0x8F, 0xFC, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF9,
  0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x07, 0xFB, 0xFF, 0x00, 0x7F, 0xBF, 0xE0,
  0x07, 0xFB, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x03,
  0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x08, 0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x00, 0x00, 0x40, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x03, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xFC, 0x07, 0xF1, 0xFF, 0x81, 0xF8, 0xFF, 0xF0, 0x7E, 0x3F, 0xFE,
  0x1F, 0x9F, 0xFF, 0xCF, 0xE7, 0xFF, 0xFF, 0xFB, 0xF8, 0xFF, 0xFC, 0xFE,
  0x1F, 0xFF, 0x3F, 0x07, 0xFF, 0x8F, 0xC0, 0xFF, 0xE3, 0xF0, 0x1F, 0xF0,
  0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph RobotoCondensed_BlackItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 16, 41, 14, 0, -40 },
  { 83, 18, 16, 17, 2, -42 },
  { 119, 28, 40, 28, 0, -40 },
  { 259, 27, 53, 28, 1, -47 },
  { 438, 26, 42, 35, 5, -41 },
  { 575, 29, 42, 32, 0, -41 },
  { 728, 9, 16, 8, 3, -42 },
  { 746, 18, 56, 18, 2, -44 },
  { 872, 18, 56, 18, -2, -44 },
  { 998, 24, 25, 25, 3, -40 },
  { 1073, 24, 29, 25, 1, -33 },
  { 1160, 13, 18, 15, -3, -7 },
  { 1190, 15, 7, 23, 4, -21 },
  { 1204, 10, 10, 16, 1, -9 },
  { 1217, 25, 43, 17, -4, -40 },
  { 1352, 25, 42, 28, 2, -41 },
  { 1484, 18, 40, 28, 6, -40 },
  { 1574, 27, 41, 28, 0, -41 },
  { 1713, 27, 42, 28, 0, -41 },
  { 1855, 26, 40, 28, 1, -40 },
  { 1985, 27, 41, 28, 1, -40 },
  { 2124, 24, 41, 28, 2, -40 },
  { 2247, 27, 40, 28, 2, -40 },
  { 2382, 26, 42, 28, 1, -41 },
  { 2519, 23, 41, 28, 4, -41 },
  { 2637, 14, 32, 16, 1, -31 },
  { 2693, 17, 42, 15, -2, -31 },
  { 2783, 23, 27, 24, 1, -30 },
  { 2861, 24, 19, 28, 2, -27 },
  { 2918, 22, 27, 24, 1, -30 },
  { 2993, 22, 42, 25, 3, -41 },
  { 3109, 40, 51, 42, 0, -39 },
  { 3364, 33, 40, 33, -3, -40 },
  { 3529, 30, 40, 31, 0, -40 },
  { 3679, 30, 42, 31, 2, -41 },
  { 3837, 30, 40, 30, 0, -40 },
  { 3987, 30, 40, 27, 0, -40 },
  { 4137, 29, 40, 26, 0, -40 },
  { 4282, 30, 42, 32, 2, -41 },
  { 4440, 35, 40, 33, 0, -40 },
  { 4615, 16, 40, 15, 0, -40 },
  { 4695, 28, 41, 27, 0, -40 },
  { 4839, 35, 40, 30, 0, -40 },
  { 5014, 23, 40, 26, 0, -40 },
  { 5129, 43, 40, 41, 0, -40 },
  { 5344, 35, 40, 33, 0, -40 },
  { 5519, 30, 42, 33, 2, -41 },
  { 5677, 31, 40, 31, 0, -40 },
  { 5832, 30, 48, 33, 2, -41 },
  { 6012, 31, 40, 31, 0, -40 },
  { 6167, 29, 42, 30, 1, -41 },
  { 6320, 29, 40, 30, 4, -40 },
  { 6465, 31, 41, 31, 2, -40 },
  { 6624, 31, 40, 32, 4, -40 },
  { 6779, 38, 40, 40, 5, -40 },
  { 6969, 36, 40, 31, -2, -40 },
  { 7149, 30, 40, 30, 4, -40 },
  { 7299, 33, 40, 29, -1, -40 },
  { 7464, 19, 57, 15, -1, -47 },
  { 7600, 15, 43, 21, 4, -40 },
  { 7681, 20, 57, 15, -3, -47 },
  { 7824, 20, 20, 22, 1, -40 },
  { 7874, 22, 7, 22, -4, 0 },
  { 7894, 13, 9, 18, 6, -42 },
  { 7909, 24, 32, 25, 0, -31 },
  { 8005, 26, 43, 27, 0, -42 },
  { 8145, 23, 32, 25, 1, -31 },
  { 8237, 28, 43, 27, 1, -42 },
  { 8388, 24, 32, 26, 1, -31 },
  { 8484, 21, 43, 18, 1, -43 },
  { 8597, 28, 42, 28, -1, -31 },
  { 8744, 26, 42, 27, -1, -42 },
  { 8881, 15, 42, 14, 0, -42 },
  { 8960, 22, 53, 14, -7, -42 },
  { 9106, 29, 42, 27, 0, -42 },
  { 9259, 16, 42, 14, 0, -42 },
  { 9343, 38, 31, 40, 0, -31 },
  { 9491, 26, 31, 27, -1, -31 },
  { 9592, 24, 32, 27, 1, -31 },
  { 9688, 28, 42, 27, -2, -31 },
  { 9835, 26, 42, 27, 1, -31 },
  { 9972, 21, 31, 19, -1, -31 },
  { 10054, 24, 32, 25, 0, -31 },
  { 10150, 16, 38, 17, 2, -37 },
  { 10226, 26, 31, 27, 1, -30 },
  { 10327, 24, 30, 25, 3, -30 },
  { 10417, 33, 30, 34, 3, -30 },
  { 10541, 29, 30, 25, -2, -30 },
  { 10650, 28, 41, 25, -1, -30 },
  { 10794, 26, 30, 25, -1, -30 },
  { 10892, 17, 54, 16, 1, -44 },
  { 11007, 12, 47, 14, 1, -40 },
  { 11078, 17, 54, 16, -2, -44 },
  { 11193, 26, 13, 29, 2, -23 },
};

const GFXfont RobotoCondensed_BlackItalic56pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic56pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic56pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _ROBOTOCONDENSED_BLACKITALIC56PT7B_H_
