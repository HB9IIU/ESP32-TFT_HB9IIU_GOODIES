#ifndef _ROBOTOCONDENSED_BLACKITALIC35PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x7E, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x00, 0x00,
  0x00, 0xE0, 0x7C, 0x3F, 0x0F, 0xC1, 0xF0, 0x38, 0x00, 0x3C, 0xF3, 0xCE,
  0x39, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x71, 0xC7, 0x1C, 0x73, 0xCF, 0x3C,
  0x00, 0xF7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x07, 0xBC, 0x01, 0xCE, 0x00,
  0x73, 0x80, 0x1D, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0x7B,
  0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0xDE, 0x00, 0xE7, 0x01, 0xFF, 0xF8,
  0xFF, 0xFE, 0x3F, 0xFF, 0x81, 0xCE, 0x00, 0x77, 0x80, 0x3D, 0xC0, 0x0E,
  0x70, 0x03, 0xBC, 0x01, 0xEF, 0x00, 0x73, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F,
  0xFE, 0x1F, 0xBF, 0x1F, 0x1F, 0x3F, 0x1F, 0x3F, 0x1F, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xFC, 0x7C, 0xFC, 0xFC, 0x7F,
  0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0E, 0x70, 0xCF, 0x3C, 0xF7,
  0x9E, 0x73, 0xCE, 0x71, 0xE7, 0x78, 0xF7, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC,
  0x07, 0xFC, 0x00, 0x1C, 0x00, 0x1D, 0xE0, 0x1F, 0xFC, 0x1F, 0xFE, 0x0E,
  0xE7, 0x0F, 0xF3, 0xCF, 0x79, 0xE7, 0x3C, 0xE7, 0x1E, 0x73, 0x8F, 0x78,
  0x83, 0xFC, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFF, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E,
  0x78, 0x0F, 0xBE, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE3,
  0xC7, 0xFC, 0xF3, 0xFF, 0x7D, 0xFF, 0xFF, 0x7D, 0xFF, 0xBF, 0x3F, 0xEF,
  0xCF, 0xFB, 0xF1, 0xFC, 0x7E, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF,
  0xFE, 0x0F, 0x8F, 0xC0, 0x7B, 0xDE, 0xF7, 0x7B, 0xDE, 0xF7, 0x00, 0x00,
  0x40, 0x70, 0x3C, 0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x07,
  0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1C,
  0x07, 0x81, 0xE0, 0x3C, 0x06, 0x00, 0x80, 0x02, 0x00, 0x30, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80,
  0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x07, 0x00, 0x40, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x06, 0x38, 0xFF, 0x77, 0xFF,
  0xFF, 0x9F, 0xFE, 0x07, 0xC0, 0x1F, 0x80, 0xFF, 0x03, 0xE7, 0x0F, 0x8F,
  0x0E, 0x1E, 0x00, 0x10, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C,
  0x01, 0xF0, 0x00, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3C, 0x7C, 0x78,
  0xF8, 0x30, 0x7F, 0xDF, 0xF7, 0xFB, 0xFE, 0x73, 0xEF, 0xFF, 0xF9, 0xC0,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFC,
  0x1F, 0xFE, 0x1F, 0xBE, 0x3F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x7E, 0x3F,
  0x7E, 0x3F, 0x7E, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0xFC, 0x3E,
  0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7C, 0xF8, 0x7C, 0x7C, 0xFC, 0x7D, 0xF8,
  0x7F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x00, 0x60, 0x7C, 0x3F,
  0x3F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF6, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0xE1, 0xFB, 0xF8, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFC,
  0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF8,
  0xFC, 0xFC, 0x7C, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0xFF,
  0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x3F, 0x0F, 0x9F, 0x8F, 0xC7, 0xEF, 0xE3, 0xFF, 0xE0,
  0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07,
  0xFC, 0x0F, 0x7C, 0x0F, 0x7C, 0x1E, 0xFC, 0x3E, 0xFC, 0x3C, 0xFC, 0x7C,
  0xF8, 0xF8, 0xF8, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xFF, 0x0F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3F, 0xE0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC, 0x3C, 0x7C, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0xF8, 0x7C, 0xF8,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x00,
  0x3C, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x3E, 0xF0, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xF7, 0xEF, 0xEF,
  0x8F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF, 0xF1, 0xFB, 0xE3,
  0xE7, 0xFF, 0xCF, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF,
  0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE,
  0x1F, 0xBF, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x1F, 0x7E,
  0x1F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF8, 0x7C, 0x7C, 0xFC, 0x7C,
  0xFC, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0xFD, 0xFC, 0xFF, 0xF8,
  0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0xE0, 0x7F, 0xE1,
  0xFF, 0xE3, 0xF7, 0xCF, 0xCF, 0x9F, 0x1F, 0xBE, 0x3F, 0xFC, 0x7F, 0xF8,
  0xFF, 0xF1, 0xFF, 0xE3, 0xE7, 0xCF, 0xCF, 0xFF, 0x9F, 0xFF, 0x1F, 0xFE,
  0x1F, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x87, 0xFE, 0x0F, 0xF8, 0x1F,
  0xE0, 0x3F, 0x00, 0x78, 0x00, 0x0E, 0x1F, 0x3F, 0x3F, 0x3F, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF8, 0xFC, 0xFC, 0xFC,
  0x78, 0x01, 0x80, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F,
  0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x70, 0x0F, 0x80, 0xFE, 0x0F, 0xF8,
  0xFF, 0xEF, 0xFE, 0x3F, 0xC0, 0xFC, 0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0x38, 0x00, 0x20, 0x3F, 0xFE, 0x7F,
  0xFC, 0xFF, 0xFB, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x7F, 0xFD, 0xFF, 0xFB, 0xFF, 0xE0, 0x10, 0x00, 0x38, 0x00, 0x7C, 0x00,
  0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0xFC, 0x07,
  0xF8, 0x3F, 0xF3, 0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x38, 0x00,
  0x80, 0x00, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x7E, 0xFF, 0xF3,
  0xFF, 0xCF, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3C, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3E, 0x07, 0xC0, 0x3E,
  0x00, 0xE0, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x1E, 0x1F, 0x0E, 0x1E,
  0x1F, 0xE3, 0x8F, 0x1F, 0xF1, 0xCF, 0x1F, 0x78, 0xE7, 0x9F, 0x3C, 0x73,
  0x8F, 0x1E, 0x3B, 0xCF, 0x8E, 0x1D, 0xE7, 0x8F, 0x1E, 0xE3, 0xC7, 0x8E,
  0x71, 0xE3, 0xC7, 0x78, 0xF1, 0xC3, 0xBC, 0xF9, 0xE3, 0xDE, 0x38, 0xF1,
  0xCF, 0x1E, 0xF9, 0xE7, 0x8F, 0xFF, 0xE3, 0xC7, 0xEF, 0xE0, 0xE1, 0xE3,
  0xE0, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xF0, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0xFB, 0xC0, 0x07, 0xDF, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x3F, 0x3E,
  0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF9,
  0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x01, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0x0F, 0xC7, 0xE1,
  0xF8, 0xFC, 0x3F, 0x1F, 0x07, 0xE3, 0xE1, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0x87, 0xE3, 0xF0, 0x7C, 0x7E, 0x0F,
  0x8F, 0xC1, 0xF1, 0xF8, 0x7E, 0x3E, 0x0F, 0xC7, 0xFF, 0xF9, 0xFF, 0xFE,
  0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7F,
  0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3E, 0x0F, 0x8F, 0xC1,
  0xF9, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x1F,
  0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x3E, 0x1F, 0x87, 0xFF, 0xF0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0x1F, 0x87, 0xE1,
  0xF0, 0xFC, 0x3E, 0x1F, 0x07, 0xE3, 0xE0, 0xFC, 0xFC, 0x1F, 0x1F, 0x87,
  0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F,
  0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3E, 0x1F, 0x87, 0xFF, 0xF1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE,
  0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x0F, 0xCF, 0xC1, 0xF9, 0xF0, 0x3F,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE3, 0xFC,
  0xF8, 0xFF, 0xBF, 0x1F, 0xF7, 0xE3, 0xFE, 0xFC, 0x0F, 0x9F, 0x83, 0xF3,
  0xF0, 0x7E, 0x3F, 0x0F, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0,
  0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0xF8,
  0x1F, 0x83, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F,
  0x87, 0xE0, 0x7C, 0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0xC3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0x81,
  0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7C, 0x1F, 0x01, 0xF0,
  0x7C, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC,
  0x0F, 0x80, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xC3, 0xF0, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xC3, 0xF3, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x07,
  0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xFC, 0x3F, 0x0F,
  0xE0, 0xF8, 0x7F, 0x03, 0xE3, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x7F, 0x01,
  0xF9, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0x7E, 0x00, 0x7D, 0xF8, 0x03, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x1F,
  0x0F, 0xC0, 0x7C, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0x0F,
  0xE0, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0x7F,
  0xFE, 0xFF, 0xFC, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xF8, 0x3F, 0xC0,
  0xFF, 0x07, 0xF8, 0x1F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x87,
  0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x3F,
  0xF0, 0xFF, 0xC7, 0xBE, 0x1F, 0xF8, 0xFF, 0xC3, 0xEF, 0x3D, 0xF0, 0x7D,
  0xE7, 0xBE, 0x0F, 0xBD, 0xF7, 0xC3, 0xF7, 0xBD, 0xF8, 0x7E, 0x77, 0xBF,
  0x0F, 0xCF, 0xE7, 0xE1, 0xF9, 0xFC, 0xF8, 0x3F, 0x3F, 0x1F, 0x07, 0xC7,
  0xE7, 0xE1, 0xF8, 0xFC, 0xFC, 0x3F, 0x1F, 0x1F, 0x87, 0xE3, 0xE3, 0xF0,
  0xFC, 0x78, 0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x3F, 0x03, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x1F, 0xE1, 0xF8, 0x7F, 0x87, 0xE1, 0xFE, 0x1F, 0x07,
  0xF8, 0x7C, 0x1F, 0xF3, 0xF0, 0x7F, 0xCF, 0xC3, 0xF7, 0x3F, 0x0F, 0xDC,
  0xFC, 0x3F, 0x73, 0xE0, 0xFD, 0xEF, 0x83, 0xE7, 0xFE, 0x1F, 0x8F, 0xF8,
  0x7E, 0x3F, 0xE1, 0xF8, 0xFF, 0x87, 0xE3, 0xFC, 0x1F, 0x87, 0xF0, 0x7C,
  0x1F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC1, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0x0F, 0xCF, 0xC1, 0xF9, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0,
  0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xC0, 0x7F, 0xF8, 0x0F, 0xBF, 0x03,
  0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xF3, 0xF0, 0x7E, 0x3E, 0x0F,
  0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xE0,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF,
  0xFE, 0x3F, 0x0F, 0xC7, 0xE0, 0xF8, 0xFC, 0x1F, 0x1F, 0x07, 0xE3, 0xE0,
  0xFC, 0xFC, 0x1F, 0x9F, 0x87, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF,
  0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0x0F, 0xCF, 0xC1, 0xF9, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0,
  0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xF8, 0x0F, 0xBF, 0x01,
  0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x7E, 0x3E, 0x0F,
  0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x10,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF,
  0xFE, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x07, 0xE3, 0xE0,
  0xFC, 0xFC, 0x3F, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x1F,
  0x87, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x1F,
  0x80, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF,
  0x8F, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x3E, 0x0F, 0xCF, 0x83, 0xF3, 0xF0, 0xFC, 0xFF, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x83,
  0xE1, 0xF8, 0x3E, 0x1F, 0x07, 0xE1, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0,
  0x7E, 0x3F, 0x07, 0xC3, 0xF0, 0x7C, 0x3E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E,
  0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x8F,
  0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x0F, 0xC3, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0xFC, 0x0F, 0xFF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x0F, 0xEF, 0xC1,
  0xF9, 0xF8, 0x3F, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3E, 0x0F, 0x8F,
  0xC1, 0xF1, 0xF8, 0x3E, 0x3E, 0x07, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0x7E,
  0x03, 0xEF, 0xC0, 0x7D, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3E, 0xF8, 0xFC,
  0x7E, 0xF8, 0xFC, 0x7E, 0xF8, 0xFC, 0x7C, 0xF9, 0xFC, 0xFC, 0xF9, 0xFC,
  0xFC, 0xF9, 0xFC, 0xF8, 0xFB, 0xFD, 0xF8, 0xFB, 0xFD, 0xF8, 0xFB, 0xFD,
  0xF0, 0xFF, 0xFD, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xBF, 0xE0, 0xFF, 0xBF,
  0xE0, 0xFF, 0xBF, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F,
  0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x3F,
  0x81, 0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x3E, 0xFC, 0x00,
  0xFB, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x3F, 0x7C, 0x01, 0xF9, 0xF0, 0x07, 0xE7, 0xE0, 0x3F,
  0x1F, 0x80, 0xFC, 0x7E, 0x07, 0xF1, 0xF8, 0x3F, 0x83, 0xF0, 0xFE, 0x0F,
  0xC0, 0xFC, 0x0F, 0xFF, 0x07, 0xEF, 0xC1, 0xF9, 0xF0, 0xFC, 0x7C, 0x3F,
  0x1F, 0x1F, 0x87, 0xC7, 0xE1, 0xFB, 0xF0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7C, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xFC, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x00,
  0x03, 0xC0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE1, 0xEE, 0x1E, 0xE3, 0xCF,
  0x3C, 0xF7, 0x8F, 0x78, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x1E, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1,
  0xFF, 0xF3, 0xF7, 0xE7, 0xCF, 0xC0, 0x1F, 0x83, 0xFF, 0x3F, 0xFC, 0xFF,
  0xF9, 0xF9, 0xF7, 0xE7, 0xEF, 0xCF, 0xDF, 0x1F, 0xBF, 0xFE, 0x7F, 0xFC,
  0x7E, 0xF8, 0x79, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x78, 0x1F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFF, 0x3F, 0x3F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x3F,
  0x7E, 0x3F, 0x7E, 0x3F, 0x7C, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0xFE, 0xFE,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFB, 0xF8, 0xF9, 0xF0, 0x03, 0xF0, 0x1F, 0xF0,
  0x7F, 0xF1, 0xFF, 0xF3, 0xF7, 0xEF, 0xC7, 0xDF, 0x8F, 0xBE, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE3, 0xE7, 0xC7, 0xCF, 0xDF, 0x1F, 0xFE,
  0x1F, 0xF8, 0x3F, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x07, 0xDF, 0x83, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0x7F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC7,
  0xE3, 0xF1, 0xF8, 0x7C, 0x7E, 0x1F, 0xBF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x3F, 0xFC, 0x07, 0xDF, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF,
  0xE7, 0xEF, 0xCF, 0x8F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xF7, 0xC0, 0x0F, 0x82, 0x1F, 0xDE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x7F, 0xE3, 0xFF, 0x3F, 0xF9, 0xFF, 0xC3, 0xF0,
  0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xCF,
  0x87, 0xF7, 0xC7, 0xFF, 0xE7, 0xFF, 0xF3, 0xF3, 0xF3, 0xF0, 0xF9, 0xF8,
  0x7C, 0xF8, 0x7E, 0x7C, 0x3F, 0x3E, 0x1F, 0x9F, 0x0F, 0x8F, 0x87, 0xC7,
  0xC7, 0xE3, 0xF3, 0xF1, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xBE,
  0x00, 0x3F, 0x00, 0x1F, 0x87, 0x1F, 0x83, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF,
  0xC0, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x78, 0x3F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0x7F, 0x3E, 0x3F, 0x3E, 0x3F, 0x7E, 0x3F,
  0x7E, 0x3E, 0x7E, 0x3E, 0x7C, 0x7E, 0x7C, 0x7E, 0xFC, 0x7E, 0xFC, 0x7C,
  0xFC, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0xF8, 0xFC, 0x03, 0x03, 0xE0, 0xFC,
  0x3F, 0x0F, 0x81, 0xC0, 0x00, 0x00, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x3F,
  0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x07,
  0xC3, 0xF0, 0xFC, 0x3F, 0x00, 0x00, 0x30, 0x03, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F,
  0x80, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x1F, 0xC7,
  0xCF, 0xE3, 0xF7, 0xF0, 0xFD, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x7E, 0xF8, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xF8, 0x7E, 0x3E,
  0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x7E,
  0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x00, 0x1F,
  0x7C, 0x7C, 0x1F, 0xFE, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F,
  0x7F, 0xFF, 0x3E, 0x3F, 0x3F, 0x3E, 0x3E, 0x3F, 0x3E, 0x3E, 0x3F, 0x7E,
  0x3E, 0x3E, 0x7E, 0x7E, 0x3E, 0x7E, 0x7E, 0x3E, 0x7C, 0x7E, 0x7E, 0x7C,
  0x7C, 0x7E, 0x7C, 0x7C, 0x7E, 0xFC, 0x7C, 0x7C, 0xFC, 0xFC, 0x7C, 0xF8,
  0xFC, 0x7C, 0xF8, 0xFC, 0xFC, 0x1F, 0x7C, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFF, 0x3F, 0x7F, 0x3E, 0x3F, 0x3E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3E, 0x7E,
  0x3E, 0x7C, 0x7E, 0x7C, 0x7E, 0x7C, 0x7E, 0xFC, 0x7C, 0xFC, 0x7C, 0xF8,
  0x7C, 0xF8, 0xFC, 0xF8, 0xFC, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x1F,
  0xFE, 0x3F, 0x7E, 0x3E, 0x3F, 0x7E, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7C,
  0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7E, 0x7E, 0xFC, 0x7F, 0xFC, 0x3F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xC0, 0x07, 0xDE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFF, 0x0F, 0xDF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xEF,
  0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3E, 0xFE, 0x0F, 0x9E, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xCF, 0x8F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0xF7,
  0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x3F,
  0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE3, 0xF7, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x1F, 0x78, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xC8, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xE7, 0xE7,
  0xCF, 0xCF, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F,
  0xCF, 0x8F, 0x9F, 0x1F, 0x3F, 0xFE, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x00,
  0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xCF,
  0x83, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0xF3,
  0xFC, 0x7F, 0x1F, 0xC1, 0xF0, 0x3E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3E, 0x7E,
  0x3E, 0x7C, 0x3E, 0x7C, 0x7E, 0x7C, 0x7E, 0xFC, 0x7E, 0xFC, 0x7C, 0xFC,
  0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0xF8, 0xFC, 0xFD, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF8, 0x7F, 0xF8, 0x3C, 0xF8, 0xF8, 0x7D, 0xF1, 0xFB, 0xE3, 0xF7, 0xC7,
  0xCF, 0x9F, 0x9F, 0x3E, 0x3E, 0x7C, 0x7D, 0xF8, 0xFB, 0xE0, 0xF7, 0xC1,
  0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0xFC, 0x00, 0xF8, 0xF1, 0xFF, 0x9F, 0x3F, 0xF9, 0xF3, 0xEF, 0x9F,
  0x3E, 0xFB, 0xF3, 0xEF, 0xBF, 0x7C, 0xFB, 0xF7, 0xCF, 0xFF, 0x78, 0xFF,
  0xFF, 0x8F, 0xF7, 0xF8, 0xFF, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F,
  0xE7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0,
  0x1F, 0x9F, 0x87, 0xE7, 0xE0, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFF, 0x03, 0xE7, 0xC1, 0xF9, 0xF0,
  0x7C, 0x7C, 0x3F, 0x1F, 0x80, 0x1F, 0x0F, 0xC7, 0xC7, 0xE1, 0xF1, 0xF8,
  0x7C, 0x7C, 0x1F, 0x3F, 0x07, 0xCF, 0xC1, 0xF7, 0xE0, 0x7D, 0xF8, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0xF0, 0xFF, 0xF8,
  0x7F, 0xFC, 0x7F, 0xFE, 0x00, 0x00, 0xC0, 0xF0, 0x7C, 0x1F, 0x0F, 0x83,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x8F, 0xC3,
  0xE0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78,
  0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xE0, 0x08, 0x00, 0x0E,
  0x1C, 0x38, 0x71, 0xE3, 0x87, 0x0E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0xF1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x00, 0x04, 0x01, 0xC0, 0xF8, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x1F,
  0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x07, 0xC3,
  0xF1, 0xF8, 0x7C, 0x1F, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xC0, 0x40, 0x00, 0x1E, 0x00, 0x3F, 0x8F,
  0x7F, 0x8F, 0x7F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFE, 0xF0, 0xFC, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_BlackItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 25, 9, 0, -25 },
  { 33, 12, 10, 11, 1, -26 },
  { 48, 18, 25, 17, 0, -25 },
  { 105, 16, 32, 17, 1, -29 },
  { 169, 17, 25, 22, 3, -25 },
  { 223, 18, 25, 20, 0, -25 },
  { 280, 5, 10, 5, 2, -26 },
  { 287, 10, 35, 11, 2, -27 },
  { 331, 12, 35, 11, -2, -27 },
  { 384, 15, 15, 16, 2, -25 },
  { 413, 14, 19, 16, 1, -21 },
  { 447, 8, 11, 9, -2, -4 },
  { 458, 10, 4, 14, 2, -13 },
  { 463, 6, 6, 10, 1, -6 },
  { 468, 16, 27, 11, -3, -25 },
  { 522, 16, 25, 17, 1, -25 },
  { 572, 11, 25, 17, 4, -25 },
  { 607, 17, 25, 17, 0, -25 },
  { 661, 17, 25, 17, 0, -25 },
  { 715, 16, 25, 17, 1, -25 },
  { 765, 16, 25, 17, 1, -25 },
  { 815, 15, 25, 17, 1, -25 },
  { 862, 17, 25, 17, 1, -25 },
  { 916, 16, 25, 17, 1, -25 },
  { 966, 15, 25, 17, 2, -25 },
  { 1013, 8, 20, 10, 1, -20 },
  { 1033, 11, 27, 10, -2, -20 },
  { 1071, 14, 17, 15, 1, -19 },
  { 1101, 15, 11, 18, 1, -16 },
  { 1122, 15, 17, 15, 0, -19 },
  { 1154, 14, 25, 16, 2, -25 },
  { 1198, 25, 32, 26, 0, -24 },
  { 1298, 21, 25, 21, -2, -25 },
  { 1364, 19, 25, 19, 0, -25 },
  { 1424, 19, 25, 19, 1, -25 },
  { 1484, 19, 25, 19, 0, -25 },
  { 1544, 19, 25, 17, 0, -25 },
  { 1604, 18, 25, 16, 0, -25 },
  { 1661, 19, 25, 20, 1, -25 },
  { 1721, 22, 25, 21, 0, -25 },
  { 1790, 10, 25, 10, 0, -25 },
  { 1822, 18, 25, 17, 0, -25 },
  { 1879, 22, 25, 19, 0, -25 },
  { 1948, 15, 25, 16, 0, -25 },
  { 1995, 27, 25, 26, 0, -25 },
  { 2080, 22, 25, 21, 0, -25 },
  { 2149, 19, 25, 20, 1, -25 },
  { 2209, 19, 25, 20, 0, -25 },
  { 2269, 19, 30, 20, 1, -25 },
  { 2341, 19, 25, 19, 0, -25 },
  { 2401, 18, 25, 19, 1, -25 },
  { 2458, 19, 25, 19, 2, -25 },
  { 2518, 20, 25, 20, 1, -25 },
  { 2581, 19, 25, 20, 3, -25 },
  { 2641, 24, 25, 25, 3, -25 },
  { 2716, 22, 25, 19, -1, -25 },
  { 2785, 18, 25, 19, 3, -25 },
  { 2842, 21, 25, 18, -1, -25 },
  { 2908, 12, 35, 9, -1, -29 },
  { 2961, 10, 27, 13, 2, -25 },
  { 2995, 12, 35, 9, -2, -29 },
  { 3048, 12, 12, 14, 1, -25 },
  { 3066, 13, 4, 13, -2, 0 },
  { 3073, 8, 5, 12, 4, -26 },
  { 3078, 15, 18, 16, 0, -18 },
  { 3112, 16, 26, 17, 0, -26 },
  { 3164, 15, 18, 16, 0, -18 },
  { 3198, 18, 26, 17, 0, -26 },
  { 3257, 15, 18, 16, 1, -18 },
  { 3291, 13, 26, 11, 1, -26 },
  { 3334, 17, 25, 17, 0, -18 },
  { 3388, 16, 26, 17, 0, -26 },
  { 3440, 10, 26, 9, 0, -26 },
  { 3473, 14, 33, 9, -4, -26 },
  { 3531, 18, 26, 17, 0, -26 },
  { 3590, 10, 26, 9, 0, -26 },
  { 3623, 24, 18, 25, 0, -18 },
  { 3677, 16, 18, 17, 0, -18 },
  { 3713, 16, 18, 17, 0, -18 },
  { 3749, 18, 25, 17, -2, -18 },
  { 3806, 17, 25, 17, 0, -18 },
  { 3860, 13, 18, 12, 0, -18 },
  { 3890, 15, 18, 15, 0, -18 },
  { 3924, 10, 23, 11, 1, -23 },
  { 3953, 16, 18, 17, 1, -18 },
  { 3989, 15, 18, 16, 2, -18 },
  { 4023, 20, 18, 21, 2, -18 },
  { 4068, 18, 18, 16, -1, -18 },
  { 4109, 18, 25, 16, -1, -18 },
  { 4166, 17, 18, 16, -1, -18 },
  { 4205, 10, 33, 10, 1, -27 },
  { 4247, 7, 30, 9, 1, -25 },
  { 4274, 10, 33, 10, -1, -27 },
  { 4316, 16, 8, 18, 1, -14 },
};

const GFXfont RobotoCondensed_BlackItalic35pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic35pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic35pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOCONDENSED_BLACKITALIC35PT7B_H_
