#ifndef _ROBOTOCONDENSED_BLACKITALIC32PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x07, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0x8F,
  0xC7, 0xC1, 0xE0, 0x39, 0xCF, 0x39, 0xE7, 0x3D, 0xE7, 0x3C, 0xE7, 0x1C,
  0xE7, 0x9C, 0xE3, 0x80, 0x00, 0xEE, 0x01, 0xCE, 0x01, 0xDC, 0x01, 0xDC,
  0x03, 0x9C, 0x03, 0x9C, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x07, 0x70,
  0x07, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x7F, 0xFC, 0xFF, 0xFC,
  0xFF, 0xF8, 0x39, 0xC0, 0x39, 0xC0, 0x3B, 0x80, 0x3B, 0x80, 0x73, 0x80,
  0x77, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x1F, 0x00, 0x7F, 0x81,
  0xFF, 0x87, 0xFF, 0x1F, 0x9E, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF0, 0x01, 0xF3,
  0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x3F, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F,
  0xE0, 0x3F, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0xFE,
  0x01, 0xFC, 0x07, 0xB8, 0xEE, 0x71, 0xDC, 0xE7, 0x39, 0xDC, 0x73, 0xB8,
  0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x00, 0x1C, 0x00, 0x77, 0x81, 0xFF, 0x83,
  0xFF, 0x8E, 0xE7, 0x3F, 0xCE, 0x77, 0x1D, 0xCE, 0x7F, 0x1E, 0xF2, 0x1F,
  0xC0, 0x3F, 0x80, 0x3C, 0x00, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x01,
  0xFF, 0x80, 0xFB, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0xF8, 0x0F, 0xF8,
  0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0xF3, 0xFE, 0xF9, 0xFF, 0x79, 0xFF,
  0xFC, 0xFB, 0xFE, 0xFD, 0xFE, 0x7C, 0x7F, 0x3F, 0x1F, 0x0F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFF, 0xF0, 0x7E, 0x7C, 0x7B, 0x9D, 0xEF, 0x7B, 0x9C, 0xE0,
  0x00, 0x40, 0x70, 0x3C, 0x1E, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x1E, 0x0F,
  0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x38,
  0x0F, 0x01, 0xC0, 0x20, 0x04, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x81, 0xE0,
  0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1E, 0x07,
  0x83, 0xC1, 0xF0, 0xF8, 0x3C, 0x0E, 0x02, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x0E, 0x31, 0xFD, 0xFF, 0xFF, 0xE1, 0xF8, 0x1F, 0x01, 0xFC,
  0x1E, 0x71, 0xE3, 0x87, 0x1E, 0x10, 0x40, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x78, 0x03, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0x1E,
  0x3C, 0x78, 0xF3, 0xE7, 0x8F, 0x3C, 0xF0, 0x40, 0x7F, 0xBF, 0xFF, 0xDF,
  0xE0, 0xF7, 0xFF, 0xF7, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x1F, 0xC0, 0xFF, 0x87, 0xFF, 0x3E, 0x7C, 0xF8, 0xF3,
  0xC3, 0xDF, 0x0F, 0x7C, 0x7D, 0xF1, 0xF7, 0xC7, 0xDF, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x8F, 0xBE, 0x3E, 0xF8, 0xFB, 0xE3, 0xE7, 0x9F, 0x1F, 0xFC,
  0x7F, 0xE0, 0xFF, 0x01, 0xF0, 0x00, 0x00, 0x60, 0x78, 0x7F, 0x3F, 0xE7,
  0xFC, 0xFF, 0x9D, 0xF4, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x80, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8,
  0x03, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x3E, 0x3F, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF0,
  0x07, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C,
  0x7C, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFE,
  0x0F, 0xF8, 0x7B, 0xE3, 0xEF, 0x8F, 0x7C, 0x79, 0xF3, 0xE7, 0xCF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE3, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7F, 0xE0, 0xFF, 0xE1, 0xFF, 0xC3,
  0xFF, 0xC0, 0x8F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0xF8, 0xF9, 0xF1,
  0xF3, 0xE7, 0xC7, 0xFF, 0x87, 0xFE, 0x07, 0xF8, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x07, 0xE0, 0x7F, 0x83, 0xFE, 0x1F, 0xC0, 0x7C, 0x03, 0xE0, 0x0F,
  0x80, 0x7D, 0xE1, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0xFC, 0xFF, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0xFF, 0xE3, 0xE7, 0x9F, 0x9F, 0xFC, 0x7F, 0xF0,
  0xFF, 0x80, 0xF8, 0x00, 0x3F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE3, 0xF7, 0xC7,
  0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0x3F, 0xF0, 0x3F, 0xC1, 0xFF,
  0x07, 0xFF, 0x0F, 0x9F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF1, 0xF3,
  0xE7, 0xC7, 0xFF, 0x87, 0xFE, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0xFF, 0x0F, 0xFC, 0x7F, 0xF7, 0xCF, 0xBE, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8,
  0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0xFF, 0xBF, 0xF8, 0xFF, 0xC3, 0xFE,
  0x03, 0xE0, 0x3F, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0x01, 0xC0, 0x00,
  0x1E, 0x7C, 0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x9F,
  0x3E, 0x7C, 0x70, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x1F,
  0x0F, 0x0F, 0x87, 0x81, 0x80, 0x00, 0x0C, 0x00, 0xE0, 0x0F, 0x80, 0xFE,
  0x1F, 0xF9, 0xFF, 0x87, 0xF8, 0x1F, 0x00, 0x7E, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFC, 0x03, 0xE0, 0x03, 0x80, 0x02, 0x00, 0x3F, 0xFC, 0xFF, 0xF7,
  0xFF, 0xDF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xFB,
  0xFF, 0xCF, 0xFF, 0x00, 0x10, 0x00, 0xE0, 0x07, 0xC0, 0x7F, 0x83, 0xFF,
  0x07, 0xFC, 0x07, 0xE0, 0x1F, 0x07, 0xF8, 0xFF, 0xDF, 0xF0, 0xFE, 0x07,
  0xC0, 0x38, 0x02, 0x00, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF,
  0xDF, 0x7C, 0xFB, 0xE7, 0xC0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0x03, 0xC0, 0x78, 0x03, 0xC1, 0xE0, 0x03,
  0x83, 0x80, 0x07, 0x0F, 0x0F, 0x86, 0x1C, 0x3F, 0x8E, 0x78, 0xFF, 0x9C,
  0xE3, 0xCE, 0x3B, 0xCF, 0x1C, 0x77, 0x1E, 0x78, 0xEE, 0x38, 0xF3, 0x9C,
  0xF1, 0xC7, 0x79, 0xE3, 0x8E, 0xF3, 0xCF, 0x1D, 0xE7, 0x9E, 0x73, 0x8F,
  0x78, 0xE7, 0x1F, 0xFF, 0x8F, 0x1F, 0x7E, 0x0E, 0x1C, 0x78, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x18, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xBC, 0x01, 0xF7, 0x80, 0x3E, 0xF0, 0x0F, 0x9E, 0x01, 0xF3, 0xE0,
  0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xF1, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0x83, 0xF3, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF,
  0x01, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF1, 0xF1,
  0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x7E, 0x1F, 0x3F, 0x1F, 0x9F, 0xFF, 0x8F,
  0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xE3, 0xF0, 0xF9, 0xF8, 0x7C, 0xF8, 0x3E,
  0x7C, 0x1F, 0x3E, 0x1F, 0x9F, 0x1F, 0x9F, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF,
  0xC3, 0xFF, 0x80, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1,
  0xF1, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0xF8, 0x1F, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x1F, 0x1F, 0x8F, 0xFF, 0x83, 0xFF, 0x81,
  0xFF, 0x80, 0x3F, 0x00, 0x0F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x83, 0xFF,
  0xE1, 0xF1, 0xF0, 0xF8, 0xFC, 0x7C, 0x3E, 0x7E, 0x1F, 0x3F, 0x0F, 0x9F,
  0x07, 0xCF, 0x87, 0xE7, 0xC3, 0xF3, 0xE1, 0xF3, 0xF0, 0xF9, 0xF8, 0x7C,
  0xF8, 0x3E, 0x7C, 0x3F, 0x3E, 0x1F, 0x1F, 0x3F, 0x9F, 0xFF, 0x8F, 0xFF,
  0x87, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xC3,
  0xFF, 0xE1, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x83, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0x8F,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0xE1, 0xF9, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0xFC, 0x1F, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x1F, 0xEF, 0x9F, 0xEF, 0xCF, 0xF7, 0xE7, 0xFB, 0xE0, 0x7D,
  0xF0, 0x7E, 0xF8, 0x3F, 0x7E, 0x1F, 0x1F, 0x9F, 0x8F, 0xFF, 0xC3, 0xFF,
  0xE0, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x1F, 0x83,
  0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x07, 0xE3, 0xF0,
  0x7C, 0x3F, 0x07, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC7, 0xE0, 0xF8, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87,
  0xC0, 0xF8, 0x7C, 0x1F, 0x8F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0,
  0xF8, 0x1F, 0x00, 0x0F, 0x87, 0xC3, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E,
  0x1F, 0x1F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC7, 0xE3, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0xFD, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F,
  0xC0, 0x1F, 0x80, 0x0F, 0x87, 0xF0, 0xF8, 0xFE, 0x1F, 0x8F, 0xC1, 0xF1,
  0xF8, 0x1F, 0x1F, 0x81, 0xF3, 0xF0, 0x1F, 0x7E, 0x03, 0xF7, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07,
  0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xC7, 0xC0,
  0x7C, 0x7E, 0x0F, 0xC7, 0xE0, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F,
  0x00, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0, 0xFF,
  0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE,
  0x1F, 0xE1, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE7, 0xBE,
  0x3F, 0xE7, 0xFC, 0x3E, 0xE7, 0x7C, 0x7E, 0xEF, 0x7C, 0x7C, 0xEF, 0x7C,
  0x7C, 0xFE, 0x7C, 0x7C, 0xFE, 0xFC, 0x7C, 0xFC, 0xF8, 0x7C, 0xFC, 0xF8,
  0xFC, 0xF8, 0xF8, 0xFC, 0xF8, 0xF8, 0xF8, 0xF9, 0xF8, 0xF8, 0xF1, 0xF8,
  0x0F, 0x83, 0xF0, 0xF8, 0x3E, 0x1F, 0x83, 0xE1, 0xFC, 0x3E, 0x1F, 0xC3,
  0xE1, 0xFC, 0x3E, 0x1F, 0xC7, 0xE3, 0xFE, 0x7C, 0x3F, 0xE7, 0xC3, 0xEE,
  0x7C, 0x3E, 0xE7, 0xC3, 0xEE, 0x7C, 0x3E, 0xFF, 0xC7, 0xE7, 0xF8, 0x7E,
  0x7F, 0x87, 0xC7, 0xF8, 0x7C, 0x7F, 0x87, 0xC3, 0xF8, 0x7C, 0x3F, 0x8F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x00, 0x01, 0xF8,
  0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xF9, 0xF9, 0xF0, 0x7C, 0xF8,
  0x3E, 0xFC, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xFF, 0x81, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7E, 0x1F,
  0x1F, 0x1F, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x0F, 0x87, 0xC3,
  0xF1, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0x8F, 0x83, 0xE3, 0xE3, 0xF8,
  0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1,
  0xF9, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0xFC, 0x1F, 0x7C, 0x0F, 0xBE, 0x07,
  0xDF, 0x03, 0xEF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7D, 0xF0,
  0x3E, 0xF8, 0x1F, 0x7E, 0x1F, 0x1F, 0x1F, 0x8F, 0xFF, 0x83, 0xFF, 0x80,
  0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x04,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3F, 0x0F, 0x8F, 0x87, 0xE3,
  0xE3, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xF3,
  0xF0, 0x7C, 0xFC, 0x1F, 0x1F, 0x07, 0xC7, 0xC3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3E, 0x1F, 0x8F, 0x83, 0xE0, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F,
  0xFF, 0x3F, 0x3F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x00, 0x3F, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xFC, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F,
  0xF0, 0x0F, 0xC0, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xDF, 0xFF, 0xE0,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xF8, 0xF8,
  0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F,
  0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x3F, 0x3F, 0x0F, 0x8F,
  0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x1F, 0x8F, 0xCF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x0F, 0xFF, 0x03,
  0xF7, 0xC1, 0xF9, 0xF0, 0x7E, 0x7C, 0x1F, 0x1F, 0x0F, 0xC7, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x7E, 0x1F, 0x1F, 0x07, 0xC7, 0xC0, 0xF3, 0xE0, 0x3C,
  0xF8, 0x0F, 0xBE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xF8, 0xF8, 0xFF, 0xE3, 0xE3, 0xEF, 0x9F, 0x8F, 0xBE, 0x7E, 0x7E, 0xF9,
  0xF9, 0xF3, 0xE7, 0xE7, 0xCF, 0xBF, 0x9F, 0x3E, 0xFE, 0xF8, 0xFB, 0xFB,
  0xE3, 0xFF, 0xEF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xE0, 0xFE, 0x7F, 0x03, 0xF9,
  0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1, 0xF8,
  0x0F, 0x87, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0,
  0x7C, 0xFC, 0x07, 0xCF, 0xC0, 0x7C, 0xF8, 0x07, 0xDF, 0x80, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFB, 0xE0, 0x1F, 0xBE, 0x01, 0xFB,
  0xE0, 0x3F, 0x3E, 0x03, 0xF3, 0xF0, 0x7E, 0x3F, 0x07, 0xE1, 0xF0, 0xFC,
  0x1F, 0x80, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x7E, 0xF8, 0x7C, 0x78, 0x7C,
  0x7C, 0xF8, 0x7C, 0xF8, 0x7D, 0xF0, 0x7D, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0x87,
  0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC,
  0x3F, 0x87, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x0F, 0x80, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0,
  0xFC, 0x3F, 0x87, 0xF0, 0x07, 0x80, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x3B,
  0x8F, 0x71, 0xCF, 0x79, 0xEE, 0x3F, 0xC3, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7C, 0x7C, 0x3E, 0x1E, 0x1E, 0x07, 0xE0, 0x3F, 0xC1, 0xFF,
  0x8F, 0xFE, 0x3E, 0x7C, 0xFB, 0xF0, 0x0F, 0x83, 0xFE, 0x3F, 0xF9, 0xFF,
  0xEF, 0xCF, 0xBE, 0x3E, 0xF9, 0xF3, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3D,
  0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF1, 0xF3, 0xF3,
  0xE3, 0xE7, 0xC7, 0xDF, 0x1F, 0xBE, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF1,
  0xF3, 0xE7, 0xEF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFC, 0x79, 0xF0, 0x07, 0xE0,
  0x3F, 0xC1, 0xFF, 0x8F, 0xFE, 0x3E, 0x7D, 0xF1, 0xF7, 0xC7, 0xDF, 0x00,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x1E, 0x3E, 0x78, 0xF9, 0xFF, 0xC7, 0xFF,
  0x0F, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x7C, 0x1F, 0xFE, 0x1F,
  0xFF, 0x0F, 0xFF, 0x8F, 0xCF, 0xC7, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0,
  0xF8, 0xF8, 0x7C, 0x7C, 0x7C, 0x7E, 0x3E, 0x3E, 0x0F, 0x9F, 0x07, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3D, 0xE0, 0x07, 0xC0, 0xFF, 0x8F, 0xFC,
  0xFF, 0xF7, 0xCF, 0xFC, 0x3F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xF0, 0x0F, 0x84, 0x7F, 0xF1, 0xFF, 0xC7, 0xFC, 0x1F, 0x80, 0x03,
  0xE0, 0xFC, 0x3F, 0x8F, 0xF1, 0xF8, 0x3E, 0x07, 0xC3, 0xFE, 0xFF, 0xDF,
  0xFB, 0xFE, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x07, 0x9F, 0x1F, 0xDE,
  0x1F, 0xFE, 0x3F, 0xFE, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0x7C, 0xFC, 0x7F, 0xF8,
  0x7F, 0xF8, 0x3F, 0xF8, 0x1E, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x41, 0xF0,
  0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0x00, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xBC, 0x3F, 0xF8,
  0xFF, 0xF3, 0xFF, 0xCF, 0x9F, 0x3E, 0x7D, 0xF1, 0xF7, 0xC7, 0xDF, 0x1F,
  0x7C, 0x7D, 0xF1, 0xF7, 0xCF, 0xBE, 0x3E, 0xF8, 0xFB, 0xE3, 0xEF, 0x8F,
  0xBE, 0x3E, 0x0F, 0x07, 0xC7, 0xE1, 0xF0, 0xF0, 0x00, 0x00, 0x3E, 0x1F,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC7, 0xC3, 0xE1, 0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x7E, 0x01, 0xF0,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07,
  0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x7E, 0x3E, 0x7E, 0x1F, 0x3F, 0x0F, 0xBF, 0x07, 0xFF, 0x03, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0x7C,
  0x0F, 0xBE, 0x0F, 0x9F, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF8, 0x0F,
  0x87, 0xC3, 0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xC3,
  0xE1, 0xF0, 0x1E, 0xF8, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x3E, 0x7E, 0x7C, 0xF9, 0xF1, 0xF3, 0xE7, 0xC7, 0xDF, 0x1F, 0x3E,
  0x7C, 0x7C, 0xF9, 0xF1, 0xF3, 0xE7, 0xCF, 0x8F, 0x9F, 0x3E, 0x3E, 0x7C,
  0xF8, 0xFB, 0xE3, 0xE7, 0xCF, 0x8F, 0x9F, 0x3E, 0x3E, 0x7C, 0xF9, 0xF1,
  0xF0, 0x3E, 0xF0, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x3E, 0x7C, 0xF9, 0xF7,
  0xC7, 0xDF, 0x1F, 0x7C, 0x7D, 0xF1, 0xF7, 0xC7, 0xDF, 0x3E, 0xF8, 0xFB,
  0xE3, 0xEF, 0x8F, 0xBE, 0x3E, 0xF8, 0xF8, 0x03, 0xE0, 0x1F, 0xF0, 0x7F,
  0xE1, 0xFF, 0xE3, 0xE7, 0xCF, 0x87, 0x9F, 0x0F, 0x3E, 0x3E, 0x7C, 0x7C,
  0xF8, 0xF9, 0xE1, 0xF3, 0xC3, 0xE7, 0xCF, 0x8F, 0xFF, 0x0F, 0xFC, 0x1F,
  0xF0, 0x0F, 0x80, 0x0F, 0x78, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F,
  0x3F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x7D,
  0xE0, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x07, 0x9E, 0x3F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF7, 0xE7,
  0xEF, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0x7D, 0xF8, 0xFB, 0xE3, 0xF7,
  0xC7, 0xC7, 0xCF, 0x8F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0,
  0x1E, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7C, 0x0F, 0x83, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x00,
  0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x8F, 0xFE, 0x3C, 0x7D, 0xF0, 0x03, 0xE0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x3C, 0x7C, 0xF9, 0xF3, 0xFF,
  0xC7, 0xFE, 0x0F, 0xF8, 0x1F, 0x80, 0x1F, 0x0F, 0x87, 0xC7, 0xC7, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3E, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE1, 0xF0,
  0xF8, 0x7F, 0x1F, 0x8F, 0xC3, 0xE0, 0x7C, 0x7D, 0xF1, 0xF7, 0xC7, 0xDF,
  0x1F, 0x7C, 0x7D, 0xF3, 0xFF, 0x8F, 0xBE, 0x3E, 0xF8, 0xFB, 0xE3, 0xEF,
  0x8F, 0xBE, 0x7C, 0xF9, 0xF3, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3D, 0xF0,
  0x7C, 0x7D, 0xF3, 0xF7, 0xCF, 0x9F, 0x3E, 0x7D, 0xF1, 0xF7, 0xC7, 0xDF,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF1, 0xE7, 0xFC, 0x79, 0xFF, 0x3E,
  0x7B, 0xCF, 0xBE, 0xF7, 0xEF, 0xBD, 0xFB, 0xCF, 0x7E, 0xF3, 0xFF, 0xFC,
  0xFE, 0xFE, 0x3F, 0xBF, 0x8F, 0xEF, 0xE3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F,
  0x3F, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0xF0, 0x00, 0x1F, 0x1F, 0x1F,
  0x3E, 0x1F, 0x3E, 0x0F, 0x7C, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3E, 0xF0, 0x3E,
  0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xF8, 0x1F, 0x1F, 0x0F, 0x8F, 0x87,
  0xCF, 0xC3, 0xE7, 0xC1, 0xF7, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0xFE,
  0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xFF,
  0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0x01, 0x81, 0xC1, 0xE1, 0xE0, 0xF0,
  0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0xC3, 0xC7, 0xE3, 0xE1, 0xC0,
  0xF0, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xF8, 0x78, 0x1C,
  0x0F, 0x07, 0x81, 0xC0, 0x40, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C,
  0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x30, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x60, 0x04, 0x03, 0x80, 0xF0,
  0x1C, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F,
  0x01, 0xF0, 0x7C, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83,
  0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x38, 0x04, 0x00, 0x1E,
  0x00, 0x7E, 0x3D, 0xFE, 0x7F, 0xFF, 0xEF, 0x3F, 0xDE, 0x3F, 0x00, 0x3C,
  0x00,
};

const GFXglyph RobotoCondensed_BlackItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 23, 8, 0, -23 },
  { 27, 11, 9, 10, 1, -24 },
  { 40, 16, 23, 16, 0, -23 },
  { 86, 15, 29, 16, 1, -26 },
  { 141, 15, 23, 20, 3, -23 },
  { 185, 17, 23, 19, 0, -23 },
  { 234, 5, 9, 5, 2, -24 },
  { 240, 10, 32, 10, 1, -25 },
  { 280, 10, 32, 10, -1, -25 },
  { 320, 13, 14, 14, 2, -23 },
  { 343, 13, 17, 14, 1, -19 },
  { 371, 7, 10, 8, -2, -4 },
  { 380, 9, 4, 13, 2, -12 },
  { 385, 5, 5, 9, 1, -5 },
  { 389, 14, 25, 10, -2, -23 },
  { 433, 14, 23, 16, 1, -23 },
  { 474, 11, 23, 16, 3, -23 },
  { 506, 16, 23, 16, 0, -23 },
  { 552, 16, 23, 16, 0, -23 },
  { 598, 14, 23, 16, 1, -23 },
  { 639, 15, 23, 16, 1, -23 },
  { 683, 14, 23, 16, 1, -23 },
  { 724, 16, 23, 16, 1, -23 },
  { 770, 15, 23, 16, 1, -23 },
  { 814, 13, 23, 16, 2, -23 },
  { 852, 7, 17, 9, 1, -17 },
  { 867, 9, 23, 9, -1, -17 },
  { 893, 14, 15, 14, 0, -17 },
  { 920, 14, 11, 16, 1, -15 },
  { 940, 13, 15, 14, 0, -17 },
  { 965, 13, 23, 14, 2, -23 },
  { 1003, 23, 29, 24, 0, -22 },
  { 1087, 19, 23, 19, -2, -23 },
  { 1142, 17, 23, 18, 0, -23 },
  { 1191, 17, 23, 18, 1, -23 },
  { 1240, 17, 23, 17, 0, -23 },
  { 1289, 17, 23, 15, 0, -23 },
  { 1338, 16, 23, 15, 0, -23 },
  { 1384, 17, 23, 18, 1, -23 },
  { 1433, 20, 23, 19, 0, -23 },
  { 1491, 9, 23, 9, 0, -23 },
  { 1517, 16, 23, 15, 0, -23 },
  { 1563, 20, 23, 17, 0, -23 },
  { 1621, 13, 23, 15, 0, -23 },
  { 1659, 24, 23, 24, 0, -23 },
  { 1728, 20, 23, 19, 0, -23 },
  { 1786, 17, 23, 19, 1, -23 },
  { 1835, 18, 23, 18, 0, -23 },
  { 1887, 17, 27, 19, 1, -23 },
  { 1945, 18, 23, 18, 0, -23 },
  { 1997, 16, 23, 17, 1, -23 },
  { 2043, 17, 23, 17, 2, -23 },
  { 2092, 18, 23, 18, 1, -23 },
  { 2144, 18, 23, 18, 2, -23 },
  { 2196, 22, 23, 23, 3, -23 },
  { 2260, 20, 23, 17, -1, -23 },
  { 2318, 16, 23, 17, 3, -23 },
  { 2364, 19, 23, 17, -1, -23 },
  { 2419, 11, 32, 8, -1, -27 },
  { 2463, 9, 25, 12, 2, -23 },
  { 2492, 11, 32, 8, -2, -27 },
  { 2536, 11, 11, 12, 1, -23 },
  { 2552, 12, 4, 12, -2, 0 },
  { 2558, 8, 5, 11, 3, -24 },
  { 2563, 14, 17, 14, 0, -17 },
  { 2593, 15, 24, 15, 0, -24 },
  { 2638, 14, 17, 14, 0, -17 },
  { 2668, 17, 24, 15, 0, -24 },
  { 2719, 13, 17, 15, 1, -17 },
  { 2747, 11, 24, 10, 1, -24 },
  { 2780, 16, 24, 16, 0, -17 },
  { 2828, 14, 24, 15, 0, -24 },
  { 2870, 9, 24, 8, 0, -24 },
  { 2897, 13, 31, 8, -4, -24 },
  { 2948, 17, 24, 15, 0, -24 },
  { 2999, 9, 24, 8, 0, -24 },
  { 3026, 22, 17, 23, 0, -17 },
  { 3073, 14, 17, 15, 0, -17 },
  { 3103, 15, 17, 15, 0, -17 },
  { 3135, 16, 24, 15, -1, -17 },
  { 3183, 15, 24, 15, 0, -17 },
  { 3228, 11, 17, 11, 0, -17 },
  { 3252, 14, 17, 14, 0, -17 },
  { 3282, 9, 21, 10, 1, -21 },
  { 3306, 14, 17, 15, 1, -17 },
  { 3336, 14, 17, 14, 1, -17 },
  { 3366, 18, 17, 19, 2, -17 },
  { 3405, 16, 17, 14, -1, -17 },
  { 3439, 17, 24, 14, -1, -17 },
  { 3490, 15, 17, 14, -1, -17 },
  { 3522, 9, 31, 9, 1, -25 },
  { 3557, 8, 27, 8, 0, -23 },
  { 3584, 10, 31, 9, -1, -25 },
  { 3623, 15, 7, 17, 1, -13 },
};

const GFXfont RobotoCondensed_BlackItalic32pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic32pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic32pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOCONDENSED_BLACKITALIC32PT7B_H_
