#ifndef _ROBOTOCONDENSED_BLACKITALIC21PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0xF3, 0xCE, 0x38, 0xE3, 0x8E, 0x31, 0xC7, 0x00, 0x63, 0xC6,
  0x00, 0x6C, 0xDB, 0xB6, 0x6C, 0xDB, 0x00, 0x06, 0xC0, 0xD8, 0x36, 0x06,
  0xC3, 0xFC, 0x7F, 0x86, 0xC0, 0xD8, 0x16, 0x1F, 0xF3, 0xFE, 0x1A, 0x06,
  0xC0, 0xD8, 0x1B, 0x00, 0x06, 0x03, 0x07, 0x87, 0xE7, 0xFB, 0x9D, 0xCE,
  0xE0, 0x3C, 0x1F, 0x03, 0xC0, 0xEE, 0x77, 0x3B, 0xFD, 0xFC, 0x3C, 0x08,
  0x0C, 0x00, 0x78, 0x3E, 0x0D, 0x9B, 0x66, 0xDB, 0x3F, 0x87, 0xE0, 0x30,
  0x1F, 0x8D, 0xE3, 0xCD, 0xB3, 0xCD, 0xD3, 0xE0, 0x70, 0x0F, 0x03, 0xF0,
  0x7E, 0x1C, 0xC3, 0xB8, 0x3F, 0x07, 0xC1, 0xF7, 0x7E, 0xEF, 0xFF, 0xDF,
  0x7B, 0xEF, 0xF8, 0xFF, 0x8F, 0x70, 0x6D, 0xFD, 0x80, 0x04, 0x31, 0xCE,
  0x31, 0xC7, 0x18, 0xE3, 0x8E, 0x38, 0xC3, 0x0C, 0x30, 0xC3, 0x86, 0x1C,
  0x20, 0x10, 0x30, 0x30, 0x60, 0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x61,
  0xC3, 0x87, 0x0C, 0x38, 0x61, 0xC7, 0x0C, 0x00, 0x0C, 0x06, 0x13, 0x3F,
  0xF3, 0xF0, 0xE0, 0xD8, 0xCC, 0x04, 0x00, 0x0E, 0x07, 0x03, 0x81, 0xC7,
  0xFB, 0xFD, 0xFE, 0x38, 0x1C, 0x0E, 0x0F, 0x00, 0x39, 0x9C, 0xE7, 0x71,
  0x00, 0x7D, 0xF7, 0xC0, 0x07, 0xF7, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x07,
  0x01, 0x80, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x07,
  0x01, 0x80, 0x1E, 0x1F, 0x9F, 0xEE, 0x77, 0x3F, 0x9F, 0xCF, 0xC7, 0xE7,
  0xF3, 0xB9, 0xDC, 0xEF, 0xE3, 0xF0, 0xF0, 0x06, 0x3D, 0xFF, 0xED, 0xC3,
  0x87, 0x1E, 0x38, 0x70, 0xE1, 0xC3, 0x8F, 0x1C, 0x00, 0x0F, 0x07, 0xE3,
  0xFC, 0xE7, 0x79, 0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xFF, 0xBF, 0xEF, 0xF8, 0x0F, 0x07, 0xE3, 0xFC, 0xE7, 0x01, 0xC0, 0x70,
  0xF8, 0x3C, 0x0F, 0x80, 0xE0, 0x3B, 0x8E, 0xFF, 0x9F, 0xC3, 0xE0, 0x03,
  0xC0, 0xF0, 0x7C, 0x1F, 0x0F, 0x87, 0xE1, 0xB8, 0xEE, 0x77, 0x9F, 0xFF,
  0xFB, 0xFE, 0x07, 0x01, 0xC0, 0xF0, 0x1F, 0xC7, 0xF3, 0xFC, 0xE0, 0x38,
  0x0F, 0xC7, 0xF9, 0xCE, 0x03, 0x80, 0xE0, 0x3B, 0xCE, 0x7F, 0x9F, 0xC3,
  0xE0, 0x07, 0x0F, 0x8F, 0xC7, 0x07, 0x03, 0xF3, 0xFD, 0xFE, 0xE7, 0xF3,
  0xF9, 0xFC, 0xEF, 0xF3, 0xF0, 0xF0, 0x7F, 0xDF, 0xF7, 0xF8, 0x0E, 0x07,
  0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xE0, 0x78, 0x3C, 0x0F,
  0x00, 0x0F, 0x07, 0xE3, 0xFC, 0xE7, 0x39, 0xCE, 0x73, 0xF8, 0x7C, 0x3F,
  0x9C, 0xE7, 0x39, 0xCE, 0x7F, 0x9F, 0xC3, 0xE0, 0x1E, 0x1F, 0x9F, 0xEE,
  0x7F, 0x3F, 0x9F, 0xCE, 0xEF, 0x7F, 0x9F, 0x81, 0xC1, 0xC7, 0xE3, 0xE1,
  0xC0, 0x00, 0xE3, 0xCE, 0x00, 0x00, 0x00, 0x01, 0xCF, 0x1C, 0x00, 0x71,
  0xC7, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x8C, 0x71, 0xCE, 0x10, 0x00, 0x81,
  0xC7, 0xCF, 0xE7, 0x87, 0x81, 0xF8, 0x7E, 0x0E, 0x01, 0x00, 0x7F, 0xBF,
  0xDF, 0xC0, 0x0F, 0xF7, 0xFB, 0xFC, 0x20, 0x1C, 0x0F, 0x83, 0xF0, 0x78,
  0x79, 0xFC, 0xF8, 0xF0, 0x40, 0x00, 0x3E, 0x3F, 0x9F, 0xDE, 0xE0, 0x70,
  0x78, 0x78, 0x78, 0x38, 0x1C, 0x00, 0x00, 0x07, 0x03, 0x81, 0xC0, 0x01,
  0xF0, 0x0F, 0xF0, 0x38, 0x30, 0xC0, 0x63, 0x9E, 0x66, 0x7E, 0xDD, 0xD9,
  0xB3, 0x33, 0x6E, 0x67, 0xD9, 0xCF, 0x33, 0x36, 0x66, 0x6C, 0xFF, 0x98,
  0xEE, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x01,
  0xC0, 0x3C, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0E, 0xE1, 0xEE, 0x1C,
  0xE1, 0xFE, 0x3F, 0xF3, 0xFF, 0x78, 0xF7, 0x0F, 0xF0, 0x70, 0x3F, 0x87,
  0xFC, 0xFF, 0x9C, 0x73, 0x8E, 0x71, 0xDE, 0x7B, 0xFE, 0x7F, 0xCE, 0x39,
  0xC7, 0x38, 0xEF, 0xFD, 0xFF, 0x3F, 0xC0, 0x0F, 0x87, 0xF8, 0xFF, 0x38,
  0xF7, 0x1F, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x8F, 0x71, 0xEF,
  0xF8, 0xFE, 0x0F, 0x80, 0x3F, 0x87, 0xF8, 0xFF, 0x1C, 0xF3, 0x8E, 0x71,
  0xDE, 0x3B, 0xCF, 0x71, 0xEE, 0x3D, 0xC7, 0x39, 0xEF, 0xF9, 0xFE, 0x3F,
  0x80, 0x3F, 0xE7, 0xFC, 0xFF, 0x9C, 0x03, 0x80, 0x70, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8E, 0x01, 0xC0, 0x38, 0x0F, 0xF9, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7,
  0xFC, 0xFF, 0x1C, 0x03, 0x80, 0x70, 0x1F, 0xE3, 0xFC, 0x7F, 0x8E, 0x01,
  0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x00, 0x0F, 0x87, 0xF8, 0xFF, 0xBC,
  0x77, 0x0F, 0xE0, 0x3C, 0x07, 0xBE, 0xE7, 0xDC, 0x3B, 0x8F, 0x71, 0xEF,
  0xFC, 0xFF, 0x0F, 0x80, 0x3C, 0x79, 0xE3, 0xCE, 0x1E, 0x70, 0xE3, 0x87,
  0x1C, 0x39, 0xFF, 0xCF, 0xFE, 0x7F, 0xE3, 0x87, 0x1C, 0x38, 0xE1, 0xCF,
  0x1E, 0x78, 0xF3, 0x87, 0x00, 0x1C, 0xF3, 0xCE, 0x38, 0xE3, 0x9E, 0x79,
  0xC7, 0x1C, 0x73, 0xCF, 0x00, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C,
  0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x73, 0xDE, 0x73, 0xCF, 0xF0, 0xFC,
  0x0F, 0x00, 0x3C, 0xF9, 0xE7, 0x8E, 0x78, 0x73, 0x83, 0xBC, 0x1F, 0xC1,
  0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xE7, 0x0F, 0x3C, 0x79,
  0xE3, 0x8F, 0x00, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0,
  0x70, 0x38, 0x1C, 0x0E, 0x0F, 0xFF, 0xFB, 0xFC, 0x3E, 0x1F, 0x3E, 0x1F,
  0x3E, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x7E, 0x7E, 0x76, 0x7E,
  0x76, 0xFE, 0x76, 0xDC, 0x77, 0xDC, 0x77, 0x9C, 0xF7, 0xBC, 0xF7, 0x3C,
  0xE3, 0x38, 0x3C, 0x79, 0xE3, 0xCF, 0x1E, 0x7C, 0xE3, 0xE7, 0x1F, 0x39,
  0xFB, 0xCF, 0xDE, 0x73, 0xE3, 0x9F, 0x1C, 0xF8, 0xE7, 0xCF, 0x3E, 0x78,
  0xF3, 0x87, 0x00, 0x0F, 0x87, 0xF8, 0xFF, 0x3C, 0xF7, 0x0F, 0xE1, 0xFC,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3B, 0x87, 0x71, 0xEF, 0xF8, 0xFE, 0x0F, 0x80,
  0x3F, 0x83, 0xFE, 0x3F, 0xE3, 0x8E, 0x38, 0xF3, 0x8F, 0x78, 0xE7, 0xFE,
  0x7F, 0xC7, 0xF8, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x00, 0x0F,
  0x87, 0xF8, 0xFF, 0x3C, 0xF7, 0x0F, 0xE1, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC,
  0x3B, 0x87, 0x71, 0xEF, 0xF8, 0xFE, 0x0F, 0xC0, 0x3C, 0x03, 0x80, 0x20,
  0x3F, 0x87, 0xFC, 0xFF, 0x9C, 0x73, 0x8E, 0x71, 0xDE, 0x7B, 0xFF, 0x7F,
  0xCF, 0xF1, 0xDE, 0x39, 0xCF, 0x39, 0xE7, 0xB8, 0xF0, 0x07, 0x83, 0xF8,
  0xFF, 0x9E, 0x73, 0x8E, 0x78, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7B, 0xC7,
  0x39, 0xE7, 0xFC, 0x7F, 0x07, 0xC0, 0x7F, 0xEF, 0xFD, 0xFF, 0x87, 0x00,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0,
  0x78, 0x0E, 0x00, 0x78, 0xEF, 0x1D, 0xC7, 0xB8, 0xF7, 0x1E, 0xE3, 0xBC,
  0x77, 0x8E, 0xE3, 0xDC, 0x7B, 0x8F, 0x71, 0xCF, 0xF8, 0xFE, 0x0F, 0x80,
  0x70, 0xF7, 0x0F, 0x71, 0xE7, 0x1E, 0x71, 0xC7, 0x3C, 0x7B, 0xC7, 0xB8,
  0x7F, 0x83, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x00, 0xE7,
  0x1F, 0x9C, 0xFE, 0x73, 0xBB, 0xCE, 0xEF, 0x7B, 0xBD, 0xCF, 0xF7, 0x3F,
  0xDC, 0xFF, 0xE3, 0xEF, 0x8F, 0xBE, 0x3E, 0xF8, 0xF3, 0xC3, 0xCF, 0x0F,
  0x3C, 0x00, 0x1E, 0x78, 0x79, 0xE1, 0xEF, 0x03, 0xBC, 0x0F, 0xE0, 0x3F,
  0x00, 0xFC, 0x01, 0xE0, 0x0F, 0x80, 0x7F, 0x01, 0xDC, 0x0F, 0x70, 0x39,
  0xE1, 0xE7, 0x8F, 0x1E, 0x00, 0xE1, 0xDC, 0x7B, 0xCE, 0x7B, 0xC7, 0x70,
  0xFE, 0x1F, 0x83, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1C, 0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07,
  0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xFF, 0xCF, 0xFC, 0xFF,
  0x80, 0x0F, 0x0F, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x78, 0x78, 0x78, 0x71,
  0xC7, 0x1C, 0x71, 0xE7, 0x8E, 0x38, 0xE3, 0x8E, 0x3C, 0xF1, 0xC7, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0x87, 0x0E, 0x1C, 0x38, 0xF1, 0xE3, 0x87, 0x0E,
  0x1C, 0x78, 0xF1, 0xC7, 0x8F, 0x1E, 0x00, 0x1C, 0x38, 0xF3, 0xE6, 0xFD,
  0xF1, 0x80, 0xFF, 0xFF, 0xFE, 0xF3, 0x8E, 0x1E, 0x1F, 0xDF, 0xEE, 0x73,
  0xFB, 0xFF, 0xDD, 0xCE, 0xEF, 0x7F, 0x9D, 0xC0, 0x3C, 0x0F, 0x03, 0x80,
  0xE0, 0x38, 0x0F, 0xC7, 0xF9, 0xFE, 0x73, 0xDC, 0xF7, 0x39, 0xCE, 0xF3,
  0xBF, 0xEF, 0xF3, 0xB8, 0x1F, 0x1F, 0x9F, 0xEE, 0x77, 0x07, 0x83, 0xC1,
  0xCE, 0x7F, 0x3F, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C,
  0x3B, 0x8F, 0xF3, 0xFE, 0x73, 0x8E, 0x73, 0xCE, 0x79, 0xCE, 0x79, 0xFF,
  0x1F, 0xC1, 0xF8, 0x1F, 0x1F, 0xDF, 0xEE, 0x77, 0x3B, 0xFF, 0xFF, 0xE0,
  0x7F, 0x3F, 0x8F, 0x80, 0x07, 0x1F, 0x1F, 0x1C, 0x3C, 0x7E, 0x7E, 0x38,
  0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0x1D, 0xCF, 0xF7, 0xFD,
  0xCF, 0x73, 0xFC, 0xEF, 0x3B, 0xCE, 0x7F, 0x9F, 0xE3, 0xF0, 0x1C, 0x7F,
  0x3F, 0x87, 0xC0, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xF9, 0xFE, 0xFF,
  0x73, 0xB9, 0xDC, 0xFE, 0x7F, 0x3F, 0x3F, 0x9D, 0xCE, 0x3C, 0xF1, 0x80,
  0x38, 0xE7, 0x9E, 0x71, 0xC7, 0x1C, 0xF3, 0xCE, 0x00, 0x0F, 0x0F, 0x06,
  0x00, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x38,
  0x38, 0xF8, 0xF0, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x77,
  0x9E, 0xF3, 0xFC, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x8F, 0x71, 0xEE, 0x39,
  0xE7, 0x3C, 0x1C, 0xF3, 0xCE, 0x38, 0xE3, 0x9E, 0x79, 0xC7, 0x1C, 0x73,
  0xCF, 0x38, 0x3F, 0xB8, 0xFF, 0xF7, 0xFF, 0xDC, 0xE7, 0x73, 0x9D, 0xCE,
  0x77, 0x39, 0xFD, 0xEF, 0xF7, 0xBB, 0x9C, 0xEE, 0x73, 0x80, 0x3F, 0x3F,
  0xDF, 0xEE, 0x77, 0x3B, 0x9D, 0xCF, 0xE7, 0xE7, 0xF3, 0xB9, 0xC0, 0x1F,
  0x0F, 0xE7, 0xF9, 0xCE, 0x73, 0xBC, 0xEF, 0x3B, 0xCE, 0x7F, 0x9F, 0xC3,
  0xE0, 0x1F, 0x87, 0xF8, 0xFF, 0x1C, 0xF3, 0x9E, 0x73, 0x8E, 0x73, 0xCE,
  0x7F, 0xCF, 0xF1, 0xDC, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x00, 0x1D, 0xCF,
  0xF7, 0xFD, 0xCE, 0x73, 0xBC, 0xEF, 0x3B, 0x9E, 0xFF, 0x9F, 0xC3, 0xF0,
  0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x3E, 0x7E, 0x7E, 0x78, 0x70, 0x70, 0x70,
  0xF0, 0xF0, 0xE0, 0xE0, 0x1E, 0x1F, 0x9C, 0xEE, 0x77, 0x81, 0xF0, 0x7D,
  0xCE, 0xE7, 0x3F, 0x0F, 0x00, 0x39, 0xE7, 0x3F, 0xFD, 0xC7, 0x3C, 0xE3,
  0x8E, 0x3C, 0xF1, 0xC0, 0x39, 0xDE, 0x77, 0xBD, 0xCF, 0x73, 0x9C, 0xE7,
  0x3B, 0xCE, 0xFF, 0x9F, 0xC7, 0xF0, 0xE7, 0xF3, 0xB9, 0xDD, 0xEE, 0xE3,
  0x71, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x00, 0xE6, 0x7E, 0xE7, 0xEE, 0xEE,
  0xEE, 0xFE, 0xEF, 0xEC, 0xFF, 0xCF, 0x7C, 0xF3, 0x8F, 0x38, 0xE3, 0x80,
  0x3D, 0xE3, 0xB8, 0x7F, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F,
  0x8E, 0x73, 0xCE, 0x00, 0x73, 0xDC, 0xF7, 0x39, 0xDE, 0x77, 0x0F, 0xC3,
  0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0xF0, 0x3C, 0x0E, 0x00, 0x3F,
  0xBF, 0xDF, 0xE1, 0xE1, 0xE0, 0xE0, 0xF0, 0xF0, 0xFF, 0x7F, 0xBF, 0xC0,
  0x04, 0x1C, 0x70, 0xE1, 0x87, 0x0E, 0x1C, 0x71, 0xE3, 0x83, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE0, 0xC0, 0x80, 0x18, 0xC6, 0x23, 0x18, 0xC6, 0x31,
  0x18, 0xC6, 0x31, 0x8C, 0x46, 0x00, 0x18, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x1C, 0x71, 0xC3, 0x87, 0x0E, 0x18, 0x70, 0xE3, 0x82, 0x00,
  0x71, 0xBC, 0xFF, 0xF9, 0xEC, 0x70,
};

const GFXglyph RobotoCondensed_BlackItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 15, 5, 0, -15 },
  { 13, 7, 6, 6, 1, -16 },
  { 19, 11, 15, 10, 0, -15 },
  { 40, 9, 19, 10, 1, -17 },
  { 62, 10, 15, 13, 2, -15 },
  { 81, 11, 15, 12, 0, -15 },
  { 102, 3, 6, 3, 1, -16 },
  { 105, 6, 21, 7, 1, -16 },
  { 121, 7, 21, 7, -1, -16 },
  { 140, 9, 9, 9, 1, -15 },
  { 151, 9, 11, 9, 0, -13 },
  { 164, 5, 7, 5, -1, -3 },
  { 169, 6, 3, 9, 1, -8 },
  { 172, 4, 4, 6, 0, -4 },
  { 174, 10, 16, 6, -2, -15 },
  { 194, 9, 15, 10, 1, -15 },
  { 211, 7, 15, 10, 2, -15 },
  { 225, 10, 15, 10, 0, -15 },
  { 244, 10, 15, 10, 0, -15 },
  { 263, 10, 15, 10, 0, -15 },
  { 282, 10, 15, 10, 0, -15 },
  { 301, 9, 15, 10, 1, -15 },
  { 318, 10, 15, 10, 1, -15 },
  { 337, 10, 15, 10, 0, -15 },
  { 356, 9, 15, 10, 1, -15 },
  { 373, 6, 12, 6, 0, -12 },
  { 382, 6, 16, 6, -1, -12 },
  { 394, 9, 10, 9, 0, -11 },
  { 406, 9, 7, 11, 1, -10 },
  { 414, 9, 10, 9, 0, -11 },
  { 426, 9, 15, 9, 1, -15 },
  { 443, 15, 19, 16, 0, -14 },
  { 479, 12, 15, 12, -1, -15 },
  { 502, 11, 15, 12, 0, -15 },
  { 523, 11, 15, 12, 1, -15 },
  { 544, 11, 15, 11, 0, -15 },
  { 565, 11, 15, 10, 0, -15 },
  { 586, 11, 15, 10, 0, -15 },
  { 607, 11, 15, 12, 1, -15 },
  { 628, 13, 15, 12, 0, -15 },
  { 653, 6, 15, 6, 0, -15 },
  { 665, 11, 15, 10, 0, -15 },
  { 686, 13, 15, 11, 0, -15 },
  { 711, 9, 15, 10, 0, -15 },
  { 728, 16, 15, 15, 0, -15 },
  { 758, 13, 15, 12, 0, -15 },
  { 783, 11, 15, 12, 1, -15 },
  { 804, 12, 15, 12, 0, -15 },
  { 827, 11, 18, 12, 1, -15 },
  { 852, 11, 15, 12, 0, -15 },
  { 873, 11, 15, 11, 0, -15 },
  { 894, 11, 15, 11, 1, -15 },
  { 915, 11, 15, 12, 1, -15 },
  { 936, 12, 15, 12, 1, -15 },
  { 959, 14, 15, 15, 2, -15 },
  { 986, 14, 15, 11, -1, -15 },
  { 1013, 11, 15, 11, 2, -15 },
  { 1034, 12, 15, 11, 0, -15 },
  { 1057, 8, 22, 5, -1, -18 },
  { 1079, 6, 16, 8, 1, -15 },
  { 1091, 7, 22, 5, -1, -18 },
  { 1111, 7, 7, 8, 1, -15 },
  { 1118, 8, 3, 8, -1, 0 },
  { 1121, 5, 3, 7, 2, -16 },
  { 1123, 9, 11, 10, 0, -11 },
  { 1136, 10, 16, 10, 0, -16 },
  { 1156, 9, 11, 9, 0, -11 },
  { 1169, 11, 16, 10, 0, -16 },
  { 1191, 9, 11, 10, 0, -11 },
  { 1204, 8, 16, 7, 0, -16 },
  { 1220, 10, 15, 10, 0, -11 },
  { 1239, 9, 16, 10, 0, -16 },
  { 1257, 6, 15, 5, 0, -15 },
  { 1269, 8, 19, 5, -2, -15 },
  { 1288, 11, 16, 10, 0, -16 },
  { 1310, 6, 16, 5, 0, -16 },
  { 1322, 14, 11, 15, 0, -11 },
  { 1342, 9, 11, 10, 0, -11 },
  { 1355, 10, 11, 10, 0, -11 },
  { 1369, 11, 15, 10, -1, -11 },
  { 1390, 10, 15, 10, 0, -11 },
  { 1409, 8, 11, 7, 0, -11 },
  { 1420, 9, 11, 9, 0, -11 },
  { 1433, 6, 14, 6, 1, -14 },
  { 1444, 10, 11, 10, 0, -11 },
  { 1458, 9, 11, 9, 1, -11 },
  { 1471, 12, 11, 13, 1, -11 },
  { 1488, 11, 11, 9, -1, -11 },
  { 1504, 10, 15, 9, 0, -11 },
  { 1523, 9, 11, 9, 0, -11 },
  { 1536, 7, 20, 6, 0, -16 },
  { 1554, 5, 18, 5, 0, -15 },
  { 1566, 7, 20, 6, -1, -16 },
  { 1584, 9, 5, 11, 1, -9 },
};

const GFXfont RobotoCondensed_BlackItalic21pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic21pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic21pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOCONDENSED_BLACKITALIC21PT7B_H_
