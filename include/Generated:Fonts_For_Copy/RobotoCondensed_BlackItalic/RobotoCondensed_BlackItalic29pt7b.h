#ifndef _ROBOTOCONDENSED_BLACKITALIC29PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C,
  0x3C, 0x3C, 0x38, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF8, 0x70, 0x7B, 0xB9,
  0xDC, 0xEE, 0x77, 0x3B, 0x3B, 0x9D, 0xCE, 0x01, 0xDC, 0x03, 0x30, 0x0E,
  0xE0, 0x1D, 0xC0, 0x33, 0x00, 0xEE, 0x0F, 0xFF, 0x9F, 0xFE, 0x3F, 0xFC,
  0x1D, 0xC0, 0x3B, 0x80, 0x66, 0x0F, 0xFF, 0x9F, 0xFE, 0x3F, 0xFC, 0x1D,
  0xC0, 0x3B, 0x80, 0x77, 0x01, 0xCC, 0x03, 0xB8, 0x07, 0x70, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x07, 0x80, 0xFF, 0x0F, 0xF8, 0xFF, 0xE7, 0xCF,
  0x3C, 0x79, 0xE3, 0xCF, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7C, 0x01, 0xF7, 0x8F, 0xBC, 0x7D, 0xE3, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF,
  0x03, 0xE0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1E, 0x00, 0xFC, 0x07, 0xF1,
  0x1D, 0xC7, 0x77, 0x39, 0x9D, 0xC6, 0x77, 0x1F, 0xF8, 0x7F, 0xC0, 0xF7,
  0x00, 0x38, 0x01, 0xDC, 0x07, 0xFC, 0x3F, 0xF1, 0xDD, 0xCE, 0xE7, 0x3B,
  0x9D, 0xCE, 0x72, 0x1F, 0xC0, 0x7E, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x78, 0x0F,
  0xE0, 0x1F, 0x80, 0x7E, 0x79, 0xFE, 0xF7, 0xFD, 0xEF, 0x7F, 0xFE, 0xFF,
  0x7C, 0xFE, 0xF8, 0xF8, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xE1, 0xF3, 0xC0,
  0x3B, 0xDE, 0xE7, 0x39, 0xDC, 0x00, 0x81, 0xC1, 0xE0, 0xE0, 0xE0, 0xF0,
  0x70, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x0E, 0x03,
  0x00, 0x80, 0x08, 0x06, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC1,
  0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x3C, 0x1C, 0x08, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x17, 0x33, 0xBF, 0xFC, 0xFF, 0xC1, 0xE0,
  0x1F, 0x81, 0xEC, 0x1E, 0x70, 0x61, 0xC0, 0x08, 0x00, 0x07, 0x80, 0x78,
  0x0F, 0x80, 0xF8, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE1, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x00, 0x1E, 0x3C, 0x78, 0xE3,
  0xC7, 0x9E, 0x38, 0x20, 0x7F, 0xFF, 0xFE, 0xFE, 0x31, 0xE7, 0xDE, 0x38,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x7F, 0xE3, 0xC7, 0x9E, 0x3D,
  0xF1, 0xEF, 0x1F, 0x78, 0xFB, 0xC7, 0xFE, 0x3F, 0xF1, 0xEF, 0x8F, 0x7C,
  0x7B, 0xC7, 0xDE, 0x3C, 0xF1, 0xE3, 0xFF, 0x1F, 0xF0, 0x7F, 0x01, 0xF0,
  0x00, 0x00, 0x83, 0xCF, 0xEF, 0xFF, 0xFF, 0xFA, 0x3C, 0x1E, 0x1F, 0x0F,
  0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x87,
  0xC0, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x87, 0xFF, 0x3E, 0x7C, 0xF9, 0xF3,
  0xC7, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC,
  0xFF, 0xF0, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x87, 0xFF, 0x3E, 0x7C, 0xF9,
  0xF0, 0x07, 0xC0, 0x1F, 0x07, 0xF8, 0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0x00,
  0xF0, 0x03, 0xE0, 0x0F, 0xBE, 0x3E, 0xF8, 0xF9, 0xFF, 0xC7, 0xFE, 0x0F,
  0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8,
  0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x7B, 0xC1, 0xEF, 0x0F, 0x7C,
  0x3D, 0xF1, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF8, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC7, 0xFF, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x70, 0x3F, 0xF0, 0xFF, 0xC3, 0xCF, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xBE, 0x3E, 0x78, 0xF1, 0xFF, 0xC7,
  0xFE, 0x0F, 0xF0, 0x0F, 0x80, 0x00, 0xF0, 0x3F, 0x0F, 0xE1, 0xFE, 0x1F,
  0x03, 0xE0, 0x3C, 0x07, 0xFC, 0x7F, 0xE7, 0xFF, 0xFF, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF0, 0xFF, 0x1F, 0xF9, 0xF7, 0xFE, 0x7F, 0xC3, 0xFC, 0x1F,
  0x00, 0x3F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFE, 0x00, 0xF8, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x7F, 0x87, 0xFC, 0x7F, 0xF3, 0xEF, 0x9E, 0x7C,
  0xF3, 0xE7, 0x9F, 0x3F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xCF, 0x9E, 0x7C,
  0xFB, 0xC7, 0xDE, 0x3E, 0xF1, 0xE7, 0xFF, 0x3F, 0xF0, 0xFF, 0x01, 0xF0,
  0x00, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0xFE, 0x79, 0xFF, 0x9F, 0xF9, 0xFF,
  0x1F, 0xF1, 0xFF, 0x9F, 0xFB, 0xEF, 0xFE, 0x7F, 0xE3, 0xFE, 0x03, 0xC0,
  0x7C, 0x0F, 0x87, 0xF0, 0x7E, 0x07, 0xC0, 0x70, 0x00, 0x18, 0x78, 0xF9,
  0xE1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x0F, 0x1F, 0x3E, 0x38, 0x06,
  0x07, 0x87, 0xC1, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x06, 0x00, 0x00,
  0x10, 0x07, 0x01, 0xF0, 0x7F, 0x3F, 0xF7, 0xF8, 0x7E, 0x07, 0xC0, 0xFF,
  0x03, 0xFC, 0x1F, 0xE0, 0x7C, 0x01, 0xC0, 0x04, 0x3F, 0xFB, 0xFF, 0x9F,
  0xFC, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF,
  0x00, 0x10, 0x03, 0xC0, 0x3E, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xF0,
  0x3F, 0x1F, 0xF7, 0xFC, 0x7F, 0x07, 0xC0, 0x70, 0x08, 0x00, 0x1F, 0x07,
  0xF9, 0xFF, 0xFF, 0xFF, 0xBF, 0xE7, 0xC0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0,
  0x7C, 0x1F, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x30, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xFC, 0xF8, 0x0F,
  0x01, 0xC0, 0xF0, 0x07, 0x07, 0x00, 0x38, 0x70, 0xF0, 0xC7, 0x8F, 0xE6,
  0x38, 0xFF, 0x39, 0xCF, 0x39, 0xDC, 0x73, 0x8E, 0xE7, 0x1C, 0x77, 0x38,
  0xE3, 0x71, 0xC7, 0x3B, 0x9E, 0x71, 0xDC, 0xF3, 0x8C, 0xE7, 0x9C, 0xE7,
  0x1F, 0xFE, 0x38, 0xFB, 0xF0, 0xC3, 0x9E, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x03, 0xFE, 0x03, 0xDE, 0x07, 0xDE, 0x07, 0x9E, 0x0F, 0x9E, 0x0F, 0x9E,
  0x0F, 0x1E, 0x1F, 0xFE, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x7C, 0x1F,
  0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x1F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE,
  0x1F, 0xFE, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x3E, 0x3E, 0x7E,
  0x3F, 0xFC, 0x3F, 0xF0, 0x7F, 0xFC, 0x7C, 0x3C, 0x7C, 0x3C, 0x7C, 0x3C,
  0x7C, 0x7C, 0x78, 0x7C, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0,
  0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF3, 0xE3, 0xE7, 0x83, 0xDF,
  0x07, 0xBE, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x1F, 0x7C, 0x3E, 0xF8, 0xF8, 0xFF, 0xF1, 0xFF, 0xC1,
  0xFF, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1,
  0xE3, 0xE7, 0xC3, 0xCF, 0x87, 0x9F, 0x0F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF0,
  0xFB, 0xE1, 0xF7, 0xC3, 0xEF, 0x87, 0xDF, 0x1F, 0x3E, 0x3E, 0x78, 0xF9,
  0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x3F, 0xFC,
  0x7F, 0xF8, 0xFF, 0xF1, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F,
  0xF8, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0x87, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x78, 0x01, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x00,
  0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE1, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0x87, 0xFF,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE,
  0x3E, 0x1E, 0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF8, 0xFE, 0xF9, 0xFE, 0xF9, 0xFC, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0x7C, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x1F, 0x07,
  0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1E, 0x1E, 0x0F, 0x8F, 0x83, 0xE3,
  0xE0, 0xF8, 0xF8, 0x3E, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF,
  0xFC, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xE1, 0xF0, 0x78, 0x78, 0x3E,
  0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3C, 0x00, 0x0F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0xF8, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x3E, 0x7C, 0x7C,
  0xF8, 0xF9, 0xF0, 0xFF, 0xC1, 0xFF, 0x01, 0xFE, 0x01, 0xF0, 0x00, 0x1F,
  0x0F, 0xC7, 0xC7, 0xE1, 0xF1, 0xF0, 0x7C, 0xFC, 0x1E, 0x7E, 0x0F, 0x9F,
  0x03, 0xEF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xEF, 0x81, 0xF3, 0xE0, 0x78,
  0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x00, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0xFC, 0x7F, 0x07,
  0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0xFF, 0x1F, 0xC3, 0xF8, 0xFF, 0x0F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3D, 0xC7, 0xF8, 0xF7, 0x3F, 0xC3, 0xDC,
  0xEF, 0x1F, 0x77, 0xBC, 0x7D, 0xDD, 0xF1, 0xF7, 0x77, 0xC7, 0xDF, 0xDF,
  0x1F, 0x7E, 0x78, 0x79, 0xF9, 0xE3, 0xE7, 0xCF, 0x8F, 0x9F, 0x3E, 0x3E,
  0x38, 0xF8, 0xF8, 0xE3, 0xE0, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF8, 0x78,
  0x7E, 0x1E, 0x1F, 0x8F, 0x8F, 0xE3, 0xE3, 0xF8, 0xF8, 0xFF, 0x3E, 0x3F,
  0xCF, 0x0F, 0xF3, 0xC3, 0xDD, 0xF1, 0xF3, 0xFC, 0x7C, 0xFF, 0x1F, 0x3F,
  0xC7, 0xCF, 0xE1, 0xF1, 0xF8, 0x78, 0x7E, 0x3E, 0x1F, 0x8F, 0x87, 0xE3,
  0xE1, 0xF8, 0xF8, 0x3C, 0x00, 0x03, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFE, 0x3E, 0x3E, 0x3C, 0x1E, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x1E, 0xF8,
  0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3C, 0xF8,
  0x7C, 0xF8, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x1F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E,
  0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x3E, 0x3F, 0xFE, 0x7F, 0xFC, 0x7F,
  0xF8, 0x7F, 0xE0, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFE, 0x3E, 0x3E, 0x3C, 0x1E, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x78,
  0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3C, 0xF8,
  0x7C, 0xF8, 0x7C, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x20, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFE, 0x1F, 0xFE, 0x1E, 0x1F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E,
  0x1E, 0x3E, 0x3E, 0x3F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x7D,
  0xF0, 0x7C, 0xF8, 0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8,
  0x7C, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xE3, 0xE7, 0x87,
  0xCF, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x1F, 0x80, 0x1F, 0x3C, 0x3E, 0x78, 0x7C, 0xF8, 0xF9, 0xFF, 0xE1, 0xFF,
  0xC1, 0xFF, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x3E, 0x1F, 0x3E,
  0x1F, 0x3E, 0x1F, 0x3E, 0x1E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x78, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0xF8, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F,
  0xE0, 0x1F, 0x80, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0x78,
  0x7C, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF0, 0x7D,
  0xF0, 0x7D, 0xF0, 0x7D, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0xF8, 0xF1, 0xFF,
  0x8F, 0x1F, 0xF9, 0xF1, 0xFF, 0x9F, 0x1E, 0xF9, 0xF3, 0xEF, 0xBF, 0x3E,
  0xFB, 0xF3, 0xCF, 0xBF, 0x7C, 0xFB, 0xF7, 0xCF, 0xFF, 0x78, 0xFF, 0xF7,
  0x8F, 0xFF, 0xF8, 0xFF, 0x7F, 0x0F, 0xF7, 0xF0, 0xFF, 0x7F, 0x0F, 0xE7,
  0xF0, 0xFE, 0x7E, 0x0F, 0xE7, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xC0, 0x7C,
  0x7C, 0x00, 0x1F, 0x87, 0xC1, 0xF1, 0xF8, 0x3E, 0x3E, 0x07, 0xCF, 0x80,
  0x79, 0xF0, 0x0F, 0x7C, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0xFB, 0xE0, 0x3F, 0x7C, 0x07, 0xCF, 0x81, 0xF8, 0xF0, 0x3E,
  0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x78, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0xF8, 0x3C, 0xF8, 0x3D, 0xF0, 0x3D, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0F, 0xFF,
  0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0xFE,
  0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x07, 0xC1, 0xF0, 0xFC, 0x3E,
  0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07,
  0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1E, 0x07, 0xC3, 0xF0, 0xFC, 0x00, 0xF8, 0xF8, 0xF8, 0x78,
  0x78, 0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E,
  0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0,
  0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0xC0, 0x07,
  0x03, 0xE0, 0xF8, 0x7E, 0x1F, 0x8E, 0xE3, 0xB9, 0xC7, 0x71, 0xFC, 0x70,
  0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0xF0, 0xF0, 0xE0, 0x07, 0xC1,
  0xFE, 0x3F, 0xF3, 0xEF, 0x7C, 0xF0, 0x0F, 0x0F, 0xF3, 0xFF, 0x7F, 0xFF,
  0x9F, 0xF9, 0xEF, 0x9E, 0xFB, 0xEF, 0xFE, 0x7F, 0xE3, 0xDE, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xFF, 0x87, 0xFE, 0x3F,
  0xF9, 0xFF, 0xCF, 0x1E, 0x78, 0xF7, 0xC7, 0xBE, 0x3D, 0xF3, 0xEF, 0x1F,
  0x78, 0xFB, 0xC7, 0xBF, 0xFD, 0xFF, 0xEF, 0x7E, 0x79, 0xE0, 0x07, 0xC0,
  0xFF, 0x0F, 0xFC, 0x7F, 0xE7, 0xCF, 0x3C, 0x79, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x3E, 0x7C, 0xF3, 0xC7, 0xFE, 0x3F, 0xF0, 0xFF, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x83,
  0xDF, 0x0F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF1, 0xF1, 0xE3, 0xC7, 0xC7, 0x8F,
  0x8F, 0x1F, 0x1E, 0x3E, 0x7C, 0x78, 0xF8, 0xF1, 0xF3, 0xE1, 0xFF, 0xC3,
  0xFF, 0x87, 0xFF, 0x07, 0xBC, 0x00, 0x07, 0xC0, 0xFF, 0x87, 0xFC, 0x7F,
  0xF3, 0xC7, 0xBE, 0x3D, 0xE1, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDE, 0x00,
  0xF0, 0x87, 0xFE, 0x3F, 0xF0, 0xFF, 0x81, 0xF0, 0x03, 0xC3, 0xF1, 0xFC,
  0x7F, 0x1E, 0x0F, 0x8F, 0xFB, 0xFE, 0xFF, 0x8F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x00,
  0x0F, 0xBC, 0x7E, 0xF3, 0xFF, 0xCF, 0xFF, 0x7C, 0x7D, 0xF1, 0xE7, 0x87,
  0x9E, 0x3E, 0x78, 0xFB, 0xE3, 0xEF, 0x8F, 0x9E, 0x3C, 0x7F, 0xF1, 0xFF,
  0xC3, 0xFF, 0x07, 0xFC, 0x01, 0xF0, 0x0F, 0x87, 0xFE, 0x3F, 0xF0, 0xFF,
  0x80, 0xFC, 0x00, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xFF, 0x87, 0xFE, 0x3F, 0xF9, 0xFF, 0xCF, 0x3E, 0xF9, 0xF7, 0xCF,
  0xBE, 0x7D, 0xE3, 0xEF, 0x1E, 0x78, 0xF7, 0xCF, 0xBE, 0x7D, 0xF3, 0xEF,
  0x1F, 0x78, 0xF0, 0x06, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x1E, 0x3E,
  0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF8,
  0xF8, 0xF8, 0x00, 0x80, 0x7C, 0x0F, 0x81, 0xF0, 0x1C, 0x00, 0x00, 0x00,
  0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E,
  0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x9F, 0x9F, 0x7E, 0x3E, 0xF8, 0x7B,
  0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xE0, 0xF7, 0xC3, 0xE7, 0x87, 0xCF, 0x8F, 0x9F, 0x1E, 0x3E, 0x00,
  0x0F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C,
  0x3C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0xF8, 0xF8, 0x3E, 0xF3,
  0xC3, 0xFF, 0x7E, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3C, 0xF9, 0xF3, 0xCF,
  0x9F, 0x7C, 0xF9, 0xF7, 0xCF, 0x9E, 0x7C, 0xF1, 0xE7, 0x8F, 0x3E, 0x79,
  0xF3, 0xE7, 0x9F, 0x3E, 0xF9, 0xF3, 0xEF, 0x9F, 0x3C, 0xF9, 0xE3, 0xCF,
  0x1E, 0x3C, 0x3C, 0xE1, 0xFF, 0x8F, 0xFE, 0x7F, 0xF3, 0xCF, 0xBE, 0x7D,
  0xF3, 0xEF, 0x9F, 0x78, 0xFB, 0xC7, 0x9E, 0x3D, 0xF3, 0xEF, 0x9F, 0x7C,
  0xFB, 0xC7, 0xDE, 0x3C, 0x07, 0xC0, 0xFF, 0x87, 0xFC, 0x7F, 0xF7, 0xC7,
  0xBE, 0x3D, 0xE1, 0xEF, 0x1F, 0x78, 0xFF, 0xC7, 0xFE, 0x3E, 0xF1, 0xE7,
  0xFF, 0x3F, 0xF0, 0xFF, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7,
  0xFF, 0x1E, 0x3C, 0xF8, 0xF3, 0xE3, 0xCF, 0x8F, 0x3E, 0x7C, 0xF1, 0xF3,
  0xC7, 0xDF, 0x1E, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x1E, 0x78, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x0F, 0x3C, 0x7F,
  0xF3, 0xFF, 0x8F, 0xFE, 0x7C, 0xF9, 0xE3, 0xE7, 0x8F, 0x9E, 0x3E, 0x78,
  0xF3, 0xE3, 0xCF, 0x8F, 0x3E, 0x7C, 0x7F, 0xF1, 0xFF, 0xC7, 0xFE, 0x0F,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xDF, 0x07, 0xC1, 0xF0, 0x7C, 0x1E,
  0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0x07, 0xC1, 0xFE, 0x3F,
  0xF3, 0xCF, 0x7C, 0xF7, 0xC0, 0x3E, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03,
  0xEF, 0x1E, 0xF3, 0xEF, 0xFE, 0x7F, 0xC1, 0xF0, 0x1E, 0x3E, 0x3E, 0xFF,
  0xFF, 0xFF, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF8, 0xF8, 0xFC,
  0xFC, 0x7C, 0x3C, 0x7C, 0xFB, 0xE7, 0xDE, 0x3E, 0xF1, 0xE7, 0x8F, 0x7C,
  0x7B, 0xE7, 0xDF, 0x3E, 0xF1, 0xF7, 0x8F, 0x3C, 0x79, 0xE3, 0xCF, 0xFE,
  0x7F, 0xF3, 0xFF, 0x8F, 0x78, 0xF8, 0xFF, 0xCF, 0x9E, 0x7C, 0xF3, 0xC7,
  0x9E, 0x3D, 0xF1, 0xEF, 0x0F, 0x78, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFE,
  0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0xF3, 0x8F, 0xF3, 0xCF, 0xF7,
  0xDF, 0xF7, 0xDE, 0xF7, 0xDE, 0xFF, 0xFE, 0xFF, 0xFC, 0xEF, 0xFC, 0xFD,
  0xF8, 0xFD, 0xF8, 0xFD, 0xF8, 0xF9, 0xF0, 0xF9, 0xF0, 0xF9, 0xF0, 0xF1,
  0xE0, 0xF1, 0xE0, 0x1E, 0x3C, 0x3C, 0xF8, 0x7D, 0xE0, 0x7F, 0xC0, 0xFF,
  0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81,
  0xFF, 0x03, 0xDE, 0x0F, 0xBE, 0x1F, 0x3C, 0x7C, 0x78, 0x3E, 0x3E, 0x3C,
  0x78, 0x79, 0xF0, 0xF3, 0xE1, 0xEF, 0x83, 0xDF, 0x07, 0xBC, 0x0F, 0xF8,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFE, 0x01, 0xF0,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xF8, 0x03, 0x07, 0x0F, 0x1E, 0x1E,
  0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0xF0, 0xE0, 0xF0, 0xF0,
  0x78, 0x78, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0x30, 0x10, 0x0E,
  0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x87, 0x0E,
  0x18, 0x30, 0x61, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0x60, 0x0C, 0x07, 0x03,
  0x81, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x3C, 0x1E, 0x1F, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70,
  0x78, 0x78, 0x38, 0x08, 0x00, 0x3C, 0x3B, 0xF1, 0xDF, 0xCF, 0xFF, 0xFE,
  0x3F, 0x71, 0xF8, 0x07, 0x80,
};

const GFXglyph RobotoCondensed_BlackItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 21, 7, 0, -21 },
  { 22, 9, 8, 9, 1, -22 },
  { 31, 15, 21, 14, 0, -21 },
  { 71, 13, 27, 14, 1, -24 },
  { 115, 14, 21, 18, 2, -21 },
  { 152, 15, 21, 17, 0, -21 },
  { 192, 5, 8, 4, 1, -22 },
  { 197, 9, 29, 9, 1, -23 },
  { 230, 9, 29, 9, -1, -23 },
  { 263, 13, 13, 13, 1, -21 },
  { 285, 12, 15, 13, 1, -17 },
  { 308, 7, 9, 8, -2, -4 },
  { 316, 8, 4, 12, 2, -11 },
  { 320, 6, 5, 9, 0, -5 },
  { 324, 13, 23, 9, -2, -21 },
  { 362, 13, 21, 14, 1, -21 },
  { 397, 9, 21, 14, 3, -21 },
  { 421, 14, 21, 14, 0, -21 },
  { 458, 14, 21, 14, 0, -21 },
  { 495, 14, 21, 14, 0, -21 },
  { 532, 14, 21, 14, 0, -21 },
  { 569, 12, 21, 14, 1, -21 },
  { 601, 14, 21, 14, 1, -21 },
  { 638, 13, 21, 14, 1, -21 },
  { 673, 12, 21, 14, 2, -21 },
  { 705, 7, 16, 8, 1, -16 },
  { 719, 9, 21, 8, -1, -16 },
  { 743, 12, 14, 13, 0, -16 },
  { 764, 13, 10, 15, 1, -14 },
  { 781, 12, 14, 13, 0, -16 },
  { 802, 11, 21, 13, 2, -21 },
  { 831, 21, 26, 22, 0, -20 },
  { 900, 16, 21, 17, -1, -21 },
  { 942, 16, 21, 16, 0, -21 },
  { 984, 15, 21, 16, 1, -21 },
  { 1024, 15, 21, 16, 0, -21 },
  { 1064, 15, 21, 14, 0, -21 },
  { 1104, 15, 21, 13, 0, -21 },
  { 1144, 16, 21, 17, 1, -21 },
  { 1186, 18, 21, 17, 0, -21 },
  { 1234, 8, 21, 8, 0, -21 },
  { 1255, 15, 21, 14, 0, -21 },
  { 1295, 18, 21, 16, 0, -21 },
  { 1343, 12, 21, 13, 0, -21 },
  { 1375, 22, 21, 21, 0, -21 },
  { 1433, 18, 21, 17, 0, -21 },
  { 1481, 16, 21, 17, 1, -21 },
  { 1523, 16, 21, 16, 0, -21 },
  { 1565, 16, 25, 17, 1, -21 },
  { 1615, 16, 21, 16, 0, -21 },
  { 1657, 15, 21, 15, 1, -21 },
  { 1697, 15, 21, 16, 2, -21 },
  { 1737, 16, 21, 16, 1, -21 },
  { 1779, 16, 21, 16, 2, -21 },
  { 1821, 20, 21, 21, 2, -21 },
  { 1874, 19, 21, 16, -1, -21 },
  { 1924, 16, 21, 16, 2, -21 },
  { 1966, 17, 21, 15, -1, -21 },
  { 2011, 10, 29, 8, -1, -24 },
  { 2048, 8, 23, 11, 2, -21 },
  { 2071, 11, 29, 8, -2, -24 },
  { 2111, 10, 10, 11, 1, -21 },
  { 2124, 11, 4, 11, -2, 0 },
  { 2130, 7, 4, 10, 3, -21 },
  { 2134, 12, 16, 13, 0, -16 },
  { 2158, 13, 22, 14, 0, -22 },
  { 2194, 13, 16, 13, 0, -16 },
  { 2220, 15, 22, 14, 0, -22 },
  { 2262, 13, 16, 14, 0, -16 },
  { 2288, 10, 22, 9, 1, -22 },
  { 2316, 14, 22, 14, 0, -16 },
  { 2355, 13, 22, 14, 0, -22 },
  { 2391, 8, 23, 7, 0, -23 },
  { 2414, 11, 29, 7, -3, -23 },
  { 2454, 15, 22, 14, 0, -22 },
  { 2496, 8, 22, 7, 0, -22 },
  { 2518, 20, 16, 21, 0, -16 },
  { 2558, 13, 16, 14, 0, -16 },
  { 2584, 13, 16, 14, 0, -16 },
  { 2610, 14, 22, 14, -1, -16 },
  { 2649, 14, 22, 14, 0, -16 },
  { 2688, 10, 16, 10, 0, -16 },
  { 2708, 12, 16, 13, 0, -16 },
  { 2732, 8, 19, 9, 1, -19 },
  { 2751, 13, 16, 14, 1, -16 },
  { 2777, 13, 16, 13, 1, -16 },
  { 2803, 16, 16, 18, 2, -16 },
  { 2835, 15, 16, 13, -1, -16 },
  { 2865, 15, 22, 13, -1, -16 },
  { 2907, 14, 16, 13, -1, -16 },
  { 2935, 8, 28, 8, 1, -23 },
  { 2963, 7, 25, 7, 0, -21 },
  { 2985, 9, 28, 8, -1, -23 },
  { 3017, 13, 7, 15, 1, -12 },
};

const GFXfont RobotoCondensed_BlackItalic29pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic29pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic29pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOCONDENSED_BLACKITALIC29PT7B_H_
