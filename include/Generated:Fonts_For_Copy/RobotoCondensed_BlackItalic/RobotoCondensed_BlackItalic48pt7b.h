#ifndef _ROBOTOCONDENSED_BLACKITALIC48PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x1F, 0xC0, 0x7F, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0xF8,
  0x00, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xFB, 0xF3, 0xF7, 0xC7, 0xCF, 0x8F,
  0x9F, 0x1F, 0x3E, 0x3E, 0x78, 0x79, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF,
  0x0F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x7C, 0xF0, 0x00, 0x79, 0xF0, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x01, 0xF3, 0xC0, 0x01,
  0xE3, 0xC0, 0x01, 0xE7, 0xC0, 0x03, 0xE7, 0x80, 0x03, 0xC7, 0x80, 0x03,
  0xCF, 0x80, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0x0F, 0x9E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3E, 0x00, 0x1F,
  0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3C,
  0x78, 0x00, 0x3C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0x8F, 0xE0, 0xFF, 0x1F, 0xC1, 0xFC, 0x3F,
  0x83, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x8F, 0xF0, 0x7F, 0x1F, 0xE0, 0xFE, 0x3F, 0xC3,
  0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x9F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x07, 0xCF, 0x83, 0x0F, 0x9F, 0x0F, 0xBE, 0x3E, 0x1E, 0x7C,
  0x7C, 0x7C, 0xF8, 0xF9, 0xF1, 0xF1, 0xF7, 0xC3, 0xE3, 0xEF, 0x87, 0xEF,
  0xBE, 0x07, 0xFF, 0xF8, 0x0F, 0xFD, 0xE0, 0x0F, 0xF7, 0xC0, 0x07, 0xDF,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x0F, 0xBF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xF7, 0xCF, 0x83, 0xDF, 0x1F,
  0x0F, 0xBE, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF8, 0xF9, 0xF1, 0xF1, 0xF7,
  0xC3, 0xE7, 0xC7, 0x07, 0xCF, 0x84, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x0F, 0xE7, 0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xFC, 0x03, 0xF8, 0xFC,
  0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0x83, 0xFF,
  0x0F, 0xC3, 0xFF, 0xC7, 0xE3, 0xFF, 0xE7, 0xF3, 0xFF, 0xFB, 0xF3, 0xFD,
  0xFF, 0xF9, 0xFE, 0xFF, 0xFC, 0xFE, 0x3F, 0xFE, 0x7F, 0x1F, 0xFE, 0x7F,
  0x87, 0xFF, 0x1F, 0xC3, 0xFF, 0x0F, 0xF1, 0xFF, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFC, 0xFF,
  0x01, 0xF8, 0x7F, 0x80, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7C,
  0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0x00, 0x04, 0x00, 0x38, 0x00, 0xF8, 0x03,
  0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x02,
  0x00, 0x00, 0x80, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x0F,
  0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x38, 0x00, 0x40, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x10, 0x1E,
  0x04, 0xE0, 0xF1, 0xEF, 0xCF, 0x3F, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC3,
  0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF8,
  0x03, 0xF3, 0xC0, 0x3F, 0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x38,
  0x0E, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x1F,
  0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x3F,
  0x87, 0xE0, 0xF8, 0x06, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0x9F, 0xC3, 0xF8, 0x7F, 0x3F, 0x83,
  0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0xFF, 0x07, 0xF7, 0xF8, 0x3F, 0xBF,
  0xC3, 0xFD, 0xFC, 0x1F, 0xEF, 0xE0, 0xFF, 0x7F, 0x07, 0xF7, 0xF8, 0x3F,
  0xBF, 0xC1, 0xFD, 0xFE, 0x0F, 0xEF, 0xE0, 0xFF, 0x7F, 0x07, 0xFB, 0xF8,
  0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0xFF, 0x3F, 0x87, 0xF1,
  0xFE, 0x7F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x03,
  0xF8, 0x3F, 0xF3, 0xFF, 0xEF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFD,
  0xF7, 0xFB, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0x87, 0xF0, 0xFF, 0x1F, 0xE1,
  0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF,
  0x1F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x03,
  0xF9, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F, 0xE3, 0xFC, 0x7F, 0x87, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xBF, 0xC0, 0x7E, 0xFF, 0x03, 0xF3, 0xFC, 0x0F,
  0xCF, 0xE0, 0x7E, 0x3F, 0x83, 0xF9, 0xFE, 0x0F, 0xC7, 0xF8, 0x7F, 0x1F,
  0xE3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0xF8, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F,
  0xDF, 0xF0, 0x0E, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x0F,
  0xF1, 0xFC, 0x1F, 0xE3, 0xFC, 0x3F, 0x87, 0xF8, 0xFF, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF9, 0xF0, 0x7F, 0xFF, 0x87,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0xFE, 0x1F, 0xEF, 0xF3,
  0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F,
  0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF,
  0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F,
  0xC3, 0xF8, 0xFF, 0x0F, 0xE3, 0xF8, 0x3F, 0x9F, 0xE0, 0x7F, 0xFF, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x7F, 0x8F, 0xE1, 0xFE, 0x1F, 0xC7, 0xF0, 0x7F, 0x3F, 0xC1, 0xFC,
  0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0xC7, 0xF8, 0x7F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xCF, 0xE7, 0xF8, 0x7E,
  0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0x80, 0x07, 0xC0, 0x00, 0x07, 0x80, 0xFE, 0x1F, 0xE1, 0xFF, 0x1F,
  0xF1, 0xFE, 0x0F, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7F,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x3C, 0x00, 0x00, 0xF0,
  0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F,
  0x80, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x07, 0xC0, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x07,
  0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0x0F, 0xFF,
  0x03, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F,
  0x80, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0x10, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00,
  0x3F, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xF3,
  0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F,
  0x80, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xE7, 0xFF,
  0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F,
  0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xE0,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xE0, 0x7E,
  0x07, 0xE0, 0x7C, 0x1F, 0x07, 0xFE, 0x0F, 0x0F, 0x83, 0xFF, 0xC3, 0xC3,
  0xE1, 0xFF, 0xF8, 0xF1, 0xF0, 0x7F, 0x7C, 0x3C, 0x7C, 0x3F, 0x1F, 0x0F,
  0x3E, 0x1F, 0x87, 0xC3, 0xCF, 0x87, 0xC3, 0xE0, 0xF3, 0xE3, 0xF0, 0xF8,
  0x3C, 0xF0, 0xFC, 0x3E, 0x1F, 0x7C, 0x3E, 0x0F, 0x87, 0xDF, 0x1F, 0x87,
  0xC1, 0xE7, 0xC7, 0xE1, 0xF0, 0x79, 0xF1, 0xF8, 0x7C, 0x1E, 0x78, 0x7E,
  0x1F, 0x0F, 0x9E, 0x1F, 0x0F, 0x83, 0xCF, 0x87, 0xC3, 0xE0, 0xF3, 0xE1,
  0xF9, 0xF8, 0x78, 0xF8, 0x7F, 0xFE, 0x3E, 0x3E, 0x1F, 0xFF, 0xFF, 0x07,
  0x83, 0xFF, 0xFF, 0x81, 0xE0, 0xFF, 0x3F, 0xC0, 0x7C, 0x0F, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x01,
  0x00, 0x00, 0x3F, 0xE7, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x1F,
  0xCF, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0xC7, 0xF0,
  0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF0,
  0x3F, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF3, 0xFE, 0x01,
  0xFE, 0x7F, 0x80, 0x3F, 0xDF, 0xF0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x7F, 0x0F, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3,
  0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0x7F,
  0x87, 0xF8, 0x3F, 0xE1, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFE, 0x03, 0xFC,
  0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE1, 0xFE, 0x1F,
  0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xCF, 0xF8, 0x3F, 0xC0, 0xFF, 0x1F,
  0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xF1,
  0xFC, 0x03, 0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x87, 0xF8, 0x3F,
  0xE1, 0xFF, 0x9F, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0x1F, 0xF0, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF8,
  0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x07,
  0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF0, 0x1F, 0xE3, 0xFC,
  0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3,
  0xFC, 0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F,
  0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x3F, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xE3, 0xFE, 0x3F,
  0xC0, 0xFF, 0x3F, 0xC0, 0x3F, 0x9F, 0xE0, 0x1F, 0xCF, 0xF0, 0x0F, 0xEF,
  0xF0, 0x07, 0xF7, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x0F, 0xFE, 0x7F, 0x0F, 0xFF, 0x7F, 0x87, 0xFF, 0xBF, 0xC3, 0xFF,
  0xDF, 0xE1, 0xFF, 0xEF, 0xF0, 0xFF, 0xF7, 0xF8, 0x0F, 0xF3, 0xFC, 0x07,
  0xF9, 0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xC0,
  0xFF, 0x8F, 0xF9, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x81,
  0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F,
  0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x0F,
  0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC,
  0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x81, 0xFE, 0x01,
  0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F,
  0x81, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0,
  0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0x7F, 0x9F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xE0, 0x7F, 0xE0, 0x7F, 0x81,
  0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0xE0, 0x1F, 0xE1, 0xFF,
  0x00, 0x7F, 0x0F, 0xF8, 0x03, 0xFC, 0x7F, 0xC0, 0x0F, 0xF1, 0xFF, 0x00,
  0x3F, 0xCF, 0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xC7, 0xF8, 0x01,
  0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFF, 0x00, 0x7F,
  0x83, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x1F,
  0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF,
  0x80, 0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0x7C, 0x3F, 0x7F, 0x03, 0xFB, 0xF1, 0xFF,
  0xF8, 0x1F, 0xDF, 0x8F, 0xFF, 0xC0, 0xFE, 0xFC, 0xFD, 0xFE, 0x0F, 0xF7,
  0xE7, 0xEF, 0xE0, 0x7F, 0xBF, 0x7E, 0x7F, 0x03, 0xFC, 0xFB, 0xF7, 0xF8,
  0x1F, 0xE7, 0xDF, 0x3F, 0xC0, 0xFE, 0x3F, 0xF9, 0xFE, 0x07, 0xF1, 0xFF,
  0xCF, 0xE0, 0x7F, 0x8F, 0xFC, 0xFF, 0x03, 0xFC, 0x7F, 0xE7, 0xF8, 0x1F,
  0xE3, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x0F,
  0xF0, 0x3F, 0x87, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0x87, 0xF8, 0x1F, 0xE0,
  0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xE1, 0xFE, 0x07, 0xF8, 0x3E, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xF0, 0x0F, 0xE0, 0x7F, 0xC0, 0x7F,
  0x81, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xF8, 0x1F, 0xE0,
  0x7F, 0xE0, 0x7F, 0x03, 0xFF, 0x83, 0xFC, 0x0F, 0xFE, 0x0F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xC0, 0xFF, 0xF0, 0xFF, 0x03, 0xFF, 0xC3, 0xFC, 0x0F, 0xFF,
  0x0F, 0xE0, 0x7F, 0xBC, 0x7F, 0x81, 0xFE, 0xF9, 0xFE, 0x07, 0xFB, 0xE7,
  0xF8, 0x1F, 0xEF, 0x9F, 0xE0, 0x7F, 0xBE, 0x7F, 0x83, 0xFC, 0x79, 0xFC,
  0x0F, 0xF1, 0xFF, 0xF0, 0x3F, 0xC7, 0xFF, 0xC0, 0xFF, 0x1F, 0xFF, 0x03,
  0xFC, 0x3F, 0xFC, 0x0F, 0xE0, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0x81, 0xFE,
  0x0F, 0xFE, 0x07, 0xF8, 0x3F, 0xF8, 0x1F, 0xE0, 0x7F, 0xE0, 0x7F, 0x81,
  0xFF, 0x81, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F,
  0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0x9F, 0xF0, 0x7F, 0x81, 0xFE, 0x3F,
  0xC0, 0x7F, 0x8F, 0xF0, 0x0F, 0xE3, 0xF8, 0x03, 0xF9, 0xFE, 0x00, 0xFE,
  0x7F, 0x80, 0x3F, 0x9F, 0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xFB, 0xFC, 0x01,
  0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC,
  0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xE0, 0x0F, 0xF3,
  0xF8, 0x03, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x3F,
  0xC1, 0xFF, 0x3F, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFC, 0x1F, 0xF0,
  0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0xC0,
  0x7F, 0x07, 0xF8, 0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87,
  0xF8, 0x1F, 0xF0, 0xFF, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC1, 0xFF, 0x9F, 0xF8, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0x7F,
  0x8F, 0xF0, 0x0F, 0xE3, 0xFC, 0x03, 0xF9, 0xFE, 0x00, 0xFE, 0x7F, 0x80,
  0x3F, 0x9F, 0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0xFF,
  0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFC,
  0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03,
  0xFC, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC1, 0xFF,
  0x3F, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x02, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x7F, 0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC,
  0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0x3F, 0xC7,
  0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x87, 0xFE, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFE, 0x3F, 0xE0, 0x7F,
  0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xF0,
  0x7F, 0x87, 0xFC, 0x1F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F,
  0xF8, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xE3, 0xFC, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0x7F,
  0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF,
  0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC1, 0xFF, 0x0F, 0xF9, 0xFF, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xE1, 0xFE, 0x03,
  0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFC, 0x1F,
  0xE0, 0x7F, 0x83, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F,
  0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC,
  0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xF8,
  0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0,
  0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x83,
  0xFC, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x3F, 0xE3, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xFD, 0xFE, 0x01, 0xFF, 0x3F,
  0xC0, 0x3F, 0xE7, 0xF8, 0x07, 0xF8, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x3F,
  0xE3, 0xFC, 0x07, 0xF8, 0x7F, 0x81, 0xFF, 0x07, 0xF0, 0x3F, 0xC0, 0xFE,
  0x07, 0xF8, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x87, 0xF8,
  0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x07, 0xF9,
  0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xEF, 0xF0, 0x01, 0xFD, 0xFE, 0x00,
  0x3F, 0xBF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x7F,
  0xFF, 0x87, 0xF8, 0x3F, 0xFF, 0xC3, 0xFC, 0x3F, 0xDF, 0xE1, 0xFE, 0x1F,
  0xEF, 0xE1, 0xFF, 0x0F, 0xF7, 0xF0, 0xFF, 0x87, 0xF3, 0xF8, 0x7F, 0xC7,
  0xF9, 0xFC, 0x7F, 0xE3, 0xFC, 0xFE, 0x3F, 0xF1, 0xFC, 0x7F, 0x1F, 0xF9,
  0xFE, 0x3F, 0x8F, 0xFC, 0xFF, 0x1F, 0xCF, 0xFE, 0x7F, 0x0F, 0xE7, 0xFF,
  0x7F, 0x87, 0xF3, 0xFF, 0xBF, 0xC3, 0xFB, 0xFF, 0xDF, 0xC1, 0xFD, 0xFF,
  0xEF, 0xE0, 0xFE, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0x7F, 0xFC, 0x0F, 0xFF, 0xBF, 0xFC, 0x07, 0xFF,
  0xDF, 0xFE, 0x03, 0xFF, 0xCF, 0xFF, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0xFF,
  0xF3, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F,
  0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x03,
  0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF,
  0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x9F, 0xF0,
  0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFD, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xE3,
  0xF8, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x1F,
  0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0x81, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xBF,
  0xC0, 0x7F, 0xCF, 0xE0, 0x3F, 0xC7, 0xF0, 0x3F, 0xE3, 0xFC, 0x1F, 0xE1,
  0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC7, 0xF8,
  0x0F, 0xE3, 0xF8, 0x07, 0xF3, 0xFC, 0x01, 0xF9, 0xFC, 0x00, 0xFD, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x01, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xBE, 0x07, 0xDF, 0x07,
  0xEF, 0x83, 0xE7, 0xC3, 0xF3, 0xE1, 0xF1, 0xF9, 0xF8, 0x7C, 0xF8, 0x3E,
  0xFC, 0x1F, 0x7C, 0x0F, 0x80, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0xFF, 0x0F, 0xE0, 0xFE,
  0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0x1F,
  0xC7, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0xFC, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0x3F, 0x8F, 0xF1, 0xFC,
  0xFF, 0x1F, 0xE7, 0xF8, 0xFF, 0x3F, 0xC7, 0xF9, 0xFC, 0x3F, 0xCF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xDF, 0xC0,
  0x7C, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x7C, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xCF, 0xF0, 0x7F, 0x3F, 0xC3,
  0xFC, 0xFF, 0x0F, 0xF3, 0xF8, 0x3F, 0xCF, 0xE0, 0xFE, 0x3F, 0x83, 0xF9,
  0xFE, 0x0F, 0xE7, 0xF8, 0x3F, 0x9F, 0xE0, 0xFE, 0x7F, 0x07, 0xF9, 0xFE,
  0x3F, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFB, 0xFF,
  0x0F, 0xEF, 0xF8, 0x3F, 0x8F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x0F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0x8F, 0xE7,
  0xF0, 0x7E, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x1F,
  0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE3, 0xF8, 0xFF, 0xFF, 0x87, 0xFF,
  0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF3, 0xFC, 0x07, 0xFB, 0xFC, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F,
  0x8F, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0xFF,
  0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE,
  0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xDF, 0xC0, 0x0F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0xFF, 0x1F, 0xCF, 0xF0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8,
  0x3F, 0x9F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xDF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x41, 0xFF, 0x0E, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xC0,
  0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x07, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0xFF, 0xBF, 0x80,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x7F, 0xC7, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFF,
  0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F,
  0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC1,
  0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFB, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0xC0, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xCF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xE3, 0xFC, 0x1F,
  0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x0F, 0xE1, 0xFE, 0x1F, 0xC3, 0xF8,
  0x3F, 0x87, 0xF0, 0xFF, 0x0F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x87,
  0xF0, 0xFF, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF,
  0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1,
  0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x80, 0x00, 0xE0, 0x1F, 0x81, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFC,
  0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x01, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0xE1, 0xFC, 0x7F,
  0xE0, 0xFE, 0x3F, 0xE0, 0x7F, 0x3F, 0xE0, 0x7F, 0xBF, 0xE0, 0x3F, 0xDF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0xF9, 0xFC, 0x03, 0xF8, 0xFF, 0x01, 0xFC, 0x7F, 0x81,
  0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0x83, 0xFC,
  0x1F, 0xC1, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xE7, 0xE0, 0xFC, 0x07,
  0xF7, 0xF9, 0xFF, 0x03, 0xFF, 0xFD, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE,
  0x3F, 0x87, 0xF0, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x9F, 0xE1, 0xFC, 0x3F,
  0xCF, 0xF1, 0xFE, 0x1F, 0xC7, 0xF8, 0xFF, 0x0F, 0xE3, 0xF8, 0x7F, 0x8F,
  0xF1, 0xFC, 0x3F, 0xC7, 0xF8, 0xFE, 0x1F, 0xC3, 0xFC, 0xFF, 0x0F, 0xE1,
  0xFE, 0x7F, 0x87, 0xF0, 0xFE, 0x3F, 0xC7, 0xF8, 0x7F, 0x1F, 0xC3, 0xFC,
  0x3F, 0x8F, 0xE1, 0xFE, 0x3F, 0xC7, 0xF0, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F,
  0x0F, 0xF3, 0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x3F, 0xC3, 0xF8, 0xFE, 0x1F,
  0xE1, 0xFC, 0x7F, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF3, 0xE0, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x83, 0xFC, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xF8,
  0x7F, 0x87, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F,
  0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x07, 0xF0, 0xFE,
  0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x1F, 0xC1,
  0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xF1, 0xFE, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0xFF, 0x1F, 0xCF, 0xF0, 0xFE, 0x7F, 0x07, 0xFB, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFB, 0xF8,
  0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x0F, 0xF7, 0xF0, 0x7F, 0xBF, 0x83, 0xF9,
  0xFE, 0x3F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF9, 0xF0, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0,
  0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0,
  0xFF, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xE1,
  0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xE3, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xBF, 0xE0, 0x3F, 0x8F,
  0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF1, 0xFC, 0x1F, 0xE7,
  0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7,
  0xF8, 0x7F, 0x9F, 0xE1, 0xFE, 0x7F, 0x07, 0xFB, 0xFC, 0x1F, 0xCF, 0xF0,
  0x7F, 0x3F, 0xC3, 0xFC, 0xFF, 0x0F, 0xF3, 0xF8, 0x3F, 0xCF, 0xE0, 0xFF,
  0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x8F, 0xE1, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x3E, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xE7,
  0x87, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F,
  0xFC, 0x3F, 0xF2, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFE, 0xFF, 0x3F, 0xC7, 0xF3,
  0xF8, 0x7F, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0xFE, 0x1F, 0xEF, 0xE1, 0xFC, 0xFF, 0x3F, 0xC7, 0xFF,
  0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x8F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x8F, 0xF0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xC1, 0xFF, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0xC1, 0xFC, 0x7F, 0x0F,
  0xF3, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0xC3, 0xF8, 0xFE, 0x0F, 0xE3,
  0xF8, 0x3F, 0x8F, 0xE1, 0xFE, 0x7F, 0x87, 0xF9, 0xFE, 0x1F, 0xE7, 0xF8,
  0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF,
  0x3F, 0xC3, 0xF8, 0xFF, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x3F, 0xDF, 0xC0, 0x7E, 0x00, 0x00, 0xFF, 0x07, 0xFF, 0xF8, 0x7F,
  0xBF, 0xC3, 0xFC, 0xFE, 0x1F, 0xE7, 0xF1, 0xFE, 0x3F, 0x8F, 0xF1, 0xFC,
  0x7F, 0x0F, 0xE7, 0xF8, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xDF, 0xE0,
  0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x1F, 0x0F, 0xFF, 0xC7, 0xE1, 0xFF, 0xF8,
  0xFC, 0x7F, 0xFF, 0x1F, 0x8F, 0xEF, 0xC7, 0xF1, 0xFD, 0xF8, 0xFE, 0x3F,
  0xBF, 0x3F, 0xCF, 0xE7, 0xE7, 0xF9, 0xFC, 0xFC, 0xFF, 0x3F, 0x9F, 0xBF,
  0xEF, 0xE3, 0xF7, 0xFD, 0xFC, 0x7E, 0xFF, 0xBF, 0x0F, 0xFE, 0xF7, 0xE1,
  0xFF, 0xDF, 0xFC, 0x3F, 0xFB, 0xFF, 0x07, 0xFE, 0x7F, 0xE0, 0xFF, 0xCF,
  0xFC, 0x1F, 0xF9, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x0F,
  0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF0, 0x7F,
  0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x03,
  0xF8, 0x7F, 0x81, 0xFE, 0x3F, 0x80, 0x7F, 0x3F, 0xC0, 0x3F, 0x9F, 0xC0,
  0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFD, 0xFC, 0x01, 0xFE,
  0xFE, 0x00, 0xFE, 0x7F, 0x80, 0xFF, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x87, 0xF0, 0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF,
  0x0F, 0xE1, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F, 0xE3, 0xFC, 0x0F, 0xE3, 0xFC,
  0x0F, 0xE3, 0xFC, 0x0F, 0xE7, 0xF8, 0x0F, 0xE7, 0xF8, 0x0F, 0xEF, 0xF0,
  0x0F, 0xEF, 0xF0, 0x0F, 0xEF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x00, 0x08, 0x00, 0xF0, 0x07, 0xC0,
  0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x3E, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0E,
  0x00, 0x08, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x00, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x3F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x7E, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0x80, 0x0C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0xE0, 0xFC, 0x7F, 0xC1, 0xF9, 0xFF, 0xC3, 0xE3, 0xFF, 0xCF, 0xCF, 0xFF,
  0xFF, 0x9F, 0x9F, 0xFE, 0x3E, 0x1F, 0xFC, 0x7C, 0x1F, 0xF0, 0xF8, 0x1F,
  0xC0, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoCondensed_BlackItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 14, 34, 12, 0, -34 },
  { 61, 15, 13, 15, 2, -36 },
  { 86, 24, 34, 24, 0, -34 },
  { 188, 23, 44, 24, 1, -39 },
  { 315, 23, 34, 30, 4, -34 },
  { 413, 25, 34, 28, 0, -34 },
  { 520, 8, 13, 7, 2, -36 },
  { 533, 15, 49, 15, 2, -38 },
  { 625, 15, 49, 15, -2, -38 },
  { 717, 21, 21, 22, 2, -34 },
  { 773, 20, 25, 22, 1, -29 },
  { 836, 11, 15, 13, -3, -6 },
  { 857, 13, 6, 20, 3, -18 },
  { 867, 8, 8, 14, 1, -8 },
  { 875, 21, 37, 14, -3, -34 },
  { 973, 21, 34, 24, 2, -34 },
  { 1063, 15, 34, 24, 5, -34 },
  { 1127, 23, 34, 24, 0, -34 },
  { 1225, 23, 34, 24, 0, -34 },
  { 1323, 22, 34, 24, 1, -34 },
  { 1417, 23, 34, 24, 1, -34 },
  { 1515, 20, 34, 24, 2, -34 },
  { 1600, 23, 34, 24, 2, -34 },
  { 1698, 22, 34, 24, 1, -34 },
  { 1792, 20, 34, 24, 3, -34 },
  { 1877, 12, 27, 14, 1, -27 },
  { 1918, 14, 36, 13, -2, -27 },
  { 1981, 19, 23, 21, 1, -26 },
  { 2036, 20, 16, 24, 2, -23 },
  { 2076, 19, 23, 21, 1, -26 },
  { 2131, 19, 34, 21, 3, -34 },
  { 2212, 34, 44, 36, 0, -33 },
  { 2399, 27, 34, 28, -2, -34 },
  { 2514, 26, 34, 26, 0, -34 },
  { 2625, 26, 34, 27, 1, -34 },
  { 2736, 26, 34, 26, 0, -34 },
  { 2847, 25, 34, 23, 0, -34 },
  { 2954, 25, 34, 22, 0, -34 },
  { 3061, 25, 34, 28, 2, -34 },
  { 3168, 30, 34, 28, 0, -34 },
  { 3296, 14, 34, 13, 0, -34 },
  { 3356, 24, 34, 23, 0, -34 },
  { 3458, 30, 34, 26, 0, -34 },
  { 3586, 20, 34, 22, 0, -34 },
  { 3671, 37, 34, 35, 0, -34 },
  { 3829, 30, 34, 28, 0, -34 },
  { 3957, 26, 34, 28, 2, -34 },
  { 4068, 27, 34, 27, 0, -34 },
  { 4183, 26, 40, 28, 2, -34 },
  { 4313, 26, 34, 26, 0, -34 },
  { 4424, 25, 34, 26, 1, -34 },
  { 4531, 25, 34, 26, 3, -34 },
  { 4638, 27, 34, 27, 1, -34 },
  { 4753, 27, 34, 27, 3, -34 },
  { 4868, 33, 34, 35, 4, -34 },
  { 5009, 31, 34, 26, -2, -34 },
  { 5141, 25, 34, 26, 4, -34 },
  { 5248, 28, 34, 25, -1, -34 },
  { 5367, 17, 48, 12, -1, -40 },
  { 5469, 13, 37, 18, 3, -34 },
  { 5530, 17, 48, 12, -3, -40 },
  { 5632, 17, 17, 19, 1, -34 },
  { 5669, 19, 6, 18, -3, 0 },
  { 5684, 11, 7, 16, 5, -36 },
  { 5694, 21, 26, 22, 0, -26 },
  { 5763, 22, 36, 23, 0, -36 },
  { 5862, 20, 26, 21, 1, -26 },
  { 5927, 24, 36, 23, 1, -36 },
  { 6035, 21, 26, 23, 1, -26 },
  { 6104, 18, 36, 15, 1, -36 },
  { 6185, 25, 36, 24, -1, -26 },
  { 6298, 23, 36, 23, -1, -36 },
  { 6402, 13, 37, 12, 0, -37 },
  { 6463, 19, 47, 12, -6, -37 },
  { 6575, 25, 36, 23, 0, -36 },
  { 6688, 14, 36, 12, 0, -36 },
  { 6751, 33, 26, 34, 0, -26 },
  { 6859, 23, 26, 23, -1, -26 },
  { 6934, 21, 26, 23, 1, -26 },
  { 7003, 24, 36, 23, -2, -26 },
  { 7111, 22, 36, 23, 1, -26 },
  { 7210, 17, 26, 16, 0, -26 },
  { 7266, 20, 26, 21, 0, -26 },
  { 7331, 14, 32, 15, 2, -32 },
  { 7387, 22, 26, 23, 1, -26 },
  { 7459, 21, 26, 21, 2, -26 },
  { 7528, 27, 26, 29, 3, -26 },
  { 7616, 25, 26, 21, -2, -26 },
  { 7698, 24, 36, 21, -1, -26 },
  { 7806, 22, 26, 21, -1, -26 },
  { 7878, 14, 46, 14, 1, -38 },
  { 7959, 10, 40, 12, 1, -34 },
  { 8009, 15, 46, 14, -2, -37 },
  { 8096, 23, 11, 25, 1, -20 },
};

const GFXfont RobotoCondensed_BlackItalic48pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic48pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic48pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _ROBOTOCONDENSED_BLACKITALIC48PT7B_H_
