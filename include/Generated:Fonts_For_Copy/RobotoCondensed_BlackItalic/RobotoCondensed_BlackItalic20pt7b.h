#ifndef _ROBOTOCONDENSED_BLACKITALIC20PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0xE3, 0x8E, 0x38, 0xE3, 0x0C, 0x71, 0xC0, 0x18, 0xF1, 0x80,
  0x6F, 0xBC, 0xF7, 0xDB, 0x60, 0x07, 0x83, 0x60, 0xD8, 0x34, 0x3F, 0xCF,
  0xF1, 0xA0, 0x58, 0xFF, 0xBF, 0xC2, 0xC1, 0xB0, 0x6C, 0x1E, 0x00, 0x06,
  0x02, 0x07, 0x87, 0xE7, 0xF3, 0x9D, 0xCE, 0xE0, 0x3C, 0x0F, 0x03, 0xDC,
  0xEE, 0x77, 0xF3, 0xF8, 0xF8, 0x30, 0x18, 0x00, 0x70, 0x7C, 0x36, 0x7B,
  0x6D, 0xE7, 0xF1, 0xF0, 0x3E, 0x3F, 0x9E, 0xDB, 0x79, 0xB4, 0xF8, 0x38,
  0x0F, 0x03, 0xF0, 0x7E, 0x1D, 0xC3, 0xB8, 0x7E, 0x07, 0x81, 0xF6, 0x7E,
  0xDF, 0xFB, 0x9F, 0x7F, 0xC7, 0xF8, 0x7B, 0x80, 0x6F, 0xED, 0x80, 0x04,
  0x31, 0x8E, 0x31, 0xC6, 0x18, 0xE3, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC1,
  0x86, 0x08, 0x10, 0x30, 0x70, 0x60, 0xC1, 0x83, 0x87, 0x0E, 0x18, 0x30,
  0xE1, 0xC3, 0x86, 0x1C, 0x30, 0xE3, 0x86, 0x00, 0x0C, 0x06, 0x03, 0x1F,
  0xF7, 0xF1, 0xE1, 0xF1, 0xCC, 0x44, 0x00, 0x0E, 0x07, 0x03, 0x81, 0x87,
  0xFB, 0xFF, 0xFC, 0x38, 0x1C, 0x0C, 0x0E, 0x00, 0x33, 0x77, 0xEC, 0x7D,
  0xFF, 0x80, 0x7F, 0x60, 0x03, 0x07, 0x06, 0x06, 0x0C, 0x0C, 0x1C, 0x18,
  0x38, 0x30, 0x30, 0x60, 0x60, 0xC0, 0xC0, 0x1E, 0x1F, 0x9F, 0xCE, 0x7F,
  0x3F, 0x3F, 0x9D, 0xCE, 0xE7, 0x73, 0xB9, 0xDF, 0xCF, 0xC3, 0xC0, 0x04,
  0x7B, 0xF7, 0xE9, 0xC7, 0x8E, 0x1C, 0x38, 0x70, 0xE3, 0xC7, 0x0E, 0x00,
  0x0F, 0x07, 0xE3, 0xF8, 0xEF, 0x73, 0x80, 0xE0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xFE, 0xFF, 0x3F, 0xC0, 0x0F, 0x0F, 0xE3, 0xFC, 0xE7, 0x03,
  0xC1, 0xE0, 0xF0, 0x7C, 0x03, 0x80, 0xEE, 0x3B, 0xFC, 0x7F, 0x0F, 0x00,
  0x03, 0xC1, 0xE0, 0x78, 0x3E, 0x1F, 0x86, 0xE3, 0xF9, 0xDC, 0x7F, 0xBF,
  0xEF, 0xF8, 0x1C, 0x0E, 0x03, 0x80, 0x1F, 0xC7, 0xF3, 0xFC, 0xE0, 0x38,
  0x1F, 0xC7, 0xF0, 0xDE, 0x03, 0x80, 0xEF, 0x39, 0xFC, 0x7F, 0x0F, 0x00,
  0x07, 0x1F, 0x3F, 0x78, 0x70, 0xEE, 0xFF, 0xFF, 0xE7, 0xE7, 0xE7, 0xFF,
  0x7E, 0x3C, 0x7F, 0xBF, 0xFF, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C,
  0x1C, 0x1E, 0x0E, 0x0F, 0x07, 0x00, 0x0F, 0x07, 0xE3, 0xFC, 0xE7, 0x3B,
  0xCF, 0xE1, 0xF0, 0xFC, 0x73, 0x9C, 0xEF, 0x79, 0xFC, 0x7F, 0x0F, 0x00,
  0x1E, 0x1F, 0x9F, 0xCE, 0x6E, 0x7F, 0x3F, 0xDC, 0xFE, 0x3F, 0x07, 0x83,
  0x8F, 0x87, 0x83, 0x80, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x77, 0x98, 0x1C,
  0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x0C, 0x71, 0x84, 0x00, 0x01,
  0x03, 0x87, 0xCF, 0xC7, 0x87, 0x81, 0xF0, 0x7C, 0x0E, 0x01, 0x00, 0x7F,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0xFE, 0x20, 0x38, 0x7C, 0x1F, 0x07,
  0x0F, 0x7F, 0x78, 0xE0, 0x80, 0x3E, 0x7F, 0x7F, 0xE7, 0x0F, 0x0E, 0x1C,
  0x38, 0x30, 0x00, 0x00, 0x70, 0x70, 0x70, 0x03, 0xE0, 0x1F, 0xE0, 0xC1,
  0x86, 0x03, 0x31, 0xCC, 0xCF, 0xB6, 0x66, 0xDB, 0xBB, 0x6C, 0xCF, 0x33,
  0x3C, 0xCC, 0xF3, 0x76, 0xCF, 0xFB, 0x1B, 0xC6, 0x00, 0x1C, 0x00, 0x3F,
  0x80, 0x7C, 0x00, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x06, 0xC0, 0xEE,
  0x0E, 0xE1, 0xCE, 0x1F, 0xE3, 0xFE, 0x3F, 0xE7, 0x8E, 0x70, 0xEF, 0x0F,
  0x3F, 0x87, 0xF8, 0xFF, 0x9C, 0x73, 0x9E, 0xF3, 0x9F, 0xE3, 0xFC, 0x71,
  0xCE, 0x39, 0xCF, 0x7F, 0xEF, 0xF9, 0xFC, 0x00, 0x0F, 0x0F, 0xE7, 0xFD,
  0xC7, 0xF1, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0xEE, 0x3B, 0xFE, 0x7F,
  0x0F, 0x00, 0x3F, 0x07, 0xF0, 0xFF, 0x1C, 0xE3, 0x9E, 0xF3, 0xDC, 0x73,
  0x8E, 0x71, 0xCE, 0x39, 0xCF, 0x7F, 0xCF, 0xF1, 0xFC, 0x00, 0x3F, 0xC7,
  0xF8, 0xFF, 0x1C, 0x03, 0x80, 0xFF, 0x1F, 0xE3, 0xF8, 0x70, 0x0E, 0x01,
  0xC0, 0x7F, 0xCF, 0xF1, 0xFE, 0x00, 0x3F, 0xCF, 0xF3, 0xFC, 0xE0, 0x38,
  0x1F, 0xE7, 0xF9, 0xFC, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x00,
  0x0F, 0x0F, 0xE7, 0xFD, 0xC7, 0xF1, 0xFC, 0x0E, 0x03, 0x9F, 0xE7, 0xF8,
  0xFE, 0x3B, 0xFE, 0x7F, 0x8F, 0x80, 0x3C, 0x73, 0x87, 0x38, 0x73, 0x8F,
  0x38, 0xF7, 0xFE, 0x7F, 0xE7, 0xFE, 0x70, 0xE7, 0x1E, 0x71, 0xEF, 0x1C,
  0xE1, 0xCE, 0x1C, 0x3C, 0xF3, 0x8E, 0x38, 0xE7, 0x9C, 0x71, 0xC7, 0x1C,
  0xF3, 0x80, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x07, 0xB9, 0xCE, 0x73, 0xFC, 0x7E, 0x0F, 0x00, 0x3C, 0xF1, 0xCF, 0x0E,
  0x78, 0x77, 0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC,
  0x1D, 0xE1, 0xE7, 0x0E, 0x38, 0x71, 0xE0, 0x3C, 0x38, 0x38, 0x38, 0x38,
  0x78, 0x70, 0x70, 0x70, 0x70, 0x70, 0xFF, 0xFF, 0xFF, 0x3E, 0x1E, 0x7C,
  0x7C, 0xF8, 0xF9, 0xF1, 0xF3, 0xE7, 0xCE, 0xCF, 0x9D, 0xBF, 0x3B, 0x6E,
  0x76, 0xDC, 0xEF, 0x79, 0xDE, 0xE7, 0xBD, 0xCE, 0x73, 0x9C, 0xE7, 0x00,
  0x3C, 0x73, 0xC7, 0x3C, 0x73, 0xCF, 0x3E, 0xF7, 0xEE, 0x76, 0xE7, 0x6E,
  0x76, 0xE7, 0x3E, 0x73, 0xCF, 0x3C, 0xE3, 0xCE, 0x1C, 0x0F, 0x0F, 0xE7,
  0xFD, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFE, 0x3B, 0xFE,
  0x7F, 0x0F, 0x80, 0x3F, 0x87, 0xF8, 0xFF, 0x9C, 0x73, 0x8E, 0xF3, 0xDF,
  0xF3, 0xFE, 0x7F, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x00, 0x0F,
  0x07, 0xF1, 0xFF, 0x38, 0xEF, 0x1D, 0xE3, 0xB8, 0x77, 0x0E, 0xE1, 0xDC,
  0x7B, 0x8E, 0x7F, 0xC7, 0xF0, 0x7E, 0x01, 0xC0, 0x18, 0x02, 0x00, 0x3F,
  0x87, 0xF8, 0xFF, 0x9C, 0x73, 0x8E, 0xF3, 0xDF, 0xF3, 0xFC, 0x7F, 0x0E,
  0xF1, 0xDE, 0x79, 0xCE, 0x39, 0xC7, 0x80, 0x0F, 0x83, 0xF8, 0xFF, 0x9C,
  0x73, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0x9E, 0x79, 0xCF, 0x3F, 0xC7,
  0xF8, 0x3C, 0x00, 0x7F, 0xEF, 0xFB, 0xFF, 0x07, 0x01, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x79,
  0xEE, 0x39, 0xC7, 0x38, 0xE7, 0x1D, 0xE3, 0xB8, 0xF7, 0x1C, 0xE3, 0x9C,
  0x73, 0x8E, 0x7F, 0x8F, 0xF0, 0x78, 0x00, 0xF0, 0xE7, 0x1E, 0x71, 0xE7,
  0x1C, 0x73, 0xC7, 0x38, 0x73, 0x87, 0x70, 0x77, 0x03, 0x70, 0x3E, 0x03,
  0xE0, 0x3C, 0x03, 0xC0, 0xE7, 0x3F, 0x39, 0xFB, 0xDF, 0xDE, 0xEE, 0xF7,
  0x7F, 0xFB, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFE, 0x3D, 0xF1, 0xEF, 0x8F,
  0x78, 0x73, 0xC0, 0x1C, 0x78, 0xE3, 0x87, 0xBC, 0x1D, 0xC0, 0xFC, 0x07,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0x70, 0x73, 0x87, 0x9C,
  0x78, 0xF0, 0xE3, 0xF8, 0xEE, 0x7B, 0x9C, 0x6F, 0x1F, 0x87, 0xC1, 0xF0,
  0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x00, 0x3F, 0xE7, 0xFC, 0xFF,
  0x81, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xE0, 0x7F,
  0xCF, 0xF9, 0xFF, 0x00, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0x78, 0x70,
  0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1E, 0x38, 0xE3, 0x8E, 0x38, 0xF3, 0xC0,
  0x1E, 0x3C, 0x78, 0xE1, 0xC3, 0x87, 0x0E, 0x3C, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x3C, 0x70, 0xE3, 0xC7, 0x80, 0x1C, 0x78, 0xF3, 0xE6, 0xDD, 0xB3,
  0x80, 0xFF, 0xFC, 0xE3, 0x8C, 0x1E, 0x1F, 0x9D, 0xC0, 0xE3, 0xF3, 0xFB,
  0xDD, 0xCE, 0xEF, 0x7F, 0x9D, 0xC0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xF3,
  0xFD, 0xFE, 0xE7, 0x73, 0xB9, 0xDC, 0xFE, 0x7F, 0xF7, 0xFB, 0xB8, 0x1E,
  0x1F, 0x9F, 0xCE, 0x77, 0x07, 0x83, 0x81, 0xCE, 0x7F, 0x3F, 0x0F, 0x00,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x1F, 0xCF, 0xE7, 0xF9, 0xCE, 0x73, 0xBC,
  0xEE, 0x7B, 0x9C, 0xFF, 0x1F, 0xC7, 0xF0, 0x1E, 0x1F, 0x9F, 0xEE, 0x77,
  0x3B, 0xFF, 0xFF, 0xE0, 0x7E, 0x3F, 0x8F, 0x80, 0x0F, 0x1F, 0x1F, 0x3C,
  0x7E, 0x7E, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0x1D,
  0xCF, 0xF7, 0xF9, 0xCE, 0x73, 0xBC, 0xEE, 0x3B, 0x9E, 0xFF, 0x1F, 0xC3,
  0xF0, 0x1C, 0x4F, 0x3F, 0x87, 0x80, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xF3,
  0xFD, 0xFE, 0xE7, 0x73, 0xB9, 0xDD, 0xFC, 0xEE, 0x77, 0x3B, 0x9C, 0x38,
  0xE1, 0x80, 0x38, 0xE7, 0x9C, 0x71, 0xC7, 0x1C, 0xF3, 0x8E, 0x00, 0x0E,
  0x0E, 0x06, 0x00, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C,
  0x38, 0x38, 0x38, 0xF8, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3B,
  0xDF, 0xE7, 0x71, 0xFC, 0x7E, 0x1F, 0x87, 0xE3, 0xFC, 0xE7, 0x39, 0xCE,
  0x70, 0x3C, 0xE3, 0x8E, 0x38, 0xE7, 0x9C, 0x71, 0xC7, 0x1C, 0xF3, 0x8E,
  0x00, 0x3F, 0x79, 0xFF, 0xE7, 0xFF, 0xDC, 0xEF, 0x73, 0xB9, 0xDE, 0xE7,
  0x73, 0xBD, 0xCE, 0xE7, 0x3B, 0x9C, 0xEE, 0x77, 0x00, 0x77, 0x3F, 0xDF,
  0xEE, 0x77, 0x3B, 0x9F, 0xDF, 0xCE, 0xE7, 0x73, 0xB9, 0xC0, 0x1E, 0x1F,
  0x9F, 0xEE, 0x77, 0x3F, 0x9F, 0x8F, 0xC7, 0x7F, 0x3F, 0x0F, 0x00, 0x1F,
  0x8F, 0xF3, 0xFC, 0xE7, 0x39, 0xCE, 0x73, 0x9D, 0xE7, 0x7F, 0x9F, 0xE7,
  0x71, 0xC0, 0x70, 0x3C, 0x0E, 0x00, 0x3D, 0x8F, 0xE7, 0xF9, 0xCE, 0x73,
  0xBC, 0xEE, 0x73, 0x9C, 0xFF, 0x1F, 0xC7, 0xF0, 0x3C, 0x0E, 0x03, 0x80,
  0xE0, 0x3E, 0xFD, 0xFB, 0xC7, 0x0E, 0x1C, 0x78, 0xE1, 0xC3, 0x80, 0x1E,
  0x1F, 0x9D, 0xCE, 0x07, 0x81, 0xF0, 0x7D, 0xCE, 0xEF, 0x7F, 0x0F, 0x00,
  0x79, 0xCF, 0xBE, 0x71, 0xCE, 0x38, 0xE3, 0x8F, 0x3C, 0x70, 0x3B, 0xDC,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x7B, 0xDC, 0xFF, 0x1F, 0xC7, 0xF0,
  0xE7, 0x73, 0xBB, 0xDD, 0xCE, 0xE7, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1C,
  0x00, 0xE6, 0x7E, 0xEE, 0xEE, 0xEF, 0xEC, 0xFF, 0xCF, 0xFC, 0xFF, 0x8F,
  0x78, 0xF7, 0x8E, 0x70, 0xE7, 0x00, 0x39, 0xC6, 0xF1, 0xF8, 0x7E, 0x1F,
  0x07, 0x81, 0xF0, 0xFC, 0x3F, 0x1D, 0xC7, 0x38, 0x73, 0xDC, 0xE7, 0x79,
  0xDC, 0x77, 0x1F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0xF0,
  0x3C, 0x0E, 0x00, 0x3F, 0xBF, 0xDF, 0xC1, 0xC1, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFF, 0x7F, 0x3F, 0x80, 0x04, 0x31, 0xC6, 0x38, 0xE3, 0x8E, 0x73, 0x8E,
  0x1C, 0x71, 0xC7, 0x1C, 0x61, 0x83, 0x08, 0x18, 0x84, 0x63, 0x18, 0xC6,
  0x23, 0x18, 0xC6, 0x31, 0x08, 0xC0, 0x10, 0x61, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x31, 0xCE, 0x38, 0xE3, 0x0C, 0x71, 0xCE, 0x10, 0x71, 0xFD, 0xFF,
  0xD9, 0xEC, 0x60,
};

const GFXglyph RobotoCondensed_BlackItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 14, 5, 0, -14 },
  { 12, 6, 6, 6, 1, -15 },
  { 17, 10, 14, 10, 0, -14 },
  { 35, 9, 18, 10, 1, -16 },
  { 56, 9, 14, 12, 2, -14 },
  { 72, 11, 14, 12, 0, -14 },
  { 92, 3, 6, 3, 1, -15 },
  { 95, 6, 20, 6, 1, -16 },
  { 110, 7, 20, 6, -1, -16 },
  { 128, 9, 9, 9, 1, -14 },
  { 139, 9, 11, 9, 0, -12 },
  { 152, 4, 6, 5, -1, -2 },
  { 155, 6, 3, 8, 1, -8 },
  { 158, 4, 3, 6, 0, -3 },
  { 160, 8, 15, 6, -1, -14 },
  { 175, 9, 14, 10, 1, -14 },
  { 191, 7, 14, 10, 2, -14 },
  { 204, 10, 14, 10, 0, -14 },
  { 222, 10, 14, 10, 0, -14 },
  { 240, 10, 14, 10, 0, -14 },
  { 258, 10, 14, 10, 0, -14 },
  { 276, 8, 14, 10, 1, -14 },
  { 290, 9, 14, 10, 1, -14 },
  { 306, 10, 14, 10, 0, -14 },
  { 324, 9, 14, 10, 1, -14 },
  { 340, 5, 11, 6, 0, -11 },
  { 347, 6, 15, 6, -1, -11 },
  { 359, 9, 10, 9, 0, -11 },
  { 371, 8, 8, 10, 1, -10 },
  { 379, 8, 10, 9, 0, -11 },
  { 389, 8, 14, 9, 1, -14 },
  { 403, 14, 18, 15, 0, -14 },
  { 435, 12, 14, 12, -1, -14 },
  { 456, 11, 14, 11, 0, -14 },
  { 476, 10, 14, 11, 1, -14 },
  { 494, 11, 14, 11, 0, -14 },
  { 514, 11, 14, 9, 0, -14 },
  { 534, 10, 14, 9, 0, -14 },
  { 552, 10, 14, 11, 1, -14 },
  { 570, 12, 14, 12, 0, -14 },
  { 591, 6, 14, 5, 0, -14 },
  { 602, 10, 14, 10, 0, -14 },
  { 620, 13, 14, 11, 0, -14 },
  { 643, 8, 14, 9, 0, -14 },
  { 657, 15, 14, 15, 0, -14 },
  { 684, 12, 14, 12, 0, -14 },
  { 705, 10, 14, 12, 1, -14 },
  { 723, 11, 14, 11, 0, -14 },
  { 743, 11, 17, 12, 1, -14 },
  { 767, 11, 14, 11, 0, -14 },
  { 787, 11, 14, 11, 0, -14 },
  { 807, 11, 14, 11, 1, -14 },
  { 827, 11, 14, 11, 1, -14 },
  { 847, 12, 14, 11, 1, -14 },
  { 868, 13, 14, 14, 2, -14 },
  { 891, 13, 14, 11, -1, -14 },
  { 914, 10, 14, 11, 2, -14 },
  { 932, 11, 14, 10, 0, -14 },
  { 952, 8, 20, 5, -1, -17 },
  { 972, 6, 15, 7, 1, -14 },
  { 984, 7, 20, 5, -1, -17 },
  { 1002, 7, 7, 8, 1, -14 },
  { 1009, 7, 2, 8, -1, 0 },
  { 1011, 5, 3, 7, 2, -15 },
  { 1013, 9, 11, 9, 0, -11 },
  { 1026, 9, 15, 10, 0, -15 },
  { 1043, 9, 11, 9, 0, -11 },
  { 1056, 10, 15, 10, 0, -15 },
  { 1075, 9, 11, 9, 0, -11 },
  { 1088, 8, 15, 6, 0, -15 },
  { 1103, 10, 15, 10, 0, -11 },
  { 1122, 9, 15, 10, 0, -15 },
  { 1139, 6, 15, 5, 0, -15 },
  { 1151, 8, 19, 5, -2, -15 },
  { 1170, 10, 15, 10, 0, -15 },
  { 1189, 6, 15, 5, 0, -15 },
  { 1201, 14, 11, 14, 0, -11 },
  { 1221, 9, 11, 10, 0, -11 },
  { 1234, 9, 11, 10, 0, -11 },
  { 1247, 10, 15, 10, -1, -11 },
  { 1266, 10, 15, 10, 0, -11 },
  { 1285, 7, 11, 7, 0, -11 },
  { 1295, 9, 11, 9, 0, -11 },
  { 1308, 6, 13, 6, 1, -13 },
  { 1318, 10, 11, 10, 0, -11 },
  { 1332, 9, 11, 9, 1, -11 },
  { 1345, 12, 11, 12, 1, -11 },
  { 1362, 10, 11, 9, -1, -11 },
  { 1376, 10, 15, 9, 0, -11 },
  { 1395, 9, 11, 9, 0, -11 },
  { 1408, 6, 20, 6, 0, -16 },
  { 1423, 5, 17, 5, 0, -14 },
  { 1434, 6, 20, 6, -1, -16 },
  { 1449, 9, 5, 11, 1, -9 },
};

const GFXfont RobotoCondensed_BlackItalic20pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic20pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic20pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _ROBOTOCONDENSED_BLACKITALIC20PT7B_H_
