#ifndef _ROBOTOCONDENSED_BLACKITALIC13PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x36, 0x66, 0x66, 0x0C, 0xC0, 0xBA, 0xAA, 0x14, 0x38, 0xE3, 0xE2,
  0x9F, 0x94, 0x28, 0xF0, 0x08, 0xE3, 0xDB, 0x60, 0xE1, 0xF3, 0x79, 0xE2,
  0x00, 0x63, 0xDB, 0x9E, 0x10, 0xF5, 0x75, 0x1C, 0x38, 0x79, 0xB1, 0xC7,
  0x7F, 0xF7, 0x7E, 0x7C, 0xEA, 0x22, 0x4C, 0xC8, 0x88, 0x88, 0x8C, 0x40,
  0x20, 0x84, 0x31, 0x8C, 0x62, 0x31, 0x88, 0xC4, 0x00, 0x31, 0x3E, 0xCD,
  0x48, 0x10, 0xC7, 0xFF, 0x30, 0x80, 0x6D, 0xE0, 0xFC, 0xD8, 0x0C, 0x21,
  0x84, 0x30, 0x82, 0x18, 0x43, 0x00, 0x38, 0xF6, 0xDB, 0x6D, 0xB4, 0xDE,
  0x70, 0x13, 0xBC, 0x63, 0x19, 0x8C, 0x60, 0x39, 0xF6, 0xC3, 0x18, 0xC7,
  0x3F, 0xF8, 0x39, 0xF0, 0xCF, 0x38, 0x3C, 0xFE, 0x70, 0x0C, 0x73, 0xCB,
  0x7B, 0xFF, 0xC6, 0x18, 0x3D, 0xF6, 0x1E, 0x7C, 0x3C, 0xDE, 0x70, 0x1C,
  0xF6, 0x1E, 0x7F, 0xBC, 0xDE, 0x78, 0x7E, 0xF8, 0x30, 0xC1, 0x86, 0x0C,
  0x30, 0x60, 0x3D, 0xF6, 0xDF, 0x79, 0xBC, 0xFE, 0x70, 0x77, 0xF7, 0xBF,
  0xFC, 0xDE, 0xC0, 0x6C, 0x01, 0xB0, 0x33, 0x00, 0x02, 0x66, 0xC0, 0x08,
  0xEF, 0x38, 0x38, 0x60, 0x7D, 0xF0, 0x00, 0x7F, 0xE0, 0x43, 0x8E, 0x7F,
  0x40, 0x77, 0xF6, 0x66, 0x30, 0x18, 0xC0, 0x0F, 0x18, 0xC8, 0x29, 0xD5,
  0xAE, 0xB7, 0xD3, 0x6A, 0x9F, 0x60, 0x19, 0x07, 0x80, 0x0E, 0x0E, 0x0E,
  0x1E, 0x1E, 0x3E, 0x3F, 0x63, 0x63, 0x7C, 0xFD, 0x9B, 0x77, 0xCD, 0xBB,
  0x7E, 0xF8, 0x1C, 0x7D, 0x9B, 0x06, 0x1C, 0x39, 0xBE, 0x38, 0x7C, 0xF9,
  0x9B, 0x36, 0x6D, 0xFB, 0x7E, 0xF8, 0x7E, 0xFD, 0x83, 0xE7, 0xCC, 0x38,
  0x7E, 0xF8, 0x7E, 0xF9, 0x83, 0xE7, 0xCC, 0x38, 0x60, 0xC0, 0x1C, 0x7D,
  0x9B, 0x06, 0xED, 0xD9, 0xBF, 0x3C, 0x73, 0x63, 0x67, 0x7E, 0x7E, 0x66,
  0xE6, 0xC6, 0xCE, 0x37, 0x66, 0x66, 0xEC, 0xC0, 0x0C, 0x18, 0x30, 0x60,
  0xC3, 0xB6, 0x7C, 0x70, 0x77, 0x6E, 0x6C, 0x78, 0x78, 0x78, 0xFC, 0xCC,
  0xCC, 0x73, 0x18, 0xC6, 0x33, 0x9F, 0xF8, 0x71, 0xDC, 0xF7, 0x39, 0xCE,
  0x77, 0x9F, 0x6D, 0xDB, 0x7E, 0xDB, 0x00, 0x73, 0x73, 0x77, 0x76, 0x7E,
  0x6E, 0xEE, 0xCE, 0xCC, 0x1C, 0x7D, 0x9B, 0x36, 0x7C, 0xD9, 0xBE, 0x38,
  0x7C, 0xFD, 0x9B, 0x37, 0xEF, 0xB8, 0x60, 0xC0, 0x1C, 0x7D, 0x9B, 0x36,
  0x7C, 0xD9, 0xBE, 0x38, 0x18, 0x10, 0x7C, 0xFD, 0x9B, 0x37, 0xEF, 0x3F,
  0x66, 0xCC, 0x3C, 0xFD, 0x9B, 0x83, 0x81, 0xB3, 0x3E, 0x78, 0xFF, 0xF8,
  0xC1, 0x83, 0x0C, 0x18, 0x30, 0x60, 0x77, 0x66, 0x66, 0x66, 0x66, 0x66,
  0xEC, 0x7C, 0x78, 0xC7, 0x9F, 0x36, 0x6D, 0x8B, 0x1C, 0x38, 0x60, 0xD9,
  0xED, 0xF6, 0xDF, 0x6F, 0xB7, 0xF3, 0xB9, 0xDC, 0xCC, 0x00, 0x33, 0x9D,
  0x87, 0x83, 0xC1, 0xC0, 0xE0, 0xD8, 0xEC, 0x66, 0x00, 0xCF, 0x99, 0xE3,
  0xC7, 0x0E, 0x18, 0x30, 0x60, 0x7E, 0xFC, 0x30, 0xC3, 0x86, 0x18, 0x7E,
  0xFC, 0x37, 0x66, 0x66, 0x66, 0xCC, 0xCC, 0xC0, 0xDB, 0x66, 0xDB, 0x6C,
  0x39, 0xCC, 0x63, 0x18, 0xC6, 0x73, 0x18, 0xCE, 0x00, 0x31, 0x8E, 0xF5,
  0x80, 0xFF, 0xC0, 0x6C, 0x39, 0xE1, 0x9E, 0xDB, 0xEF, 0x80, 0x31, 0x86,
  0x1E, 0x7D, 0xBE, 0xF3, 0xFB, 0xE0, 0x39, 0xEC, 0xF0, 0xDB, 0xE7, 0x00,
  0x06, 0x18, 0x33, 0xE7, 0xD9, 0xB3, 0x6C, 0xF8, 0xF0, 0x39, 0xF6, 0xFF,
  0xC3, 0xE7, 0x80, 0x19, 0xDC, 0xE6, 0x31, 0x8C, 0xE6, 0x00, 0x3D, 0xFC,
  0xF3, 0xCF, 0xE7, 0x86, 0xFB, 0xC0, 0x61, 0x86, 0x1E, 0x7D, 0xBC, 0xF6,
  0xDB, 0x60, 0x62, 0x06, 0x66, 0x6C, 0xCC, 0x18, 0x20, 0x06, 0x18, 0x61,
  0x8C, 0x30, 0xC3, 0x1C, 0x60, 0x30, 0xC1, 0x83, 0x67, 0xCF, 0x3E, 0x7C,
  0xD9, 0xB0, 0x36, 0x66, 0x66, 0x6C, 0xCC, 0x7B, 0x3F, 0xDB, 0x7D, 0xBD,
  0xB6, 0xDB, 0x6C, 0x79, 0xF6, 0xF3, 0xDB, 0x6D, 0x80, 0x39, 0xFC, 0xF3,
  0xCF, 0xE7, 0x00, 0x3C, 0x7C, 0xD9, 0xB6, 0x6F, 0x9F, 0x30, 0x60, 0xC0,
  0x7D, 0xFC, 0xF3, 0xDB, 0xE7, 0x86, 0x18, 0x60, 0x7B, 0x99, 0xCC, 0x63,
  0x00, 0x79, 0xE6, 0x1C, 0x1B, 0x67, 0x00, 0x36, 0x76, 0x66, 0x66, 0x60,
  0x6D, 0xB6, 0xF3, 0xDF, 0xE7, 0x80, 0xDE, 0xFD, 0xEE, 0x73, 0x80, 0xD7,
  0xEE, 0xD7, 0xED, 0xDB, 0x36, 0x00, 0x36, 0x78, 0xF1, 0xC3, 0x8D, 0x9B,
  0x00, 0x6D, 0xB7, 0x9E, 0x71, 0xC7, 0x18, 0xE3, 0x00, 0x7D, 0xE3, 0x8C,
  0x63, 0xEF, 0x80, 0x13, 0x26, 0x66, 0xC4, 0x44, 0x44, 0x24, 0xB4, 0x92,
  0x5A, 0x00, 0x46, 0x66, 0x66, 0x66, 0x4C, 0xC8, 0x65, 0xFD, 0xC0,
};

const GFXglyph RobotoCondensed_BlackItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 9, 3, 0, -9 },
  { 6, 4, 4, 4, 1, -10 },
  { 8, 7, 9, 6, 0, -9 },
  { 16, 6, 11, 6, 0, -10 },
  { 25, 6, 9, 8, 1, -9 },
  { 32, 7, 9, 8, 0, -9 },
  { 40, 2, 4, 2, 1, -10 },
  { 41, 4, 13, 4, 1, -10 },
  { 48, 5, 13, 4, -1, -10 },
  { 57, 5, 6, 6, 1, -9 },
  { 61, 6, 6, 6, 0, -7 },
  { 66, 3, 4, 3, -1, -2 },
  { 68, 3, 2, 5, 1, -5 },
  { 69, 3, 2, 4, 0, -2 },
  { 70, 6, 10, 4, -1, -9 },
  { 78, 6, 9, 6, 0, -9 },
  { 85, 5, 9, 6, 1, -9 },
  { 91, 6, 9, 6, 0, -9 },
  { 98, 6, 9, 6, 0, -9 },
  { 105, 6, 9, 6, 0, -9 },
  { 112, 6, 9, 6, 0, -9 },
  { 119, 6, 9, 6, 0, -9 },
  { 126, 7, 9, 6, 0, -9 },
  { 134, 6, 9, 6, 0, -9 },
  { 141, 5, 9, 6, 1, -9 },
  { 147, 3, 7, 4, 0, -7 },
  { 150, 4, 9, 4, -1, -7 },
  { 155, 6, 6, 6, 0, -7 },
  { 160, 6, 6, 7, 0, -7 },
  { 165, 5, 6, 6, 0, -7 },
  { 169, 5, 9, 6, 1, -9 },
  { 175, 9, 12, 10, 0, -9 },
  { 189, 8, 9, 8, -1, -9 },
  { 198, 7, 9, 7, 0, -9 },
  { 206, 7, 9, 7, 0, -9 },
  { 214, 7, 9, 7, 0, -9 },
  { 222, 7, 9, 6, 0, -9 },
  { 230, 7, 9, 6, 0, -9 },
  { 238, 7, 9, 7, 0, -9 },
  { 246, 8, 9, 8, 0, -9 },
  { 255, 4, 9, 4, 0, -9 },
  { 260, 7, 9, 6, 0, -9 },
  { 268, 8, 9, 7, 0, -9 },
  { 277, 5, 9, 6, 0, -9 },
  { 283, 10, 9, 10, 0, -9 },
  { 295, 8, 9, 8, 0, -9 },
  { 304, 7, 9, 8, 0, -9 },
  { 312, 7, 9, 7, 0, -9 },
  { 320, 7, 11, 8, 0, -9 },
  { 330, 7, 9, 7, 0, -9 },
  { 338, 7, 9, 7, 0, -9 },
  { 346, 7, 9, 7, 1, -9 },
  { 354, 8, 9, 7, 0, -9 },
  { 363, 7, 9, 7, 1, -9 },
  { 371, 9, 9, 9, 1, -9 },
  { 382, 9, 9, 7, -1, -9 },
  { 393, 7, 9, 7, 1, -9 },
  { 401, 7, 9, 7, 0, -9 },
  { 409, 4, 13, 3, 0, -11 },
  { 416, 3, 10, 5, 1, -9 },
  { 420, 5, 13, 3, -1, -11 },
  { 429, 5, 5, 5, 0, -9 },
  { 433, 5, 2, 5, -1, 0 },
  { 435, 3, 2, 4, 1, -10 },
  { 436, 6, 7, 6, 0, -7 },
  { 442, 6, 10, 6, 0, -10 },
  { 450, 6, 7, 6, 0, -7 },
  { 456, 7, 10, 6, 0, -10 },
  { 465, 6, 7, 6, 0, -7 },
  { 471, 5, 10, 4, 0, -10 },
  { 478, 6, 10, 6, 0, -7 },
  { 486, 6, 10, 6, 0, -10 },
  { 494, 4, 10, 3, 0, -10 },
  { 499, 6, 13, 3, -2, -10 },
  { 509, 7, 10, 6, 0, -10 },
  { 518, 4, 10, 3, 0, -10 },
  { 523, 9, 7, 9, 0, -7 },
  { 531, 6, 7, 6, 0, -7 },
  { 537, 6, 7, 6, 0, -7 },
  { 543, 7, 10, 6, -1, -7 },
  { 552, 6, 10, 6, 0, -7 },
  { 560, 5, 7, 4, 0, -7 },
  { 565, 6, 7, 6, 0, -7 },
  { 571, 4, 9, 4, 0, -9 },
  { 576, 6, 7, 6, 0, -7 },
  { 582, 5, 7, 6, 1, -7 },
  { 587, 7, 7, 8, 1, -7 },
  { 594, 7, 7, 6, -1, -7 },
  { 601, 6, 10, 6, 0, -7 },
  { 609, 6, 7, 6, 0, -7 },
  { 615, 4, 12, 4, 0, -10 },
  { 621, 3, 11, 3, 0, -9 },
  { 626, 4, 12, 4, 0, -10 },
  { 632, 6, 3, 7, 0, -5 },
};

const GFXfont RobotoCondensed_BlackItalic13pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic13pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic13pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOCONDENSED_BLACKITALIC13PT7B_H_
