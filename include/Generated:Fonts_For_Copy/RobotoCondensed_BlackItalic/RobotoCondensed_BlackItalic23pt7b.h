#ifndef _ROBOTOCONDENSED_BLACKITALIC23PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0xF1, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0x71, 0xC0, 0x00,
  0x0C, 0x3C, 0x78, 0x60, 0x66, 0xCD, 0xBF, 0x6C, 0xD9, 0x80, 0x07, 0x60,
  0x6C, 0x06, 0xC0, 0x6C, 0x0D, 0xC3, 0xFE, 0x3F, 0xE1, 0xD8, 0x1B, 0x01,
  0xB0, 0xFF, 0xCF, 0xFC, 0x36, 0x03, 0x60, 0x66, 0x06, 0xC0, 0x6C, 0x00,
  0x03, 0x00, 0xC0, 0xF0, 0x7E, 0x3F, 0xDE, 0x77, 0x9D, 0xE0, 0x78, 0x0F,
  0x01, 0xF0, 0x3C, 0x07, 0x80, 0xEE, 0x3B, 0x9E, 0xFF, 0x1F, 0xC3, 0xC0,
  0x60, 0x10, 0x00, 0x38, 0x0F, 0x83, 0xB3, 0x66, 0x6C, 0xD9, 0x9F, 0x3F,
  0xC3, 0xF0, 0x0E, 0x01, 0xF8, 0x7F, 0x1F, 0x33, 0x66, 0xCD, 0xF9, 0xB8,
  0x3E, 0x03, 0x80, 0x07, 0x80, 0xFC, 0x1F, 0xC1, 0xDC, 0x1D, 0xC1, 0xDC,
  0x1F, 0x81, 0xF0, 0x1E, 0x07, 0xF7, 0x7F, 0x7F, 0x7F, 0xF3, 0xEF, 0x3E,
  0x7F, 0xC7, 0xFE, 0x3E, 0xE0, 0x76, 0x66, 0xEE, 0x02, 0x1C, 0x38, 0xE3,
  0x87, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x83, 0x07, 0x06, 0x04, 0x00, 0x08, 0x38, 0x30, 0x70, 0xE1, 0xC1, 0x83,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0xE3, 0x87, 0x1C,
  0x20, 0x00, 0x06, 0x01, 0x80, 0x61, 0x97, 0xFF, 0xC7, 0x83, 0xE1, 0xD8,
  0x63, 0x08, 0x80, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x7F, 0xDF, 0xF7, 0xFC,
  0x78, 0x1C, 0x07, 0x01, 0xC0, 0x39, 0xCC, 0xE7, 0x71, 0x00, 0xFF, 0xFF,
  0x80, 0x73, 0xBC, 0xE0, 0x00, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xC0,
  0x70, 0x18, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0,
  0x70, 0x18, 0x00, 0x0F, 0x07, 0xE3, 0xFD, 0xE7, 0x71, 0xDC, 0x7F, 0x3F,
  0xCF, 0xF3, 0xFC, 0xFE, 0x3B, 0x8E, 0xE3, 0xB9, 0xEF, 0xF1, 0xF8, 0x3C,
  0x00, 0x03, 0x0F, 0x7E, 0x7E, 0x7E, 0x9E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C,
  0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x0F, 0x83, 0xF8, 0xFF, 0x9C, 0xF7,
  0x9E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF8, 0x3F, 0xF7, 0xFE, 0xFF, 0xC0, 0x0F, 0x83, 0xF8, 0xFF, 0x9C, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x7E, 0x0F, 0x81, 0xF0, 0x07, 0x00, 0xEF, 0x1D,
  0xE7, 0x9F, 0xE3, 0xFC, 0x3E, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x83, 0xF0,
  0x7C, 0x1F, 0x87, 0xF0, 0xDE, 0x3B, 0xCE, 0x79, 0xFF, 0x7F, 0xEF, 0xFC,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x9E, 0x03,
  0x80, 0x70, 0x0F, 0xE3, 0xFC, 0x7F, 0xC0, 0x38, 0x07, 0x00, 0xEF, 0x3C,
  0xE7, 0x9F, 0xE1, 0xF8, 0x1E, 0x00, 0x03, 0x83, 0xE1, 0xF8, 0xF0, 0x78,
  0x1E, 0x07, 0x73, 0xFE, 0xFF, 0xBC, 0xFE, 0x3F, 0x8F, 0xE3, 0xB9, 0xEF,
  0xF1, 0xFC, 0x3C, 0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0x81, 0xE0, 0x3C, 0x0F,
  0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E,
  0x07, 0x80, 0xF0, 0x00, 0x07, 0x81, 0xF8, 0x7F, 0x9E, 0xF3, 0xDE, 0x7B,
  0xCF, 0x78, 0xFE, 0x1F, 0x87, 0xF1, 0xEF, 0x38, 0xE7, 0x3C, 0xE7, 0x9F,
  0xE3, 0xFC, 0x1E, 0x00, 0x0F, 0x0F, 0xE3, 0xF9, 0xEF, 0x71, 0xDC, 0xFF,
  0x3D, 0xCF, 0x7F, 0xDF, 0xF3, 0xF8, 0x1E, 0x07, 0x03, 0xC7, 0xE1, 0xF0,
  0x70, 0x00, 0x18, 0xF3, 0xC6, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x1C, 0x70,
  0x0C, 0x3C, 0x78, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE1, 0xC3, 0x87,
  0x1C, 0x70, 0x40, 0x00, 0x40, 0xE0, 0xF8, 0xFE, 0x7E, 0x1C, 0x0F, 0xC1,
  0xFC, 0x1F, 0x01, 0xC0, 0x10, 0x7F, 0xDF, 0xF7, 0xF8, 0x00, 0x00, 0x3F,
  0xEF, 0xFB, 0xFC, 0x20, 0x0E, 0x03, 0xE0, 0xFE, 0x0F, 0xC0, 0xE1, 0xF9,
  0xFC, 0x7C, 0x1C, 0x08, 0x00, 0x1E, 0x1F, 0xDF, 0xEE, 0x7F, 0x38, 0x3C,
  0x1E, 0x1E, 0x1E, 0x0E, 0x0F, 0x07, 0x00, 0x01, 0x81, 0xE0, 0xF0, 0x30,
  0x00, 0x01, 0xF8, 0x03, 0xFC, 0x0F, 0x0E, 0x0C, 0x07, 0x18, 0x03, 0x38,
  0xF3, 0x31, 0xFB, 0x73, 0xB3, 0x67, 0x33, 0x66, 0x33, 0xE6, 0x73, 0xEE,
  0x63, 0xEE, 0x66, 0xCE, 0xE6, 0xE7, 0xFC, 0xE7, 0x38, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x40, 0x3F, 0xC0, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0xE0, 0x3F, 0x03, 0xB8, 0x1D, 0xC1, 0xEE, 0x0E, 0x70, 0xF3, 0x87,
  0x9C, 0x7F, 0xF3, 0xFF, 0xBF, 0xFD, 0xE1, 0xEF, 0x0F, 0xF0, 0x78, 0x1F,
  0xC1, 0xFF, 0x0F, 0xFC, 0x79, 0xE3, 0xC7, 0x1E, 0x38, 0xE3, 0xCF, 0xFC,
  0x7F, 0xC3, 0xFF, 0x1E, 0x38, 0xF1, 0xC7, 0x0E, 0x78, 0xF3, 0xFF, 0x9F,
  0xF8, 0xFF, 0x00, 0x0F, 0x81, 0xFE, 0x3F, 0xE7, 0x8F, 0x78, 0xF7, 0x0F,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x1E, 0xE1, 0xEF, 0x3C,
  0xFF, 0xC7, 0xF8, 0x3E, 0x00, 0x1F, 0x83, 0xFE, 0x3F, 0xE3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x38, 0xF7, 0x8F, 0x78, 0xF7, 0x8F, 0x78, 0xF7, 0x8E, 0x71,
  0xEF, 0x3E, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0x1F, 0xF3, 0xFF, 0x3F, 0xF3,
  0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0xFC, 0x7F, 0xC7, 0xFC, 0x78, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0xFF, 0xCF, 0xFC, 0xFF, 0x80, 0x1F, 0xF3, 0xFF,
  0x3F, 0xE3, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0xFC, 0x7F, 0xC7, 0xFC,
  0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x0F,
  0x81, 0xFE, 0x3F, 0xE7, 0xCF, 0x78, 0xF7, 0x0F, 0xF0, 0x0F, 0x00, 0xF3,
  0xFF, 0x3E, 0xF3, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0x7F, 0xE7, 0xFC, 0x3F,
  0x00, 0x1C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x38, 0xF0, 0xE3,
  0x87, 0x9F, 0xFE, 0x7F, 0xF9, 0xFF, 0xE7, 0x87, 0x1E, 0x1C, 0x70, 0xF3,
  0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xE0, 0x1E, 0x38, 0x71, 0xE3, 0xC7,
  0x8F, 0x1C, 0x78, 0xF1, 0xE3, 0xC7, 0x8E, 0x3C, 0x78, 0xF0, 0x00, 0xF0,
  0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0xF3, 0xCF, 0x78, 0xFF, 0x87, 0xF0, 0x3E, 0x00,
  0x1C, 0x7C, 0xF1, 0xE3, 0xCF, 0x8F, 0x3C, 0x3D, 0xE0, 0xFF, 0x03, 0xBC,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xFC, 0x1E, 0xF0, 0x7B, 0xC3, 0xCF,
  0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE0, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F,
  0xFB, 0xFE, 0xFF, 0x80, 0x1F, 0x0F, 0x8F, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xE3, 0xF3, 0xF1, 0xFC, 0xFC, 0x7F, 0x77,
  0x1F, 0xDF, 0xC7, 0xB6, 0xF1, 0xCF, 0xBC, 0x73, 0xCE, 0x3C, 0xF3, 0x8F,
  0x3D, 0xE3, 0xCE, 0x78, 0xF3, 0x9E, 0x00, 0x1E, 0x3C, 0xF8, 0xF3, 0xE3,
  0xCF, 0x8F, 0x3E, 0x38, 0xFC, 0xE3, 0xB7, 0x9E, 0xDE, 0x7B, 0x79, 0xED,
  0xE7, 0xBF, 0x1E, 0x7C, 0x71, 0xF3, 0xC7, 0xCF, 0x1F, 0x3C, 0x7C, 0xF0,
  0xE0, 0x0F, 0x81, 0xFE, 0x3F, 0xE7, 0x8F, 0x78, 0xF7, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0E, 0xF1, 0xEF, 0x3C, 0x7F, 0xC7,
  0xF8, 0x1E, 0x00, 0x1F, 0xC1, 0xFF, 0x0F, 0xFC, 0x78, 0xF3, 0xC7, 0x9E,
  0x3C, 0xE1, 0xEF, 0x1E, 0x7F, 0xF3, 0xFF, 0x1F, 0xE0, 0xF0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x81, 0xFE, 0x3F, 0xE7,
  0x8F, 0x78, 0xF7, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0E, 0xF1, 0xEF, 0x3E, 0x7F, 0xC7, 0xF8, 0x1F, 0x80, 0x3C, 0x01, 0xC0,
  0x10, 0x1F, 0xC1, 0xFF, 0x0F, 0xFC, 0x78, 0xE3, 0xC7, 0x1E, 0x38, 0xE3,
  0xCF, 0x1E, 0x7F, 0xE3, 0xFE, 0x1F, 0xF0, 0xF7, 0x87, 0x3C, 0x39, 0xE3,
  0xCF, 0x1E, 0x3C, 0xF1, 0xE0, 0x07, 0xC0, 0xFE, 0x1F, 0xF3, 0xCF, 0x3C,
  0x73, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xEF, 0x1E, 0x71,
  0xE7, 0x9E, 0x7F, 0xC3, 0xFC, 0x1F, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xE1,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x00, 0x38, 0x77, 0x8F,
  0x78, 0xF7, 0x8F, 0x78, 0xF7, 0x8F, 0x70, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E,
  0xF1, 0xEF, 0x1E, 0xF1, 0xCF, 0x3C, 0xFF, 0xC7, 0xF8, 0x3E, 0x00, 0xF0,
  0xF7, 0x87, 0xBC, 0x79, 0xE3, 0xCF, 0x1E, 0x79, 0xE3, 0xCF, 0x1E, 0x70,
  0x77, 0x83, 0xBC, 0x1D, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x00, 0xF3, 0x8F, 0xF3, 0x8E, 0xE7, 0x9E, 0xE7, 0x9E, 0xE7,
  0x9C, 0xEF, 0xBC, 0xEF, 0xBC, 0xEF, 0xB8, 0xFF, 0xB8, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xF0, 0xF9, 0xF0, 0xF9, 0xF0, 0xF9, 0xE0, 0xF1, 0xE0, 0xF1,
  0xE0, 0x1E, 0x3E, 0x3C, 0x78, 0x79, 0xE0, 0x7B, 0xC0, 0xFF, 0x01, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFF, 0x01,
  0xFE, 0x07, 0x9C, 0x1F, 0x3C, 0x3C, 0x78, 0xF8, 0xF0, 0xF0, 0xFF, 0x1E,
  0xF1, 0xE7, 0x3C, 0x73, 0x87, 0x78, 0x77, 0x07, 0xF0, 0x3E, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x00, 0x3F,
  0xF9, 0xFF, 0xCF, 0xFC, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xFF, 0x9F,
  0xF8, 0xFF, 0xC0, 0x0F, 0x07, 0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x38,
  0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC3, 0xE0, 0xE3, 0x8F, 0x3C, 0xF3, 0xC7, 0x1C, 0x71,
  0xE7, 0x9E, 0x79, 0xE3, 0x8E, 0x3C, 0xF0, 0x1F, 0x1F, 0x1E, 0x0E, 0x0E,
  0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38,
  0x78, 0x78, 0x78, 0xF8, 0xF0, 0xF0, 0x0E, 0x1E, 0x3E, 0x36, 0x76, 0x76,
  0xE7, 0xE7, 0xFF, 0xFF, 0xFF, 0x71, 0xE3, 0x86, 0x0F, 0x0F, 0xE7, 0xFD,
  0xEF, 0x03, 0xCF, 0xE7, 0xFB, 0xCE, 0xF7, 0xBF, 0xEF, 0xF9, 0xDE, 0x1C,
  0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0xE1, 0xFE, 0x7F, 0xCF,
  0x39, 0xE7, 0x38, 0xE7, 0x1C, 0xE3, 0xBC, 0xF7, 0xFE, 0xEF, 0x9D, 0xE0,
  0x0F, 0x0F, 0xE7, 0xFD, 0xE7, 0x71, 0xDC, 0x0F, 0x03, 0xCE, 0xF3, 0x9F,
  0xE7, 0xF0, 0xF8, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E,
  0x1F, 0xE3, 0xFE, 0x7F, 0xC7, 0x9C, 0x71, 0xC7, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0x87, 0xF8, 0x7F, 0x83, 0xB8, 0x0F, 0x0F, 0xF3, 0xFD, 0xE7, 0x71,
  0xDF, 0xF7, 0xFF, 0xC0, 0x71, 0x1F, 0xE7, 0xF8, 0x7C, 0x07, 0x87, 0xC7,
  0xE3, 0xC1, 0xC1, 0xE1, 0xFC, 0xFE, 0x7F, 0x1C, 0x0E, 0x07, 0x07, 0x83,
  0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x00, 0x1E, 0xE7, 0xFD, 0xFF, 0xBC, 0xF7,
  0x1E, 0xE3, 0xBC, 0x77, 0x9E, 0xF3, 0xCF, 0xF9, 0xFF, 0x1F, 0xC0, 0x38,
  0x0F, 0x1F, 0xC7, 0xF8, 0x7C, 0x00, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0E, 0x03, 0xB9, 0xFF, 0x7F, 0xDE, 0x77, 0x9D, 0xC7, 0x73, 0xFC, 0xFF,
  0x3F, 0xCE, 0xF3, 0xB9, 0xE0, 0x18, 0x73, 0xC7, 0x00, 0xF3, 0x8E, 0x79,
  0xE7, 0x9E, 0x71, 0xCF, 0x3C, 0xF0, 0x01, 0x01, 0xC1, 0xE0, 0x70, 0x00,
  0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x0F, 0x8F, 0x87, 0x80, 0x1C, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0x80, 0x39, 0xF3, 0xBE, 0x7B, 0xC7, 0xF8, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0xF7, 0x8F, 0x78, 0xF3, 0x8E, 0x3C, 0x1C, 0x38,
  0x71, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0xF1, 0xE3, 0xC7, 0x0E, 0x1C, 0x78,
  0xF1, 0xE0, 0x3B, 0x9E, 0x3F, 0xFE, 0x7F, 0xFF, 0x79, 0xCF, 0x79, 0xCF,
  0x7B, 0xCE, 0x73, 0xCE, 0x73, 0xDE, 0xF3, 0x9E, 0xF3, 0x9E, 0xF3, 0x9E,
  0xF7, 0x9C, 0x3B, 0x8F, 0xF7, 0xFD, 0xE7, 0x79, 0xDC, 0x77, 0x3F, 0xCF,
  0xF3, 0xFC, 0xEF, 0x3B, 0x9E, 0x0F, 0x0F, 0xE3, 0xFD, 0xE7, 0x71, 0xDC,
  0x7F, 0x1F, 0xCF, 0xF3, 0xDF, 0xE7, 0xF0, 0xF8, 0x1D, 0xC1, 0xFE, 0x3F,
  0xE3, 0xCE, 0x3C, 0xE3, 0xCE, 0x38, 0xE3, 0x8E, 0x79, 0xE7, 0xFC, 0x7F,
  0xC7, 0xF8, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0xE7,
  0xFD, 0xFF, 0xBC, 0xE7, 0x1C, 0xE7, 0xBC, 0xF7, 0x9E, 0xF3, 0xDF, 0xF1,
  0xFE, 0x1F, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0x3B, 0x3F,
  0x7F, 0x7F, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xE0, 0x1F, 0x0F,
  0xE7, 0xFD, 0xCF, 0x78, 0x0F, 0x81, 0xF0, 0x3E, 0xE7, 0xBF, 0xE7, 0xF0,
  0xF8, 0x38, 0xE7, 0xBF, 0xFF, 0xF7, 0x1C, 0xF3, 0xCF, 0x3C, 0xFB, 0xE7,
  0x80, 0x39, 0xE7, 0x3D, 0xE7, 0xBC, 0xF7, 0x9C, 0xE3, 0x9C, 0xF3, 0x9E,
  0xF3, 0xCF, 0xF1, 0xFE, 0x1D, 0xC0, 0xF3, 0xFC, 0xEF, 0x7B, 0xDE, 0x77,
  0x1F, 0xC7, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0xF7, 0x3B, 0xDC,
  0xEF, 0x77, 0xBB, 0xDC, 0xEF, 0x73, 0xBF, 0xCF, 0xFE, 0x3E, 0xF8, 0xFB,
  0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xE0, 0x3C, 0xF1, 0xDE, 0x1D, 0xC1, 0xFC,
  0x1F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xB8, 0x7B, 0xCF, 0x3C,
  0x79, 0xEF, 0x3D, 0xEF, 0x3D, 0xE3, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3E,
  0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x3E, 0x07, 0x80, 0xE0, 0x00,
  0x3F, 0xCF, 0xF7, 0xFC, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x3F,
  0xEF, 0xF3, 0xFC, 0x02, 0x1C, 0x38, 0xE1, 0xC3, 0x87, 0x1E, 0x38, 0xF1,
  0xC7, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x83, 0x02, 0x00, 0x18,
  0xC6, 0x31, 0x8C, 0xC6, 0x31, 0x8C, 0x66, 0x31, 0x8C, 0x63, 0x19, 0x80,
  0x08, 0x38, 0x30, 0x70, 0xE3, 0xC7, 0x0E, 0x1C, 0x1C, 0x18, 0xF1, 0xC7,
  0x0E, 0x1C, 0x38, 0x71, 0xC3, 0x8E, 0x08, 0x00, 0x38, 0xDF, 0x7F, 0xFF,
  0xBE, 0xC7, 0x00,
};

const GFXglyph RobotoCondensed_BlackItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 17, 6, 0, -17 },
  { 16, 7, 6, 7, 1, -17 },
  { 22, 12, 17, 11, 0, -17 },
  { 48, 10, 21, 11, 1, -19 },
  { 75, 11, 17, 14, 2, -17 },
  { 99, 12, 17, 13, 0, -17 },
  { 125, 4, 6, 3, 1, -17 },
  { 128, 7, 23, 7, 1, -18 },
  { 149, 7, 23, 7, -1, -18 },
  { 170, 10, 10, 10, 1, -17 },
  { 183, 10, 11, 10, 0, -13 },
  { 197, 5, 7, 6, -1, -3 },
  { 202, 6, 3, 9, 2, -9 },
  { 205, 5, 4, 7, 0, -4 },
  { 208, 10, 18, 7, -2, -17 },
  { 231, 10, 17, 11, 1, -17 },
  { 253, 8, 17, 11, 2, -17 },
  { 270, 11, 17, 11, 0, -17 },
  { 294, 11, 17, 11, 0, -17 },
  { 318, 11, 17, 11, 0, -17 },
  { 342, 11, 17, 11, 0, -17 },
  { 366, 10, 17, 11, 1, -17 },
  { 388, 11, 17, 11, 1, -17 },
  { 412, 11, 17, 11, 0, -17 },
  { 436, 10, 17, 11, 1, -17 },
  { 458, 6, 13, 7, 0, -13 },
  { 468, 7, 17, 6, -1, -13 },
  { 483, 10, 11, 10, 0, -12 },
  { 497, 10, 8, 12, 1, -11 },
  { 507, 10, 11, 10, 0, -12 },
  { 521, 9, 17, 10, 1, -17 },
  { 541, 16, 21, 17, 0, -16 },
  { 583, 13, 17, 14, -1, -17 },
  { 611, 13, 17, 13, 0, -17 },
  { 639, 12, 17, 13, 1, -17 },
  { 665, 12, 17, 13, 0, -17 },
  { 691, 12, 17, 11, 0, -17 },
  { 717, 12, 17, 11, 0, -17 },
  { 743, 12, 17, 13, 1, -17 },
  { 769, 14, 17, 14, 0, -17 },
  { 799, 7, 17, 6, 0, -17 },
  { 814, 12, 17, 11, 0, -17 },
  { 840, 14, 17, 12, 0, -17 },
  { 870, 10, 17, 11, 0, -17 },
  { 892, 18, 17, 17, 0, -17 },
  { 931, 14, 17, 14, 0, -17 },
  { 961, 12, 17, 13, 1, -17 },
  { 987, 13, 17, 13, 0, -17 },
  { 1015, 12, 20, 13, 1, -17 },
  { 1045, 13, 17, 13, 0, -17 },
  { 1073, 12, 17, 12, 0, -17 },
  { 1099, 12, 17, 12, 2, -17 },
  { 1125, 12, 17, 13, 1, -17 },
  { 1151, 13, 17, 13, 2, -17 },
  { 1179, 16, 17, 17, 2, -17 },
  { 1213, 15, 17, 13, -1, -17 },
  { 1245, 12, 17, 12, 2, -17 },
  { 1271, 13, 17, 12, 0, -17 },
  { 1299, 9, 23, 6, -1, -19 },
  { 1325, 6, 18, 9, 2, -17 },
  { 1339, 8, 23, 6, -1, -19 },
  { 1362, 8, 8, 9, 1, -17 },
  { 1370, 8, 3, 9, -1, 0 },
  { 1373, 6, 4, 8, 2, -18 },
  { 1376, 10, 12, 10, 0, -12 },
  { 1391, 11, 18, 11, 0, -18 },
  { 1416, 10, 12, 10, 0, -12 },
  { 1431, 12, 18, 11, 0, -18 },
  { 1458, 10, 12, 11, 0, -12 },
  { 1473, 9, 18, 7, 0, -18 },
  { 1494, 11, 17, 11, 0, -12 },
  { 1518, 10, 18, 11, 0, -18 },
  { 1541, 6, 17, 6, 0, -17 },
  { 1554, 9, 22, 6, -3, -17 },
  { 1579, 12, 18, 11, 0, -18 },
  { 1606, 7, 18, 6, 0, -18 },
  { 1622, 16, 12, 16, 0, -12 },
  { 1646, 10, 12, 11, 0, -12 },
  { 1661, 10, 12, 11, 0, -12 },
  { 1676, 12, 17, 11, -1, -12 },
  { 1702, 11, 17, 11, 0, -12 },
  { 1726, 8, 12, 8, 0, -12 },
  { 1738, 10, 12, 10, 0, -12 },
  { 1753, 6, 15, 7, 1, -15 },
  { 1765, 11, 12, 11, 0, -12 },
  { 1782, 10, 12, 10, 1, -12 },
  { 1797, 14, 12, 14, 1, -12 },
  { 1818, 12, 12, 10, -1, -12 },
  { 1836, 11, 17, 10, 0, -12 },
  { 1860, 10, 12, 10, 0, -12 },
  { 1875, 7, 22, 7, 0, -18 },
  { 1895, 5, 20, 6, 0, -17 },
  { 1908, 7, 22, 7, -1, -18 },
  { 1928, 10, 5, 12, 1, -9 },
};

const GFXfont RobotoCondensed_BlackItalic23pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic23pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic23pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _ROBOTOCONDENSED_BLACKITALIC23PT7B_H_
