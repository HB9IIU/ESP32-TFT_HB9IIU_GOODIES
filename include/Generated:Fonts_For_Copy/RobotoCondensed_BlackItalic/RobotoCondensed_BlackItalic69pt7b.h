#ifndef _ROBOTOCONDENSED_BLACKITALIC69PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0x00,
  0x1F, 0xC3, 0xFC, 0x7F, 0x0F, 0xF3, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x3F,
  0xC3, 0xF8, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x8F, 0xE1, 0xFC, 0x7F, 0x87,
  0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0,
  0x7F, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x1F,
  0xC7, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x80,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x3F,
  0x80, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x7E,
  0x3F, 0x80, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x01, 0xF8,
  0xFE, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01,
  0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x1F,
  0xC0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x3F,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x8F, 0xFE,
  0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFE, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFF,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF0,
  0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFE, 0x7F, 0x00, 0xC0, 0xFE, 0x1F, 0x80, 0xF8, 0x7F, 0x0F, 0xE0,
  0x7E, 0x7F, 0x07, 0xF0, 0x7F, 0x3F, 0x83, 0xF8, 0x7F, 0x1F, 0xC1, 0xFC,
  0x7F, 0x0F, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0x83, 0xF8, 0x7F,
  0x3F, 0x81, 0xFC, 0x3F, 0x9F, 0xC0, 0xFE, 0x3F, 0xDF, 0xC0, 0x3F, 0xFF,
  0xDF, 0xC0, 0x1F, 0xFF, 0xEF, 0xE0, 0x0F, 0xFF, 0xEF, 0xE0, 0x03, 0xFF,
  0xEF, 0xE0, 0x00, 0xFF, 0xE7, 0xF0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0xFF, 0x00,
  0x01, 0xFD, 0xFF, 0xC0, 0x01, 0xFD, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFE, 0xFF, 0xFF, 0x00, 0xFE, 0xFF, 0xFF, 0x80, 0x7F, 0x7F, 0x9F,
  0xC0, 0x7F, 0x7F, 0x87, 0xE0, 0x7F, 0x3F, 0x83, 0xF8, 0x3F, 0x9F, 0xC1,
  0xFC, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x87, 0xF0, 0x7E, 0x1F, 0xC3, 0xF8,
  0x7F, 0x1F, 0xC1, 0xFC, 0x3F, 0x9F, 0xC0, 0xFE, 0x1F, 0xCF, 0xE0, 0x7F,
  0x0F, 0xE1, 0xE0, 0x3F, 0xDF, 0xE0, 0x60, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xF8, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0xC3, 0xFE, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xE7,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xF1, 0xFF, 0xFF,
  0xC3, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xCF, 0xFF, 0xFF, 0x9F, 0xFB, 0xFF,
  0xBF, 0xFB, 0xFE, 0x7F, 0xF7, 0xFF, 0x7F, 0xDF, 0xFC, 0x7F, 0xFF, 0xFB,
  0xFF, 0x8F, 0xFF, 0xFF, 0x7F, 0xF0, 0xFF, 0xFF, 0xCF, 0xFE, 0x1F, 0xFF,
  0xF9, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0x03,
  0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF3, 0xFF, 0x80, 0x7F, 0xF8, 0x7F, 0xF8, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC7, 0xF0, 0xFE, 0x3F, 0xC7, 0xF8, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x80,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x1C, 0x03, 0xF0, 0x1C, 0xFC, 0x0F, 0x83, 0xF3, 0xFC, 0x7E, 0x3F, 0xDF,
  0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFD, 0xF8,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0xFF, 0x8F, 0xC0, 0x07, 0xFC, 0x3F, 0x80,
  0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x03, 0x00, 0x38, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x1E, 0x00, 0x04, 0x00, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x07, 0x01, 0xFC, 0x7F, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF7, 0xFE, 0x3F, 0xC0,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F,
  0xF1, 0xFF, 0x80, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0x3F, 0xF8, 0x0F, 0xFC,
  0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x01, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0x7F,
  0xF0, 0x1F, 0xFD, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0x01, 0xFF, 0xDF, 0xFC,
  0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0xEF, 0xFE, 0x03,
  0xFF, 0xBF, 0xF8, 0x0F, 0xFE, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0x80, 0xFF,
  0xEF, 0xFE, 0x03, 0xFF, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xF3,
  0xFF, 0x01, 0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF,
  0xC0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0,
  0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFD, 0xFF, 0xC7, 0x87,
  0xFF, 0x30, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0xFF,
  0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xBF, 0xF8, 0x00, 0x7F, 0xBF, 0xF8, 0x00,
  0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0x3F, 0xF8, 0x01, 0xFE, 0x3F, 0xF0, 0x03,
  0xFE, 0x7F, 0xF0, 0x07, 0xFC, 0x7F, 0xF0, 0x07, 0xFC, 0x7F, 0xF0, 0x0F,
  0xF8, 0x7F, 0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F,
  0xF0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x7E, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFC, 0x1F, 0xFC, 0x00, 0x3C, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x0F,
  0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x7E, 0x00, 0x7F, 0xF7, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xE0, 0xFF, 0xE7,
  0xFF, 0x03, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0x7F, 0xF0, 0x1F, 0xFD, 0xFF,
  0xC0, 0x7F, 0xF7, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x0F,
  0xFE, 0x7F, 0xE0, 0x3F, 0xF9, 0xFF, 0x80, 0xFF, 0xE7, 0xFE, 0x07, 0xFF,
  0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x83,
  0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xE1, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F,
  0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0,
  0x3F, 0xFC, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x0F, 0xFC, 0x7F, 0xF0,
  0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0xBF, 0xF8, 0x0F, 0xFD, 0xFF, 0xC0, 0xFF,
  0xEF, 0xFE, 0x07, 0xFF, 0x7F, 0xF0, 0x3F, 0xFB, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xBF, 0xF0,
  0x1F, 0xFD, 0xFF, 0x80, 0xFF, 0xEF, 0xFE, 0x0F, 0xFE, 0x7F, 0xF0, 0x7F,
  0xF3, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xEF, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xFC, 0x01, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE,
  0x03, 0xFE, 0x00, 0xFE, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x02, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x04,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0x1F, 0xFD, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x03, 0xFC, 0x03, 0xFF, 0xC0, 0x7E,
  0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x7E, 0x07, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F,
  0x07, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x0F, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F,
  0x0F, 0xE0, 0x7F, 0xE7, 0xF8, 0x3F, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x3F,
  0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0x1F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F,
  0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0x3F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F,
  0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0x3F, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F,
  0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x7F, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x7F, 0x07, 0xF8, 0x1F, 0xC0, 0x7E, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7E,
  0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0x7E, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE,
  0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0xFC, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0xFC,
  0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0xFC, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xF8,
  0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xF8, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xF8,
  0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xF0, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xF0,
  0xFE, 0x0F, 0xFF, 0xFF, 0x8F, 0xE0, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0x9F, 0xFF, 0x80,
  0xFE, 0x03, 0xFF, 0x1F, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x0F, 0xFC, 0x00,
  0x7F, 0x00, 0x38, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0xFF, 0xCF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x01, 0xFF, 0xBF, 0xF0,
  0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF8,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x3F, 0xFC,
  0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0x0F,
  0xFE, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFF, 0x03,
  0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00,
  0xFF, 0xE3, 0xFF, 0x80, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0xFF,
  0xE0, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE1, 0xFF, 0xC0,
  0x07, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xF3, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFF, 0x00, 0xFF,
  0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0xC1,
  0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07,
  0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF,
  0xC0, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x07, 0xFF,
  0x83, 0xFF, 0x80, 0x3F, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC0,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x83,
  0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F,
  0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x8F,
  0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x7F,
  0xF0, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0xFF,
  0xE3, 0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0xF3, 0xFF,
  0xC0, 0xFF, 0xFF, 0x9F, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC7, 0xFF, 0x03, 0xFF, 0xFE, 0x3F, 0xF8, 0x1F, 0xFF, 0xF1, 0xFF, 0xC0,
  0xFF, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0xFC, 0x7F, 0xF0, 0x01, 0xFF, 0xE3,
  0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x03,
  0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xE1, 0xFF,
  0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF,
  0x81, 0xFF, 0xF9, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F,
  0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x1F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xF9, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0xFF,
  0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE3, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xBF, 0xFE, 0x00,
  0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x1F, 0xFD, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xBF,
  0xF8, 0x00, 0x07, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xF7, 0xF8, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xBF, 0xC0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFD, 0xFE,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xEF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0x7F, 0x83, 0xFF, 0xFF, 0xC0, 0x3F, 0xFB, 0xFC, 0x1F, 0xEF, 0xFE, 0x01,
  0xFF, 0xDF, 0xE1, 0xFF, 0x7F, 0xE0, 0x0F, 0xFE, 0xFF, 0x0F, 0xF3, 0xFF,
  0x00, 0x7F, 0xE7, 0xF8, 0x7F, 0xBF, 0xF8, 0x03, 0xFF, 0x3F, 0xC7, 0xFD,
  0xFF, 0xC0, 0x3F, 0xF9, 0xFE, 0x3F, 0xCF, 0xFE, 0x01, 0xFF, 0xC7, 0xF3,
  0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0x9F, 0xE7, 0xFF, 0x00, 0x7F, 0xF1,
  0xFC, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x8F, 0xEF, 0xF1, 0xFF, 0xC0, 0x1F,
  0xFC, 0x7F, 0x7F, 0x8F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xF0,
  0x0F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xFE, 0x3F,
  0xF8, 0x03, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xFF,
  0x0F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xFF, 0x0F,
  0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF,
  0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x80, 0x7F, 0xF8, 0x1F, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0x81,
  0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F,
  0xC0, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0x00,
  0xFF, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x3F, 0xF8, 0x03, 0xFF,
  0xBF, 0x07, 0xFF, 0x00, 0x7F, 0xF7, 0xF0, 0xFF, 0xE0, 0x1F, 0xFE, 0xFE,
  0x1F, 0xFC, 0x03, 0xFF, 0xDF, 0xC7, 0xFF, 0x80, 0x7F, 0xF1, 0xF8, 0xFF,
  0xE0, 0x0F, 0xFE, 0x3F, 0x9F, 0xFC, 0x01, 0xFF, 0xC7, 0xF3, 0xFF, 0x80,
  0x3F, 0xF8, 0xFE, 0x7F, 0xF0, 0x0F, 0xFF, 0x1F, 0xCF, 0xFE, 0x01, 0xFF,
  0xE1, 0xFB, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xEF, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x1F,
  0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFF,
  0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0xFF,
  0xE3, 0xFF, 0x80, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xFE, 0x7F, 0xF8,
  0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x07, 0xFF,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x7F, 0xF1, 0xFF, 0xC0,
  0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0xFF, 0xF0, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFF, 0x00,
  0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x01,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xFD, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x07,
  0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x03,
  0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xEF, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x87,
  0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00,
  0xFF, 0xE1, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0x0F, 0xFE, 0x3F,
  0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x03,
  0xFF, 0x8F, 0xFE, 0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0x7F, 0xF9, 0xFF,
  0xE0, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x1F,
  0xFC, 0x7F, 0xF0, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x01, 0xFF, 0xC7, 0xFF,
  0x00, 0x0F, 0xFF, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x7F, 0xF0, 0x00, 0xFF,
  0xE1, 0xFF, 0xC0, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xFC,
  0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x80,
  0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x81,
  0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x03, 0xFF,
  0xC3, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFE,
  0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF0,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF8,
  0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF0, 0x07,
  0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8,
  0x1F, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF0,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xC0,
  0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFE, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x03,
  0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0xC1, 0xFF,
  0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFD, 0xFF, 0xE0, 0x00, 0xFF,
  0xFB, 0xFF, 0xC0, 0x01, 0xFF, 0xF7, 0xFF, 0x80, 0x07, 0xFF, 0xCF, 0xFF,
  0x00, 0x0F, 0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x7F,
  0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF,
  0xF0, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x07, 0xFF, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xFC, 0x00,
  0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xE3,
  0xFF, 0x80, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00,
  0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xDF, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x3F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x7F, 0xF0, 0x7F, 0xF8, 0x1F,
  0xFC, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF9, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xE3, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xC7, 0xFE, 0x0F, 0xFF, 0x83, 0xFF,
  0x8F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFE, 0x1F, 0xF8, 0x7F, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xFC, 0x3F, 0xF8, 0x7F, 0xE3, 0xFF, 0xF8, 0xFF, 0xE0,
  0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0x83,
  0xFF, 0x3F, 0xFF, 0xCF, 0xFE, 0x07, 0xFE, 0x7F, 0xFF, 0x9F, 0xFC, 0x0F,
  0xFC, 0xFF, 0xFF, 0x3F, 0xF8, 0x1F, 0xFB, 0xFF, 0xFE, 0x7F, 0xE0, 0x3F,
  0xF7, 0xFF, 0xFD, 0xFF, 0xC0, 0x7F, 0xEF, 0xFF, 0xFB, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF7, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x83,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xE7, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFB,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xDF, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFB, 0xFF, 0x80, 0x07, 0xFF, 0x9F,
  0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x3F,
  0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0,
  0x07, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x01,
  0xFF, 0x8F, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFF,
  0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFB, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFD, 0xFC, 0x03, 0xFD, 0xFC,
  0x03, 0xF9, 0xFC, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE,
  0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x3F, 0xC0, 0xFF,
  0x3F, 0xC0, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x80, 0x7F,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x3F, 0xF8, 0x3F, 0xF8, 0xFF, 0xE0,
  0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xF1, 0xFF, 0xC7, 0xFF, 0x87, 0xFF,
  0x1F, 0xFC, 0x3F, 0xF8, 0xFF, 0xF0, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0x8F,
  0xFE, 0x0F, 0xFE, 0x3F, 0xF8, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF,
  0x9F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xEF, 0xFC, 0x07, 0xFF, 0x3F,
  0xF8, 0x0F, 0xF8, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x8F, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07,
  0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x80,
  0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFC,
  0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xEF, 0xFF, 0xF0, 0x3F, 0xF7, 0xFF, 0xF0, 0x1F,
  0xF9, 0xFF, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF,
  0x8F, 0xFE, 0x07, 0xFC, 0x7F, 0xE0, 0x3F, 0xE3, 0xFF, 0x01, 0xFF, 0xBF,
  0xF8, 0x0F, 0xFD, 0xFF, 0xC0, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x3F, 0xF0,
  0x3F, 0xF1, 0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0x3F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xFC, 0xFF,
  0xE0, 0x0F, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x81,
  0xFF, 0x80, 0x7F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFB, 0xFF,
  0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xE1,
  0xFF, 0xC0, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0x3F, 0xF8, 0x0F, 0xFC, 0xFF,
  0xC0, 0x3F, 0xF7, 0xFF, 0x01, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x20, 0x1F, 0xFC, 0x01, 0x80, 0x7F, 0xF8, 0x3F, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0xFF, 0xF9, 0xFF, 0x80, 0x7F, 0xFF, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F,
  0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xF8,
  0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F,
  0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00, 0x7C, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x08, 0x00, 0xFF,
  0xF0, 0x01, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x87, 0xC0, 0x03, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0x0F, 0xFF, 0x07, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE,
  0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE,
  0x07, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC,
  0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC,
  0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0,
  0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xE0,
  0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x81, 0xFF, 0xF0, 0x1F, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xF8,
  0x07, 0xFF, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xF8, 0x01, 0xFF, 0x8F,
  0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xF8, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x07,
  0xFF, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFE,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x87, 0xFF, 0x00,
  0x1F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFE, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x07,
  0xC0, 0x01, 0xFF, 0x9F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0xBF, 0xFC, 0x7F,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x07,
  0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F,
  0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0x1F, 0xF0, 0x03, 0xFF, 0x7F,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x07,
  0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07,
  0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0x3F,
  0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F,
  0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0x7F,
  0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0xCF, 0xFE,
  0x03, 0xFF, 0x3F, 0xF0, 0x0F, 0xFD, 0xFF, 0xC0, 0x3F, 0xF7, 0xFF, 0x00,
  0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0x7F, 0xF0, 0x1F, 0xFD, 0xFF, 0xC0, 0x7F,
  0xF7, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xBF, 0xF8, 0x0F, 0xFE, 0xFF,
  0xE0, 0x3F, 0xFB, 0xFF, 0x80, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0x1F, 0xF8,
  0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFD, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x3F, 0xF8,
  0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xF0,
  0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0xE3, 0xFF,
  0x03, 0xFF, 0xF3, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x1F, 0xFC,
  0x7F, 0xF0, 0x1F, 0xFC, 0x7F, 0xF0, 0x1F, 0xFC, 0x7F, 0xF0, 0x1F, 0xFC,
  0x7F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF8,
  0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF8,
  0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0,
  0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF0,
  0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFD, 0xFF, 0xC0, 0x00, 0xF1, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x7F, 0xEF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x3F, 0xF8, 0x7F, 0xE0,
  0xFF, 0xC7, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x3F,
  0xF0, 0x3F, 0xF9, 0xFF, 0x81, 0xFF, 0xCF, 0xFC, 0x0F, 0xFC, 0x7F, 0xF0,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07,
  0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07,
  0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F,
  0xFE, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F,
  0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xE0, 0x3F,
  0xF0, 0x7F, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F,
  0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF,
  0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0x9F, 0xF8, 0x1F, 0xFC,
  0x7F, 0xE0, 0x7F, 0xF1, 0xFF, 0x83, 0xFF, 0xC7, 0xFE, 0x0F, 0xFE, 0x1F,
  0xF8, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0x07, 0xFE,
  0x1F, 0xFC, 0x1F, 0xF8, 0xFF, 0xE0, 0x7F, 0xE3, 0xFF, 0x80, 0xFF, 0x8F,
  0xFC, 0x03, 0xFE, 0x7F, 0xF0, 0x0F, 0xF9, 0xFF, 0x80, 0x3F, 0xF7, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFE, 0x07, 0xFE, 0xFF, 0xC1,
  0xFE, 0x07, 0xFE, 0xFF, 0xC3, 0xFE, 0x0F, 0xFE, 0xFF, 0xC3, 0xFE, 0x0F,
  0xFC, 0xFF, 0xC3, 0xFE, 0x0F, 0xFC, 0xFF, 0xC7, 0xFF, 0x1F, 0xF8, 0xFF,
  0xC7, 0xFF, 0x1F, 0xF8, 0xFF, 0x87, 0xFF, 0x1F, 0xF8, 0xFF, 0x8F, 0xFF,
  0x3F, 0xF0, 0xFF, 0x8F, 0xFF, 0x3F, 0xF0, 0xFF, 0x9F, 0xFF, 0x3F, 0xF0,
  0xFF, 0x9F, 0xFF, 0x3F, 0xE0, 0xFF, 0x9F, 0xFF, 0x7F, 0xE0, 0xFF, 0xBF,
  0xFF, 0x7F, 0xE0, 0xFF, 0xBF, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x7F,
  0xFF, 0x00, 0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x7F, 0xFE, 0x00,
  0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0xFF, 0xF8,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xC1,
  0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x0F,
  0xFE, 0x7F, 0xF8, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xE0,
  0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0xFF,
  0xE3, 0xFF, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x80,
  0x3F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xF8, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xC1, 0xFF,
  0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC0,
  0x7F, 0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF,
  0xC0, 0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xE3,
  0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x3F,
  0xF3, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xDF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0x0F, 0xFF,
  0x80, 0xFF, 0x1F, 0xFF, 0xC0, 0xFF, 0x3F, 0xFF, 0xE1, 0xFE, 0x3F, 0xFF,
  0xE1, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0x87,
  0xFF, 0xFC, 0x7F, 0x83, 0xFF, 0xFC, 0x7F, 0x03, 0xFF, 0xF8, 0xFF, 0x01,
  0xFF, 0xF0, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0x80,
};

const GFXglyph RobotoCondensed_BlackItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 19, 50, 18, 1, -49 },
  { 120, 22, 19, 21, 3, -52 },
  { 173, 35, 49, 34, 0, -49 },
  { 388, 32, 65, 34, 2, -57 },
  { 648, 33, 51, 43, 6, -50 },
  { 859, 35, 51, 40, 1, -50 },
  { 1083, 11, 19, 10, 3, -52 },
  { 1110, 21, 69, 22, 3, -54 },
  { 1292, 22, 69, 22, -3, -54 },
  { 1482, 30, 30, 31, 3, -49 },
  { 1595, 30, 36, 31, 1, -41 },
  { 1730, 16, 22, 18, -4, -9 },
  { 1774, 18, 9, 28, 5, -26 },
  { 1795, 12, 12, 20, 1, -11 },
  { 1813, 30, 53, 21, -5, -49 },
  { 2012, 30, 51, 34, 3, -50 },
  { 2204, 22, 49, 34, 7, -49 },
  { 2339, 33, 50, 34, 0, -50 },
  { 2546, 34, 51, 34, 0, -50 },
  { 2763, 32, 49, 34, 1, -49 },
  { 2959, 33, 50, 34, 1, -49 },
  { 3166, 30, 50, 34, 2, -49 },
  { 3354, 34, 49, 34, 2, -49 },
  { 3563, 33, 51, 34, 1, -50 },
  { 3774, 29, 50, 34, 4, -50 },
  { 3956, 17, 39, 20, 1, -38 },
  { 4039, 21, 51, 19, -3, -38 },
  { 4173, 28, 33, 30, 1, -37 },
  { 4289, 30, 24, 35, 2, -33 },
  { 4379, 28, 33, 30, 1, -37 },
  { 4495, 27, 51, 31, 4, -50 },
  { 4668, 48, 63, 51, 1, -48 },
  { 5046, 40, 49, 41, -3, -49 },
  { 5291, 38, 49, 38, 0, -49 },
  { 5524, 37, 51, 38, 2, -50 },
  { 5760, 37, 49, 38, 0, -49 },
  { 5987, 36, 49, 33, 0, -49 },
  { 6208, 35, 49, 32, 0, -49 },
  { 6423, 37, 51, 40, 2, -50 },
  { 6659, 43, 49, 41, 0, -49 },
  { 6923, 20, 49, 19, 0, -49 },
  { 7046, 35, 50, 33, 0, -49 },
  { 7265, 43, 49, 37, 0, -49 },
  { 7529, 29, 49, 32, 0, -49 },
  { 7707, 53, 49, 51, 0, -49 },
  { 8032, 43, 49, 41, 0, -49 },
  { 8296, 38, 51, 40, 2, -50 },
  { 8539, 38, 49, 38, 0, -49 },
  { 8772, 38, 59, 40, 2, -50 },
  { 9053, 38, 49, 38, 0, -49 },
  { 9286, 36, 51, 37, 1, -50 },
  { 9516, 36, 49, 37, 5, -49 },
  { 9737, 38, 50, 39, 2, -49 },
  { 9975, 39, 49, 39, 5, -49 },
  { 10214, 47, 49, 50, 6, -49 },
  { 10502, 45, 49, 38, -3, -49 },
  { 10778, 37, 49, 37, 5, -49 },
  { 11005, 40, 49, 36, -1, -49 },
  { 11250, 25, 69, 18, -2, -57 },
  { 11466, 18, 53, 26, 5, -49 },
  { 11586, 24, 69, 18, -4, -57 },
  { 11793, 24, 25, 27, 2, -49 },
  { 11868, 26, 8, 26, -4, 0 },
  { 11894, 16, 10, 23, 7, -51 },
  { 11914, 30, 38, 31, 0, -37 },
  { 12057, 33, 53, 33, -1, -52 },
  { 12276, 29, 38, 31, 1, -37 },
  { 12414, 35, 53, 33, 1, -52 },
  { 12646, 30, 38, 32, 1, -37 },
  { 12789, 26, 53, 22, 1, -53 },
  { 12962, 35, 51, 34, -1, -37 },
  { 13186, 32, 52, 33, -1, -52 },
  { 13394, 19, 51, 17, 0, -51 },
  { 13516, 27, 65, 17, -8, -51 },
  { 13736, 37, 52, 33, -1, -52 },
  { 13977, 20, 52, 17, 0, -52 },
  { 14107, 48, 37, 49, -1, -37 },
  { 14329, 32, 37, 33, -1, -37 },
  { 14477, 30, 38, 33, 1, -37 },
  { 14620, 35, 51, 33, -3, -37 },
  { 14844, 32, 51, 33, 1, -37 },
  { 15048, 26, 37, 23, -1, -37 },
  { 15169, 29, 38, 30, 0, -37 },
  { 15307, 20, 47, 21, 2, -46 },
  { 15425, 32, 37, 33, 1, -36 },
  { 15573, 30, 36, 31, 3, -36 },
  { 15708, 40, 36, 42, 4, -36 },
  { 15888, 36, 36, 31, -3, -36 },
  { 16050, 35, 50, 31, -1, -36 },
  { 16269, 32, 36, 31, -1, -36 },
  { 16413, 21, 66, 20, 1, -54 },
  { 16587, 15, 58, 17, 1, -49 },
  { 16696, 21, 66, 20, -2, -54 },
  { 16870, 32, 16, 36, 2, -28 },
};

const GFXfont RobotoCondensed_BlackItalic69pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic69pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic69pt7bGlyphs,
  0x20, 0x7E, 81
};

#endif // _ROBOTOCONDENSED_BLACKITALIC69PT7B_H_
