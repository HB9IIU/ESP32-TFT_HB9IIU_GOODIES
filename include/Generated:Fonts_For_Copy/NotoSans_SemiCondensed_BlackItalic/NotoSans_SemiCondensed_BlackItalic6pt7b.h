#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC6PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x5A, 0xC0, 0x7F, 0xEC, 0x2D, 0x3C, 0xFF, 0x4E, 0xB0, 0x66, 0xBF,
  0x80, 0x6A, 0x80, 0x56, 0x80, 0x5D, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80,
  0x29, 0x40, 0x76, 0xE0, 0x75, 0x20, 0x65, 0x70, 0x6C, 0xF0, 0x2F, 0xA0,
  0x7C, 0xF0, 0x7E, 0xF0, 0x72, 0x4C, 0x6E, 0xF0, 0x75, 0xE0, 0x48, 0x4A,
  0x39, 0x80, 0xFC, 0x8F, 0x00, 0xEC, 0x60, 0x7D, 0xFF, 0x06, 0x00, 0x6F,
  0xD0, 0x76, 0xAE, 0x7C, 0x86, 0x75, 0xAE, 0x6E, 0x70, 0x6E, 0x40, 0x7F,
  0xA6, 0x57, 0xAA, 0x69, 0x60, 0x25, 0xAC, 0x76, 0xAA, 0x4A, 0x70, 0x5A,
  0xEB, 0x60, 0x57, 0xBB, 0x7D, 0x96, 0x6F, 0x40, 0x7D, 0x96, 0x20, 0x6E,
  0xD0, 0x69, 0xE0, 0xE9, 0x20, 0x55, 0xAE, 0xF6, 0x64, 0xFE, 0xE5, 0x94,
  0x76, 0x6A, 0xFA, 0x40, 0xEB, 0x70, 0x6A, 0x80, 0xF0, 0x56, 0x80, 0x6E,
  0x80, 0xE0, 0x80, 0x77, 0x80, 0x49, 0xDE, 0x73, 0x00, 0x12, 0x6A, 0xE0,
  0x7F, 0x80, 0x13, 0x66, 0x4C, 0x77, 0xF0, 0x49, 0xDA, 0x46, 0x80, 0x20,
  0xA5, 0x80, 0x45, 0x6E, 0xA0, 0x56, 0x80, 0x7D, 0x6E, 0x76, 0x80, 0x77,
  0x80, 0x77, 0xC0, 0x77, 0xB0, 0x72, 0x00, 0xAB, 0x00, 0x7A, 0x60, 0x77,
  0x80, 0xB9, 0x00, 0xAF, 0xBC, 0xF4, 0xA0, 0xB9, 0x40, 0xEB, 0x00, 0x6A,
  0x4C, 0xFC, 0xD6, 0x80, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 4, 2, 0, -4 },
  { 2, 2, 1, 3, 1, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 5, 4, 5, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 1, 1, -4 },
  { 13, 2, 5, 2, 0, -4 },
  { 15, 2, 5, 2, 0, -4 },
  { 17, 3, 3, 3, 0, -5 },
  { 19, 3, 3, 3, 0, -4 },
  { 21, 1, 2, 2, 0, -1 },
  { 22, 2, 1, 2, 0, -2 },
  { 23, 1, 1, 2, 0, -1 },
  { 24, 3, 4, 3, 0, -4 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 4, 4, 3, 0, -4 },
  { 42, 3, 4, 3, 0, -4 },
  { 44, 3, 4, 3, 0, -4 },
  { 46, 2, 3, 2, 0, -3 },
  { 47, 2, 4, 2, 0, -3 },
  { 48, 3, 3, 3, 0, -4 },
  { 50, 3, 2, 3, 0, -3 },
  { 51, 3, 3, 3, 0, -4 },
  { 53, 3, 4, 3, 0, -4 },
  { 55, 5, 5, 5, 0, -4 },
  { 59, 3, 4, 4, 0, -4 },
  { 61, 4, 4, 4, 0, -4 },
  { 63, 4, 4, 3, 0, -4 },
  { 65, 4, 4, 4, 0, -4 },
  { 67, 3, 4, 3, 0, -4 },
  { 69, 3, 4, 3, 0, -4 },
  { 71, 4, 4, 4, 0, -4 },
  { 73, 4, 4, 4, 0, -4 },
  { 75, 3, 4, 2, 0, -4 },
  { 77, 3, 5, 2, -1, -4 },
  { 79, 4, 4, 4, 0, -4 },
  { 81, 3, 4, 3, 0, -4 },
  { 83, 5, 4, 5, 0, -4 },
  { 86, 4, 4, 4, 0, -4 },
  { 88, 4, 4, 4, 0, -4 },
  { 90, 3, 4, 3, 0, -4 },
  { 92, 4, 5, 4, 0, -4 },
  { 95, 3, 4, 4, 0, -4 },
  { 97, 3, 4, 3, 0, -4 },
  { 99, 3, 4, 3, 0, -4 },
  { 101, 4, 4, 4, 0, -4 },
  { 103, 4, 4, 3, 0, -4 },
  { 105, 6, 4, 5, 0, -4 },
  { 108, 4, 4, 4, 0, -4 },
  { 110, 3, 4, 3, 1, -4 },
  { 112, 3, 4, 3, 0, -4 },
  { 114, 2, 5, 2, 0, -4 },
  { 116, 1, 4, 3, 1, -4 },
  { 117, 2, 5, 2, 0, -4 },
  { 119, 3, 3, 3, 0, -4 },
  { 121, 3, 1, 3, -1, 0 },
  { 122, 1, 1, 2, 1, -5 },
  { 123, 3, 3, 3, 0, -3 },
  { 125, 3, 5, 3, 0, -5 },
  { 127, 3, 3, 3, 0, -3 },
  { 129, 4, 5, 3, 0, -5 },
  { 132, 3, 3, 3, 0, -3 },
  { 134, 4, 6, 2, -1, -5 },
  { 137, 3, 4, 3, 0, -3 },
  { 139, 3, 5, 3, 0, -5 },
  { 141, 2, 5, 2, 0, -5 },
  { 143, 3, 6, 2, -1, -5 },
  { 146, 4, 5, 3, 0, -5 },
  { 149, 2, 5, 2, 0, -5 },
  { 151, 5, 3, 5, 0, -3 },
  { 153, 3, 3, 3, 0, -3 },
  { 155, 3, 3, 3, 0, -3 },
  { 157, 3, 4, 3, 0, -3 },
  { 159, 3, 4, 3, 0, -3 },
  { 161, 3, 3, 2, 0, -3 },
  { 163, 3, 3, 3, 0, -3 },
  { 165, 3, 4, 2, 0, -4 },
  { 167, 3, 3, 3, 0, -3 },
  { 169, 3, 3, 3, 0, -3 },
  { 171, 5, 3, 5, 0, -3 },
  { 173, 4, 3, 3, 0, -3 },
  { 175, 3, 4, 3, 0, -3 },
  { 177, 3, 3, 3, 0, -3 },
  { 179, 3, 5, 2, 0, -4 },
  { 181, 1, 6, 3, 1, -5 },
  { 182, 2, 5, 2, 0, -4 },
  { 184, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic6pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC6PT7B_H_
