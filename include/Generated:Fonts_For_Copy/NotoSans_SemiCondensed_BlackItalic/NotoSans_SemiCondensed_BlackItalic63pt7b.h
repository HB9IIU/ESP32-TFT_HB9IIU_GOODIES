#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC63PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x07,
  0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFC, 0x7F, 0xF3, 0xFF, 0x1F, 0xF9,
  0xFF, 0xC7, 0xFE, 0x7F, 0xE1, 0xFF, 0x9F, 0xF8, 0x7F, 0xC7, 0xFE, 0x3F,
  0xF1, 0xFF, 0x0F, 0xFC, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x8F, 0xF8,
  0x3F, 0xE3, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF0, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x00,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0x78, 0xFC, 0x0F, 0xFC, 0xF8, 0x18, 0x0F, 0xFC,
  0xF8, 0x08, 0x0F, 0xFC, 0xF0, 0x00, 0x0F, 0xFC, 0xF0, 0x00, 0x0F, 0xFE,
  0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x07, 0xBF, 0xF8, 0x00, 0x07, 0x9F, 0xF8, 0x80, 0x0F,
  0x9F, 0xF8, 0xE0, 0x0F, 0x9F, 0xF0, 0xF8, 0x0F, 0x3F, 0xF0, 0xFF, 0x0F,
  0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xF1,
  0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE,
  0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x0F, 0xF0, 0x00, 0x3F,
  0xE1, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x7F, 0xC0, 0x00,
  0x3F, 0xC3, 0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x0E,
  0x03, 0xFC, 0x7F, 0xC7, 0xFC, 0x3F, 0xF0, 0xFF, 0x1F, 0xF3, 0xFE, 0x3F,
  0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xCF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x3F, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xF1,
  0xFF, 0xFF, 0xDF, 0xFF, 0xC7, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xE3, 0xFE,
  0x3F, 0xE7, 0xFC, 0x3F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x01, 0xC0, 0x7F,
  0xC7, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x00, 0x03,
  0xFE, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xC3, 0xFE, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x3F, 0xC0,
  0x03, 0xFE, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x7F, 0xF0,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0x9F, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF3, 0xFF, 0x83, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x7F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF9, 0xFF,
  0x8F, 0xFC, 0xFF, 0xE7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x08, 0x03, 0xFC, 0x00, 0x70, 0x1F, 0xE0,
  0x03, 0xE0, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x4F,
  0xFF, 0xFC, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0x02, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xEF, 0xF8, 0x03, 0xFF,
  0x3F, 0xC0, 0x0F, 0xF1, 0xFF, 0x00, 0x3F, 0x0F, 0xF8, 0x00, 0xF8, 0x3F,
  0xE0, 0x03, 0x81, 0xFC, 0x00, 0x08, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD,
  0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xC0, 0x0F, 0xC3, 0xFE, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xC1, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0x8F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE,
  0x0F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x1F, 0xFC, 0x0F, 0xFF, 0x3F, 0xFC,
  0x0F, 0xFE, 0x3F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8,
  0x0F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFE, 0x7F, 0xF0,
  0x0F, 0xFE, 0x7F, 0xF0, 0x1F, 0xFE, 0x7F, 0xF0, 0x1F, 0xFE, 0xFF, 0xF0,
  0x1F, 0xFC, 0xFF, 0xF0, 0x1F, 0xFC, 0xFF, 0xF0, 0x3F, 0xFC, 0xFF, 0xE0,
  0x3F, 0xFC, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0,
  0x7F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF3, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFD, 0xFF, 0xC1, 0xFF, 0x3F, 0xF8, 0x3F, 0xCF, 0xFF, 0x03,
  0xE1, 0xFF, 0xC0, 0x38, 0x3F, 0xF8, 0x04, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x8F, 0xFF, 0x80, 0x1F,
  0xC0, 0xFF, 0xF0, 0x01, 0xE0, 0x1F, 0xFE, 0x00, 0x38, 0x03, 0xFF, 0x80,
  0x02, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0x01, 0xFF, 0xE0, 0x06, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x20, 0x00, 0x0F, 0xFF, 0x1C, 0x00, 0x0F, 0xFF,
  0x8F, 0xC0, 0x1F, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x0F,
  0xF7, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0xC0, 0x03, 0xFE, 0x7F, 0xF0, 0x01,
  0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0x8F, 0xFE, 0x00, 0x3F, 0xE3, 0xFF, 0x80,
  0x1F, 0xF0, 0xFF, 0xE0, 0x0F, 0xF8, 0x3F, 0xF8, 0x07, 0xFC, 0x1F, 0xFE,
  0x01, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x80, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x40, 0x00, 0x3F, 0xFC, 0x30, 0x00, 0x3F, 0xFE, 0x1F, 0x00,
  0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x7F, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFE,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x7F, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x1F,
  0xFF, 0x07, 0xFF, 0x8F, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0x81, 0xFF, 0xE3,
  0xFF, 0xC0, 0xFF, 0xF1, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF, 0xF0, 0x3F, 0xF8,
  0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xE3, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFC, 0x07,
  0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xCF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0x81, 0xFF, 0xC1, 0xFF,
  0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xE0, 0x1F,
  0xFC, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xFC, 0x07,
  0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0x7F, 0xF1, 0xFF, 0xC0,
  0xFF, 0xE7, 0xFF, 0x81, 0xFF, 0xCF, 0xFF, 0x03, 0xFF, 0x9F, 0xFC, 0x07,
  0xFF, 0x3F, 0xF8, 0x0F, 0xFE, 0x7F, 0xF0, 0x3F, 0xFC, 0xFF, 0xE0, 0x7F,
  0xF9, 0xFF, 0xC0, 0xFF, 0xF3, 0xFF, 0x83, 0xFF, 0xE7, 0xFF, 0x8F, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0xFF, 0xC0,
  0xFF, 0xFB, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0x00, 0x7F, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x08, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x1F, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xF8, 0x1F,
  0xFC, 0x78, 0x07, 0xFF, 0x08, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xFF, 0x07, 0xF8,
  0x3F, 0xE0, 0x3F, 0xFF, 0xF1, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF, 0xF0, 0xFF,
  0x1F, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0x8F, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F,
  0xC7, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xE7, 0xF8, 0x3F, 0xE0, 0xFE, 0x0F,
  0xF3, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xF9, 0xFC, 0x1F, 0xE0, 0x7F, 0x83,
  0xFD, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0xFF, 0x0F, 0xF0, 0x1F, 0xC0,
  0xFF, 0x7F, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x3F, 0x83, 0xFC, 0x0F, 0xF0,
  0x3F, 0xBF, 0xC3, 0xFC, 0x07, 0xF8, 0x3F, 0xDF, 0xE1, 0xFE, 0x07, 0xF8,
  0x1F, 0xCF, 0xF0, 0xFF, 0x03, 0xFC, 0x0F, 0xE7, 0xF8, 0x7F, 0x81, 0xFE,
  0x0F, 0xF3, 0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE0, 0xFF,
  0x8F, 0xF8, 0xFF, 0x0F, 0xF9, 0xFF, 0xCF, 0xF8, 0x7F, 0x87, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xFC, 0xFF, 0xF8, 0x03, 0xFC, 0x1F, 0xFC,
  0x3F, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xDF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x0F,
  0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x7F,
  0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x07,
  0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0xFF, 0xE1,
  0xFF, 0xE0, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x03, 0xFF, 0x8F, 0xFF, 0x00,
  0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0x1F, 0xFD,
  0xFF, 0xF0, 0x00, 0x3F, 0xFB, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x87,
  0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F,
  0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0x80, 0xFF, 0xFE,
  0x00, 0xF0, 0x0F, 0xFF, 0x80, 0x02, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x20, 0x0F, 0xFF, 0x80,
  0x0E, 0x00, 0x7F, 0xFE, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F,
  0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0xFC,
  0x01, 0xFF, 0xF8, 0x00, 0x70, 0x0F, 0xFF, 0xC0, 0x00, 0x40, 0x3F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x04, 0x7F, 0xF8, 0x3F, 0xFF, 0xE1,
  0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFC, 0x1F,
  0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F,
  0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x1F,
  0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F,
  0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7B, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xF8,
  0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE1,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE3, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xCF, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xDF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xBF, 0xFC, 0x00, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0x7F, 0x80,
  0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFD,
  0xFE, 0x07, 0xFB, 0xFF, 0x80, 0x1F, 0xFB, 0xFC, 0x1F, 0xF7, 0xFE, 0x00,
  0x3F, 0xF7, 0xF8, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xEF, 0xF0, 0xFF, 0xBF,
  0xF8, 0x01, 0xFF, 0xDF, 0xE1, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0x3F, 0xC7,
  0xFC, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0x8F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC,
  0xFF, 0x3F, 0xE7, 0xFF, 0x00, 0x3F, 0xF9, 0xFE, 0x7F, 0xCF, 0xFE, 0x00,
  0x7F, 0xF3, 0xFC, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xC7, 0xFB, 0xFE, 0x3F,
  0xF0, 0x01, 0xFF, 0x8F, 0xF7, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x1F, 0xFF,
  0xF1, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xFC,
  0x7F, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0x0F, 0xFC, 0x00,
  0x7F, 0xE1, 0xFF, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F,
  0xF0, 0x03, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFF,
  0xC1, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F,
  0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xBF, 0xF0,
  0x3F, 0xF0, 0x01, 0xFF, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0xE1,
  0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x87,
  0xFF, 0x00, 0x3F, 0xF3, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xE7, 0xFF, 0x1F,
  0xF8, 0x01, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0xFF,
  0xE0, 0x07, 0xFE, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xFB, 0xFF,
  0x00, 0x3F, 0xF8, 0x7F, 0xF7, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xEF, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0,
  0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xF1,
  0xFF, 0xF0, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xFE, 0x00,
  0x1F, 0xFC, 0xFF, 0xF0, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x01, 0xFF, 0xDF,
  0xFE, 0x00, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00,
  0xFF, 0xF7, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x07,
  0xFF, 0xBF, 0xFC, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x7F, 0xFB, 0xFF,
  0xC0, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x7F,
  0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F, 0xFF, 0x8F, 0xFF,
  0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF0,
  0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F,
  0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80,
  0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xF1, 0xFF, 0xF0, 0x01, 0xFF, 0xC7,
  0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00,
  0x7F, 0xF3, 0xFF, 0xC0, 0x01, 0xFF, 0xDF, 0xFE, 0x00, 0x07, 0xFF, 0x7F,
  0xF8, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x1F,
  0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xFB, 0xFF, 0xC0, 0x03, 0xFF, 0xCF, 0xFF,
  0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0xFF, 0xF0, 0x03, 0xFF,
  0xE3, 0xFF, 0xC0, 0x0F, 0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFE,
  0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xF9, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x0F, 0xFE,
  0x3F, 0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xFC, 0x01,
  0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF,
  0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8,
  0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x7F, 0xF8, 0x07, 0xFF, 0x87,
  0xFF, 0x80, 0x7F, 0xF8, 0x7F, 0xF8, 0x07, 0xFF, 0xC7, 0xFF, 0x00, 0x3F,
  0xFC, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFE, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0xF0, 0x03, 0xFF, 0x80,
  0x08, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x10, 0x00, 0x3F, 0xFC, 0x07, 0x00, 0x0F, 0xFF, 0x01, 0xF0,
  0x03, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xF0,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFC,
  0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFC,
  0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF,
  0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F,
  0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x3F,
  0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07,
  0xFF, 0xE3, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x7F, 0xFD, 0xFF, 0xE0, 0x03, 0xFF,
  0xCF, 0xFF, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0xC0,
  0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x83,
  0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xE1,
  0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xF0, 0x01,
  0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xF3, 0xFF,
  0x80, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x7F,
  0xEF, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xFB, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x9F, 0xFC, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF1, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xFC,
  0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x07,
  0xFF, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x1F,
  0xF7, 0xF8, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xE0, 0x1F,
  0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x7F, 0xC7, 0xFF,
  0x00, 0x7F, 0xE3, 0xFE, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xCF, 0xFD, 0xFF,
  0x3F, 0xF8, 0x01, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x3F,
  0xE7, 0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0x8F, 0xFB, 0xFF, 0x80, 0x0F,
  0xFD, 0xFF, 0x1F, 0xF7, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x87,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFB, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF3, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xF7, 0xFF, 0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x03, 0xFF, 0xC7,
  0xFF, 0x80, 0x7F, 0xFC, 0x7F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0xFF,
  0xF0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8,
  0x3F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xF8, 0x01,
  0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0xCF, 0xFE,
  0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x7F, 0xCF,
  0xF0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF8, 0x03, 0xFC, 0x0F, 0xF8,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xC7, 0xFC,
  0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xC1,
  0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xC0, 0x3F, 0xFE, 0x7F, 0xE0,
  0x3F, 0xFF, 0xBF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0x8F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0x87, 0xFF, 0x81, 0xFF,
  0xC3, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0xE0, 0x3F,
  0xF0, 0xFF, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F,
  0xFE, 0x3F, 0xFC, 0x07, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0x0F, 0xFF, 0x03,
  0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0xFF, 0xC0, 0x3F,
  0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0x3F, 0xE0, 0x01, 0xFE, 0x1F, 0xF0, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF1, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFC, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xFC, 0x3F,
  0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE0,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF,
  0x87, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xE3,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF3, 0xFF, 0xF0, 0x0F, 0xFC, 0x7F, 0xF8, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xF0, 0x38, 0x3F, 0xFE, 0x00, 0x83,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x06,
  0x0F, 0xFF, 0x81, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x03, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x0F,
  0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xFB, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x1F, 0xFE, 0x01, 0xFF,
  0xE1, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x7F,
  0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xF7, 0xFE, 0x00, 0x1F, 0xFE, 0x7F, 0xC0, 0x00, 0x7F,
  0x87, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFC, 0x7F,
  0xF0, 0x3F, 0xF9, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0xCF, 0xFF,
  0x07, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xA0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x41, 0xFF, 0xE0, 0x03,
  0x03, 0xFF, 0xE0, 0x1E, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xC1, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x61, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x3F,
  0xE0, 0x03, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xF9, 0xFF, 0x80, 0x3F, 0xFF,
  0xBF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xF8, 0xFF, 0xF0, 0x1F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0x81, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0x87,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0xEF, 0xFE,
  0x00, 0x0F, 0xF9, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x06, 0x00,
  0x0F, 0xFF, 0x00, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF1, 0xFF, 0x00, 0x1F,
  0xFD, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0x3F,
  0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE,
  0x0F, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x81,
  0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFC,
  0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x02,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x03,
  0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x3F,
  0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x00, 0x7F, 0xF1, 0xFF, 0xE0, 0x01,
  0xFF, 0xE7, 0xFF, 0x80, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0x07, 0xFF, 0x7F,
  0xF8, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0x1F, 0xFC,
  0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF,
  0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0xE3, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFC, 0xFF, 0xFC, 0x3F,
  0xFF, 0x00, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0x1F, 0xF7, 0xFF, 0xFB,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFF,
  0x0F, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xC3,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF,
  0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE,
  0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC3,
  0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE,
  0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC7, 0xFF, 0x80, 0x1F,
  0xF3, 0xFF, 0xF0, 0x07, 0xFD, 0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE,
  0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE,
  0x0F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F,
  0xF8, 0x7F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC,
  0x0F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xF0,
  0x3F, 0xF9, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0x80, 0xFF, 0xEF, 0xFF, 0x01,
  0xFF, 0xDF, 0xFE, 0x03, 0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0x7F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xEF, 0xFF, 0x01, 0xFF, 0xDF, 0xFE, 0x07, 0xFF, 0xBF, 0xF8, 0x0F, 0xFF,
  0x7F, 0xF0, 0x3F, 0xFC, 0xFF, 0xF0, 0x7F, 0xF9, 0xFF, 0xE1, 0xFF, 0xE3,
  0xFF, 0xE7, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xFC,
  0x00, 0x0F, 0xF9, 0xFF, 0xF0, 0x00, 0x7F, 0xDF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC7,
  0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F,
  0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFE, 0x07,
  0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x3F,
  0xFE, 0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xF8, 0x00,
  0xFF, 0xE7, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xF8, 0x1C,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x80,
  0x3F, 0xF8, 0x7F, 0xC0, 0x3F, 0xFE, 0x7F, 0xE0, 0x3F, 0xFF, 0xBF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF,
  0x07, 0xFF, 0x87, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF,
  0xE1, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xFC, 0x07,
  0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x81,
  0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0xFF, 0xE0, 0x0F,
  0xFE, 0xFF, 0xE0, 0x01, 0xFE, 0x7F, 0xF0, 0x00, 0x10, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x07, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xF3, 0xFF,
  0x01, 0xFF, 0x7F, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x0F, 0x81, 0xFF, 0xC0, 0x30,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x80, 0x07, 0xFF, 0x0C, 0x00, 0xFF, 0xF0, 0xFC, 0x1F, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x20, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF,
  0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xFC, 0x3F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE0,
  0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF,
  0x07, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F,
  0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x80,
  0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFE,
  0x07, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F,
  0xF0, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0xFF, 0x80, 0x3F, 0xFF, 0x3F, 0xE0, 0x07, 0xFF, 0x8F, 0xF8, 0x00, 0xFF,
  0xC3, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xC7,
  0xFE, 0x01, 0xFF, 0xE3, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0xFF, 0xF0,
  0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x1F, 0xFE,
  0x03, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xE7, 0xFF,
  0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x0F, 0xFD, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xBF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0x9F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xCF, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xC7, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xE3, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xF1, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF,
  0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0xFF, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x7F, 0xFF, 0x8F, 0xFE, 0x07, 0xFE, 0x3F,
  0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0x3F, 0xDF, 0xE7, 0xFF, 0x01, 0xFF, 0x9F,
  0xEF, 0xF3, 0xFF, 0x80, 0xFF, 0xCF, 0xF7, 0xF9, 0xFF, 0x80, 0x7F, 0xEF,
  0xF3, 0xFD, 0xFF, 0xC0, 0x3F, 0xF7, 0xF9, 0xFE, 0xFF, 0xC0, 0x1F, 0xFB,
  0xFC, 0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0xFC, 0x7F, 0x7F, 0xE0, 0x07, 0xFF,
  0xFE, 0x3F, 0xBF, 0xF0, 0x03, 0xFE, 0xFF, 0x1F, 0xDF, 0xF0, 0x01, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x87, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x01, 0xFF, 0xE3,
  0xFF, 0xC0, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x00, 0x3F, 0xF9, 0xFF, 0xC0,
  0x00, 0x1F, 0xFD, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFB, 0xFF,
  0x80, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xE1,
  0xFF, 0xE0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0,
  0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x00, 0x7F,
  0xE7, 0xFF, 0x00, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x43, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x04,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC8, 0x00, 0x1F,
  0xFE, 0x20, 0x00, 0x03, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 21, 46, 18, 0, -45 },
  { 122, 26, 16, 29, 6, -45 },
  { 174, 39, 45, 38, 0, -45 },
  { 394, 32, 52, 34, 2, -48 },
  { 602, 50, 47, 55, 4, -46 },
  { 896, 43, 47, 43, 0, -46 },
  { 1149, 13, 16, 15, 6, -45 },
  { 1175, 24, 56, 21, 2, -46 },
  { 1343, 24, 56, 21, -4, -46 },
  { 1511, 29, 30, 32, 4, -48 },
  { 1620, 30, 31, 35, 3, -38 },
  { 1737, 16, 16, 18, -3, -8 },
  { 1769, 18, 10, 20, 1, -22 },
  { 1792, 12, 12, 18, 0, -11 },
  { 1810, 36, 47, 28, -3, -46 },
  { 2022, 32, 47, 34, 2, -46 },
  { 2210, 27, 45, 34, 5, -45 },
  { 2362, 35, 46, 34, -2, -46 },
  { 2564, 33, 47, 34, 0, -46 },
  { 2758, 34, 45, 34, 0, -45 },
  { 2950, 33, 46, 34, 1, -45 },
  { 3140, 33, 47, 34, 2, -46 },
  { 3334, 36, 45, 34, 1, -45 },
  { 3537, 33, 47, 34, 1, -46 },
  { 3731, 31, 47, 34, 2, -46 },
  { 3914, 18, 36, 18, 0, -35 },
  { 3995, 22, 43, 18, -4, -35 },
  { 4114, 30, 34, 35, 3, -40 },
  { 4242, 30, 22, 35, 3, -33 },
  { 4325, 30, 34, 35, 3, -40 },
  { 4453, 26, 47, 28, 4, -46 },
  { 4606, 49, 51, 52, 2, -46 },
  { 4919, 39, 45, 39, -4, -45 },
  { 5139, 37, 45, 37, 0, -45 },
  { 5348, 36, 47, 36, 3, -46 },
  { 5560, 39, 45, 40, 0, -45 },
  { 5780, 34, 45, 32, 0, -45 },
  { 5972, 34, 45, 32, 0, -45 },
  { 6164, 38, 47, 41, 3, -46 },
  { 6388, 43, 45, 42, 0, -45 },
  { 6630, 32, 45, 26, -2, -45 },
  { 6810, 32, 59, 21, -10, -45 },
  { 7046, 44, 45, 39, 0, -45 },
  { 7294, 27, 45, 30, 0, -45 },
  { 7446, 55, 45, 53, 0, -45 },
  { 7756, 47, 45, 45, 0, -45 },
  { 8021, 38, 47, 43, 3, -46 },
  { 8245, 36, 45, 36, 0, -45 },
  { 8448, 38, 57, 43, 3, -46 },
  { 8719, 36, 45, 38, 0, -45 },
  { 8922, 34, 47, 32, 0, -46 },
  { 9122, 31, 45, 32, 5, -45 },
  { 9297, 39, 46, 41, 3, -45 },
  { 9522, 37, 45, 37, 5, -45 },
  { 9731, 55, 45, 55, 5, -45 },
  { 10041, 47, 45, 38, -4, -45 },
  { 10306, 36, 45, 35, 5, -45 },
  { 10509, 38, 45, 32, -3, -45 },
  { 10723, 27, 57, 21, -2, -46 },
  { 10916, 16, 47, 28, 7, -46 },
  { 11010, 27, 57, 21, -4, -46 },
  { 11203, 33, 30, 32, -1, -45 },
  { 11327, 29, 8, 27, -6, 4 },
  { 11356, 15, 10, 22, 9, -48 },
  { 11375, 33, 36, 35, 2, -35 },
  { 11524, 34, 49, 35, 0, -48 },
  { 11733, 28, 36, 29, 2, -35 },
  { 11859, 36, 49, 35, 2, -48 },
  { 12080, 31, 36, 34, 2, -35 },
  { 12220, 37, 63, 24, -7, -48 },
  { 12512, 35, 50, 35, 0, -35 },
  { 12731, 34, 48, 36, 0, -48 },
  { 12935, 21, 49, 19, 0, -49 },
  { 13064, 29, 64, 19, -8, -49 },
  { 13296, 39, 48, 36, 0, -48 },
  { 13530, 22, 48, 19, 0, -48 },
  { 13662, 51, 35, 54, 0, -35 },
  { 13886, 34, 35, 36, 0, -35 },
  { 14035, 31, 36, 35, 2, -35 },
  { 14175, 37, 50, 35, -3, -35 },
  { 14407, 33, 50, 35, 2, -35 },
  { 14614, 28, 35, 26, 0, -35 },
  { 14737, 28, 36, 29, 1, -35 },
  { 14863, 25, 43, 26, 2, -42 },
  { 14998, 34, 36, 36, 2, -35 },
  { 15151, 33, 35, 32, 3, -35 },
  { 15296, 49, 35, 49, 3, -35 },
  { 15511, 41, 35, 33, -4, -35 },
  { 15691, 40, 50, 32, -4, -35 },
  { 15941, 32, 35, 28, -2, -35 },
  { 16081, 27, 55, 22, 0, -45 },
  { 16267, 8, 62, 32, 12, -48 },
  { 16329, 26, 55, 22, -4, -45 },
  { 16508, 30, 12, 35, 3, -28 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic63pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC63PT7B_H_
