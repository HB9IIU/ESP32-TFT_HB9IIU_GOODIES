#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC24PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x38, 0x78,
  0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF0, 0x7B, 0xDE, 0xF7, 0x39, 0xCE, 0xF7,
  0xB9, 0xE0, 0x03, 0x9C, 0x07, 0x78, 0x1C, 0xE0, 0x39, 0xC3, 0xFF, 0xE7,
  0xFF, 0xCF, 0xFF, 0x87, 0x38, 0x0E, 0xE0, 0x39, 0xC3, 0xFF, 0xF7, 0xFF,
  0xC3, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1D, 0xC0, 0x73, 0x80, 0x01, 0x80,
  0x38, 0x1F, 0xF3, 0xFF, 0x3F, 0xE7, 0xB2, 0x7A, 0x07, 0xE0, 0x3F, 0x01,
  0xFC, 0x07, 0xC0, 0x5E, 0x8D, 0xEC, 0xDC, 0xFF, 0xCF, 0xF8, 0xFF, 0x01,
  0x80, 0x18, 0x00, 0x1F, 0x03, 0x83, 0xF0, 0x70, 0x7F, 0x8F, 0x07, 0x38,
  0xE0, 0x73, 0x9C, 0x0F, 0x7B, 0xC0, 0xF7, 0x38, 0x8F, 0xF7, 0x7E, 0x7E,
  0xFF, 0xE7, 0xCE, 0xEF, 0x01, 0xCE, 0xF0, 0x3D, 0xEE, 0x03, 0x9C, 0xE0,
  0x71, 0xCE, 0x0E, 0x1F, 0xE1, 0xE1, 0xFC, 0x3C, 0x0F, 0x80, 0x07, 0xF0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1E, 0x78, 0x1E, 0x78, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xEF, 0x3F, 0xCF, 0x7F, 0xDF, 0x7B, 0xFE, 0xF9, 0xFC, 0xF9, 0xFC,
  0xF9, 0xF8, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xBE, 0x7B, 0xDC, 0xEF, 0x70,
  0x07, 0x87, 0x83, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0x70, 0x78, 0x3C,
  0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x1E, 0x0F, 0x03,
  0x80, 0x07, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x03,
  0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0E, 0x07, 0x81,
  0xC0, 0xF0, 0x78, 0x3C, 0x00, 0x0F, 0x01, 0xE1, 0xB8, 0x7F, 0x3F, 0xFE,
  0x7F, 0xCF, 0xFB, 0xF8, 0xF7, 0x06, 0xF0, 0x8C, 0x00, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x00, 0x3D, 0xE7, 0x9E, 0xF3, 0x80, 0x7E, 0xFF, 0xF8, 0x77, 0xFF, 0xE0,
  0x00, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x00, 0x0F, 0xC1, 0xFE, 0x3F, 0xE3, 0xDF, 0x7C, 0xF7,
  0x8F, 0xF9, 0xFF, 0x9F, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x3E, 0xF3, 0xCF,
  0xFC, 0xFF, 0x87, 0xF0, 0x3E, 0x00, 0x03, 0xC3, 0xF1, 0xFC, 0xFE, 0xFF,
  0xBD, 0xE6, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0x81,
  0xE0, 0x78, 0x3E, 0x00, 0x07, 0xF0, 0x7F, 0xC7, 0xFE, 0x1F, 0xF0, 0xC7,
  0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x1F, 0xF9, 0xFF, 0xCF, 0xFE, 0xFF, 0xE0, 0x0F, 0xE1, 0xFF, 0x87,
  0xFC, 0x31, 0xF0, 0x0F, 0x00, 0x78, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFF,
  0x00, 0x78, 0x03, 0xE8, 0x1E, 0x73, 0xF3, 0xFF, 0x9F, 0xF8, 0xFF, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0xC3,
  0xBC, 0x3D, 0xE3, 0xCF, 0x1F, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x0F, 0xF8, 0x7F, 0xC7, 0xFE, 0x3F, 0xE1, 0xE0,
  0x0F, 0x00, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0x9F, 0x80, 0x7C, 0x03, 0xE8,
  0x1E, 0x73, 0xF3, 0xFF, 0x9F, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFF, 0x1F,
  0xF3, 0xF0, 0x7C, 0x07, 0x80, 0x7F, 0xCF, 0xFE, 0xFF, 0xEF, 0x9E, 0xF1,
  0xEF, 0x1E, 0xF3, 0xEF, 0xBC, 0xFF, 0xC7, 0xF8, 0x3F, 0x00, 0x1F, 0xFC,
  0x7F, 0xF3, 0xFF, 0xCF, 0xFE, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0x1F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x3C, 0xF1, 0xE7,
  0x8F, 0x78, 0x7F, 0xC1, 0xF8, 0x1F, 0xC1, 0xFF, 0x1F, 0x78, 0xF3, 0xEF,
  0x8F, 0x7C, 0xF1, 0xFF, 0x8F, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xFE, 0x7F,
  0xE7, 0xDE, 0x79, 0xFF, 0x9F, 0xF9, 0xFF, 0xBE, 0xFF, 0xE7, 0xFE, 0x3D,
  0xE0, 0x3C, 0x07, 0xC8, 0xF8, 0xFF, 0x0F, 0xE0, 0xFC, 0x00, 0x1E, 0x7C,
  0xF8, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE3, 0xE7, 0xCF, 0x00, 0x0F, 0x1F,
  0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x78, 0x70,
  0xF0, 0xE0, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xF3, 0xF9, 0xFC, 0x3E, 0x07,
  0xF0, 0x3F, 0xC1, 0xFC, 0x07, 0x80, 0x30, 0x02, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x1C, 0x03,
  0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x78, 0x7F, 0x3F, 0x9F, 0xC3, 0xE0,
  0x70, 0x08, 0x00, 0x3F, 0x8F, 0xF9, 0xFF, 0x99, 0xF0, 0x3C, 0x0F, 0x83,
  0xF0, 0xF8, 0x3E, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x07,
  0xC0, 0x70, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xC1, 0xF8, 0xF8, 0xF0, 0x0F,
  0x38, 0xF9, 0xDC, 0x7F, 0x77, 0x3F, 0xDF, 0x9C, 0xE7, 0xE7, 0x39, 0xFB,
  0xCE, 0x7E, 0xE3, 0x9F, 0xB9, 0xEE, 0xEF, 0xFF, 0x39, 0xFF, 0x8E, 0x00,
  0x01, 0xC0, 0x20, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x1E, 0xF0, 0x7B, 0xC3, 0xCF,
  0x0F, 0x3C, 0x78, 0xF1, 0xFF, 0xCF, 0xFF, 0x3F, 0xFD, 0xFF, 0xF7, 0x83,
  0xFE, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0x9F, 0x1E,
  0x3C, 0x79, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0xFF, 0xC3, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xFF, 0xC7, 0xFF, 0x3F, 0xF8, 0xFF, 0x80, 0x07, 0xF8,
  0x3F, 0xF1, 0xFF, 0x8F, 0xCE, 0x7E, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF7, 0x87, 0xFE,
  0x1F, 0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1,
  0xE3, 0xE3, 0xC7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3C, 0x3E, 0x78, 0x78, 0xF1,
  0xF3, 0xE3, 0xE7, 0xCF, 0x8F, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0x80,
  0x0F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xFF, 0x87,
  0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xE1, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0xF8, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xF8,
  0x7F, 0xF1, 0xF8, 0xC3, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0xFE, 0xF9,
  0xF9, 0xF3, 0xF3, 0xE9, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0xFE, 0x1F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xE0, 0x0F, 0x0F, 0x1F, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3C, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0xF8, 0x78,
  0xF8, 0xF8, 0x0F, 0xF1, 0xFF, 0x0F, 0xE0, 0x78, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x7F,
  0x8F, 0xF8, 0xFF, 0x80, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x27, 0xC1, 0xFE,
  0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0x1F, 0x8F, 0x9F, 0x07, 0xCF, 0x83, 0xCF,
  0x81, 0xEF, 0x80, 0xF7, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xC7, 0x81, 0xE3, 0xE1,
  0xF1, 0xF0, 0xF8, 0xF8, 0x00, 0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07,
  0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0xF7, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xC1, 0xF8, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x3F,
  0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE7, 0xF8, 0xFF, 0x3F, 0x87, 0xFB, 0xFC,
  0x3F, 0xDD, 0xE1, 0xFF, 0xEF, 0x0F, 0xFE, 0xF8, 0xF7, 0xF7, 0x87, 0xBF,
  0x3C, 0x3D, 0xF9, 0xE1, 0xEF, 0xCF, 0x1F, 0x7C, 0xF0, 0xF3, 0xE7, 0x80,
  0x0F, 0x83, 0xC7, 0xE1, 0xE1, 0xFC, 0x78, 0x7F, 0x1E, 0x1F, 0xC7, 0x87,
  0xF1, 0xE3, 0xDE, 0xF0, 0xF7, 0xBC, 0x3D, 0xEF, 0x0F, 0x7B, 0xC3, 0xCF,
  0xF1, 0xE3, 0xF8, 0x78, 0xFE, 0x1E, 0x3F, 0x87, 0x87, 0xE3, 0xC1, 0xF0,
  0xF0, 0x7C, 0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFB, 0xE3, 0xC3,
  0xEF, 0x87, 0xDE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7B, 0xE1, 0xF7,
  0xC3, 0xEF, 0x8F, 0x9F, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x1F, 0x80, 0x0F,
  0xE0, 0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x1E, 0x7C, 0x79, 0xF3, 0xE7, 0xCF,
  0xBE, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x7F, 0xF1, 0xFB,
  0xE3, 0xE3, 0xEF, 0x87, 0xDE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7B,
  0xE1, 0xF7, 0xC3, 0xEF, 0x8F, 0x9F, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x1F,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x7F,
  0xE1, 0xFF, 0xC7, 0xBF, 0x1E, 0x7C, 0x79, 0xF3, 0xE7, 0xCF, 0xFE, 0x3F,
  0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0x78, 0x7D, 0xF1, 0xE7, 0xC7, 0x8F, 0x3E,
  0x3E, 0xF8, 0xF8, 0x07, 0xF0, 0xFF, 0xC7, 0xFC, 0x7C, 0xE3, 0xE0, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC8, 0x3E,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF0, 0x7F, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF,
  0xFE, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x00, 0x1E, 0x3E, 0x7C,
  0x7C, 0xF8, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x8F, 0x9F, 0x1F, 0x3E, 0x3C,
  0x78, 0x78, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0x8F, 0x8F, 0x1F, 0xFE, 0x1F,
  0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0xF0, 0x7F, 0xC1, 0xEF, 0x0F, 0xBC, 0x3C,
  0xF1, 0xF3, 0xC7, 0x8F, 0x3E, 0x3C, 0xF0, 0xF3, 0xC3, 0xDE, 0x0F, 0x78,
  0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0xF0,
  0xF0, 0xFF, 0x87, 0x87, 0xBC, 0x7C, 0x7D, 0xE3, 0xE3, 0xCF, 0x1F, 0x1E,
  0x79, 0xF9, 0xF3, 0xCF, 0xCF, 0x1E, 0xFE, 0x78, 0xF7, 0x77, 0x87, 0xFB,
  0xBC, 0x3F, 0xDF, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7E, 0x3F, 0x03,
  0xF1, 0xF8, 0x1F, 0x8F, 0x80, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x87, 0x8F,
  0x83, 0xE7, 0x80, 0xF7, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xEF, 0x81,
  0xF7, 0xC1, 0xF1, 0xE0, 0xF0, 0xF8, 0xF8, 0x7C, 0x00, 0xF8, 0xFF, 0xE3,
  0xE7, 0x9F, 0x1E, 0x78, 0x7B, 0xE1, 0xEF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x78, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xE0, 0x07,
  0xE0, 0xF8, 0x3F, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3F, 0x0F, 0xC1, 0xF8, 0x00, 0xF0, 0xE1, 0xC3, 0xC7, 0x8F, 0x0E,
  0x1C, 0x38, 0x78, 0xF1, 0xE3, 0xC3, 0x87, 0x0E, 0x1E, 0x07, 0xE0, 0xFC,
  0x3F, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x3F,
  0x07, 0xE1, 0xF8, 0x00, 0x01, 0x80, 0x3C, 0x07, 0xC0, 0x7C, 0x0F, 0xC1,
  0xFE, 0x1C, 0xE3, 0xCE, 0x78, 0xE7, 0x0F, 0xF0, 0x70, 0xFF, 0xFF, 0xF8,
  0xF8, 0xE3, 0xC0, 0x04, 0x01, 0xF7, 0x3F, 0xF7, 0xFF, 0x7D, 0xFF, 0x9E,
  0xF9, 0xEF, 0x1E, 0xF1, 0xEF, 0x3E, 0xFF, 0xCF, 0xFC, 0xFF, 0xC7, 0xBC,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE4, 0x0F, 0xF8, 0xFF, 0xC7,
  0xFF, 0x3E, 0xF9, 0xE7, 0xCF, 0x3E, 0xF1, 0xF7, 0x8F, 0x3C, 0xF9, 0xF7,
  0xCF, 0xFC, 0xFF, 0xC7, 0xBC, 0x00, 0x02, 0x03, 0xFC, 0xFF, 0x3F, 0xE7,
  0xC9, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE4, 0x7F, 0x87, 0xF0,
  0x7E, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x04, 0xF8, 0x7F,
  0xC3, 0xFF, 0x1F, 0xFC, 0x7D, 0xF3, 0xE7, 0x8F, 0x9E, 0x3C, 0x78, 0xF1,
  0xE3, 0xCF, 0x8F, 0xBC, 0x3F, 0xF0, 0xFF, 0xC1, 0xEF, 0x00, 0x01, 0x03,
  0xF8, 0xFF, 0xBF, 0xF7, 0x9F, 0xF3, 0xFF, 0xFF, 0xFE, 0xFF, 0x1E, 0x03,
  0xC2, 0x7F, 0xC7, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0x00, 0x1E, 0x00, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x38, 0x00, 0x02, 0x00, 0x7D, 0xC7, 0xFE, 0x7F, 0xF3, 0xEF, 0xBE,
  0x79, 0xF3, 0xCF, 0x1E, 0x78, 0xF3, 0xCF, 0x9F, 0x78, 0xFF, 0xC7, 0xFE,
  0x1E, 0xF0, 0x0F, 0x90, 0x78, 0xFF, 0xC7, 0xFC, 0x3F, 0xC0, 0xF8, 0x00,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE4, 0x0F, 0xF8, 0xFF, 0xE7,
  0xFF, 0x3E, 0xF9, 0xE7, 0xCF, 0x3E, 0xF9, 0xE7, 0xCF, 0x3C, 0x79, 0xE7,
  0xCF, 0x3E, 0xF9, 0xE7, 0x8F, 0x00, 0x06, 0x0F, 0x1F, 0x0F, 0x00, 0x00,
  0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF8,
  0xF0, 0x00, 0xC0, 0x3C, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x1E,
  0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xF0, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x23, 0xCF, 0x8F,
  0x9E, 0x1F, 0x78, 0x3D, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xFC, 0x1E, 0x78, 0x3C, 0xF0, 0xF9, 0xF1, 0xE3, 0xE0, 0x0F, 0x0F,
  0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x7C, 0x7C, 0x78,
  0x78, 0x78, 0xF8, 0xF0, 0x00, 0x40, 0x81, 0xDF, 0x3E, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x3E, 0xFD, 0xF3, 0xCF, 0x9E, 0x3C, 0xF9, 0xE7, 0xCF, 0x1E,
  0x7C, 0xF1, 0xE7, 0x8F, 0x3E, 0x79, 0xF3, 0xE7, 0x9F, 0x3C, 0xF9, 0xE3,
  0xCF, 0x1E, 0x7C, 0x00, 0x40, 0xEF, 0x8F, 0xFE, 0x7F, 0xF3, 0xEF, 0x9E,
  0x7C, 0xF3, 0xEF, 0x9E, 0x7C, 0xF3, 0xC7, 0x9E, 0x7C, 0xF3, 0xEF, 0x9E,
  0x78, 0xF0, 0x02, 0x01, 0xFC, 0x3F, 0xE7, 0xFE, 0x79, 0xFF, 0x9F, 0xF9,
  0xFF, 0x1E, 0xF1, 0xEF, 0x3E, 0xF3, 0xCF, 0xFC, 0x7F, 0x83, 0xF0, 0x00,
  0x20, 0x3B, 0xE1, 0xFF, 0x87, 0xFF, 0x1F, 0x7C, 0x79, 0xF1, 0xE7, 0xCF,
  0x1F, 0x3C, 0x78, 0xF1, 0xE3, 0xEF, 0x8F, 0xFC, 0x7F, 0xE1, 0xEF, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x04, 0x01,
  0xF7, 0x3F, 0xF7, 0xFF, 0x7D, 0xFF, 0x9E, 0xF9, 0xEF, 0x1E, 0xF1, 0xEF,
  0x3E, 0xFB, 0xCF, 0xFC, 0xFF, 0xC7, 0xBC, 0x07, 0xC0, 0x78, 0x07, 0x80,
  0x78, 0x0F, 0x80, 0xF8, 0x00, 0x43, 0xBC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7C,
  0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x00,
  0x02, 0x03, 0xFC, 0xFF, 0x1F, 0xE3, 0xC4, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFB, 0x1F, 0x7F, 0xCF, 0xF9, 0xFC, 0x00, 0x0E, 0x0F, 0x07, 0x8F,
  0xFF, 0xFF, 0xFD, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0xA7, 0xF3,
  0xF8, 0xFC, 0x3C, 0xFB, 0xE7, 0x9E, 0x3C, 0xF1, 0xE7, 0x9F, 0x3C, 0xFB,
  0xE7, 0x9E, 0x3C, 0xF3, 0xE7, 0xFF, 0x3F, 0xF1, 0xFB, 0x87, 0x9C, 0x00,
  0xF0, 0xFF, 0xCF, 0xBE, 0x78, 0xF7, 0xC7, 0xBC, 0x3D, 0xE1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x00, 0xF1, 0xF3,
  0xFE, 0x7E, 0x7B, 0xCF, 0xDF, 0x79, 0xFB, 0xCF, 0x77, 0x79, 0xEF, 0xDE,
  0x1D, 0xFB, 0xC3, 0xF7, 0x70, 0x7E, 0xFE, 0x0F, 0xDF, 0x81, 0xF3, 0xF0,
  0x3E, 0x7E, 0x07, 0x8F, 0x80, 0x1F, 0x3E, 0x3E, 0xF8, 0x3F, 0xE0, 0x7F,
  0x80, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0,
  0xF7, 0x83, 0xCF, 0x8F, 0x8F, 0x00, 0x3E, 0x3E, 0x7C, 0xF8, 0xF9, 0xE0,
  0xF7, 0xC1, 0xEF, 0x03, 0xDE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x7F, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0x80, 0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0x3E,
  0x03, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x7F, 0xC7, 0xFC,
  0xFF, 0xC0, 0x03, 0xC1, 0xF0, 0xFC, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78,
  0x7E, 0x3F, 0x0F, 0x03, 0xE0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1F,
  0x07, 0xC0, 0xF0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x38, 0x0F, 0xC3, 0xE0, 0x78, 0x7E, 0x1E, 0x0F, 0x03, 0xC0,
  0xF0, 0x38, 0x3E, 0x0F, 0x83, 0xC0, 0xC0, 0x00, 0x38, 0x3F, 0xEF, 0xFF,
  0xEF, 0xF8, 0x3C,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 17, 7, 0, -17 },
  { 18, 10, 6, 11, 2, -17 },
  { 26, 15, 17, 14, 0, -17 },
  { 58, 12, 19, 13, 1, -18 },
  { 87, 20, 17, 21, 1, -17 },
  { 130, 16, 17, 16, 0, -17 },
  { 164, 5, 6, 6, 2, -17 },
  { 168, 9, 22, 8, 1, -18 },
  { 193, 10, 22, 8, -2, -18 },
  { 221, 11, 11, 12, 2, -18 },
  { 237, 11, 11, 13, 1, -14 },
  { 253, 6, 6, 7, -1, -3 },
  { 258, 7, 3, 8, 0, -8 },
  { 261, 5, 4, 7, 0, -4 },
  { 264, 13, 17, 11, -1, -17 },
  { 292, 12, 17, 13, 1, -17 },
  { 318, 10, 17, 13, 2, -17 },
  { 340, 13, 17, 13, -1, -17 },
  { 368, 13, 17, 13, 0, -17 },
  { 396, 13, 17, 13, 0, -17 },
  { 424, 13, 17, 13, 0, -17 },
  { 452, 12, 17, 13, 1, -17 },
  { 478, 14, 17, 13, 0, -17 },
  { 508, 13, 17, 13, 0, -17 },
  { 536, 12, 17, 13, 1, -17 },
  { 562, 7, 13, 7, 0, -13 },
  { 574, 8, 16, 7, -1, -13 },
  { 590, 11, 13, 13, 1, -15 },
  { 608, 11, 9, 13, 1, -13 },
  { 621, 11, 13, 13, 1, -15 },
  { 639, 11, 17, 11, 1, -17 },
  { 663, 18, 19, 20, 1, -17 },
  { 706, 14, 17, 15, -1, -17 },
  { 736, 14, 17, 14, 0, -17 },
  { 766, 14, 17, 14, 1, -17 },
  { 796, 15, 17, 15, 0, -17 },
  { 828, 13, 17, 12, 0, -17 },
  { 856, 13, 17, 12, 0, -17 },
  { 884, 15, 17, 15, 1, -17 },
  { 916, 16, 17, 16, 0, -17 },
  { 950, 12, 17, 10, -1, -17 },
  { 976, 13, 22, 8, -4, -17 },
  { 1012, 17, 17, 15, 0, -17 },
  { 1049, 10, 17, 12, 0, -17 },
  { 1071, 21, 17, 20, 0, -17 },
  { 1116, 18, 17, 17, 0, -17 },
  { 1155, 15, 17, 16, 1, -17 },
  { 1187, 14, 17, 14, 0, -17 },
  { 1217, 15, 21, 16, 1, -17 },
  { 1257, 14, 17, 14, 0, -17 },
  { 1287, 13, 17, 12, 0, -17 },
  { 1315, 12, 17, 12, 2, -17 },
  { 1341, 15, 17, 15, 1, -17 },
  { 1373, 14, 17, 14, 2, -17 },
  { 1403, 21, 17, 21, 2, -17 },
  { 1448, 17, 17, 14, -1, -17 },
  { 1485, 14, 17, 13, 2, -17 },
  { 1515, 15, 17, 12, -1, -17 },
  { 1547, 11, 22, 8, -1, -18 },
  { 1578, 7, 17, 11, 2, -17 },
  { 1593, 11, 22, 8, -2, -18 },
  { 1624, 12, 11, 12, 0, -17 },
  { 1641, 11, 2, 10, -2, 2 },
  { 1644, 6, 3, 8, 3, -18 },
  { 1647, 12, 14, 14, 1, -14 },
  { 1668, 13, 18, 14, 0, -18 },
  { 1698, 11, 14, 11, 1, -14 },
  { 1718, 14, 18, 13, 1, -18 },
  { 1750, 11, 14, 13, 1, -14 },
  { 1770, 15, 24, 9, -3, -18 },
  { 1815, 13, 20, 14, 0, -14 },
  { 1848, 13, 18, 14, 0, -18 },
  { 1878, 8, 19, 7, 0, -19 },
  { 1897, 11, 25, 7, -3, -19 },
  { 1932, 15, 18, 14, 0, -18 },
  { 1966, 8, 18, 7, 0, -18 },
  { 1984, 20, 14, 20, 0, -14 },
  { 2019, 13, 14, 14, 0, -14 },
  { 2042, 12, 14, 13, 1, -14 },
  { 2063, 14, 20, 14, -1, -14 },
  { 2098, 12, 20, 14, 1, -14 },
  { 2128, 11, 14, 10, 0, -14 },
  { 2148, 11, 14, 11, 0, -14 },
  { 2168, 9, 16, 10, 1, -16 },
  { 2186, 13, 13, 14, 1, -13 },
  { 2208, 13, 13, 12, 1, -13 },
  { 2230, 19, 13, 18, 1, -13 },
  { 2261, 15, 13, 13, -1, -13 },
  { 2286, 15, 19, 12, -1, -13 },
  { 2322, 12, 13, 11, -1, -13 },
  { 2342, 10, 21, 9, 0, -17 },
  { 2369, 4, 23, 12, 4, -18 },
  { 2381, 10, 21, 9, -1, -17 },
  { 2408, 11, 5, 13, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC24PT7B_H_
