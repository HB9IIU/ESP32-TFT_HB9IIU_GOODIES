#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC37PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x80, 0x7E, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x07, 0xC0, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0xF8, 0x00, 0x7C,
  0x7C, 0x00, 0xF9, 0xF0, 0x01, 0xE3, 0xE0, 0x07, 0xC7, 0x80, 0x0F, 0x9F,
  0x00, 0x1E, 0x3E, 0x00, 0x7C, 0x7C, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x1F, 0x3E, 0x00, 0x3C, 0x7C, 0x00,
  0xF8, 0xF8, 0x01, 0xF1, 0xE0, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x78, 0xF8, 0x01, 0xF1, 0xE0, 0x03, 0xE7,
  0xC0, 0x07, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x01, 0xFF, 0xE0, 0x7F,
  0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xB0, 0x87, 0xE6,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0x7E, 0x40, 0xEF,
  0xCE, 0x1D, 0xF9, 0xFB, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0x01, 0xFF, 0x00, 0xF8,
  0x0F, 0xFE, 0x07, 0xC0, 0x7F, 0xF8, 0x1F, 0x01, 0xF3, 0xE0, 0xF8, 0x07,
  0xCF, 0x87, 0xC0, 0x3F, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0xF8, 0x03, 0xE3,
  0xE7, 0xC0, 0x0F, 0x9F, 0x1F, 0x00, 0x3E, 0x7C, 0xF9, 0xF8, 0xFF, 0xF7,
  0xCF, 0xFB, 0xFF, 0x9F, 0x7F, 0xE7, 0xFC, 0xFB, 0xFF, 0x8F, 0xE7, 0xCF,
  0x9F, 0x0E, 0x3F, 0x7E, 0x7C, 0x00, 0xF9, 0xF1, 0xF0, 0x07, 0xC7, 0xC7,
  0xC0, 0x3F, 0x1F, 0x3E, 0x00, 0xF8, 0x7C, 0xF8, 0x07, 0xC1, 0xF3, 0xE0,
  0x3F, 0x07, 0xDF, 0x80, 0xF8, 0x1F, 0xFC, 0x07, 0xC0, 0x7F, 0xE0, 0x3E,
  0x00, 0xFF, 0x81, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0x9F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xF0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF3, 0xF8,
  0x7F, 0xF1, 0xFC, 0x7F, 0xF8, 0xFC, 0x7F, 0xFE, 0xFE, 0x7F, 0xFF, 0x7E,
  0x3F, 0xBF, 0xFF, 0x3F, 0x8F, 0xFF, 0x1F, 0xC3, 0xFF, 0x8F, 0xE1, 0xFF,
  0x87, 0xF8, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFE, 0x7F, 0x80, 0x3F, 0x7E, 0x7E, 0x7E,
  0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC,
  0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0,
  0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F,
  0x80, 0x3E, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x0C,
  0x3E, 0x07, 0x9E, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0x87, 0xFF, 0xC7, 0xF9, 0xE7, 0xFE, 0x07, 0xFF, 0x07, 0xF7, 0xC0, 0xF3,
  0xF0, 0x30, 0xF8, 0x08, 0x70, 0x00, 0x20, 0x00, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x1F,
  0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0xC7, 0xE1, 0xF0, 0x7C, 0x3E, 0x00,
  0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFD, 0xFF, 0x80, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xF3, 0xF9, 0xFC, 0x7F, 0x3F, 0x8F,
  0xE7, 0xE1, 0xFD, 0xFC, 0x3F, 0xBF, 0x87, 0xF7, 0xF0, 0xFC, 0xFC, 0x1F,
  0xBF, 0x87, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F, 0xDF, 0xC3, 0xF3, 0xF8, 0xFE,
  0x7F, 0x1F, 0xCF, 0xE7, 0xF1, 0xFC, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0xFE,
  0x03, 0xFE, 0x07, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xFC,
  0x7F, 0xFC, 0x79, 0xFC, 0x31, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x03, 0xC7, 0xF0, 0x38, 0x7F, 0x01, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x7F,
  0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0x83,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFF,
  0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE8, 0x03, 0xFD, 0xE0, 0xFF,
  0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x3E, 0xFC, 0x07, 0xDF, 0xC0, 0xFD, 0xF8, 0x0F, 0x9F, 0x81, 0xF3, 0xF8,
  0x3E, 0x3F, 0x87, 0xE3, 0xF8, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03,
  0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x0C, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC8, 0x03, 0xFC, 0xF0, 0x7F, 0x8F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x80,
  0x3F, 0x7F, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF,
  0xCF, 0xF1, 0xFC, 0xFF, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1,
  0xF8, 0xFE, 0x3F, 0x87, 0xF7, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F,
  0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x10, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0x9F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F,
  0x8F, 0xC3, 0xFB, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xF8, 0x7F, 0x7F, 0x8F, 0xC7, 0xF3, 0xF0,
  0x7E, 0x7E, 0x0F, 0xCF, 0xC3, 0xF9, 0xF8, 0x7F, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0xF8,
  0xFC, 0xFE, 0x3F, 0x7F, 0x0F, 0xDF, 0xC3, 0xF7, 0xF1, 0xFD, 0xFC, 0x7F,
  0x7F, 0x3F, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xDF, 0x83,
  0xE7, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x20, 0x7F, 0x8F, 0xFF,
  0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0x81,
  0xF8, 0x3F, 0x8F, 0xF1, 0xFC, 0x3F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x03, 0xF0, 0x7E, 0x1F, 0xC3, 0xF8,
  0x7F, 0x07, 0xC0, 0x00, 0xE0, 0x1F, 0x80, 0xFE, 0x0F, 0xF0, 0x7F, 0x03,
  0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03,
  0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x03,
  0xC0, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x70,
  0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0xF0, 0xFF,
  0xE3, 0xFF, 0xC3, 0xFF, 0x81, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x30,
  0x00, 0x00, 0x03, 0xE0, 0x1F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFF,
  0x3F, 0xFF, 0x38, 0x7F, 0x20, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xFC,
  0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xC1, 0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x7E,
  0x1E, 0x1F, 0x0F, 0xFC, 0xF9, 0xF0, 0xFF, 0xE7, 0xCF, 0x8F, 0xFF, 0x3E,
  0xF8, 0xF8, 0xF1, 0xF7, 0xCF, 0x87, 0x8F, 0xBC, 0x7C, 0x7C, 0x7D, 0xE3,
  0xC3, 0xE3, 0xFF, 0x3E, 0x1F, 0x1E, 0xF9, 0xF0, 0xF1, 0xF7, 0xCF, 0x8F,
  0x8F, 0x3E, 0x7C, 0x7C, 0xF9, 0xF3, 0xFF, 0xFF, 0x8F, 0x8F, 0xFF, 0xFC,
  0x7C, 0x7F, 0x3F, 0x81, 0xF1, 0xF1, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFC, 0x03, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0xFC, 0xFC, 0x01,
  0xF9, 0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x8F, 0xC0, 0x7E,
  0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xF0, 0x1F,
  0x9F, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFF, 0xFC, 0x01, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x1F, 0x8F, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7E, 0x0F, 0xE3,
  0xF8, 0x3F, 0x9F, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xE3, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC3, 0xFC, 0x7F, 0x3F, 0xE1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0x83, 0x87, 0xF8, 0x08, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x10, 0x7F, 0xCF, 0x83, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xE0,
  0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x1F,
  0xC3, 0xF8, 0x3F, 0x87, 0xE0, 0x7F, 0x0F, 0xC0, 0xFE, 0x3F, 0x83, 0xF8,
  0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0xE1, 0xF8, 0x7F, 0x87, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x04, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF,
  0xF8, 0x1F, 0xFF, 0x81, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x81, 0xFF,
  0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0x07, 0x0F, 0xF0, 0x04, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x02, 0xFE, 0x3F, 0xF3,
  0xF8, 0xFF, 0xCF, 0xE3, 0xFF, 0x3F, 0x8F, 0xFC, 0xFE, 0x7F, 0xF3, 0xF8,
  0x1F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xFE, 0x7F,
  0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F,
  0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x81,
  0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F,
  0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x81,
  0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x03, 0xF8,
  0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x0F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x04, 0xFF, 0x81, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x7F,
  0xC1, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F, 0xF0, 0x1F, 0xC7, 0xF8, 0x07, 0xF3,
  0xFC, 0x01, 0xF8, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xBF, 0xC0, 0x0F,
  0xEF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFC,
  0x7F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01,
  0xFC, 0x3F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE,
  0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE,
  0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE,
  0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE,
  0x1F, 0xFC, 0x0F, 0xFE, 0x3F, 0xFC, 0x0F, 0xBE, 0x3E, 0xFC, 0x1F, 0xBE,
  0x7F, 0xF8, 0x1F, 0xBE, 0x7D, 0xF8, 0x1F, 0xBE, 0x7D, 0xF8, 0x1F, 0xBE,
  0xF9, 0xF8, 0x1F, 0xBE, 0xFB, 0xF8, 0x3F, 0x3F, 0xF3, 0xF0, 0x3F, 0x3F,
  0xF3, 0xF0, 0x3F, 0x3F, 0xE3, 0xF0, 0x3F, 0x3F, 0xE3, 0xF0, 0x7F, 0x3F,
  0xE7, 0xF0, 0x7E, 0x3F, 0xC7, 0xE0, 0x7E, 0x3F, 0xC7, 0xE0, 0x7E, 0x3F,
  0x87, 0xE0, 0x7E, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x0F, 0xC0, 0x03, 0xFC,
  0x07, 0xE0, 0xFF, 0x80, 0xFC, 0x1F, 0xF0, 0x1F, 0x83, 0xFF, 0x07, 0xF0,
  0x7F, 0xE0, 0xFC, 0x0F, 0xFC, 0x1F, 0x83, 0xFF, 0x83, 0xF0, 0x7F, 0xF8,
  0x7E, 0x0F, 0xFF, 0x1F, 0xC1, 0xFF, 0xE3, 0xF0, 0x3E, 0xFC, 0x7E, 0x0F,
  0xCF, 0xCF, 0xC1, 0xF9, 0xF9, 0xF8, 0x3F, 0x3F, 0x7E, 0x07, 0xE7, 0xEF,
  0xC0, 0xFC, 0xFF, 0xF8, 0x3F, 0x0F, 0xFF, 0x07, 0xE1, 0xFF, 0xE0, 0xFC,
  0x3F, 0xF8, 0x1F, 0x87, 0xFF, 0x07, 0xF0, 0x7F, 0xE0, 0xFC, 0x0F, 0xFC,
  0x1F, 0x81, 0xFF, 0x83, 0xF0, 0x3F, 0xE0, 0x7E, 0x03, 0xFC, 0x1F, 0xC0,
  0x7F, 0x80, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFE, 0x3F, 0xCF, 0xF0, 0x7F,
  0x3F, 0x81, 0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03,
  0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0xBF, 0x81, 0xFC, 0xFE, 0x0F, 0xF3,
  0xFE, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xF3, 0xFC, 0x3F, 0x8F, 0xE1,
  0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF1, 0xFE, 0x3F, 0x9F,
  0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F,
  0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFE, 0x3F, 0xCF, 0xF0, 0x7F,
  0x3F, 0x81, 0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03,
  0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0xBF, 0x81, 0xFC, 0xFE, 0x0F, 0xF3,
  0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0,
  0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xF1,
  0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3,
  0xF1, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xE7, 0xF0, 0x7E,
  0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC,
  0x7E, 0x0F, 0xF7, 0xF0, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xE1, 0xC1,
  0xFC, 0x04, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0x88, 0x03, 0xF8, 0x60, 0x7F, 0x07, 0xCF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x3F,
  0xF0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0x81, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F,
  0xE1, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC,
  0x3F, 0x83, 0xF8, 0x7E, 0x07, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87,
  0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0x81, 0xF8, 0x7F, 0x07, 0xF0, 0xFE,
  0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xF7,
  0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xEF, 0xE0, 0x7F,
  0x3F, 0x81, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF8, 0xFE, 0x07, 0xE3, 0xF0, 0x1F, 0x9F,
  0xC0, 0x7E, 0x7E, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7E,
  0xFC, 0x0F, 0xE0, 0xFE, 0xFC, 0x0F, 0xE0, 0xFE, 0xFC, 0x1F, 0xE0, 0xFC,
  0xFC, 0x1F, 0xE1, 0xFC, 0xFC, 0x3F, 0xE1, 0xF8, 0xFC, 0x3F, 0xE3, 0xF8,
  0xFC, 0x3F, 0xE3, 0xF8, 0xFC, 0x7F, 0xE3, 0xF0, 0xFC, 0x7F, 0xE7, 0xF0,
  0xFC, 0xFB, 0xE7, 0xE0, 0xFC, 0xFB, 0xE7, 0xE0, 0xFD, 0xFB, 0xEF, 0xE0,
  0xFD, 0xF3, 0xEF, 0xC0, 0xFD, 0xF3, 0xFF, 0xC0, 0xFF, 0xF3, 0xFF, 0x80,
  0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xC7, 0xFF, 0x00,
  0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0x87, 0xFE, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE,
  0x3F, 0x80, 0x1F, 0xCF, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x7F, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x3F,
  0x87, 0xF0, 0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xFC,
  0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xFB, 0xF0, 0x7F, 0x9F, 0xC3, 0xF8,
  0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x9F, 0xC0, 0xFC, 0xFE, 0x07, 0xEF,
  0xE0, 0x3F, 0x7E, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xF8, 0x7C,
  0x3F, 0x1F, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7E, 0x3F, 0x1F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7E, 0x3F, 0x1F, 0x87, 0xC3, 0xE1, 0xF0, 0xFC, 0x7E,
  0x3F, 0x1F, 0x87, 0xC3, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07,
  0xCF, 0x81, 0xF9, 0xF0, 0x3E, 0x3E, 0x0F, 0xC7, 0xC1, 0xF0, 0x7C, 0x7C,
  0x0F, 0x9F, 0x81, 0xF3, 0xE0, 0x3E, 0xF8, 0x03, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x8F, 0xC3, 0xE0,
  0xF8, 0x7C, 0x01, 0xE0, 0x00, 0x7F, 0x3F, 0x0F, 0xFB, 0xE1, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0x9F, 0xE7, 0xF0, 0xFC, 0x7F, 0x0F,
  0xC7, 0xF0, 0xFC, 0x7E, 0x1F, 0xCF, 0xE1, 0xF8, 0xFE, 0x1F, 0x8F, 0xE1,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE7, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x03, 0xFB, 0xF0, 0x1F, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x70, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xF1, 0xF8, 0x7F, 0x1F,
  0x87, 0xF3, 0xF8, 0x7E, 0x3F, 0x0F, 0xE3, 0xF0, 0xFE, 0x3F, 0x0F, 0xE7,
  0xF1, 0xFC, 0x7F, 0xBF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0,
  0xFD, 0xFE, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xE1,
  0xFF, 0xE1, 0xFF, 0xF1, 0xFF, 0xF0, 0xFE, 0x08, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x11, 0xFE, 0x38, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x80,
  0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x3C, 0xFE, 0x07,
  0xF7, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xCF, 0xF1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF0,
  0xFE, 0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x7F, 0x1F, 0xC3,
  0xF9, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xEF,
  0xC0, 0x3E, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFF, 0x1F, 0xFF, 0xCF, 0xE3, 0xF3, 0xF0, 0xFD, 0xFC, 0x3F, 0x7F, 0x3F,
  0xDF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x08, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0xCF, 0xC1, 0xFF, 0x7C, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x7F, 0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x87, 0xE1, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x87, 0xE1, 0xFC,
  0x7F, 0x0F, 0xE7, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x10, 0x0F,
  0xE0, 0xF0, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x78, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7F, 0x1F, 0x87, 0xE3,
  0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xE7, 0xF0, 0xFC,
  0x7F, 0x0F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0xC7, 0xE1, 0xFC, 0xFE, 0x1F,
  0x8F, 0xE3, 0xF8, 0x00, 0xE0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x3E,
  0x00, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x00, 0x00,
  0x07, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x01,
  0x0F, 0xE1, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F, 0x1F, 0xC0, 0x7E, 0x7F, 0x81,
  0xFC, 0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x0F, 0xF7, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7E, 0x1F,
  0xC0, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x00, 0x03, 0xF8,
  0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0,
  0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x07, 0x80, 0xE0,
  0x3F, 0x7F, 0x8F, 0xE0, 0xFF, 0xFE, 0xFF, 0xC3, 0xEF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFE, 0x7F, 0x9F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0x87, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xF3, 0xF8, 0x7E,
  0x1F, 0xCF, 0xE3, 0xF8, 0x7E, 0x3F, 0x8F, 0xE1, 0xF8, 0xFC, 0x3F, 0x8F,
  0xE7, 0xF0, 0xFC, 0x3F, 0x9F, 0xC3, 0xF0, 0xFE, 0x7F, 0x1F, 0xC3, 0xF1,
  0xF8, 0x7F, 0x1F, 0xC7, 0xE1, 0xFC, 0x7F, 0x3F, 0x87, 0xE1, 0xFC, 0xFE,
  0x3F, 0x87, 0xE0, 0x00, 0x07, 0x80, 0xFD, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0x87, 0xF1, 0xF8, 0x7E, 0x3F, 0x87, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF0, 0xFE, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xFC,
  0x7E, 0x1F, 0xCF, 0xE1, 0xF8, 0xFE, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x7F,
  0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xBF, 0x8F, 0xE3,
  0xF3, 0xF8, 0x7F, 0x7F, 0x0F, 0xEF, 0xE1, 0xFB, 0xF8, 0x3F, 0x7F, 0x0F,
  0xEF, 0xE1, 0xFD, 0xFC, 0x3F, 0xBF, 0x8F, 0xE7, 0xF1, 0xFC, 0x7F, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xC0, 0x0F, 0xDF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xE1, 0xFC, 0x1F,
  0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0xFE, 0x0F, 0xC3, 0xF8, 0x3F, 0x0F,
  0xE1, 0xFC, 0x7F, 0x07, 0xF9, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xBF, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x7F, 0x3F, 0x0F, 0xFB, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x3F, 0x8F, 0xE7, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7E, 0x1F,
  0xCF, 0xE1, 0xF8, 0xFE, 0x1F, 0x8F, 0xE1, 0xF8, 0xFE, 0x3F, 0x8F, 0xE7,
  0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x1F,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0x87, 0xEF, 0x83, 0xFF, 0xC1, 0xF7, 0xE0, 0xFF, 0xF0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x03,
  0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xF1, 0xFC, 0x30, 0xFE, 0x08,
  0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x03, 0xF9, 0x81, 0xFC, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F,
  0xFE, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x03, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xFD, 0xFF,
  0xF8, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x87, 0xFF, 0x0F, 0xFE, 0x1F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x1F, 0xC7, 0xF1, 0xF8, 0x7F, 0x1F, 0x87,
  0xF3, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xE3, 0xF0,
  0xFC, 0x7F, 0x0F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xFC, 0x7E,
  0x1F, 0x8F, 0xE3, 0xF8, 0xFE, 0x7F, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x87,
  0xFD, 0xF0, 0x7F, 0xDF, 0x03, 0xF9, 0xF0, 0xFC, 0x0F, 0xFF, 0x83, 0xFB,
  0xF0, 0x7F, 0x7F, 0x1F, 0xCF, 0xE3, 0xF9, 0xFC, 0xFE, 0x1F, 0x9F, 0x83,
  0xF3, 0xF0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0xC3, 0xFF, 0xE1,
  0xFE, 0x3F, 0xBF, 0x1F, 0xF1, 0xF9, 0xF8, 0xFF, 0x9F, 0xCF, 0xC7, 0xF8,
  0xFC, 0x7E, 0x7F, 0xC7, 0xE3, 0xF3, 0xFE, 0x7E, 0x1F, 0x9E, 0xF3, 0xF0,
  0xFD, 0xF7, 0xBF, 0x87, 0xEF, 0xBD, 0xF8, 0x3F, 0x7B, 0xEF, 0xC1, 0xFF,
  0xDF, 0xFC, 0x0F, 0xFC, 0xFF, 0xE0, 0x7F, 0xE7, 0xFE, 0x03, 0xFF, 0x3F,
  0xF0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFC, 0x7F, 0x80,
  0x1F, 0xC3, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF1, 0xFF, 0x07,
  0xF1, 0xFC, 0x03, 0xF3, 0xF8, 0x03, 0xFB, 0xF8, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xDF, 0xC0, 0x1F, 0xDF, 0xC0, 0x3F,
  0x8F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC,
  0xFE, 0x01, 0xF9, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x43, 0xFF, 0xF0, 0x7F, 0xFE,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0xC0,
  0x7F, 0x80, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0x01, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0x18,
  0x00, 0xBF, 0xC0, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFE,
  0x03, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 12, 26, 11, 0, -26 },
  { 40, 16, 9, 17, 3, -26 },
  { 58, 23, 26, 22, 0, -26 },
  { 133, 19, 30, 20, 1, -28 },
  { 205, 30, 27, 33, 2, -27 },
  { 307, 25, 27, 25, 0, -27 },
  { 392, 8, 9, 9, 3, -26 },
  { 401, 14, 33, 13, 1, -27 },
  { 459, 15, 33, 13, -3, -27 },
  { 521, 17, 18, 19, 3, -28 },
  { 560, 17, 18, 21, 2, -22 },
  { 599, 10, 10, 11, -2, -5 },
  { 612, 11, 6, 12, 0, -13 },
  { 621, 7, 7, 11, 0, -7 },
  { 628, 21, 27, 16, -2, -27 },
  { 699, 19, 27, 20, 1, -27 },
  { 764, 16, 26, 20, 3, -26 },
  { 816, 20, 27, 20, -1, -27 },
  { 884, 19, 27, 20, 0, -27 },
  { 949, 20, 26, 20, 0, -26 },
  { 1014, 20, 26, 20, 0, -26 },
  { 1079, 20, 27, 20, 1, -27 },
  { 1147, 21, 26, 20, 1, -26 },
  { 1216, 19, 27, 20, 1, -27 },
  { 1281, 18, 27, 20, 1, -27 },
  { 1342, 11, 21, 11, 0, -21 },
  { 1371, 13, 26, 11, -2, -21 },
  { 1414, 17, 19, 21, 2, -23 },
  { 1455, 17, 14, 21, 2, -20 },
  { 1485, 17, 19, 21, 2, -23 },
  { 1526, 16, 27, 17, 2, -27 },
  { 1580, 29, 30, 31, 1, -27 },
  { 1689, 23, 26, 23, -2, -26 },
  { 1764, 22, 26, 22, 0, -26 },
  { 1836, 21, 27, 21, 2, -27 },
  { 1907, 23, 26, 23, 0, -26 },
  { 1982, 20, 26, 19, 0, -26 },
  { 2047, 20, 26, 19, 0, -26 },
  { 2112, 22, 27, 24, 2, -27 },
  { 2187, 25, 26, 24, 0, -26 },
  { 2269, 18, 26, 15, -1, -26 },
  { 2328, 19, 34, 12, -6, -26 },
  { 2409, 26, 26, 23, 0, -26 },
  { 2494, 16, 26, 18, 0, -26 },
  { 2546, 32, 26, 31, 0, -26 },
  { 2650, 27, 26, 27, 0, -26 },
  { 2738, 22, 27, 25, 2, -27 },
  { 2813, 21, 26, 21, 0, -26 },
  { 2882, 22, 33, 25, 2, -27 },
  { 2973, 21, 26, 22, 0, -26 },
  { 3042, 20, 27, 19, 0, -27 },
  { 3110, 18, 26, 19, 3, -26 },
  { 3169, 23, 26, 24, 2, -26 },
  { 3244, 22, 26, 22, 3, -26 },
  { 3316, 32, 26, 32, 3, -26 },
  { 3420, 27, 26, 22, -2, -26 },
  { 3508, 21, 26, 21, 3, -26 },
  { 3577, 23, 26, 19, -2, -26 },
  { 3652, 16, 33, 12, -1, -27 },
  { 3718, 9, 27, 16, 4, -27 },
  { 3749, 17, 33, 12, -3, -27 },
  { 3820, 19, 17, 19, 0, -26 },
  { 3861, 16, 5, 16, -3, 2 },
  { 3871, 9, 6, 13, 5, -28 },
  { 3878, 20, 21, 21, 1, -21 },
  { 3931, 20, 28, 21, 0, -28 },
  { 4001, 17, 21, 17, 1, -21 },
  { 4046, 21, 28, 21, 1, -28 },
  { 4120, 18, 21, 20, 1, -21 },
  { 4168, 22, 37, 14, -4, -28 },
  { 4270, 21, 30, 21, 0, -21 },
  { 4349, 20, 28, 21, 0, -28 },
  { 4419, 12, 29, 11, 0, -29 },
  { 4463, 18, 38, 11, -5, -29 },
  { 4549, 23, 28, 21, 0, -28 },
  { 4630, 13, 28, 11, 0, -28 },
  { 4676, 30, 21, 32, 0, -21 },
  { 4755, 20, 21, 21, 0, -21 },
  { 4808, 19, 21, 21, 1, -21 },
  { 4858, 22, 30, 21, -2, -21 },
  { 4941, 20, 30, 21, 1, -21 },
  { 5016, 17, 21, 15, 0, -21 },
  { 5061, 17, 21, 17, 0, -21 },
  { 5106, 15, 25, 15, 1, -25 },
  { 5153, 20, 20, 21, 1, -20 },
  { 5203, 19, 20, 19, 2, -20 },
  { 5251, 29, 20, 28, 2, -20 },
  { 5324, 24, 20, 20, -2, -20 },
  { 5384, 23, 29, 19, -2, -20 },
  { 5468, 19, 20, 17, -1, -20 },
  { 5516, 16, 32, 13, 0, -26 },
  { 5580, 5, 36, 19, 7, -28 },
  { 5603, 15, 32, 13, -2, -26 },
  { 5663, 17, 7, 21, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC37PT7B_H_
