#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC39PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x01, 0xF8, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x80, 0xF8, 0x00, 0x7E,
  0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0xFE, 0x7E, 0xFC, 0x7E, 0xFC, 0xFC, 0xFC,
  0xFC, 0xF8, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x03, 0xE3, 0xE0, 0x03, 0xE3,
  0xE0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x0F, 0x8F,
  0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x1F, 0xDB, 0xE1, 0xFB, 0x84, 0x1F, 0xB8, 0x01, 0xFB,
  0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xEF, 0xCC,
  0x0C, 0xFC, 0xF0, 0xDF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0xF0, 0x07, 0xC0, 0x7F,
  0xE0, 0x1F, 0x01, 0xFF, 0xE0, 0x7E, 0x03, 0xFF, 0xC0, 0xF8, 0x0F, 0xCF,
  0x83, 0xE0, 0x1F, 0x1F, 0x0F, 0xC0, 0x3E, 0x3E, 0x1F, 0x00, 0xFC, 0xFC,
  0x7C, 0x01, 0xF1, 0xF9, 0xF8, 0x03, 0xE3, 0xE3, 0xE0, 0x07, 0xC7, 0xCF,
  0x8F, 0xCF, 0xDF, 0xBE, 0x7F, 0xDF, 0xFE, 0xFD, 0xFF, 0xDF, 0xF9, 0xF3,
  0xFF, 0xBF, 0xE7, 0xCF, 0xDF, 0x1F, 0x9F, 0x9F, 0x3E, 0x00, 0x3E, 0x7E,
  0x7C, 0x00, 0xF8, 0xF8, 0xF8, 0x03, 0xF1, 0xF1, 0xF0, 0x07, 0xC3, 0xE3,
  0xE0, 0x1F, 0x07, 0xCF, 0xC0, 0x7E, 0x0F, 0x9F, 0x80, 0xF8, 0x1F, 0x7E,
  0x03, 0xE0, 0x3F, 0xFC, 0x0F, 0xC0, 0x7F, 0xF0, 0x1F, 0x00, 0x7F, 0xC0,
  0x7C, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xE3, 0xF0,
  0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0xFE,
  0x0F, 0xFE, 0x3F, 0x87, 0xFF, 0xC7, 0xF1, 0xFF, 0xF9, 0xFC, 0x7F, 0xFF,
  0xBF, 0x8F, 0xE7, 0xFF, 0xE3, 0xFC, 0xFF, 0xFC, 0x7F, 0x0F, 0xFF, 0x0F,
  0xE0, 0xFF, 0xE1, 0xFE, 0x1F, 0xF8, 0x3F, 0xE7, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x07,
  0xFE, 0x7F, 0x80, 0x7E, 0xFD, 0xFF, 0xFF, 0xDF, 0xBF, 0x7C, 0xF9, 0xF0,
  0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0x00, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0x81, 0x07, 0xE0, 0x71, 0xF0, 0x1F,
  0x7C, 0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F,
  0xFC, 0x3F, 0xDF, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0xC0, 0xF9, 0xF0,
  0x1C, 0x7E, 0x03, 0x1F, 0x00, 0x02, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xC7, 0xF1, 0xF8, 0xFE, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8,
  0x7C, 0x3F, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xE7, 0xFE, 0x7F, 0xEF, 0xFE,
  0x1C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x3F, 0x87, 0xF3, 0xF8,
  0x7F, 0x3F, 0x87, 0xF7, 0xF0, 0x7F, 0x7F, 0x0F, 0xF7, 0xF0, 0xFE, 0x7F,
  0x0F, 0xEF, 0xF0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE1, 0xFE, 0xFE, 0x1F, 0xCF,
  0xE1, 0xFC, 0xFE, 0x3F, 0xCF, 0xE3, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF0,
  0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0x7F, 0x0F, 0x3F, 0x86, 0x3F, 0x82,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFC, 0x0F, 0x0F, 0xE0, 0x30, 0x7F, 0x01, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x03, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x03,
  0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xEC, 0x03, 0xFE, 0xFC, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xDF, 0xC0, 0x7C, 0xFC, 0x07, 0xEF, 0xE0, 0x7E,
  0x7F, 0x07, 0xE3, 0xF8, 0x3E, 0x1F, 0xC3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x81, 0xEF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x60, 0x1F, 0xE3, 0xF7, 0xFF,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x20, 0x0F, 0xCF, 0xE0, 0x7E, 0xFF, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xF3, 0xFC, 0xFF, 0x0F, 0xE7, 0xF8,
  0x7F, 0x3F, 0xC7, 0xF9, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x8F, 0xE1,
  0xFC, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF1, 0xFE, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xFC, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF8, 0x3F, 0xFF, 0x87, 0xF3, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0xFC,
  0x1F, 0xCF, 0xC1, 0xFC, 0xFE, 0x3F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x87,
  0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xCF,
  0xE3, 0xF8, 0x7E, 0x7F, 0x87, 0xE7, 0xF0, 0xFF, 0x7F, 0x0F, 0xE7, 0xF0,
  0xFE, 0x7F, 0x9F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F,
  0xEF, 0xC1, 0xFC, 0xFC, 0x07, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0xC3, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x7E, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE0, 0xF8, 0x00,
  0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x80,
  0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0x80, 0x7F,
  0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03,
  0xF0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xC0,
  0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF0,
  0x03, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x8F, 0xFF, 0x8F, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x02, 0x00, 0x00, 0x07, 0xF8,
  0x0F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF, 0xFC, 0xE0,
  0xFE, 0x40, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x3F, 0x07, 0xC0, 0xFC, 0x3E, 0x1F, 0x0F, 0xFE, 0x7C, 0x7E, 0x3F, 0xFC,
  0x78, 0xF8, 0xFF, 0xF8, 0xF1, 0xE1, 0xF9, 0xF1, 0xF7, 0xC7, 0xC3, 0xE3,
  0xCF, 0x8F, 0x8F, 0x87, 0x9E, 0x3E, 0x1F, 0x0F, 0x3C, 0x7C, 0x3E, 0x3E,
  0xF8, 0xF8, 0x7C, 0x7D, 0xF1, 0xF1, 0xF0, 0xF3, 0xE3, 0xE3, 0xE3, 0xE7,
  0xC7, 0xCF, 0xCF, 0x8F, 0x8F, 0xFF, 0xFE, 0x1F, 0x1F, 0xFF, 0xFC, 0x1F,
  0x1F, 0xCF, 0xE0, 0x3E, 0x1E, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x08, 0x00, 0xFE, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x7E, 0x01,
  0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x07,
  0xF0, 0x7E, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0x80, 0x7F, 0x7F,
  0x80, 0x7F, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFC, 0x7F, 0x83, 0xF8, 0xFF, 0x0F, 0xF1,
  0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x8F, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xCF, 0xF0,
  0x3F, 0x8F, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x87,
  0xF1, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC1, 0xFF, 0x07, 0x0F, 0xF0, 0x04, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x06, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF1, 0xFE, 0x07, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x83,
  0xFC, 0x3F, 0x87, 0xFC, 0x3F, 0x8F, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x08, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFC,
  0x06, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF1, 0xFF, 0xDF, 0xE3, 0xFF, 0x3F, 0x8F, 0xFE,
  0x7F, 0x1F, 0xFC, 0xFE, 0x3F, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x1F, 0xC7,
  0xF0, 0x3F, 0x8F, 0xF0, 0x7F, 0x1F, 0xE0, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xF0, 0x3F,
  0x83, 0xF8, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x07, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x87, 0xF8, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x07, 0xF8, 0x0F, 0xE1, 0xFE, 0x03,
  0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x0F, 0xE3, 0xFC, 0x01, 0xFC, 0xFF,
  0x00, 0x3F, 0x9F, 0xE0, 0x0F, 0xF7, 0xF8, 0x01, 0xFD, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00,
  0x7F, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07,
  0xF8, 0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x00,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFF,
  0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF,
  0x0F, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xF1, 0xFF, 0xF0, 0x3F,
  0xFC, 0x7D, 0xF8, 0x0F, 0xFF, 0x1F, 0x7E, 0x07, 0xFF, 0xCF, 0xFF, 0x81,
  0xFF, 0xF3, 0xEF, 0xE0, 0x7E, 0xFD, 0xFB, 0xF8, 0x1F, 0xBF, 0x7C, 0xFC,
  0x07, 0xE7, 0xFF, 0x7F, 0x03, 0xF9, 0xFF, 0x9F, 0xC0, 0xFE, 0x7F, 0xE7,
  0xF0, 0x3F, 0x1F, 0xF1, 0xF8, 0x0F, 0xC7, 0xFC, 0x7E, 0x07, 0xF1, 0xFE,
  0x3F, 0x81, 0xFC, 0x7F, 0x8F, 0xE0, 0x7F, 0x1F, 0xE3, 0xF8, 0x1F, 0x87,
  0xF0, 0xFC, 0x07, 0xE1, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x1F, 0xC0, 0x03,
  0xFC, 0x03, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0xFF, 0x80, 0xFC, 0x0F, 0xFC,
  0x07, 0xE0, 0x7F, 0xE0, 0x7F, 0x03, 0xFF, 0x83, 0xF8, 0x1F, 0xFC, 0x1F,
  0xC0, 0xFF, 0xE0, 0xFC, 0x0F, 0xFF, 0x07, 0xE0, 0x7F, 0xFC, 0x7F, 0x03,
  0xF7, 0xE3, 0xF8, 0x1F, 0xBF, 0x1F, 0x80, 0xFD, 0xFC, 0xFC, 0x0F, 0xEF,
  0xE7, 0xE0, 0x7F, 0x3F, 0x7F, 0x03, 0xF1, 0xFB, 0xF8, 0x1F, 0x8F, 0xFF,
  0x80, 0xFC, 0x7F, 0xFC, 0x0F, 0xE1, 0xFF, 0xE0, 0x7F, 0x0F, 0xFF, 0x03,
  0xF0, 0x7F, 0xF8, 0x1F, 0x83, 0xFF, 0x81, 0xFC, 0x1F, 0xFC, 0x0F, 0xE0,
  0x7F, 0xE0, 0x7F, 0x03, 0xFF, 0x03, 0xF0, 0x1F, 0xF8, 0x1F, 0x80, 0xFF,
  0x81, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F,
  0xE1, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFF, 0x7F, 0x80, 0xFF, 0x7F,
  0x80, 0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFC, 0xFE,
  0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0x3F,
  0xC1, 0xFC, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0xFF, 0x0F, 0xE7, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0,
  0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01,
  0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x07,
  0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFF, 0x0F, 0xF1, 0xFC, 0x1F, 0xC3, 0xF8,
  0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFE,
  0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xE3,
  0xF8, 0x3F, 0x87, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F,
  0xE7, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0x83, 0x81, 0xFC,
  0x04, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x84, 0x03, 0xF8, 0x38,
  0x1F, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0x81, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xC1,
  0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x83,
  0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x07,
  0xF8, 0x7F, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xF7, 0xF0, 0x1F,
  0xCF, 0xE0, 0x7F, 0x9F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x07, 0xF0,
  0x7E, 0x0F, 0xE0, 0xFC, 0x3F, 0x81, 0xF8, 0x7F, 0x03, 0xF1, 0xFC, 0x07,
  0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x9F, 0xC0, 0x3F, 0x3F, 0x80, 0x7E,
  0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x03,
  0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0x03, 0xFB, 0xF8,
  0x1F, 0xC0, 0xFE, 0xFE, 0x0F, 0xF0, 0x7F, 0x3F, 0x83, 0xFC, 0x1F, 0xCF,
  0xE1, 0xFF, 0x07, 0xF3, 0xF8, 0x7F, 0xC3, 0xF8, 0xFE, 0x1F, 0xF0, 0xFE,
  0x3F, 0x8F, 0xFC, 0x7F, 0x0F, 0xE3, 0xFF, 0x1F, 0xC3, 0xF9, 0xFF, 0xC7,
  0xE0, 0xFE, 0x7D, 0xF3, 0xF8, 0x3F, 0x9F, 0x7C, 0xFE, 0x0F, 0xEF, 0xFF,
  0x3F, 0x03, 0xF3, 0xEF, 0xDF, 0xC0, 0xFD, 0xFB, 0xF7, 0xE0, 0x3F, 0x7E,
  0xFD, 0xF8, 0x0F, 0xDF, 0x3F, 0xFE, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0xFF,
  0xE3, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xF8, 0x03,
  0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x01,
  0xFE, 0x3F, 0x80, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFB, 0xF8, 0x00, 0xFF,
  0x3F, 0x80, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC1, 0xFC,
  0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF,
  0x03, 0xFD, 0xFC, 0x0F, 0xE7, 0xF0, 0x7F, 0x9F, 0xC1, 0xFC, 0x7F, 0x0F,
  0xE1, 0xFC, 0x7F, 0x83, 0xF9, 0xFC, 0x0F, 0xEF, 0xF0, 0x3F, 0xBF, 0x80,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0xFC, 0x3F, 0x0F,
  0xC1, 0xF0, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x7E, 0xF8, 0x07, 0xCF, 0xC0, 0xFC, 0x7C, 0x0F, 0x87, 0xC1, 0xF8, 0x7C,
  0x3F, 0x07, 0xE3, 0xE0, 0x3E, 0x7E, 0x03, 0xEF, 0xC0, 0x3F, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x7F, 0x1F, 0xC7, 0xE3,
  0xF0, 0xFC, 0x01, 0xF1, 0xF8, 0x3F, 0xCF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0x3F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x8F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF9, 0xFE, 0x1F, 0xCF, 0xE0, 0xFC,
  0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC7, 0xF8, 0xFF, 0x3F, 0x87, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFD, 0xF8, 0x0F, 0xCF, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE7, 0x80,
  0x7F, 0x7F, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x7F, 0x9F, 0xE3, 0xF8, 0xFF, 0x1F, 0xC3, 0xF8, 0xFC, 0x1F, 0xC7,
  0xE1, 0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x3F,
  0xCF, 0xF1, 0xFC, 0x7F, 0x9F, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xDF, 0xF0, 0x7E, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFC, 0x11, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x10, 0xFF, 0xBC, 0x1F, 0xFF, 0x07,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x01, 0xE3, 0xF8, 0x0F,
  0xF7, 0xF0, 0x3F, 0xEF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x8F, 0xE0, 0xFE, 0x1F,
  0xC1, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0xFC, 0x1F, 0xC3, 0xF8,
  0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0xE0, 0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFD, 0xF8, 0x03, 0xF3, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF1, 0xFF, 0xFE,
  0x7F, 0x9F, 0xCF, 0xE1, 0xF9, 0xFC, 0x7F, 0x7F, 0x1F, 0xEF, 0xFF, 0xF9,
  0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0x80, 0x07,
  0xF0, 0x08, 0xFF, 0x03, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81,
  0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x01, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0xFC, 0x0F, 0xF3, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE1, 0xFE, 0x7F, 0x87, 0xF1, 0xFC, 0x3F, 0xC7, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x07, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC7, 0xF8, 0x7F, 0xBF, 0xC1, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3E, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x80, 0x3F, 0x83, 0x83, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE7, 0xC0,
  0x7F, 0x7F, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x7F, 0x8F, 0xE3, 0xFC, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7,
  0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F,
  0xCF, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE,
  0x1F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE0, 0x01, 0xF0, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x27, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x0F, 0xE3, 0xFC,
  0x0F, 0xE7, 0xF8, 0x0F, 0xEF, 0xF0, 0x1F, 0xCF, 0xE0, 0x1F, 0xDF, 0xC0,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7F, 0xBF, 0xC0,
  0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xE0, 0x7F, 0x0F, 0xE0,
  0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xC7, 0xC0, 0xF8, 0x0F,
  0xCF, 0xF1, 0xFE, 0x0F, 0xDF, 0xF3, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x1F,
  0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F,
  0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x3F,
  0x87, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F,
  0x0F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F,
  0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x07,
  0xC7, 0xC0, 0x7E, 0x7F, 0x03, 0xF7, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x7F, 0x8F, 0xE3, 0xFC, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE,
  0x1F, 0xC7, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8,
  0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3,
  0xF8, 0xFE, 0x1F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF8, 0x7F, 0x7F, 0x0F, 0xF7, 0xF0, 0xFF, 0x7F, 0x0F,
  0xEF, 0xF0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x1F, 0xCF, 0xE1,
  0xFC, 0xFF, 0x3F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0xFF, 0x00, 0x01, 0xF1, 0xE0, 0x07, 0xEF, 0xF0, 0x0F, 0xDF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFE, 0x7F,
  0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x87, 0xF8,
  0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0xFF, 0x0F,
  0xF1, 0xFC, 0x1F, 0xF7, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFB, 0xFC, 0x07, 0xF3, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF1,
  0xF8, 0x3F, 0xCF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0xFF, 0x3F, 0xC7, 0xF1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F,
  0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xCF, 0xE0, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8,
  0x7F, 0x1F, 0xC7, 0xF8, 0xFF, 0x7F, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xDF, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xC7, 0xC3, 0xF3,
  0xE0, 0xFD, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xF1, 0xC3,
  0xFC, 0x10, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF2, 0x03, 0xFC, 0xE0, 0xFE,
  0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xF8, 0x00,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xFF, 0x1F, 0xFF,
  0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0xB0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE,
  0x3F, 0x87, 0xF1, 0xFC, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0,
  0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7,
  0xF0, 0xFE, 0x3F, 0x8F, 0xF1, 0xFC, 0x7F, 0x1F, 0xE7, 0xF8, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFD, 0xF8, 0x0F,
  0xCF, 0xC0, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xEF, 0xE1, 0xFE,
  0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0x7E, 0x3F, 0x87, 0xE3, 0xF8, 0x7E, 0x7F,
  0x07, 0xE7, 0xF0, 0x7E, 0xFE, 0x07, 0xEF, 0xE0, 0x7E, 0xFC, 0x07, 0xFF,
  0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x1F, 0xE1,
  0xFF, 0xF8, 0x7F, 0x87, 0xFF, 0xE3, 0xFE, 0x3F, 0xBF, 0x8F, 0xF8, 0xFE,
  0xFE, 0x3F, 0xE3, 0xF3, 0xF9, 0xFF, 0x9F, 0xCF, 0xE7, 0xFC, 0x7E, 0x3F,
  0x9E, 0xF3, 0xF8, 0xFE, 0xFF, 0xCF, 0xE3, 0xFB, 0xFF, 0x3F, 0x0F, 0xEF,
  0x7D, 0xFC, 0x3F, 0xFD, 0xF7, 0xE0, 0xFD, 0xF7, 0xDF, 0x83, 0xF7, 0x9F,
  0xFC, 0x07, 0xFE, 0x7F, 0xF0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xC7, 0xFE,
  0x01, 0xFF, 0x1F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xE1, 0xFF, 0x00,
  0x7F, 0x87, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x83,
  0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0x80, 0x7F, 0x3F, 0xC0, 0x3F, 0xBF, 0xC0,
  0x1F, 0xDF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xEF,
  0xE0, 0x0F, 0xF7, 0xF0, 0x0F, 0xF3, 0xF8, 0x07, 0xF1, 0xFE, 0x07, 0xF8,
  0xFF, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFF, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F, 0xE1, 0xFC, 0x0F, 0xE1, 0xFC, 0x07,
  0xE3, 0xF8, 0x07, 0xE3, 0xF8, 0x07, 0xE7, 0xF0, 0x07, 0xE7, 0xF0, 0x07,
  0xEF, 0xE0, 0x07, 0xEF, 0xE0, 0x07, 0xEF, 0xC0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xBF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0x80,
  0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x7F, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xC0, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x01,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x03,
  0xFE, 0x07, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 13, 28, 11, 0, -28 },
  { 47, 16, 10, 18, 4, -28 },
  { 67, 24, 28, 24, 0, -28 },
  { 151, 20, 32, 21, 1, -30 },
  { 231, 31, 28, 34, 2, -28 },
  { 340, 27, 28, 27, 0, -28 },
  { 435, 7, 10, 9, 4, -28 },
  { 444, 15, 35, 13, 1, -29 },
  { 510, 15, 35, 13, -3, -29 },
  { 576, 18, 19, 20, 3, -30 },
  { 619, 18, 19, 22, 2, -23 },
  { 662, 10, 10, 11, -2, -5 },
  { 675, 12, 6, 13, 0, -13 },
  { 684, 8, 7, 11, 0, -7 },
  { 691, 22, 28, 17, -2, -28 },
  { 768, 20, 28, 21, 1, -28 },
  { 838, 17, 28, 21, 3, -28 },
  { 898, 21, 28, 21, -1, -28 },
  { 972, 20, 28, 21, 0, -28 },
  { 1042, 21, 28, 21, 0, -28 },
  { 1116, 21, 28, 21, 0, -28 },
  { 1190, 21, 28, 21, 1, -28 },
  { 1264, 22, 28, 21, 1, -28 },
  { 1341, 20, 28, 21, 1, -28 },
  { 1411, 20, 28, 21, 1, -28 },
  { 1481, 11, 22, 11, 0, -22 },
  { 1512, 13, 27, 11, -2, -22 },
  { 1556, 18, 20, 22, 2, -24 },
  { 1601, 18, 14, 22, 2, -21 },
  { 1633, 18, 20, 22, 2, -24 },
  { 1678, 17, 28, 17, 2, -28 },
  { 1738, 31, 31, 32, 1, -28 },
  { 1859, 24, 28, 24, -2, -28 },
  { 1943, 23, 28, 23, 0, -28 },
  { 2024, 22, 28, 22, 2, -28 },
  { 2101, 24, 28, 25, 0, -28 },
  { 2185, 21, 28, 20, 0, -28 },
  { 2259, 21, 28, 20, 0, -28 },
  { 2333, 23, 28, 25, 2, -28 },
  { 2414, 26, 28, 26, 0, -28 },
  { 2505, 19, 28, 16, -1, -28 },
  { 2572, 20, 37, 13, -6, -28 },
  { 2665, 27, 28, 24, 0, -28 },
  { 2760, 17, 28, 19, 0, -28 },
  { 2820, 34, 28, 33, 0, -28 },
  { 2939, 29, 28, 28, 0, -28 },
  { 3041, 24, 28, 26, 2, -28 },
  { 3125, 22, 28, 22, 0, -28 },
  { 3202, 24, 35, 26, 2, -28 },
  { 3307, 23, 28, 23, 0, -28 },
  { 3388, 21, 28, 20, 0, -28 },
  { 3462, 19, 28, 20, 3, -28 },
  { 3529, 24, 28, 25, 2, -28 },
  { 3613, 23, 28, 23, 3, -28 },
  { 3694, 34, 28, 34, 3, -28 },
  { 3813, 28, 28, 24, -2, -28 },
  { 3911, 22, 28, 22, 3, -28 },
  { 3988, 24, 28, 20, -2, -28 },
  { 4072, 17, 36, 13, -1, -29 },
  { 4149, 10, 28, 17, 4, -28 },
  { 4184, 17, 36, 13, -3, -29 },
  { 4261, 20, 18, 20, 0, -28 },
  { 4306, 18, 4, 17, -4, 3 },
  { 4315, 9, 6, 13, 6, -30 },
  { 4322, 21, 22, 22, 1, -22 },
  { 4380, 21, 30, 22, 0, -30 },
  { 4459, 18, 22, 18, 1, -22 },
  { 4509, 23, 30, 22, 1, -30 },
  { 4596, 19, 22, 21, 1, -22 },
  { 4649, 23, 39, 15, -4, -30 },
  { 4762, 22, 31, 22, 0, -22 },
  { 4848, 21, 30, 22, 0, -30 },
  { 4927, 13, 30, 12, 0, -30 },
  { 4976, 18, 39, 12, -5, -30 },
  { 5064, 24, 30, 22, 0, -30 },
  { 5154, 13, 30, 12, 0, -30 },
  { 5203, 32, 22, 33, 0, -22 },
  { 5291, 21, 22, 22, 0, -22 },
  { 5349, 20, 22, 22, 1, -22 },
  { 5404, 23, 31, 22, -2, -22 },
  { 5494, 21, 31, 22, 1, -22 },
  { 5576, 18, 22, 16, 0, -22 },
  { 5626, 18, 22, 18, 0, -22 },
  { 5676, 16, 26, 16, 1, -26 },
  { 5728, 21, 22, 22, 1, -22 },
  { 5786, 20, 22, 20, 2, -22 },
  { 5841, 30, 22, 30, 2, -22 },
  { 5924, 25, 22, 21, -2, -22 },
  { 5993, 24, 31, 20, -2, -22 },
  { 6086, 20, 22, 18, -1, -22 },
  { 6141, 17, 34, 14, 0, -28 },
  { 6214, 5, 39, 20, 7, -30 },
  { 6239, 16, 34, 14, -2, -28 },
  { 6307, 18, 7, 22, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC39PT7B_H_
