#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC59PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03,
  0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x0C, 0x00,
  0x00, 0x3F, 0xF1, 0xFF, 0x9F, 0xF8, 0xFF, 0x8F, 0xFC, 0x7F, 0xC7, 0xFC,
  0x7F, 0xE3, 0xFE, 0x3F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0xFF,
  0x87, 0xFC, 0x7F, 0xC3, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F,
  0xF0, 0xFF, 0x87, 0xF8, 0x7F, 0x83, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x7F,
  0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xBF, 0x80, 0xFF, 0x9E, 0x0E, 0x01, 0xFF, 0x3C,
  0x04, 0x07, 0xFE, 0x78, 0x00, 0x0F, 0xFC, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xF7, 0xFE, 0x00,
  0x01, 0xE7, 0xFC, 0x20, 0x07, 0xCF, 0xF8, 0x70, 0x0F, 0x1F, 0xF0, 0xF8,
  0x1E, 0x7F, 0xC1, 0xFF, 0x3F, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x03, 0xFC, 0x00, 0x3F, 0xE7, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC7, 0xF8,
  0x07, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8,
  0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8,
  0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF1, 0xFE, 0x0F, 0xC0, 0xFF, 0x1F, 0xE3,
  0xFC, 0x3F, 0xF0, 0xFF, 0xBF, 0xE3, 0xFC, 0xFF, 0xF8, 0x7F, 0xFF, 0xE7,
  0xF9, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F,
  0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0x1F, 0xE7, 0xFF, 0xFE, 0x1F, 0xFE, 0x3F,
  0xC7, 0xF9, 0xFE, 0x0F, 0xFC, 0x7F, 0xCF, 0xF8, 0xFF, 0x01, 0xE0, 0x7F,
  0x8F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE,
  0x1F, 0xF0, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFC,
  0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8,
  0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xE0,
  0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC0,
  0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0x80,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x00,
  0xFF, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC3,
  0xFF, 0x00, 0xFF, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFE, 0x07,
  0xFF, 0xFF, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFE, 0x1F, 0xFF, 0xFF,
  0x9F, 0xFC, 0x3F, 0xFF, 0xFF, 0xDF, 0xFC, 0x3F, 0xFB, 0xFF, 0xFF, 0xF8,
  0x7F, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xF8, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFD, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE, 0x7F, 0xC7,
  0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x20, 0x1F, 0xC0, 0x0F, 0x03, 0xF8, 0x01,
  0xF8, 0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xFF, 0xF8, 0x3D, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC,
  0x04, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xEF, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xC3, 0xFE,
  0x00, 0x70, 0x3F, 0x80, 0x02, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x07,
  0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC,
  0xFF, 0xFE, 0x00, 0x1F, 0xC3, 0xFE, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFE, 0xFF, 0xC7, 0xF8, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x3F, 0xF9, 0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0x3F, 0xF1, 0xFF,
  0xC1, 0xFF, 0x8F, 0xFE, 0x0F, 0xFC, 0xFF, 0xE0, 0x7F, 0xE7, 0xFF, 0x03,
  0xFF, 0x3F, 0xF8, 0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0xDF, 0xFC, 0x07, 0xFE,
  0xFF, 0xE0, 0x7F, 0xF7, 0xFF, 0x03, 0xFF, 0xBF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0xFF, 0xE0, 0x7F, 0xF7, 0xFF, 0x03,
  0xFF, 0xBF, 0xF8, 0x1F, 0xFD, 0xFF, 0x80, 0xFF, 0xCF, 0xFC, 0x0F, 0xFE,
  0x7F, 0xE0, 0x7F, 0xF3, 0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x3F, 0xF8, 0xFF,
  0xC1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x3F, 0xF9, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC3,
  0xFF, 0x7F, 0xE1, 0xFF, 0x3F, 0xF0, 0x7E, 0x3F, 0xF8, 0x1E, 0x1F, 0xFC,
  0x0E, 0x0F, 0xFC, 0x02, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xC1, 0xFF, 0xE0, 0x07, 0xC0, 0x7F, 0xF0, 0x01, 0x80, 0x3F,
  0xF0, 0x00, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x3F, 0xFC, 0x01, 0x80, 0x3F, 0xF8,
  0x02, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x80, 0x00, 0x7F,
  0xF1, 0xC0, 0x03, 0xFF, 0xE3, 0xF8, 0x1F, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xDF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xBF, 0xF0, 0x00, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x3F, 0xF0,
  0x03, 0xFE, 0x7F, 0xF0, 0x03, 0xFC, 0x7F, 0xE0, 0x07, 0xF8, 0x7F, 0xE0,
  0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0xE0, 0x1F, 0xE0, 0xFF, 0xE0,
  0x3F, 0xC0, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0xB0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0x81, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x40, 0x00, 0xFF, 0xF0,
  0xE0, 0x03, 0xFF, 0xE1, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x05, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x10, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x7F, 0x00, 0x3F, 0xF3, 0xFF,
  0x80, 0x7F, 0xEF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF1, 0xFF, 0xE0, 0xFF, 0xE3,
  0xFF, 0xC1, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0x1F,
  0xFC, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF,
  0xE0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xCF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x9F, 0xFE, 0x07, 0xFE, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0,
  0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0xDF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x0F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F,
  0xF8, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x83, 0xFF,
  0x87, 0xFF, 0xDF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xF1, 0xFF,
  0x87, 0xFF, 0x0F, 0xFE, 0x7F, 0xF0, 0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0x9F,
  0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0x7F, 0xF0,
  0x3F, 0xFB, 0xFF, 0x81, 0xFF, 0xDF, 0xFC, 0x1F, 0xFE, 0xFF, 0xF1, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xDF, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0x8F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x30, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x80,
  0x7F, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0x3F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xF0, 0xFF, 0xF0, 0xE0, 0x1F, 0xF8,
  0x20, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x01, 0xFF, 0x00, 0x3C, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xFF,
  0x87, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0x8F, 0xE1, 0xFE, 0x07, 0xFF, 0xFE,
  0x3F, 0x87, 0xF8, 0x3F, 0xFF, 0xF8, 0xFF, 0x1F, 0xC1, 0xFF, 0xFF, 0xC1,
  0xFC, 0xFF, 0x0F, 0xFE, 0xFF, 0x07, 0xF3, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F,
  0xDF, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xFD,
  0xFC, 0x3F, 0xC0, 0xFE, 0x0F, 0xE7, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xBF,
  0xC3, 0xF8, 0x1F, 0xE0, 0xFE, 0xFE, 0x1F, 0xE0, 0x7F, 0x03, 0xFB, 0xF8,
  0x7F, 0x81, 0xFC, 0x1F, 0xCF, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x3F, 0x87,
  0xF8, 0x3F, 0xC3, 0xFC, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F,
  0x87, 0xF8, 0x7F, 0x8F, 0xE1, 0xFF, 0x7F, 0xF7, 0xFC, 0x3F, 0x87, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x3F, 0xFE,
  0xFF, 0xF8, 0x0F, 0xF0, 0x7F, 0xF3, 0xFF, 0xC0, 0x1F, 0xC0, 0xFF, 0x87,
  0xFE, 0x00, 0x7F, 0x80, 0xF8, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x40,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFC, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F,
  0xE7, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xC7, 0xFC, 0x00,
  0x0F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF8, 0x7F,
  0xE0, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFF,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFE, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x00, 0x7F,
  0xF1, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xF3, 0xFF, 0x80,
  0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0xE0,
  0x3F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0xFF,
  0xE0, 0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xFE, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xF9, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0x01, 0xFF, 0xE0,
  0x01, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x80, 0x7F, 0xFC, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF0, 0x07, 0xFF, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x0F, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF,
  0xC1, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xF8, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x9F, 0xE0, 0x3F, 0xFF, 0x00, 0x3C, 0x07,
  0xFF, 0xC0, 0x01, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xF8,
  0x3F, 0xFF, 0xCF, 0xFF, 0x0F, 0xFF, 0xF9, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F,
  0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0x07, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xFF,
  0x1F, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xF0, 0x03,
  0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8,
  0x03, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xF0, 0x1F, 0xFC, 0x1F,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x02, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xFC,
  0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x01,
  0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0xFF, 0xE1,
  0xFF, 0xE0, 0x00, 0x7F, 0xF1, 0xFF, 0xE0, 0x00, 0x3F, 0xF9, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xDF, 0xFC, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x01, 0xFF,
  0xC7, 0xFF, 0x80, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00,
  0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x1F,
  0xF7, 0xF8, 0x3F, 0xFF, 0xF8, 0x03, 0xFE, 0xFF, 0x07, 0xFB, 0xFF, 0x00,
  0x7F, 0xDF, 0xE0, 0xFF, 0x7F, 0xC0, 0x1F, 0xFB, 0xFC, 0x3F, 0xDF, 0xF8,
  0x03, 0xFF, 0x7F, 0x87, 0xFB, 0xFF, 0x00, 0x7F, 0xEF, 0xF1, 0xFE, 0x7F,
  0xE0, 0x0F, 0xF9, 0xFE, 0x3F, 0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0xCF, 0xFB,
  0xFF, 0x00, 0x7F, 0xE7, 0xF9, 0xFE, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0x7F,
  0xCF, 0xFC, 0x01, 0xFF, 0x9F, 0xEF, 0xF1, 0xFF, 0x80, 0x3F, 0xF3, 0xFF,
  0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0x7F, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0x8F,
  0xFF, 0xF1, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0xFC, 0x3F, 0xF0, 0x07, 0xFE,
  0x3F, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0x80, 0x3F,
  0xF0, 0xFF, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xFF, 0x87, 0xFE, 0x00,
  0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xFC, 0x1F, 0xF0,
  0x03, 0xFE, 0x0F, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xC0, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0xFF,
  0x81, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0xFF, 0x81,
  0xFF, 0x80, 0x3F, 0xEF, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0xFF, 0xC3, 0xFF,
  0x00, 0x3F, 0xEF, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0xC3, 0xFF, 0x00,
  0x7F, 0xE7, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0xE3, 0xFE, 0x00, 0x7F,
  0xC7, 0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xC3,
  0xFF, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF7, 0xFC, 0x00, 0xFF, 0xC3, 0xFF,
  0x7F, 0xC0, 0x0F, 0xFC, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF8, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0x80,
  0x1F, 0xF8, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFE, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE,
  0x1F, 0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xFC, 0x00,
  0x7F, 0xF3, 0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xF7, 0xFF,
  0x80, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00,
  0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFE,
  0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xFC,
  0xFF, 0xE0, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x07,
  0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x07,
  0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x83, 0xFF,
  0x80, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF,
  0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xE0,
  0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x07, 0xFF, 0x3F,
  0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x7F,
  0xF7, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xEF, 0xFE, 0x00,
  0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF,
  0xE0, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x01, 0xFF,
  0xCF, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0xCF, 0xFE, 0x00,
  0x7F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF,
  0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xCF, 0xFF,
  0xC0, 0x7F, 0xF0, 0xFF, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x07,
  0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0xFF,
  0xC3, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x1F, 0xFC, 0x7F,
  0xE0, 0x07, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xE0,
  0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F,
  0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xFC,
  0x7F, 0xF0, 0x0F, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xCF, 0xF0,
  0x0F, 0xFE, 0x03, 0xC0, 0x3F, 0xF8, 0x01, 0x80, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x20, 0x00, 0xFF,
  0xE0, 0x70, 0x01, 0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x7F,
  0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x1F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xF8, 0x03,
  0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x7F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x7F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x7F, 0xFB,
  0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xF8, 0x03, 0xFF,
  0x8F, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F,
  0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x80,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x0F, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F,
  0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x8F, 0xFE, 0x00,
  0x7F, 0xE3, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xE0,
  0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x1F, 0xFB, 0xFF,
  0x00, 0x07, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xEF,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF,
  0x3F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0xE0, 0x1F,
  0xF8, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x1F, 0xF8, 0x0F, 0xFF, 0x80,
  0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xFE,
  0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x1F,
  0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8,
  0x7F, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x1F, 0xEF, 0xF1, 0xFF, 0xC0, 0x7F,
  0xE3, 0xFD, 0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0xFF, 0xBF, 0xC7, 0xFE, 0x01,
  0xFF, 0x1F, 0xEF, 0xF9, 0xFF, 0x80, 0x3F, 0xE7, 0xFD, 0xFF, 0x3F, 0xF0,
  0x07, 0xFC, 0xFF, 0xBF, 0xEF, 0xFC, 0x00, 0xFF, 0x9F, 0xE7, 0xFD, 0xFF,
  0x80, 0x1F, 0xF7, 0xFC, 0xFF, 0xBF, 0xF0, 0x03, 0xFE, 0xFF, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xE3, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x83,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0x01,
  0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0,
  0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFE,
  0x7F, 0xF0, 0x03, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0xFF,
  0xDF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x03,
  0xFE, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0xC0, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x0F, 0xF8,
  0x01, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF9, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0x83,
  0xFE, 0x01, 0xFF, 0xC7, 0xFC, 0x07, 0xFF, 0xCF, 0xF8, 0x1F, 0xFF, 0xBF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x8F,
  0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF,
  0xE0, 0x3F, 0xF1, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF, 0x81, 0xFF, 0x87, 0xFF,
  0x03, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xF3, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xDF, 0xF0, 0x0F, 0xFF, 0xBF, 0xE0, 0x0F, 0xFE, 0x7F,
  0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0xFC, 0x00,
  0x3F, 0xF7, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFD, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF,
  0xC3, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x1F, 0xF8,
  0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xF0, 0xFF, 0xC0,
  0xFF, 0xE3, 0xFF, 0x01, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0x8F, 0xFC, 0x0F,
  0xFE, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF,
  0xE1, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0xFE, 0x07, 0xFC, 0x7F, 0xF0, 0x0F,
  0xF8, 0x7F, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xBF, 0x07, 0xFF, 0x80, 0x40, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x01, 0x07, 0xFF, 0x00, 0xC0, 0xFF, 0xF0, 0x78, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x87, 0xFE, 0x00, 0x3F,
  0xF1, 0xFF, 0x80, 0x1F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x0F, 0xFE,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFE,
  0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F,
  0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x00,
  0xFF, 0xF3, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xEF, 0xF8, 0x00, 0x7F, 0xF3, 0xFE, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xC7, 0xFF,
  0x1F, 0xFC, 0x1F, 0xF9, 0xFF, 0xC0, 0xFF, 0xCF, 0xFE, 0x07, 0xFE, 0x7F,
  0xE0, 0x7F, 0xE7, 0xFF, 0x07, 0xFF, 0x3F, 0xF9, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x20, 0xFF, 0xE0,
  0x07, 0x07, 0xFF, 0xC3, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xE3, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xC0, 0x1F, 0xFF, 0x3F, 0xE0, 0x1F,
  0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x07, 0xFC,
  0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF,
  0xE0, 0x3F, 0xFC, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFD, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0xC0, 0x03, 0xFC,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x08, 0x00, 0x1F, 0xF8, 0x06, 0x00, 0x1F, 0xFC, 0x03, 0xF0,
  0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x8F, 0xE0, 0x01, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE,
  0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC,
  0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8,
  0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xF0,
  0x7F, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0,
  0x00, 0x0F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x80, 0x7F,
  0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF8,
  0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xF3,
  0xFF, 0xC0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00,
  0xFF, 0xDF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x03,
  0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF,
  0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x03, 0xFF,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0x01,
  0xFE, 0x7F, 0xFC, 0x3F, 0xFE, 0x03, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x03,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x87, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F,
  0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x0F,
  0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x0F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F,
  0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x7F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0xFF,
  0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x3F,
  0xF8, 0x01, 0xFE, 0x7F, 0xFC, 0x03, 0xFE, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x07,
  0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F,
  0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F,
  0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFE,
  0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0xCF, 0xFE, 0x0F, 0xFE, 0x7F, 0xF0, 0x7F,
  0xF7, 0xFF, 0x03, 0xFF, 0xBF, 0xF8, 0x1F, 0xFD, 0xFF, 0xC0, 0xFF, 0xEF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFD, 0xFF, 0xC0, 0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0x7F, 0xF0, 0x3F,
  0xF3, 0xFF, 0x83, 0xFF, 0x9F, 0xFC, 0x3F, 0xFC, 0xFF, 0xE1, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE3,
  0xF8, 0x00, 0x0F, 0xF1, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0xF0, 0x01, 0xFF,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFB, 0xFF, 0xC0,
  0x3F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0x9F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xDF, 0xFE, 0x00, 0x7F, 0xF3, 0xFF,
  0x00, 0x1F, 0xFC, 0x7F, 0x80, 0x07, 0xFE, 0x06, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x83, 0xFE, 0x01, 0xFF, 0xC7,
  0xFC, 0x07, 0xFF, 0xCF, 0xF8, 0x1F, 0xFF, 0xBF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE1,
  0xFF, 0xC1, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x8F, 0xFE, 0x07, 0xFE, 0x1F,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF1, 0xFF,
  0xC0, 0x7F, 0xC3, 0xFF, 0x81, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x0F, 0xFE,
  0x07, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0,
  0xFF, 0xE0, 0xFF, 0xF3, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0x7F, 0xE0, 0x0F, 0xFD, 0xFF, 0xC0, 0x0F, 0xF3, 0xFF,
  0x00, 0x02, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xE0,
  0x3F, 0xC7, 0xF8, 0x07, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xEF,
  0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xC4, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFB, 0xF8, 0x1F, 0xFC, 0x0E, 0x07, 0xFE, 0x01, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xE2, 0x00, 0x3F, 0xF8, 0xE0, 0x1F, 0xFC, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0xC0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x0F,
  0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F,
  0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF0, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE1, 0xFF, 0xE0, 0xFF, 0xF3, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0x7F, 0xC0, 0x3F, 0xFE, 0x7F, 0x80, 0x1F, 0xFC, 0x7F, 0x80, 0x0F,
  0xF8, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFB, 0xFF, 0x00, 0xFF, 0xF7, 0xFF, 0x01, 0xFF, 0xCF, 0xFE,
  0x03, 0xFF, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0x87,
  0xFE, 0x03, 0xFF, 0x1F, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F,
  0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x7F, 0xDF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xEF, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xBF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFC, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF3, 0xFF, 0x07, 0xFF, 0xC1,
  0xFF, 0x8F, 0xFC, 0x1F, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0xFF, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF,
  0x07, 0xFC, 0x7F, 0xFF, 0x1F, 0xF8, 0x1F, 0xF1, 0xFD, 0xFC, 0x7F, 0xE0,
  0x7F, 0xCF, 0xFF, 0xF3, 0xFF, 0x01, 0xFF, 0x3F, 0xFF, 0xCF, 0xFC, 0x07,
  0xFC, 0xFE, 0xFF, 0x3F, 0xE0, 0x1F, 0xF7, 0xFB, 0xFD, 0xFF, 0x80, 0x7F,
  0xDF, 0xEF, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0x3F, 0xDF, 0xF0, 0x07, 0xFF,
  0xFC, 0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0xE3, 0xFB, 0xFE, 0x00, 0x7F, 0xFF,
  0x8F, 0xEF, 0xF8, 0x01, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x00, 0xFF, 0xE1, 0xFF,
  0xC0, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x1F,
  0xFD, 0xFF, 0xC0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x03, 0xFF, 0x8F,
  0xFE, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x7F, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x0F,
  0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00,
  0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF,
  0xC0, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x01,
  0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x09, 0xFF, 0xF8, 0x01, 0xDF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF6, 0x00, 0x0F,
  0xFE, 0x20, 0x00, 0x07, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 20, 43, 17, 0, -42 },
  { 109, 25, 15, 27, 5, -42 },
  { 156, 37, 42, 36, 0, -42 },
  { 351, 31, 48, 32, 1, -45 },
  { 537, 48, 44, 52, 3, -43 },
  { 801, 40, 44, 40, 0, -43 },
  { 1021, 12, 15, 14, 5, -42 },
  { 1044, 23, 52, 20, 1, -43 },
  { 1194, 23, 52, 20, -4, -43 },
  { 1344, 27, 28, 30, 4, -45 },
  { 1439, 28, 28, 33, 3, -35 },
  { 1537, 15, 16, 17, -3, -8 },
  { 1567, 17, 9, 19, 1, -20 },
  { 1587, 12, 11, 17, 0, -10 },
  { 1604, 34, 44, 26, -3, -43 },
  { 1791, 29, 44, 32, 2, -43 },
  { 1951, 25, 42, 32, 5, -42 },
  { 2083, 33, 43, 32, -2, -43 },
  { 2261, 31, 44, 32, 0, -43 },
  { 2432, 32, 42, 32, 0, -42 },
  { 2600, 31, 43, 32, 1, -42 },
  { 2767, 31, 44, 32, 2, -43 },
  { 2938, 34, 42, 32, 1, -42 },
  { 3117, 31, 44, 32, 1, -43 },
  { 3288, 29, 44, 32, 2, -43 },
  { 3448, 17, 34, 17, 0, -33 },
  { 3521, 20, 41, 17, -3, -33 },
  { 3624, 27, 31, 33, 3, -37 },
  { 3729, 28, 21, 33, 3, -31 },
  { 3803, 28, 31, 33, 3, -37 },
  { 3912, 26, 44, 26, 3, -43 },
  { 4055, 46, 48, 49, 2, -43 },
  { 4331, 36, 42, 37, -3, -42 },
  { 4520, 35, 42, 35, 0, -42 },
  { 4704, 33, 44, 34, 3, -43 },
  { 4886, 36, 42, 37, 0, -42 },
  { 5075, 32, 42, 30, 0, -42 },
  { 5243, 32, 42, 30, 0, -42 },
  { 5411, 35, 44, 38, 3, -43 },
  { 5604, 40, 42, 39, 0, -42 },
  { 5814, 30, 42, 24, -2, -42 },
  { 5972, 30, 55, 20, -9, -42 },
  { 6179, 41, 42, 36, 0, -42 },
  { 6395, 25, 42, 28, 0, -42 },
  { 6527, 51, 42, 50, 0, -42 },
  { 6795, 44, 42, 43, 0, -42 },
  { 7026, 36, 44, 40, 3, -43 },
  { 7224, 34, 42, 34, 0, -42 },
  { 7403, 36, 53, 40, 3, -43 },
  { 7642, 34, 42, 35, 0, -42 },
  { 7821, 31, 44, 30, 0, -43 },
  { 7992, 29, 42, 30, 5, -42 },
  { 8145, 36, 43, 38, 3, -42 },
  { 8339, 34, 42, 34, 5, -42 },
  { 8518, 51, 42, 51, 5, -42 },
  { 8786, 44, 42, 36, -4, -42 },
  { 9017, 33, 42, 33, 5, -42 },
  { 9191, 36, 42, 30, -3, -42 },
  { 9380, 26, 53, 20, -2, -43 },
  { 9553, 15, 44, 26, 6, -43 },
  { 9636, 26, 53, 20, -4, -43 },
  { 9809, 31, 28, 30, -1, -42 },
  { 9918, 26, 7, 25, -5, 4 },
  { 9941, 14, 9, 20, 8, -45 },
  { 9957, 31, 34, 33, 2, -33 },
  { 10089, 31, 46, 33, 0, -45 },
  { 10268, 27, 34, 27, 2, -33 },
  { 10383, 34, 46, 33, 2, -45 },
  { 10579, 29, 34, 32, 2, -33 },
  { 10703, 34, 59, 22, -6, -45 },
  { 10954, 33, 47, 33, 0, -33 },
  { 11148, 32, 45, 34, 0, -45 },
  { 11328, 20, 46, 18, 0, -46 },
  { 11443, 28, 60, 18, -8, -46 },
  { 11653, 37, 45, 34, 0, -45 },
  { 11862, 20, 45, 18, 0, -45 },
  { 11975, 48, 33, 50, 0, -33 },
  { 12173, 32, 33, 34, 0, -33 },
  { 12305, 29, 34, 33, 2, -33 },
  { 12429, 34, 47, 33, -3, -33 },
  { 12629, 31, 47, 33, 2, -33 },
  { 12812, 27, 33, 24, 0, -33 },
  { 12924, 26, 34, 27, 1, -33 },
  { 13035, 24, 40, 24, 2, -39 },
  { 13155, 32, 34, 34, 2, -33 },
  { 13291, 31, 33, 30, 3, -33 },
  { 13419, 46, 33, 45, 3, -33 },
  { 13609, 38, 33, 31, -3, -33 },
  { 13766, 38, 47, 30, -4, -33 },
  { 13990, 30, 33, 27, -2, -33 },
  { 14114, 25, 51, 21, 0, -42 },
  { 14274, 8, 58, 30, 11, -45 },
  { 14332, 24, 51, 21, -3, -42 },
  { 14485, 29, 11, 33, 2, -26 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic59pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC59PT7B_H_
