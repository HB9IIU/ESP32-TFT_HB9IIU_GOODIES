#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC42PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x01, 0xF8, 0x01, 0x00, 0x00, 0x7F, 0x3F, 0xBF, 0x9F,
  0xDF, 0xCF, 0xEF, 0xC7, 0xE7, 0xE3, 0xF3, 0xF3, 0xFB, 0xF1, 0xF9, 0xF8,
  0xFC, 0xFC, 0x7E, 0x7E, 0x3F, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x80,
  0x0F, 0xC7, 0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x3E,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7C, 0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0xC7, 0xC0,
  0x03, 0xE3, 0xF0, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x80, 0xF8, 0x7C, 0x00, 0x3E,
  0x3F, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xE3, 0xE0, 0x01, 0xF1, 0xF8, 0x00,
  0x7C, 0x7C, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F,
  0x70, 0xC1, 0xFD, 0xC0, 0x07, 0xF7, 0x00, 0x1F, 0xDC, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xDF, 0x88, 0x0E,
  0x7E, 0x38, 0x39, 0xF8, 0xFC, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFC,
  0x03, 0xFF, 0x00, 0x7E, 0x01, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xF8, 0x0F,
  0xC0, 0x3F, 0xFE, 0x07, 0xE0, 0x1F, 0x8F, 0x81, 0xF0, 0x07, 0xE3, 0xE0,
  0xFC, 0x01, 0xF9, 0xF8, 0x7E, 0x00, 0x7C, 0x7E, 0x1F, 0x00, 0x3F, 0x1F,
  0x8F, 0xC0, 0x0F, 0xC7, 0xE7, 0xE0, 0x03, 0xF1, 0xF1, 0xF0, 0x00, 0xFC,
  0xFC, 0xFC, 0xFF, 0x3F, 0xFF, 0x7E, 0x7F, 0xE7, 0xFF, 0x9F, 0x3F, 0xF9,
  0xFF, 0xCF, 0xDF, 0xFF, 0x3F, 0xE7, 0xE7, 0xEF, 0xC7, 0xF1, 0xF3, 0xF3,
  0xF0, 0x00, 0xFC, 0xFC, 0xFC, 0x00, 0x7E, 0x3E, 0x3F, 0x00, 0x1F, 0x1F,
  0x8F, 0xC0, 0x0F, 0xC7, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0xF8, 0x03, 0xF0,
  0x7E, 0x7E, 0x00, 0xFC, 0x1F, 0x9F, 0x80, 0x7E, 0x07, 0xFF, 0xC0, 0x3F,
  0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xF8, 0x07, 0xE0, 0x07, 0xFC, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFC,
  0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE3, 0xFC, 0x1F, 0xFE, 0x1F, 0xC1, 0xFF,
  0xF1, 0xFE, 0x3F, 0xFF, 0x8F, 0xE1, 0xFF, 0xFE, 0xFF, 0x1F, 0xEF, 0xFF,
  0xF0, 0xFE, 0x3F, 0xFF, 0x8F, 0xF0, 0xFF, 0xF8, 0x7F, 0x87, 0xFF, 0xC3,
  0xFC, 0x1F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFE, 0x3F, 0xE0, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0xFC,
  0xFC, 0xFC, 0xFC, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC,
  0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x00, 0xFA, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x10, 0x7E, 0x03, 0x0F, 0x80,
  0xF9, 0xF0, 0x1F, 0xFE, 0x0B, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x83,
  0xFB, 0xF0, 0x3F, 0x3F, 0x01, 0xC7, 0xE0, 0x10, 0xF8, 0x00, 0x08, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x1F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3,
  0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0xFB, 0xFF, 0x9F, 0xFC, 0xFF,
  0xE7, 0xFF, 0x7F, 0xF8, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x10,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xCF,
  0xE3, 0xFC, 0x7F, 0x1F, 0xC3, 0xF9, 0xFE, 0x1F, 0xCF, 0xF0, 0xFE, 0x7F,
  0x07, 0xF7, 0xF8, 0x3F, 0xBF, 0xC1, 0xFD, 0xFE, 0x1F, 0xEF, 0xE0, 0xFF,
  0x7F, 0x07, 0xFF, 0xF8, 0x3F, 0xBF, 0xC3, 0xFD, 0xFE, 0x1F, 0xEF, 0xF0,
  0xFE, 0x7F, 0x8F, 0xF3, 0xFC, 0x7F, 0x9F, 0xE7, 0xF8, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0x83, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xC3,
  0xE7, 0xF0, 0xF3, 0xFC, 0x18, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0xFC, 0xFF, 0x80, 0xE0, 0xFF, 0x01, 0x81, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x38, 0x3F, 0xC0, 0x80, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC8, 0x00, 0xFF, 0x38, 0x07, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xBF, 0x80, 0x3F, 0x7F,
  0x00, 0xFD, 0xFE, 0x03, 0xF3, 0xFC, 0x0F, 0xC7, 0xF0, 0x1F, 0x8F, 0xE0,
  0x7E, 0x1F, 0xC1, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x88, 0x01, 0xFE, 0x38, 0x1F, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xE7, 0xC0, 0xFE, 0xFF, 0x07, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0x9F, 0xE7, 0xF8, 0xFF,
  0x3F, 0xC3, 0xF9, 0xFC, 0x3F, 0xCF, 0xE1, 0xFE, 0x7F, 0x0F, 0xF3, 0xF8,
  0x7F, 0x9F, 0xC7, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xDF, 0xE0, 0xFE, 0x3F, 0xC3, 0xF8, 0xFE,
  0x1F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFF, 0x7F, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x87, 0xF9, 0xFE, 0x1F, 0xC3, 0xF8, 0xFE, 0x0F, 0xE3,
  0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFF, 0x3F, 0xE3, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x7F, 0xCF, 0xF7, 0xF8, 0x7F, 0x7F, 0x87, 0xF7,
  0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF9, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFE, 0xFE, 0x3F, 0xEF,
  0xE0, 0xF9, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x1F,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x7E, 0x07, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x07, 0xE0, 0x10, 0x00, 0x00, 0x20, 0x07, 0xE0, 0x1F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0xC0,
  0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00,
  0x08, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF1, 0xC1, 0xFC, 0x40, 0x7F, 0x00, 0x1F, 0xC0,
  0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x01, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0,
  0x03, 0xF0, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x60, 0x3E, 0x0F, 0x83,
  0xFF, 0x1F, 0x8F, 0xC3, 0xFF, 0xC7, 0xC7, 0xC3, 0xFF, 0xE3, 0xE7, 0xC3,
  0xFF, 0xF1, 0xF3, 0xE3, 0xF1, 0xF8, 0xFB, 0xF1, 0xF0, 0xF8, 0x7D, 0xF1,
  0xF8, 0x7C, 0x3E, 0xF8, 0xF8, 0x3E, 0x1F, 0x7C, 0x7C, 0x3F, 0x1F, 0x3E,
  0x7E, 0x1F, 0x0F, 0xBF, 0x3F, 0x0F, 0x87, 0xDF, 0x1F, 0x8F, 0xC7, 0xCF,
  0x8F, 0xC7, 0xE7, 0xE7, 0xE7, 0xFF, 0xFF, 0xE3, 0xF1, 0xFF, 0xFF, 0xE0,
  0xF8, 0xFF, 0xBF, 0xE0, 0x7C, 0x3F, 0x8F, 0xE0, 0x3F, 0x06, 0x01, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x40, 0x01, 0xFC, 0x01, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFE, 0xFC,
  0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xF3, 0xF0, 0x03, 0xFC,
  0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x8F, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F,
  0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xC0, 0x3F, 0x8F, 0xF0, 0x0F, 0xE7, 0xF8,
  0x03, 0xF9, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xF0,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F, 0xE3, 0xFE, 0x0F, 0xF0,
  0xFF, 0x07, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xF3, 0xFE, 0x07, 0xF0, 0xFF, 0x03,
  0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0,
  0x7F, 0x1F, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xF8, 0x3C, 0x1F, 0xF0, 0x08, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x40, 0xFF, 0xC1, 0xC0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x7F, 0xBF, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0xC1, 0xFC, 0x0F,
  0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xF8,
  0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87,
  0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0xC1, 0xFF,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xE0, 0xFE, 0x7F, 0xF0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xF0, 0x78, 0x3F, 0xE0,
  0x08, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0xFF, 0xF3, 0xFC, 0x7F, 0xF3, 0xFC, 0x3F, 0xF9, 0xFE,
  0x3F, 0xFC, 0xFF, 0x1F, 0xFE, 0x7F, 0x8F, 0xFF, 0x3F, 0xC7, 0xFF, 0x1F,
  0xE0, 0x3F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFE, 0x0F, 0xF1,
  0xFF, 0x87, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x1F,
  0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x1F, 0xC0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x80,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x83, 0xFE,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0,
  0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0x87, 0xFC,
  0x01, 0xFC, 0x7F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x07,
  0xFB, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xFC,
  0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07,
  0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF,
  0xBF, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F,
  0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0x8F,
  0xDF, 0xC0, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xDF, 0x9F, 0xBF, 0x81, 0xFD,
  0xF9, 0xFB, 0xF8, 0x1F, 0xDF, 0x9F, 0x3F, 0x81, 0xFD, 0xFB, 0xF3, 0xF8,
  0x1F, 0xDF, 0xBE, 0x7F, 0x01, 0xFD, 0xFF, 0xE7, 0xF0, 0x3F, 0x9F, 0xFE,
  0x7F, 0x03, 0xF9, 0xFF, 0xC7, 0xF0, 0x3F, 0x9F, 0xFC, 0xFF, 0x03, 0xF9,
  0xFF, 0x8F, 0xE0, 0x7F, 0x1F, 0xF8, 0xFE, 0x07, 0xF1, 0xFF, 0x0F, 0xE0,
  0x7F, 0x1F, 0xF0, 0xFE, 0x07, 0xF1, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0xE1,
  0xFC, 0x0F, 0xE1, 0xFE, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0xFE, 0x07, 0xFE,
  0x01, 0xFC, 0x0F, 0xFC, 0x03, 0xF8, 0x1F, 0xF8, 0x0F, 0xE0, 0x3F, 0xF8,
  0x1F, 0xC0, 0x7F, 0xF0, 0x3F, 0x81, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xC0,
  0xFE, 0x07, 0xFF, 0xC3, 0xF8, 0x0F, 0xFF, 0x87, 0xF0, 0x3F, 0xFF, 0x0F,
  0xE0, 0x7F, 0xFE, 0x1F, 0xC0, 0xFE, 0xFE, 0x7F, 0x01, 0xFD, 0xFC, 0xFE,
  0x03, 0xF3, 0xF9, 0xFC, 0x0F, 0xE7, 0xF3, 0xF8, 0x1F, 0xC7, 0xF7, 0xF0,
  0x3F, 0x8F, 0xEF, 0xC0, 0x7F, 0x1F, 0xDF, 0x80, 0xFE, 0x3F, 0xFF, 0x03,
  0xF8, 0x3F, 0xFE, 0x07, 0xF0, 0x7F, 0xFC, 0x0F, 0xE0, 0xFF, 0xF0, 0x1F,
  0xC1, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xC0, 0xFE, 0x03, 0xFF, 0x81, 0xFC,
  0x07, 0xFE, 0x03, 0xF8, 0x0F, 0xFC, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xC0,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE1, 0xFF,
  0x8F, 0xF8, 0x7F, 0xC1, 0xFE, 0x3F, 0xE0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF7,
  0xFC, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x0F,
  0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0,
  0x1F, 0xEF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x01, 0xFF, 0x3F,
  0xC0, 0x7F, 0x8F, 0xF0, 0x3F, 0xE3, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07,
  0xF9, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFE, 0x0F, 0xE3, 0xFE, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0x8F, 0xF8, 0x7F, 0xC1,
  0xFE, 0x3F, 0xE0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF7, 0xFC, 0x03, 0xFD, 0xFE,
  0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xFB,
  0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x0F,
  0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0,
  0x3F, 0xE3, 0xFF, 0x3F, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF,
  0x07, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF,
  0x0F, 0xF3, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xCF, 0xE0,
  0x3F, 0xCF, 0xF0, 0x3F, 0xCF, 0xF0, 0x3F, 0xCF, 0xF0, 0x3F, 0x87, 0xF8,
  0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC,
  0x7F, 0x03, 0xFE, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF,
  0x0F, 0x03, 0xFC, 0x04, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xE1, 0x00, 0x7F, 0x86, 0x01, 0xFE, 0x1F, 0x0F, 0xF0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xF8, 0x3F, 0x81,
  0xFE, 0x0F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F,
  0x81, 0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0,
  0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F,
  0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF0,
  0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xCF,
  0xE0, 0x3F, 0xC7, 0xF0, 0x1F, 0xE3, 0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xF0,
  0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xC3, 0xFC,
  0x0F, 0xE1, 0xFC, 0x07, 0xF1, 0xFE, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xBF, 0xC0, 0x1F, 0xDF,
  0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0xBF, 0xC0, 0xFF,
  0x03, 0xFD, 0xFE, 0x07, 0xF8, 0x1F, 0xEF, 0xF0, 0x3F, 0xC0, 0xFE, 0x7F,
  0x83, 0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xF0, 0x7F, 0x1F, 0xE1, 0xFF, 0x83,
  0xF8, 0xFE, 0x0F, 0xFC, 0x3F, 0xC7, 0xF0, 0xFF, 0xE1, 0xFC, 0x3F, 0x87,
  0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0xF8, 0xFE, 0x0F, 0xE3, 0xFF, 0xC7, 0xF0,
  0x3F, 0x1F, 0xFE, 0x7F, 0x01, 0xF9, 0xFB, 0xF3, 0xF8, 0x0F, 0xCF, 0xDF,
  0xBF, 0xC0, 0x7E, 0xFE, 0xFD, 0xFC, 0x03, 0xF7, 0xE7, 0xEF, 0xE0, 0x1F,
  0xBF, 0x3F, 0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xF0, 0x07, 0xFF, 0x8F, 0xFF,
  0x80, 0x3F, 0xFC, 0x7F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x0F, 0xFE,
  0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x07,
  0xF0, 0xFF, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0x3F, 0xC0,
  0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x7F, 0x81, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFB, 0xFC, 0x1F,
  0xF7, 0xF8, 0x3F, 0xC7, 0xF0, 0xFF, 0x0F, 0xE1, 0xFE, 0x1F, 0xC7, 0xF8,
  0x3F, 0xCF, 0xE0, 0x7F, 0xBF, 0xC0, 0x7F, 0x7F, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x40, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFE,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x3F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8,
  0x0F, 0xCF, 0xC0, 0xFC, 0x3E, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0xC7, 0xE0,
  0x7E, 0x3F, 0x01, 0xF3, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xF0,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC,
  0xFF, 0x1F, 0xC7, 0xF8, 0xFE, 0x1F, 0x83, 0xF0, 0x7C, 0x00, 0x60, 0x02,
  0x07, 0xF9, 0xF8, 0x1F, 0xFB, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0xFF,
  0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0xE0,
  0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF0, 0xFF, 0x0F, 0xE1, 0xFE, 0x3F,
  0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFD, 0xF8,
  0x0F, 0xFB, 0xF0, 0x0F, 0xC7, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0xC0, 0x1F, 0xDF, 0xC0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFC, 0xFF, 0x1F, 0xE1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0,
  0xFF, 0x1F, 0xC3, 0xFC, 0xFE, 0x0F, 0xF3, 0xF8, 0x3F, 0xCF, 0xE1, 0xFE,
  0x3F, 0x87, 0xF9, 0xFF, 0x3F, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xEF, 0xF8, 0x3F, 0x1F, 0xC0, 0x00, 0x1E,
  0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x87, 0xFF, 0xE1, 0xFE, 0x04, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x01, 0x1F, 0xF0, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0,
  0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x61, 0xFE, 0x03, 0xF9,
  0xFC, 0x07, 0xFD, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xC7, 0xF8, 0x3F, 0xC7, 0xF8, 0x7F, 0x87,
  0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x07,
  0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFF, 0x1F,
  0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xEF, 0xC0, 0x1F, 0xCF, 0xC0, 0x00, 0x0C, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F,
  0x0F, 0xE7, 0xF8, 0x7F, 0x3F, 0x87, 0xFB, 0xFC, 0x7F, 0x9F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xF0, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x04, 0x1F, 0xE1, 0xE0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC4, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x8F, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x01, 0x00, 0xFE, 0x7E, 0x03, 0xFF,
  0x7E, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xE3, 0xFC, 0x1F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3,
  0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x87,
  0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x87, 0xF0, 0x7F, 0x8F, 0xF0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xEF,
  0xE0, 0x0F, 0xDF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x80, 0x3F,
  0xC0, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0xC0,
  0x0F, 0xEF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xF8, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F,
  0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0xC7, 0xF8,
  0x7F, 0x8F, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF8, 0xFF, 0x0F,
  0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE1, 0xFE,
  0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF0, 0x00, 0x70, 0x07, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x18, 0x00, 0x00, 0x00, 0x20,
  0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0,
  0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x09, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xF0, 0x7F, 0x0F, 0xF8, 0x3F,
  0xC3, 0xFC, 0x0F, 0xF1, 0xFE, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x7F, 0x80,
  0x3F, 0xBF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x1F, 0xE7, 0xF8, 0x07,
  0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x1F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F,
  0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x00, 0xC0, 0x1C, 0x01, 0xF9, 0xFE, 0x1F, 0xC0,
  0x7E, 0xFF, 0xCF, 0xF8, 0x3F, 0xFF, 0xF7, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xC7, 0xFC,
  0x7F, 0x1F, 0xE1, 0xFE, 0x1F, 0xC7, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x1F,
  0xC3, 0xFC, 0x7F, 0x0F, 0xF0, 0xFF, 0x1F, 0xC3, 0xFC, 0x3F, 0x8F, 0xF0,
  0xFF, 0x0F, 0xE3, 0xFC, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE1, 0xFE, 0x3F,
  0x87, 0xF8, 0x7F, 0x9F, 0xE1, 0xFE, 0x1F, 0xC7, 0xF8, 0x7F, 0x07, 0xF1,
  0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0x07, 0xF0, 0xFF, 0x1F, 0xC3, 0xFC, 0x3F,
  0xCF, 0xF0, 0xFF, 0x0F, 0xE3, 0xFC, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0xC0,
  0x0F, 0xCF, 0xF0, 0x1F, 0xBF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xF8, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F,
  0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0xC7, 0xF8,
  0x7F, 0x8F, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF8, 0xFF, 0x0F,
  0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE1, 0xFE,
  0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0x9F,
  0xE7, 0xF8, 0xFF, 0x3F, 0xC3, 0xFB, 0xFC, 0x1F, 0xDF, 0xE1, 0xFE, 0xFF,
  0x0F, 0xF7, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xDF, 0xE1, 0xFE,
  0xFF, 0x0F, 0xF7, 0xF8, 0xFF, 0x1F, 0xEF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF,
  0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x60,
  0x01, 0xF9, 0xFC, 0x01, 0xFB, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xF8, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF,
  0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F, 0xE1, 0xFE, 0x0F, 0xE1, 0xFE,
  0x1F, 0xF3, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x3F, 0xDF, 0xE0, 0x3F, 0xCF, 0xC0, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x60, 0x02, 0x03, 0xF9, 0xF8, 0x1F, 0xFB, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F,
  0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC,
  0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F, 0x87,
  0xF0, 0xFF, 0x0F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xF7, 0xF0, 0x0F, 0xDF, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0xFC, 0xFC, 0x1F, 0xBF,
  0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xF1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xF0, 0x60, 0xFE, 0x04, 0x1F, 0xE0, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x98, 0x0F, 0xF3, 0xF7, 0xFE, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x3F, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x08, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF,
  0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC3, 0xFC, 0xFF, 0x0F,
  0xF3, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x1F, 0xE7,
  0xF8, 0x7F, 0x9F, 0xE1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x3F, 0xC7, 0xF0,
  0xFF, 0x3F, 0xC3, 0xFC, 0xFF, 0x0F, 0xE3, 0xF8, 0x7F, 0x8F, 0xE1, 0xFE,
  0x3F, 0x87, 0xF8, 0xFE, 0x3F, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0x7E, 0x03, 0xF9, 0xF8, 0x00, 0xFF,
  0x03, 0xFF, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC3, 0xFC, 0x7F, 0x0F,
  0xE1, 0xFC, 0x7F, 0x87, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x3F, 0x81,
  0xFC, 0xFE, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0x07, 0xF8, 0x3F, 0xBF,
  0x87, 0xFC, 0x3F, 0x9F, 0xC3, 0xFE, 0x1F, 0xCF, 0xE1, 0xFF, 0x1F, 0xE7,
  0xF1, 0xFF, 0x8F, 0xE3, 0xF8, 0xFF, 0xC7, 0xF0, 0xFC, 0xFF, 0xE7, 0xF0,
  0x7E, 0x7D, 0xF3, 0xF8, 0x3F, 0x3E, 0xFB, 0xF8, 0x1F, 0xBF, 0x7D, 0xFC,
  0x0F, 0xDF, 0x7E, 0xFC, 0x07, 0xEF, 0xBF, 0xFE, 0x03, 0xFF, 0xDF, 0xFF,
  0x01, 0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x7F, 0xE3, 0xFF,
  0x80, 0x3F, 0xF1, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F,
  0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x7F, 0xE0, 0xFF, 0x0F, 0xF0, 0x0F, 0xF3, 0xFE,
  0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F,
  0x80, 0xFF, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0x87,
  0xF0, 0x07, 0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03,
  0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC,
  0x00, 0x3F, 0xBF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0x80, 0x0E, 0x00, 0x00, 0x1F,
  0x00, 0x17, 0xFE, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xE8, 0x01, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 14, 31, 12, 0, -30 },
  { 56, 17, 11, 19, 4, -30 },
  { 80, 26, 30, 25, 0, -30 },
  { 178, 22, 34, 23, 1, -32 },
  { 272, 34, 30, 37, 2, -30 },
  { 400, 29, 30, 29, 0, -30 },
  { 509, 8, 11, 10, 4, -30 },
  { 520, 16, 38, 14, 1, -31 },
  { 596, 16, 38, 14, -3, -31 },
  { 672, 19, 20, 21, 3, -32 },
  { 720, 20, 20, 23, 2, -25 },
  { 770, 11, 11, 12, -2, -5 },
  { 786, 13, 6, 13, 0, -14 },
  { 796, 8, 8, 12, 0, -7 },
  { 804, 24, 30, 19, -2, -30 },
  { 894, 21, 30, 23, 1, -30 },
  { 973, 18, 30, 23, 3, -30 },
  { 1041, 23, 30, 23, -1, -30 },
  { 1128, 22, 30, 23, 0, -30 },
  { 1211, 23, 30, 23, 0, -30 },
  { 1298, 22, 30, 23, 1, -30 },
  { 1381, 21, 30, 23, 2, -30 },
  { 1460, 24, 30, 23, 1, -30 },
  { 1550, 22, 30, 23, 1, -30 },
  { 1633, 20, 30, 23, 2, -30 },
  { 1708, 12, 25, 12, 0, -24 },
  { 1746, 14, 30, 12, -2, -24 },
  { 1799, 20, 22, 23, 2, -26 },
  { 1854, 20, 15, 23, 2, -22 },
  { 1892, 20, 22, 23, 2, -26 },
  { 1947, 18, 31, 19, 2, -30 },
  { 2017, 33, 34, 35, 1, -30 },
  { 2158, 26, 30, 26, -2, -30 },
  { 2256, 25, 30, 25, 0, -30 },
  { 2350, 24, 30, 24, 2, -30 },
  { 2440, 26, 30, 27, 0, -30 },
  { 2538, 23, 30, 21, 0, -30 },
  { 2625, 23, 30, 21, 0, -30 },
  { 2712, 25, 30, 27, 2, -30 },
  { 2806, 28, 30, 28, 0, -30 },
  { 2911, 22, 30, 17, -2, -30 },
  { 2994, 22, 39, 14, -7, -30 },
  { 3102, 29, 30, 26, 0, -30 },
  { 3211, 18, 30, 20, 0, -30 },
  { 3279, 36, 30, 36, 0, -30 },
  { 3414, 31, 30, 30, 0, -30 },
  { 3531, 26, 30, 28, 2, -30 },
  { 3629, 24, 30, 24, 0, -30 },
  { 3719, 26, 37, 28, 2, -30 },
  { 3840, 24, 30, 25, 0, -30 },
  { 3930, 22, 30, 21, 0, -30 },
  { 4013, 21, 30, 21, 3, -30 },
  { 4092, 26, 30, 27, 2, -30 },
  { 4190, 25, 30, 24, 3, -30 },
  { 4284, 37, 30, 36, 3, -30 },
  { 4423, 31, 30, 25, -3, -30 },
  { 4540, 23, 30, 24, 4, -30 },
  { 4627, 26, 30, 21, -2, -30 },
  { 4725, 18, 38, 14, -1, -31 },
  { 4811, 11, 30, 19, 4, -30 },
  { 4853, 18, 38, 14, -3, -31 },
  { 4939, 21, 20, 21, 0, -30 },
  { 4992, 19, 5, 18, -4, 3 },
  { 5004, 10, 7, 14, 6, -32 },
  { 5013, 23, 24, 24, 1, -24 },
  { 5082, 22, 32, 24, 0, -32 },
  { 5170, 19, 24, 20, 1, -24 },
  { 5227, 24, 32, 24, 1, -32 },
  { 5323, 21, 24, 23, 1, -24 },
  { 5386, 24, 42, 16, -4, -32 },
  { 5512, 24, 34, 24, 0, -24 },
  { 5614, 23, 32, 24, 0, -32 },
  { 5706, 14, 33, 13, 0, -33 },
  { 5764, 19, 43, 13, -5, -33 },
  { 5867, 26, 32, 24, 0, -32 },
  { 5971, 14, 32, 13, 0, -32 },
  { 6027, 34, 24, 36, 0, -24 },
  { 6129, 23, 24, 24, 0, -24 },
  { 6198, 21, 24, 24, 1, -24 },
  { 6261, 24, 34, 24, -2, -24 },
  { 6363, 23, 34, 24, 1, -24 },
  { 6461, 19, 24, 17, 0, -24 },
  { 6518, 19, 24, 19, 0, -24 },
  { 6575, 16, 28, 17, 2, -28 },
  { 6631, 22, 23, 24, 2, -23 },
  { 6695, 22, 23, 22, 2, -23 },
  { 6759, 33, 23, 32, 2, -23 },
  { 6854, 27, 23, 22, -2, -23 },
  { 6932, 27, 33, 22, -3, -23 },
  { 7044, 21, 23, 19, -1, -23 },
  { 7105, 18, 37, 15, 0, -30 },
  { 7189, 5, 42, 21, 8, -32 },
  { 7216, 17, 37, 15, -2, -30 },
  { 7295, 20, 8, 23, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC42PT7B_H_
