#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC67PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFC, 0x7F, 0xF3, 0xFF, 0x87, 0xFF, 0x3F,
  0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xC7,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFC, 0x1F, 0xF8, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0,
  0xFF, 0x83, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x1F, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x00,
  0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0x3F,
  0xC1, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x1F,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x00,
  0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF3, 0xC3, 0xF0, 0x3F, 0xF8, 0xF0, 0x18,
  0x0F, 0xFE, 0x7C, 0x02, 0x03, 0xFF, 0x9F, 0x00, 0x00, 0xFF, 0xE7, 0xC0,
  0x00, 0x3F, 0xFD, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xF3, 0xFF, 0x80, 0x00, 0x7C, 0xFF, 0xE2, 0x00, 0x1F, 0x3F,
  0xF8, 0xE0, 0x07, 0xCF, 0xFC, 0x3E, 0x01, 0xE3, 0xFF, 0x0F, 0xF0, 0x79,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF,
  0x87, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xF0, 0x00,
  0x7F, 0xE1, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x3F, 0xE1, 0xFF,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0xFF, 0xC7, 0xFC, 0x1F, 0xF0, 0x7F, 0xC7, 0xFC, 0x7F, 0xE3, 0xFF, 0xE3,
  0xFE, 0x7F, 0xE3, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xE3, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF3, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xF3,
  0xFF, 0xFF, 0xDF, 0xFF, 0xF1, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F,
  0xF1, 0xFF, 0xDF, 0xF1, 0xFF, 0xF0, 0xFF, 0x8F, 0xF8, 0xFF, 0x87, 0xFE,
  0x0F, 0xF8, 0xFF, 0xC3, 0xFC, 0x03, 0x00, 0xFF, 0x87, 0xFC, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x1F, 0xF8, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF3, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF1, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x1F, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x83, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE7, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x8F,
  0xFE, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x02, 0x00, 0xFF, 0x80, 0x06, 0x01, 0xFE, 0x00, 0x1F, 0x03, 0xFC,
  0x00, 0x3F, 0x87, 0xF8, 0x00, 0x7F, 0xCF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x7B, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xF0,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xF9, 0xFF, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x3F,
  0xC7, 0xFE, 0x00, 0x3F, 0x07, 0xFE, 0x00, 0x3C, 0x0F, 0xFC, 0x00, 0x18,
  0x1F, 0xC0, 0x00, 0x20, 0x3E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0x03, 0xC0, 0xFF, 0x8F, 0xFE, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0xFF, 0x81,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x7F, 0xFC, 0x0F, 0xFF, 0x1F, 0xFE, 0x03, 0xFF,
  0xC7, 0xFF, 0x80, 0xFF, 0xF3, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xF0, 0x0F,
  0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0xE7, 0xFF, 0xC0,
  0x7F, 0xF9, 0xFF, 0xE0, 0x1F, 0xFE, 0x7F, 0xF8, 0x07, 0xFF, 0x9F, 0xFE,
  0x01, 0xFF, 0xE7, 0xFF, 0x80, 0xFF, 0xF9, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF,
  0xF0, 0x0F, 0xFF, 0x3F, 0xFC, 0x03, 0xFF, 0xCF, 0xFF, 0x01, 0xFF, 0xF3,
  0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xF0, 0x1F, 0xFE, 0x3F, 0xFC, 0x07, 0xFF,
  0x8F, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F,
  0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xF7, 0xFF, 0x0F, 0xFF, 0x7F, 0xF8, 0x3F, 0xF3, 0xFF, 0xC0, 0xFF,
  0x1F, 0xFC, 0x07, 0xE1, 0xFF, 0xE0, 0x1E, 0x0F, 0xFF, 0x00, 0x60, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0xF0, 0x01,
  0xF8, 0x0F, 0xFF, 0x80, 0x0F, 0x80, 0x7F, 0xFC, 0x00, 0x38, 0x03, 0xFF,
  0xE0, 0x00, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x1E, 0x01, 0xFF, 0xF0, 0x03, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x88, 0x00, 0x01, 0xFF, 0xF1, 0x80, 0x00, 0x7F, 0xFE,
  0x3E, 0x00, 0x1F, 0xFF, 0xC7, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0x7F, 0xF0, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xF0, 0x00,
  0x7F, 0xCF, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0x8F, 0xFE,
  0x00, 0x1F, 0xF1, 0xFF, 0xE0, 0x03, 0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xE1,
  0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x1F,
  0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xEF, 0xFF, 0xF8, 0x00, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x40, 0x00, 0x1F, 0xFF, 0x0C, 0x00, 0x07, 0xFF, 0xE1, 0xE0,
  0x01, 0xFF, 0xF8, 0x3F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x1F, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC3, 0xF8, 0x00, 0x7F,
  0xF9, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xFC, 0x03, 0xFF, 0xDF, 0xFF, 0xC0,
  0x7F, 0xF7, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF,
  0xF8, 0x1F, 0xFE, 0x3F, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x7F, 0xF8,
  0xFF, 0xF8, 0x1F, 0xFF, 0x1F, 0xFF, 0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0x7F,
  0xF8, 0x7F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0xE7, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xFC,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x8F, 0xFF, 0x81, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x3F, 0xFC, 0x7F, 0xF8, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0xFF,
  0xE1, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xC1,
  0xFF, 0xF0, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xF7, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF1,
  0xFF, 0xF0, 0x7F, 0xF8, 0xFF, 0xF0, 0x3F, 0xFC, 0x7F, 0xF8, 0x1F, 0xFE,
  0x7F, 0xFC, 0x0F, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0x9F, 0xFE, 0x03, 0xFF,
  0xCF, 0xFF, 0x01, 0xFF, 0xE7, 0xFF, 0x81, 0xFF, 0xF3, 0xFF, 0xC0, 0xFF,
  0xF9, 0xFF, 0xE0, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0x7F, 0xF0, 0x1F, 0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0xFE,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x81, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFB, 0xFF,
  0xF1, 0xF8, 0x0F, 0xFF, 0x0E, 0x00, 0x7F, 0xF0, 0x80, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x03, 0xFC, 0x03, 0xFE,
  0x07, 0xFE, 0x01, 0xFF, 0xFC, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0xFF, 0xF1,
  0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0xFF, 0x1F, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF1, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0xE1, 0xFE, 0x0F, 0xF3, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF3, 0xFC,
  0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x7F, 0x83, 0xFE, 0x03, 0xFC, 0x0F, 0xF7,
  0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x1F,
  0xE7, 0xF8, 0x7F, 0xC0, 0x7F, 0x81, 0xFE, 0x7F, 0x87, 0xFC, 0x0F, 0xF8,
  0x1F, 0xEF, 0xF8, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0xFF, 0x07, 0xF8, 0x0F,
  0xF0, 0x3F, 0xCF, 0xF0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xF8,
  0x1F, 0xF0, 0x7F, 0x8F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0xF8, 0xFF, 0x07,
  0xFC, 0x7F, 0xF1, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0x83, 0xFF, 0xF3, 0xFF, 0xF8, 0x07, 0xF8, 0x1F, 0xFE, 0x3F, 0xFE,
  0x00, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x9F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x7F, 0xF7, 0xFE, 0x00,
  0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x9F, 0xFC, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x7F, 0xF1,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x87, 0xFF, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x1F, 0xFE,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x7F,
  0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x87, 0xFF, 0xC0, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x9F,
  0xFF, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x7F, 0xFB, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x1F,
  0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F,
  0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF,
  0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xF8,
  0x07, 0xFF, 0xF0, 0x01, 0xC0, 0x3F, 0xFF, 0x80, 0x01, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x60, 0x07, 0xFF, 0xE0, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF3, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x7F,
  0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x0F,
  0xFF, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xFC,
  0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFE,
  0x01, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x70,
  0x07, 0xFF, 0xE0, 0x00, 0x10, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F,
  0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xFF, 0xF8,
  0x7F, 0xF8, 0x1F, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x06, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0x81, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xE1, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x8F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFD, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFB, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x8F,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xDF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xDF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xEF, 0xF8, 0x1F, 0xF7, 0xFF, 0x00, 0x7F, 0xF7,
  0xFC, 0x1F, 0xFB, 0xFF, 0x80, 0x3F, 0xFB, 0xFE, 0x0F, 0xFB, 0xFF, 0x80,
  0x1F, 0xFD, 0xFF, 0x0F, 0xFD, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0x87, 0xFC,
  0xFF, 0xE0, 0x0F, 0xFE, 0x7F, 0xC7, 0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0x3F,
  0xE3, 0xFE, 0x7F, 0xF8, 0x03, 0xFF, 0x9F, 0xF1, 0xFF, 0x3F, 0xF8, 0x01,
  0xFF, 0xCF, 0xF9, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xE7, 0xFC, 0xFF, 0x8F,
  0xFE, 0x00, 0xFF, 0xF3, 0xFE, 0xFF, 0xCF, 0xFF, 0x00, 0x7F, 0xF1, 0xFF,
  0x7F, 0xC7, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0x80, 0x1F,
  0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF,
  0xE0, 0x0F, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x0F, 0xFF,
  0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xF8, 0x01, 0xFF,
  0xC3, 0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x1F, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0,
  0x0F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xC0,
  0x7F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x7F, 0xF0, 0x3F,
  0xF8, 0x01, 0xFF, 0xBF, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xDF, 0xFC, 0x0F,
  0xFE, 0x00, 0x7F, 0xEF, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0x87,
  0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0xE1,
  0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC,
  0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0x87, 0xFF,
  0x3F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xE0, 0xFF,
  0xEF, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF7, 0xFE, 0x00, 0x7F, 0xF0, 0x3F,
  0xFB, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x3F,
  0xFF, 0x00, 0x3F, 0xFE, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0x8F, 0xFF, 0x80, 0x03, 0xFF, 0xCF, 0xFF, 0x80, 0x01, 0xFF,
  0xE7, 0xFF, 0xC0, 0x00, 0xFF, 0xF3, 0xFF, 0xE0, 0x00, 0x7F, 0xFB, 0xFF,
  0xE0, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xBF, 0xFC, 0x00, 0x07, 0xFF,
  0xBF, 0xFE, 0x00, 0x03, 0xFF, 0xDF, 0xFF, 0x00, 0x03, 0xFF, 0xEF, 0xFF,
  0x80, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0xFF, 0xF3, 0xFF, 0xE0, 0x00,
  0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F,
  0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x3F,
  0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x1F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x8F, 0xFF, 0x80, 0x03, 0xFF,
  0xCF, 0xFF, 0x80, 0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0xFF, 0xF3, 0xFF,
  0xC0, 0x00, 0x7F, 0xFB, 0xFF, 0xE0, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0xBF, 0xFC, 0x00, 0x07, 0xFF, 0xBF, 0xFE, 0x00, 0x07, 0xFF, 0xDF, 0xFF,
  0x00, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x00,
  0xFF, 0xF3, 0xFF, 0xE0, 0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x3F, 0xFE,
  0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0,
  0x7F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC7, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xE7, 0xFF, 0x80, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x1F, 0xFE, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x0F, 0xFF,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xFC,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0xE3, 0xFF, 0xC0,
  0x0F, 0xFF, 0x8F, 0xFF, 0x00, 0x3F, 0xFE, 0x3F, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0x00, 0x3F,
  0xFC, 0x00, 0x20, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFC, 0x04, 0x00, 0x03, 0xFF, 0xC0, 0x70, 0x00, 0x7F, 0xFC, 0x07, 0xC0,
  0x07, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF3, 0xFF, 0xC0, 0x03, 0xFF, 0xE7, 0xFF,
  0x80, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x1F, 0xFF, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF,
  0xF0, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x1F,
  0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x03,
  0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00,
  0x3F, 0xF8, 0xFF, 0xF0, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x00, 0xFF, 0xE7,
  0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x03, 0xFF, 0xBF, 0xFC, 0x00,
  0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFB,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF9, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xC7, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xC3, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x1F,
  0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFE, 0x03,
  0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFF, 0xE0,
  0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0xC1,
  0xFF, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xF0,
  0x07, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0xFF,
  0xC7, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xF0, 0x03, 0xFF,
  0x0F, 0xFB, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x7F, 0xE7, 0xFF,
  0x80, 0x0F, 0xFC, 0x7F, 0xEF, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0x9F, 0xF9,
  0xFF, 0x9F, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xE7, 0xFF, 0x80, 0x07,
  0xFE, 0x7F, 0xC7, 0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xDF, 0xF8, 0xFF, 0x9F,
  0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x1F, 0xF7, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC3, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xDF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF1, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x8F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFD, 0xFF,
  0xF0, 0x07, 0xFF, 0xC7, 0xFF, 0x80, 0x3F, 0xFE, 0x3F, 0xFC, 0x03, 0xFF,
  0xE1, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x80,
  0x7F, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x0F, 0xFE, 0x3F,
  0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x07, 0xFC,
  0x7F, 0xC0, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x0F,
  0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x1F,
  0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xE3, 0xFF, 0x00,
  0x07, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF1, 0xFF,
  0xF1, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x03, 0xFE,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x03,
  0xFF, 0x00, 0x7F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFF, 0xE7, 0xFE, 0x01, 0xFF,
  0xFE, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x83,
  0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x7F,
  0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF8,
  0x0F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xFC,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xFB, 0xFF, 0x00, 0x0F, 0xFF,
  0x3F, 0xF0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x0F, 0x00, 0x00, 0xFF, 0xF3, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xF0,
  0x01, 0xFF, 0xEF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x3F, 0xFF,
  0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x81,
  0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x7F,
  0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE,
  0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFE, 0x03,
  0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF,
  0xE0, 0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xF3, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0xFF, 0xFF, 0x80,
  0x7F, 0xE7, 0xFF, 0xF0, 0x0F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x1E, 0x07,
  0xFF, 0xC0, 0x18, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x10, 0x3F,
  0xFE, 0x01, 0xC0, 0x7F, 0xFC, 0x3F, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x78, 0x1F, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xF8, 0x00, 0x3F,
  0xFC, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC7, 0xFF, 0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x07,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFE, 0x00,
  0xFF, 0xF8, 0x7F, 0xFC, 0x01, 0xFF, 0xF9, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xFE, 0x7F, 0xE0,
  0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0xC0, 0x7F,
  0xF1, 0xFF, 0xE0, 0x7F, 0xF9, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xF0, 0x3F,
  0xFC, 0xFF, 0xF8, 0x7F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x04, 0x0F, 0xFF, 0x80, 0x1E, 0x03, 0xFF,
  0xF0, 0x7F, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFC, 0x60, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0xF1, 0xFF, 0x80, 0x0F, 0xFF,
  0xE7, 0xFE, 0x00, 0x7F, 0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0x3F, 0xFF, 0x01,
  0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFE, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x1F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF,
  0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x3F, 0xFF, 0x3F, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF7, 0xFF, 0x00, 0x07, 0xFF,
  0xBF, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x08, 0x00, 0x0F, 0xFF, 0x80, 0x3C, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0x8F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x07, 0x80, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x7F,
  0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x03,
  0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF,
  0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFC, 0x07,
  0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x01, 0xFF, 0xE7, 0xFF,
  0x80, 0x00, 0x7F, 0xFB, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x00,
  0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x1F, 0xFE, 0x07, 0xFF,
  0xC0, 0x0F, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0xFE,
  0x7F, 0xFF, 0xC0, 0x3F, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF,
  0xE1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00,
  0xFF, 0x8F, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0xFC, 0x01, 0xFF, 0xBF, 0xFF,
  0xE0, 0x1F, 0xFB, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xF1, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFE, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0,
  0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF,
  0x83, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xE3, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xF1, 0xFF, 0xE0, 0x7F, 0xF9, 0xFF,
  0xF0, 0x3F, 0xFC, 0xFF, 0xF0, 0x1F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F,
  0xFC, 0x07, 0xFF, 0xBF, 0xFC, 0x03, 0xFF, 0xDF, 0xFE, 0x01, 0xFF, 0xEF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFB,
  0xFF, 0xC0, 0x3F, 0xFD, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFF,
  0x7F, 0xF8, 0x0F, 0xFF, 0x3F, 0xFC, 0x0F, 0xFF, 0x9F, 0xFF, 0x07, 0xFF,
  0x8F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFF,
  0x80, 0x01, 0xFF, 0x9F, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xF9, 0xFF, 0xF8, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x07, 0xFF, 0x83,
  0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x80,
  0x7F, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0,
  0x7F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0xFC,
  0x00, 0x7F, 0xF3, 0xFF, 0xF0, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x03, 0xFF,
  0xC3, 0xFE, 0x00, 0x07, 0xFF, 0x81, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xFC, 0x7F, 0xE0,
  0x0F, 0xFF, 0xE7, 0xFE, 0x01, 0xFF, 0xFE, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x8F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xFC,
  0x07, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF,
  0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0,
  0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F,
  0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xF7, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xCF, 0xFF,
  0x00, 0x00, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xF8, 0x7F,
  0xC0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0xFF, 0xE0,
  0x1F, 0xFB, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x20, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0x07, 0xFF, 0x80, 0x70, 0x3F, 0xFC, 0x00, 0x81, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x20, 0x01,
  0xFF, 0xF1, 0x80, 0x0F, 0xFF, 0x8F, 0x00, 0x7F, 0xFC, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFC, 0x87, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0x01, 0x01, 0xFF, 0xF9, 0xE0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFC,
  0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07,
  0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x83, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x07, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xCF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFD, 0xFF, 0x80, 0x3F, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0xF1, 0xFF, 0x80,
  0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x1F, 0xFF, 0x3F, 0xF8,
  0x03, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F,
  0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xFE,
  0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F,
  0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xE0, 0x0F, 0xFE,
  0x3F, 0xFC, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x07,
  0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFD, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0x7F, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xF9, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x3F, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xC7,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFE,
  0x1F, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0xF8, 0x7F,
  0xF8, 0x7F, 0xF1, 0xFF, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x3F, 0xDF, 0xE3,
  0xFF, 0xC1, 0xFF, 0xC7, 0xFB, 0xFC, 0x7F, 0xF0, 0x3F, 0xF9, 0xFF, 0x7F,
  0x8F, 0xFE, 0x07, 0xFF, 0x3F, 0xDF, 0xF3, 0xFF, 0x80, 0xFF, 0xE7, 0xFB,
  0xFE, 0x7F, 0xF0, 0x1F, 0xFD, 0xFF, 0x7F, 0xDF, 0xFC, 0x03, 0xFF, 0xBF,
  0xCF, 0xFB, 0xFF, 0x80, 0x7F, 0xF7, 0xF9, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xBF, 0xC7, 0xFB, 0xFF, 0x80, 0x3F,
  0xF7, 0xF8, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0xFF,
  0xF0, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE1,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x8F, 0xFF,
  0x00, 0x00, 0xFF, 0xF3, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0xCF, 0xFF, 0x00, 0x01, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x7F,
  0xF8, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xDF, 0xFC, 0x00, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x00, 0x0F, 0xFD, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0x3F, 0xFE, 0x00, 0x03, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0xE0, 0x03, 0xFF, 0xFC, 0x80,
  0x00, 0x7F, 0xF8, 0x80, 0x00, 0x03, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 22, 49, 19, 0, -48 },
  { 136, 28, 17, 30, 6, -48 },
  { 196, 42, 48, 40, 0, -48 },
  { 448, 34, 55, 36, 2, -51 },
  { 682, 53, 50, 59, 4, -49 },
  { 1014, 46, 50, 46, 0, -49 },
  { 1302, 14, 17, 16, 6, -48 },
  { 1332, 26, 60, 23, 2, -49 },
  { 1527, 26, 60, 23, -5, -49 },
  { 1722, 31, 32, 34, 5, -51 },
  { 1846, 32, 33, 37, 3, -40 },
  { 1978, 18, 18, 19, -4, -9 },
  { 2019, 20, 10, 22, 1, -23 },
  { 2044, 13, 13, 19, 0, -12 },
  { 2066, 38, 50, 30, -3, -49 },
  { 2304, 34, 50, 36, 2, -49 },
  { 2517, 29, 48, 36, 5, -48 },
  { 2691, 37, 49, 36, -2, -49 },
  { 2918, 35, 50, 36, 0, -49 },
  { 3137, 36, 48, 36, 0, -48 },
  { 3353, 35, 49, 36, 1, -48 },
  { 3568, 35, 50, 36, 2, -49 },
  { 3787, 38, 48, 36, 1, -48 },
  { 4015, 35, 50, 36, 1, -49 },
  { 4234, 33, 50, 36, 2, -49 },
  { 4441, 19, 39, 20, 0, -38 },
  { 4534, 23, 47, 20, -4, -38 },
  { 4670, 32, 36, 37, 3, -42 },
  { 4814, 32, 23, 37, 3, -35 },
  { 4906, 32, 36, 37, 3, -42 },
  { 5050, 28, 50, 30, 4, -49 },
  { 5225, 52, 55, 55, 2, -49 },
  { 5583, 42, 48, 42, -4, -48 },
  { 5835, 38, 48, 40, 1, -48 },
  { 6063, 38, 50, 38, 3, -49 },
  { 6301, 40, 48, 42, 1, -48 },
  { 6541, 36, 48, 34, 1, -48 },
  { 6757, 35, 48, 34, 1, -48 },
  { 6967, 40, 50, 43, 3, -49 },
  { 7217, 44, 48, 44, 1, -48 },
  { 7481, 33, 48, 27, -2, -48 },
  { 7679, 35, 63, 23, -11, -48 },
  { 7955, 46, 48, 41, 1, -48 },
  { 8231, 28, 48, 32, 1, -48 },
  { 8399, 57, 48, 57, 1, -48 },
  { 8741, 49, 48, 48, 1, -48 },
  { 9035, 41, 50, 45, 3, -49 },
  { 9292, 38, 48, 38, 1, -48 },
  { 9520, 41, 60, 45, 3, -49 },
  { 9828, 38, 48, 40, 1, -48 },
  { 10056, 36, 50, 34, 0, -49 },
  { 10281, 33, 48, 34, 5, -48 },
  { 10479, 41, 49, 43, 3, -48 },
  { 10731, 39, 48, 39, 5, -48 },
  { 10965, 59, 48, 58, 5, -48 },
  { 11319, 49, 48, 40, -4, -48 },
  { 11613, 37, 48, 38, 6, -48 },
  { 11835, 41, 48, 34, -3, -48 },
  { 12081, 29, 60, 22, -2, -49 },
  { 12299, 17, 50, 30, 7, -49 },
  { 12406, 30, 60, 22, -5, -49 },
  { 12631, 35, 32, 34, -1, -48 },
  { 12771, 30, 8, 29, -6, 4 },
  { 12801, 15, 10, 23, 10, -51 },
  { 12820, 36, 39, 38, 2, -38 },
  { 12996, 36, 52, 38, 0, -51 },
  { 13230, 30, 39, 31, 2, -38 },
  { 13377, 39, 52, 38, 2, -51 },
  { 13631, 33, 39, 36, 2, -38 },
  { 13792, 39, 67, 25, -7, -51 },
  { 14119, 38, 54, 38, 0, -38 },
  { 14376, 36, 51, 38, 0, -51 },
  { 14606, 22, 52, 20, 0, -52 },
  { 14749, 32, 68, 20, -9, -52 },
  { 15021, 42, 51, 38, 0, -51 },
  { 15289, 23, 51, 20, 0, -51 },
  { 15436, 55, 38, 57, 0, -38 },
  { 15698, 36, 38, 38, 0, -38 },
  { 15869, 33, 39, 38, 2, -38 },
  { 16030, 39, 54, 38, -3, -38 },
  { 16294, 36, 54, 38, 2, -38 },
  { 16537, 30, 38, 27, 0, -38 },
  { 16680, 29, 39, 31, 1, -38 },
  { 16822, 27, 45, 28, 2, -44 },
  { 16974, 36, 38, 38, 2, -37 },
  { 17145, 35, 37, 34, 3, -37 },
  { 17307, 51, 37, 52, 4, -37 },
  { 17543, 43, 37, 35, -4, -37 },
  { 17742, 42, 53, 34, -4, -37 },
  { 18021, 34, 37, 30, -2, -37 },
  { 18179, 29, 59, 24, 0, -48 },
  { 18393, 9, 66, 34, 12, -51 },
  { 18468, 28, 59, 24, -4, -48 },
  { 18675, 32, 13, 37, 3, -30 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic67pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC67PT7B_H_
