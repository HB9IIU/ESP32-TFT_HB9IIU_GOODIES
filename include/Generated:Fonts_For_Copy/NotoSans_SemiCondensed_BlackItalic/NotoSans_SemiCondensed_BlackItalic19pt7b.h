#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC19PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0xF3, 0xCF, 0x38, 0xE3, 0x9C, 0x70, 0x00, 0x3C, 0xF3, 0x80,
  0xFF, 0xEE, 0xEE, 0xEE, 0xCC, 0x06, 0x60, 0x6E, 0x0E, 0xC0, 0xCC, 0x7F,
  0xF7, 0xFF, 0x19, 0x81, 0x98, 0xFF, 0xEF, 0xFE, 0x33, 0x03, 0x70, 0x77,
  0x06, 0x60, 0x03, 0x03, 0xF3, 0xFC, 0xFF, 0x3E, 0x0F, 0x83, 0xE0, 0x7E,
  0x07, 0x83, 0xE6, 0xB9, 0xFE, 0xFF, 0x06, 0x01, 0x80, 0x18, 0x1C, 0xF8,
  0x71, 0xF8, 0xC7, 0x73, 0x0E, 0xEE, 0x1D, 0x98, 0x3F, 0x6F, 0xFD, 0xDF,
  0x77, 0x76, 0x0C, 0xCC, 0x39, 0x98, 0xE3, 0x71, 0x87, 0xC7, 0x0F, 0x00,
  0x07, 0x00, 0x7E, 0x07, 0xF0, 0x3B, 0x81, 0xDC, 0x0F, 0xC0, 0x7D, 0xE7,
  0xEF, 0x7F, 0x77, 0xBF, 0xBC, 0xF9, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0xFE,
  0xEE, 0xC0, 0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70,
  0x60, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x70, 0x1C, 0x18, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x18, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE0, 0x08, 0x07,
  0x13, 0x0F, 0x9F, 0xF8, 0xFC, 0xF8, 0xEC, 0x27, 0x02, 0x00, 0x1C, 0x0E,
  0x07, 0x1F, 0xFF, 0xFF, 0xFC, 0x70, 0x38, 0x1C, 0x00, 0x7B, 0x9D, 0xCE,
  0x00, 0x7D, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0,
  0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01,
  0xE0, 0x00, 0x0E, 0x1F, 0x8F, 0xEF, 0x77, 0x3F, 0x9F, 0x8F, 0xCF, 0xE7,
  0xF3, 0xBB, 0xDF, 0xCF, 0xE3, 0xE0, 0x03, 0x87, 0x87, 0xC7, 0xEF, 0x73,
  0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0x03, 0x81,
  0xF8, 0x7F, 0x8E, 0xF0, 0x9E, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3F, 0xE7, 0xF9, 0xFF, 0x00, 0x0F, 0x0F, 0xE3, 0xFC, 0x4F, 0x03,
  0xC1, 0xE1, 0xF0, 0x7C, 0x07, 0x80, 0xE8, 0x7B, 0xFE, 0xFF, 0x3F, 0x80,
  0x01, 0xC0, 0xF0, 0x7C, 0x1F, 0x0F, 0x87, 0xE3, 0xB8, 0xDE, 0x67, 0xBF,
  0xFF, 0xF8, 0x1C, 0x0F, 0x03, 0x80, 0x1F, 0xC7, 0xF1, 0xFC, 0xF0, 0x38,
  0x0F, 0xC3, 0xF9, 0xFE, 0x07, 0x80, 0xE8, 0x7B, 0xFE, 0xFF, 0x3F, 0x80,
  0x07, 0xC7, 0xE3, 0xF9, 0xE0, 0x70, 0x3F, 0xCF, 0xF3, 0xFE, 0xE7, 0xB9,
  0xEE, 0x73, 0xFC, 0xFE, 0x1F, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x80, 0xE0,
  0x3C, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x81,
  0xF0, 0x00, 0x07, 0x07, 0xF3, 0xFC, 0xE7, 0x39, 0xCF, 0xE1, 0xF0, 0xFC,
  0x7F, 0x9C, 0xEF, 0x3B, 0xDE, 0x7F, 0x0F, 0x80, 0x1E, 0x1F, 0x9F, 0xEE,
  0xFF, 0x3F, 0xBF, 0xDF, 0xFF, 0x7F, 0x13, 0x83, 0x9F, 0xCF, 0xC7, 0xC0,
  0x19, 0xCE, 0x70, 0x00, 0x00, 0xF7, 0xB8, 0x0C, 0x71, 0xC7, 0x00, 0x00,
  0x00, 0x01, 0xE7, 0x1C, 0xE3, 0x80, 0x00, 0x81, 0xC3, 0xE7, 0xCF, 0x87,
  0x81, 0xF8, 0x3F, 0x07, 0x80, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x80, 0x70, 0x3E, 0x0F, 0xC0, 0xF8, 0x3C, 0xFD, 0xF8, 0xF0,
  0x40, 0x00, 0x1C, 0x7F, 0x7F, 0x47, 0x07, 0x1E, 0x3C, 0x38, 0x70, 0x00,
  0x00, 0xF0, 0xF0, 0xE0, 0x03, 0xC0, 0x3F, 0xC3, 0xC3, 0x8C, 0x07, 0x73,
  0xEF, 0xBF, 0xBC, 0xCC, 0xF7, 0x33, 0xDC, 0xCF, 0x77, 0x6D, 0xFF, 0xB3,
  0xBC, 0xE0, 0x01, 0xE7, 0x03, 0xFC, 0x03, 0x80, 0x03, 0xE0, 0x3E, 0x07,
  0xE0, 0x7E, 0x0F, 0xE0, 0xEE, 0x1E, 0xE1, 0xCE, 0x1C, 0xE3, 0xFE, 0x3F,
  0xE7, 0x8E, 0x70, 0xFF, 0x0F, 0x1F, 0x03, 0xF8, 0x7F, 0x9E, 0xF3, 0xCE,
  0x73, 0xCF, 0xE1, 0xFC, 0x7B, 0xCF, 0x39, 0xCF, 0x3F, 0xEF, 0xF9, 0xFE,
  0x00, 0x07, 0x83, 0xFC, 0xFF, 0x3E, 0x67, 0x81, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x1C, 0x03, 0xC2, 0x7F, 0x87, 0xF0, 0x7E, 0x00, 0x1F, 0x01, 0xFC,
  0x1F, 0xE3, 0xDE, 0x3C, 0xF3, 0x8F, 0x38, 0xF3, 0x8E, 0x78, 0xE7, 0x9E,
  0x73, 0xC7, 0xFC, 0xFF, 0x8F, 0xE0, 0x1F, 0xC7, 0xF1, 0xFC, 0xF0, 0x3C,
  0x0E, 0x03, 0xF8, 0xFE, 0x78, 0x1E, 0x07, 0x01, 0xFC, 0xFF, 0x3F, 0xC0,
  0x1F, 0xC7, 0xF1, 0xFC, 0xF0, 0x3C, 0x0E, 0x03, 0xF8, 0xFE, 0x7F, 0x1E,
  0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x00, 0x07, 0xC3, 0xFC, 0xFF, 0xBE, 0x27,
  0x81, 0xE0, 0x3D, 0xFF, 0xBE, 0xE7, 0xDC, 0x7B, 0xCF, 0x7F, 0xC7, 0xF8,
  0x7F, 0x00, 0x1E, 0x78, 0xE3, 0xC7, 0x1C, 0x78, 0xE3, 0xC7, 0x1F, 0xF8,
  0xFF, 0xC7, 0xFC, 0x78, 0xE3, 0xCF, 0x1C, 0x78, 0xE3, 0xCF, 0x1C, 0x78,
  0xE0, 0x1F, 0xC7, 0xF1, 0xF8, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1E,
  0x07, 0x01, 0xC0, 0xF0, 0x7E, 0x3F, 0x80, 0x03, 0xC0, 0xF0, 0x38, 0x0E,
  0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07,
  0x81, 0xE3, 0xF0, 0xFC, 0x3E, 0x00, 0x1E, 0x78, 0xE7, 0x87, 0x3C, 0x7B,
  0xC3, 0xFC, 0x1D, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xDC, 0x1C, 0xE0,
  0xE7, 0x8F, 0x3C, 0x78, 0xF0, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38,
  0x38, 0x78, 0x78, 0x70, 0x7F, 0xFF, 0xFF, 0x1F, 0x0F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x6E, 0x77,
  0xEE, 0x77, 0xDE, 0x77, 0xDC, 0x77, 0x9C, 0xF7, 0x9C, 0xE7, 0x3C, 0x1E,
  0x1C, 0x78, 0x71, 0xF3, 0xCF, 0xCE, 0x3F, 0x38, 0xFC, 0xE3, 0xFB, 0x8E,
  0xFE, 0x73, 0xF1, 0xCF, 0xC7, 0x3F, 0x1C, 0x7C, 0xF1, 0xF3, 0x87, 0x80,
  0x07, 0x81, 0xFC, 0x3F, 0xE7, 0xDE, 0x78, 0xEF, 0x0F, 0xF0, 0xEF, 0x0E,
  0xE1, 0xEE, 0x1E, 0xF3, 0xCF, 0xFC, 0x7F, 0x83, 0xE0, 0x1F, 0x03, 0xF8,
  0x7F, 0x9E, 0xF3, 0xDE, 0x73, 0xCE, 0xF1, 0xFE, 0x7F, 0x8F, 0x01, 0xC0,
  0x38, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x81, 0xFC, 0x3F, 0xE7, 0xDE, 0x78,
  0xEF, 0x0F, 0xF0, 0xEF, 0x0E, 0xE1, 0xEE, 0x1E, 0xF3, 0xCF, 0xFC, 0x7F,
  0x83, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x1F, 0x03, 0xF8, 0x7F, 0x9E,
  0xF3, 0xDE, 0x73, 0xCF, 0xF1, 0xFE, 0x7F, 0x0F, 0xF1, 0xCE, 0x39, 0xEF,
  0x3D, 0xE3, 0x80, 0x07, 0x07, 0xF3, 0xFC, 0xE2, 0x38, 0x0F, 0x03, 0xE0,
  0x7C, 0x0F, 0x01, 0xE8, 0x73, 0xFC, 0xFF, 0x3F, 0x00, 0x7F, 0xDF, 0xF7,
  0xFA, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0,
  0x78, 0x1C, 0x00, 0x38, 0xF3, 0x8E, 0x38, 0xE7, 0x9E, 0x79, 0xE7, 0x1E,
  0x71, 0xCF, 0x1C, 0xF3, 0xCF, 0x3C, 0xF3, 0x8F, 0xF8, 0x7F, 0x03, 0xE0,
  0xE1, 0xFC, 0x7B, 0x8F, 0x71, 0xCE, 0x79, 0xCE, 0x3B, 0xC7, 0x70, 0xEE,
  0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x00, 0xE3, 0x87, 0xE3, 0x8F,
  0xE7, 0x8E, 0xE7, 0x9E, 0xE7, 0x9C, 0xEF, 0x9C, 0xED, 0xBC, 0xFD, 0xB8,
  0xFD, 0xB8, 0xFB, 0xF0, 0xFB, 0xF0, 0xFB, 0xF0, 0xF3, 0xE0, 0xF3, 0xE0,
  0x1E, 0x3C, 0x79, 0xE0, 0xE7, 0x03, 0xBC, 0x0F, 0xE0, 0x3F, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0xC0, 0x7F, 0x03, 0xDC, 0x0E, 0x78, 0x79, 0xE3, 0xC7,
  0x80, 0xE3, 0xF8, 0xFE, 0x7B, 0xDC, 0x7F, 0x1F, 0x87, 0xC1, 0xF0, 0x78,
  0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x00, 0x1F, 0xF1, 0xFE, 0x1F, 0xE0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07,
  0xFC, 0xFF, 0x8F, 0xF8, 0x0F, 0x87, 0x87, 0x03, 0x81, 0xC0, 0xE0, 0x60,
  0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xD0, 0xF0, 0xF8, 0x00,
  0xE7, 0x39, 0xC6, 0x39, 0xCE, 0x73, 0x9C, 0x63, 0x9C, 0x1F, 0x1F, 0x06,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38,
  0xF8, 0xF0, 0x02, 0x01, 0xC0, 0xF0, 0x3C, 0x1F, 0x0E, 0xE3, 0x39, 0xC6,
  0xE1, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xEF, 0x70, 0x19, 0xCF, 0xE7, 0xFB,
  0xDE, 0xF3, 0xB9, 0xEE, 0x73, 0x9C, 0xFF, 0x3F, 0xC7, 0x70, 0x1E, 0x07,
  0x03, 0xC0, 0xFC, 0x3F, 0xCF, 0xF3, 0x9D, 0xE7, 0x71, 0xDC, 0xF7, 0x39,
  0xFE, 0xFF, 0x3B, 0xC0, 0x0E, 0x3F, 0x7F, 0xF2, 0xF0, 0xE0, 0xE0, 0xE0,
  0xFC, 0xFC, 0x7C, 0x01, 0xE0, 0x38, 0x0F, 0x0D, 0xE3, 0xF8, 0xFF, 0x3D,
  0xE7, 0x9C, 0xE7, 0x9C, 0xE3, 0x9C, 0x7F, 0x8F, 0xF0, 0xEE, 0x00, 0x0E,
  0x1F, 0x9F, 0xFE, 0x7E, 0x7F, 0xFB, 0xF1, 0xC0, 0xF2, 0x7F, 0x1F, 0x80,
  0x00, 0x80, 0x7C, 0x1F, 0x83, 0x80, 0x7C, 0x3F, 0x87, 0xF0, 0x78, 0x0E,
  0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x1F,
  0x03, 0xE0, 0x30, 0x00, 0x0C, 0xE3, 0xF8, 0xFF, 0x3D, 0xE7, 0x9C, 0xE7,
  0x9C, 0xE3, 0x9C, 0x7F, 0x8F, 0xF1, 0xFE, 0x03, 0x88, 0xF1, 0xFE, 0x3F,
  0x81, 0x80, 0x1E, 0x07, 0x03, 0xC0, 0xF6, 0x3F, 0xCF, 0xF3, 0x9D, 0xE7,
  0x79, 0xDC, 0xF7, 0x39, 0xCE, 0xF3, 0xBD, 0xE0, 0x0C, 0x71, 0xC0, 0x3C,
  0xE3, 0x8E, 0x79, 0xE7, 0x1C, 0x73, 0xCF, 0x00, 0x03, 0x07, 0x07, 0x00,
  0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x38,
  0x78, 0xF8, 0xF0, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xCF, 0x39, 0xE3,
  0xBC, 0x3B, 0x87, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x87, 0x78, 0xF3, 0x8F,
  0x3C, 0x1E, 0x38, 0xF1, 0xE3, 0x87, 0x0E, 0x3C, 0x78, 0xE1, 0xC3, 0x8F,
  0x1E, 0x00, 0x39, 0x8C, 0x3F, 0xDE, 0x3F, 0xFE, 0x39, 0xEF, 0x79, 0xCE,
  0x79, 0xCE, 0x73, 0xCE, 0x73, 0x9E, 0x73, 0x9E, 0xF3, 0x9C, 0xF7, 0x9C,
  0x3B, 0x8F, 0xF3, 0xFC, 0xE7, 0x79, 0xDE, 0x77, 0x3D, 0xCE, 0x73, 0xBC,
  0xEF, 0x78, 0x0E, 0x1F, 0x9F, 0xFE, 0x7F, 0x3F, 0x3F, 0x9F, 0xCE, 0xFF,
  0x7F, 0x1F, 0x00, 0x1D, 0x83, 0xFC, 0x7F, 0x8E, 0x73, 0xCE, 0x71, 0xCE,
  0x79, 0xCF, 0x3F, 0xCF, 0xF1, 0xDE, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07,
  0x00, 0x19, 0xCF, 0xE7, 0xFB, 0xDE, 0xF3, 0xB9, 0xEE, 0x73, 0x9C, 0xFF,
  0x3F, 0xC7, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x39, 0x9F, 0x8F,
  0xC7, 0xE7, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x00, 0x0E, 0x1F,
  0xDF, 0xCF, 0x27, 0xC1, 0xF0, 0x7C, 0x1E, 0xDE, 0x7F, 0x3F, 0x00, 0x18,
  0x70, 0xFF, 0xFF, 0xEE, 0x1C, 0x78, 0xF1, 0xC3, 0xE7, 0xCF, 0x80, 0x7B,
  0xDC, 0xF7, 0x39, 0xCE, 0xF3, 0xBD, 0xEE, 0x7B, 0x9C, 0xFF, 0x3F, 0xCF,
  0x70, 0xE3, 0xF8, 0xEE, 0x7B, 0x9C, 0xEF, 0x3B, 0x86, 0xE1, 0xF0, 0x7C,
  0x1E, 0x07, 0x80, 0xE7, 0x9F, 0xCF, 0x3B, 0x9E, 0x77, 0x7D, 0xCE, 0xDB,
  0x9D, 0xFE, 0x3F, 0xFC, 0x7D, 0xF8, 0xFB, 0xE1, 0xF7, 0xC3, 0xCF, 0x00,
  0x3C, 0xF1, 0xCE, 0x1D, 0xE1, 0xFC, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF8,
  0x3B, 0x87, 0xB8, 0xF3, 0xC0, 0x38, 0xF3, 0x8E, 0x39, 0xE3, 0x9C, 0x3F,
  0xC3, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x0F, 0x80, 0xF0, 0x0C, 0x00, 0x1F, 0xC7, 0xF3, 0xFC, 0x1E, 0x0F, 0x03,
  0x81, 0xE0, 0xF0, 0x7F, 0x1F, 0xCF, 0xF0, 0x03, 0x0F, 0x1F, 0x1C, 0x1C,
  0x1C, 0x3C, 0xF8, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x70, 0x78, 0x78, 0x38,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x10, 0x1C, 0x3E, 0x0E, 0x1C,
  0x1C, 0x1C, 0x1F, 0x0F, 0x1E, 0x3C, 0x38, 0x38, 0x38, 0xF0, 0xF0, 0xE0,
  0x20, 0xFE, 0xFF, 0xF1, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 14, 5, 0, -14 },
  { 12, 8, 5, 9, 2, -14 },
  { 17, 12, 14, 11, 0, -14 },
  { 38, 10, 15, 10, 0, -14 },
  { 57, 15, 14, 17, 1, -14 },
  { 84, 13, 14, 13, 0, -14 },
  { 107, 4, 5, 5, 2, -14 },
  { 110, 8, 17, 6, 0, -14 },
  { 127, 7, 17, 6, -1, -14 },
  { 142, 9, 10, 10, 1, -15 },
  { 154, 9, 9, 11, 1, -11 },
  { 165, 5, 5, 5, -1, -2 },
  { 169, 6, 3, 6, 0, -7 },
  { 172, 4, 3, 5, 0, -3 },
  { 174, 11, 14, 8, -1, -14 },
  { 194, 9, 14, 10, 1, -14 },
  { 210, 9, 14, 10, 1, -14 },
  { 226, 11, 14, 10, -1, -14 },
  { 246, 10, 14, 10, 0, -14 },
  { 264, 10, 14, 10, 0, -14 },
  { 282, 10, 14, 10, 0, -14 },
  { 300, 10, 14, 10, 1, -14 },
  { 318, 11, 14, 10, 0, -14 },
  { 338, 10, 14, 10, 0, -14 },
  { 356, 9, 14, 10, 1, -14 },
  { 372, 5, 11, 6, 0, -11 },
  { 379, 6, 14, 6, -1, -11 },
  { 390, 9, 10, 11, 1, -12 },
  { 402, 9, 7, 11, 1, -10 },
  { 410, 9, 10, 11, 1, -12 },
  { 422, 8, 14, 9, 1, -14 },
  { 436, 14, 16, 16, 1, -14 },
  { 464, 12, 14, 12, -1, -14 },
  { 485, 11, 14, 11, 0, -14 },
  { 505, 11, 14, 11, 1, -14 },
  { 525, 12, 14, 12, 0, -14 },
  { 546, 10, 14, 10, 0, -14 },
  { 564, 10, 14, 10, 0, -14 },
  { 582, 11, 14, 12, 1, -14 },
  { 602, 13, 14, 13, 0, -14 },
  { 625, 10, 14, 8, -1, -14 },
  { 643, 10, 18, 6, -3, -14 },
  { 666, 13, 14, 12, 0, -14 },
  { 689, 8, 14, 9, 0, -14 },
  { 703, 16, 14, 16, 0, -14 },
  { 731, 14, 14, 14, 0, -14 },
  { 756, 12, 14, 13, 1, -14 },
  { 777, 11, 14, 11, 0, -14 },
  { 797, 12, 17, 13, 1, -14 },
  { 823, 11, 14, 11, 0, -14 },
  { 843, 10, 14, 10, 0, -14 },
  { 861, 10, 14, 10, 1, -14 },
  { 879, 12, 14, 12, 1, -14 },
  { 900, 11, 14, 11, 2, -14 },
  { 920, 16, 14, 16, 2, -14 },
  { 948, 14, 14, 11, -1, -14 },
  { 973, 10, 14, 11, 2, -14 },
  { 991, 12, 14, 10, -1, -14 },
  { 1012, 9, 17, 6, -1, -14 },
  { 1032, 5, 14, 8, 2, -14 },
  { 1041, 8, 17, 6, -1, -14 },
  { 1058, 10, 9, 10, 0, -14 },
  { 1070, 9, 3, 8, -2, 1 },
  { 1074, 4, 3, 7, 3, -15 },
  { 1076, 10, 11, 11, 1, -11 },
  { 1090, 10, 14, 11, 0, -14 },
  { 1108, 8, 11, 9, 1, -11 },
  { 1119, 11, 14, 11, 1, -14 },
  { 1139, 9, 11, 10, 1, -11 },
  { 1152, 11, 20, 7, -2, -15 },
  { 1180, 11, 16, 11, 0, -11 },
  { 1202, 10, 14, 11, 0, -14 },
  { 1220, 6, 15, 6, 0, -15 },
  { 1232, 8, 20, 6, -2, -15 },
  { 1252, 12, 14, 11, 0, -14 },
  { 1273, 7, 14, 6, 0, -14 },
  { 1286, 16, 11, 16, 0, -11 },
  { 1308, 10, 11, 11, 0, -11 },
  { 1322, 9, 11, 11, 1, -11 },
  { 1335, 11, 16, 11, -1, -11 },
  { 1357, 10, 16, 11, 1, -11 },
  { 1377, 9, 11, 8, 0, -11 },
  { 1390, 9, 11, 9, 0, -11 },
  { 1403, 7, 13, 8, 1, -13 },
  { 1415, 10, 11, 11, 1, -11 },
  { 1429, 10, 11, 10, 1, -11 },
  { 1443, 15, 11, 15, 1, -11 },
  { 1464, 12, 11, 10, -1, -11 },
  { 1481, 12, 16, 10, -1, -11 },
  { 1505, 10, 11, 9, -1, -11 },
  { 1519, 8, 17, 7, 0, -14 },
  { 1536, 3, 18, 10, 3, -14 },
  { 1543, 8, 17, 7, -1, -14 },
  { 1560, 9, 4, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC19PT7B_H_
