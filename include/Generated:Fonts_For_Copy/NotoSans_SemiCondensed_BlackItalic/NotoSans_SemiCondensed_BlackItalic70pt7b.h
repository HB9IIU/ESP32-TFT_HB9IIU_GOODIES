#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC70PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0xCF,
  0xFF, 0x1F, 0xFE, 0x7F, 0xF8, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0x1F, 0xFC,
  0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0xC7, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F,
  0xE3, 0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87,
  0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8,
  0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xDF, 0x3F, 0x80, 0x7F, 0xF3, 0xE0, 0x78, 0x07, 0xFF, 0x3E,
  0x01, 0x00, 0x7F, 0xF3, 0xE0, 0x00, 0x07, 0xFF, 0x3E, 0x00, 0x00, 0x7F,
  0xF3, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xEF, 0xFF, 0x00, 0x00,
  0x3E, 0x7F, 0xF0, 0x00, 0x03, 0xE7, 0xFF, 0x0C, 0x00, 0x3E, 0x7F, 0xF0,
  0xF0, 0x03, 0xC7, 0xFF, 0x0F, 0xE0, 0x7C, 0xFF, 0xF0, 0xFF, 0xC7, 0xDF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF1, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x7F,
  0xC0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xC1, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x83,
  0xFE, 0x1F, 0xF0, 0x1F, 0x80, 0xFF, 0x87, 0xFE, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0x8F, 0xFC, 0x7F, 0xE1, 0xFF, 0xF8, 0xFF, 0xDF, 0xFC, 0x7F, 0xC3,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9,
  0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE3, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFE, 0x3F, 0xFB,
  0xFF, 0x1F, 0xFF, 0x87, 0xFC, 0x7F, 0xF1, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x7F, 0xE1, 0xFF, 0x01, 0xF0, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0xFF,
  0x83, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x00, 0x01, 0xFF,
  0x81, 0xFF, 0x83, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x00,
  0x03, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x87,
  0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x1F, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8,
  0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0xFF, 0xF1,
  0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF,
  0xE1, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x10, 0x03, 0xFE, 0x00, 0x1C, 0x07, 0xFE, 0x00,
  0x1F, 0x07, 0xFC, 0x00, 0x3F, 0x87, 0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x03, 0x7F, 0xFF, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFD, 0xFF, 0x80,
  0x7F, 0xFC, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF, 0xC0,
  0x03, 0xF0, 0x7F, 0xE0, 0x01, 0xE0, 0x7F, 0xE0, 0x00, 0xC0, 0x7F, 0x80,
  0x00, 0x40, 0x7C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xC0, 0x0F, 0xF0, 0x7F, 0xE3, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0x1F, 0xF8, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xFC, 0x0F,
  0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0xE0, 0x3F, 0xFC, 0x7F, 0xFC,
  0x07, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xF3, 0xFF, 0xE0, 0x1F, 0xFE, 0x7F,
  0xFC, 0x03, 0xFF, 0xCF, 0xFF, 0x80, 0xFF, 0xF9, 0xFF, 0xE0, 0x1F, 0xFF,
  0x7F, 0xFC, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x7F, 0xFD, 0xFF, 0xF0, 0x0F,
  0xFF, 0x3F, 0xFC, 0x03, 0xFF, 0xE7, 0xFF, 0x80, 0x7F, 0xFC, 0xFF, 0xF0,
  0x0F, 0xFF, 0xBF, 0xFE, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x7F, 0xFC, 0xFF,
  0xF8, 0x0F, 0xFF, 0x9F, 0xFF, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x3F, 0xFC,
  0x7F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F,
  0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFD, 0xFF, 0xE0, 0x3F, 0xE3, 0xFF,
  0xC0, 0x7F, 0x8F, 0xFF, 0x80, 0x7E, 0x1F, 0xFF, 0x00, 0x70, 0x3F, 0xFC,
  0x00, 0xC0, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE,
  0x3F, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xFC, 0x00, 0x3E, 0x01, 0xFF, 0xF0,
  0x00, 0xF0, 0x07, 0xFF, 0xC0, 0x01, 0x80, 0x1F, 0xFF, 0x00, 0x04, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7E, 0x03, 0xFF, 0xF0, 0x01, 0xC0, 0x0F, 0xFF, 0x80, 0x08, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xE2, 0x00, 0x00, 0x3F, 0xFE, 0x1C, 0x00, 0x03, 0xFF,
  0xF0, 0xFC, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xBF, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0xF0, 0x00, 0x3F, 0xF7, 0xFF,
  0x80, 0x01, 0xFF, 0x9F, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xF8, 0x00, 0x3F,
  0xE1, 0xFF, 0xE0, 0x01, 0xFF, 0x8F, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xFC,
  0x00, 0x7F, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xFC,
  0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFB, 0xFF, 0xFF, 0x00, 0x08, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x40, 0x00,
  0x1F, 0xFF, 0x83, 0x80, 0x01, 0xFF, 0xFC, 0x1F, 0x80, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x3F, 0xFD, 0xFF,
  0xFC, 0x07, 0xFF, 0xBF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F,
  0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xE0,
  0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFE, 0xFF, 0xFC, 0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x3F,
  0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x7F, 0xF8,
  0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0xF0,
  0xFF, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFF, 0x07, 0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0xF3, 0xFF, 0xE0, 0x7F, 0xFC,
  0xFF, 0xF0, 0x1F, 0xFF, 0x7F, 0xFC, 0x07, 0xFF, 0xDF, 0xFF, 0x01, 0xFF,
  0xF7, 0xFF, 0xC0, 0x7F, 0xFD, 0xFF, 0xF0, 0x1F, 0xFF, 0x7F, 0xFC, 0x0F,
  0xFF, 0xDF, 0xFF, 0x03, 0xFF, 0xF7, 0xFF, 0xC1, 0xFF, 0xFD, 0xFF, 0xF8,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0xFF, 0xF0, 0x3F, 0xFF, 0x3F, 0xF8,
  0x07, 0xFF, 0x9F, 0xFE, 0x00, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x80, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0,
  0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xC3, 0xF8, 0x1F, 0xFF, 0x0F, 0x00, 0x7F, 0xFC, 0x30, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x20, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xC3, 0xFE,
  0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xC7, 0xFC, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF,
  0x87, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x1F, 0xF1, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xE3, 0xFC,
  0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xCF, 0xF8, 0x3F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x9F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x3F, 0xC1, 0xFF, 0x81, 0xFF,
  0x03, 0xFC, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x07, 0xF9, 0xFF, 0x07, 0xFC,
  0x07, 0xF8, 0x0F, 0xF3, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE7, 0xF8,
  0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xCF, 0xF0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF,
  0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x7F, 0xC1, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x0F, 0xF1, 0xFF, 0x0F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xE3, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0x7F, 0xC1, 0xFF,
  0xF9, 0xFF, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF0, 0x01, 0xFF,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFB, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0xFF, 0xF3,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x8F, 0xFE,
  0x00, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x87, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE1, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0x80,
  0x01, 0xFF, 0xF3, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xCF, 0xFF, 0x80, 0x00, 0xFF, 0xFB, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0x07, 0xFF, 0xF8,
  0x01, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x60, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x06, 0x00,
  0x7F, 0xFE, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x7F, 0xF8,
  0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x83, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x7F, 0xF8, 0x03,
  0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x10, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x07, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x3C, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF1, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x40, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF1,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF1, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF3,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE7,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xDF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFB, 0xFE, 0x03, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0xBF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFB, 0xFE, 0x07, 0xFE, 0xFF, 0xE0, 0x03,
  0xFF, 0xBF, 0xE0, 0x7F, 0xEF, 0xFE, 0x00, 0x3F, 0xFB, 0xFE, 0x07, 0xFD,
  0xFF, 0xE0, 0x07, 0xFF, 0xBF, 0xE0, 0xFF, 0xDF, 0xFE, 0x00, 0x7F, 0xFB,
  0xFE, 0x0F, 0xF9, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xE1, 0xFF, 0x9F, 0xFC,
  0x00, 0x7F, 0xF3, 0xFE, 0x1F, 0xFB, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xE3,
  0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xF3, 0xFE, 0x3F, 0xF3, 0xFF, 0xC0, 0x0F,
  0xFF, 0x3F, 0xE7, 0xFE, 0x3F, 0xFC, 0x00, 0xFF, 0xE3, 0xFE, 0x7F, 0xE3,
  0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xE7, 0xFC, 0x7F, 0xF8, 0x01, 0xFF, 0xE3,
  0xFE, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xEF, 0xF8, 0x7F, 0xF8,
  0x01, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xE0,
  0x07, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFF,
  0x81, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xF7, 0xFF,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xDF,
  0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xFB, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF,
  0x3F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xE7, 0xFF, 0x8F, 0xFF, 0x00, 0x3F,
  0xF8, 0xFF, 0xF1, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x00,
  0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0xFF, 0xE0,
  0x07, 0xFF, 0x87, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xF3, 0xFF,
  0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE3, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x9F, 0xFF, 0x80,
  0x01, 0xFF, 0xF3, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xCF, 0xFF, 0x80, 0x00, 0xFF, 0xFB, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0xFF, 0xFD, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFD, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xBF, 0xFE, 0x00, 0x03,
  0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x9F, 0xFF, 0x00, 0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x07, 0xFF, 0xE1, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x1F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE3, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x9F, 0xFF, 0x80, 0x01, 0xFF, 0xF3, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xCF, 0xFF, 0x80,
  0x00, 0xFF, 0xFB, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xEF, 0xFF, 0x80, 0x00, 0xFF, 0xFD, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0xC0, 0x00, 0x7F, 0xFD, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xBF, 0xFE, 0x00, 0x03, 0xFF, 0xE7, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x9F, 0xFF, 0x00, 0x03,
  0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x8F, 0xFF, 0xC0, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x1F,
  0xFF, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xE3, 0xFF, 0xF8, 0x07, 0xFF, 0x81, 0xFF,
  0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x3F, 0xFC, 0x00,
  0x7F, 0xFC, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x03, 0xFF, 0xE1,
  0xFF, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFF,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x3F, 0xFE,
  0x00, 0xFF, 0xFC, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0xFF, 0xF8, 0x01, 0xFF,
  0xF9, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x7F, 0x80, 0x1F, 0xFF, 0x00, 0x78, 0x01, 0xFF, 0xF0, 0x00, 0xC0, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFC, 0x04, 0x00, 0x03, 0xFF, 0xE0, 0x30, 0x00, 0x1F,
  0xFF, 0x01, 0xE0, 0x00, 0xFF, 0xF8, 0x0F, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F,
  0xE1, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F,
  0xFC, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xFC,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFF,
  0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0x7F,
  0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x7F,
  0xF8, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x00, 0x7F, 0xF9,
  0xFF, 0xE0, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x7F, 0xFB, 0xFF, 0xC0,
  0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x00, 0x7F,
  0xF7, 0xFF, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0xBF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFD, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xC1,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0x03, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFE,
  0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xF8, 0x03,
  0xFF, 0x87, 0xFE, 0xFF, 0x87, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF7, 0xFC,
  0x3F, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xFF,
  0x1F, 0xFB, 0xFF, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xDF, 0xF8, 0xFF,
  0xF0, 0x01, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF, 0xFF, 0x00, 0x0F, 0xFE, 0x7F,
  0xE7, 0xFE, 0x7F, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x3F, 0xF3, 0xFF, 0x80,
  0x03, 0xFF, 0xBF, 0xF1, 0xFF, 0xBF, 0xFC, 0x00, 0x1F, 0xFD, 0xFF, 0x8F,
  0xFD, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x7F, 0xEF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF1,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xEF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xBF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xF9, 0xFF, 0xE0, 0x03, 0xFF, 0xF3, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC7, 0xFF, 0xC0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0xFF, 0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0xE0, 0x03, 0xFF, 0xC7, 0xFF,
  0xC0, 0x07, 0xFF, 0x9F, 0xFF, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x0F,
  0xFE, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x00,
  0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x07, 0xFE, 0x0F,
  0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x03,
  0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0,
  0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8, 0xFF, 0xF8,
  0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x1F,
  0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xFF, 0x8F, 0xFE, 0x01, 0xFF,
  0xFE, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x81, 0xFF,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xFC,
  0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F, 0xFF, 0x00, 0xFF, 0xE0,
  0xFF, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x7F, 0xFC, 0x03,
  0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xF9, 0xFF, 0xC0, 0x07,
  0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE7, 0xFC, 0x00, 0x1F,
  0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xF8, 0x1F, 0xFF, 0x07,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF,
  0xE0, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x7F, 0xF8,
  0x07, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xE0,
  0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x7F, 0xF8, 0x0F,
  0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xBF, 0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0xFE, 0x01, 0xFF, 0xC7, 0xFF,
  0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xF0, 0x1F, 0xFF, 0x80, 0x10, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x40, 0xFF,
  0xFC, 0x01, 0xC0, 0x7F, 0xFC, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00,
  0x7F, 0xFE, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xC7, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF,
  0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F,
  0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x3F,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xDF, 0xFC,
  0x00, 0x1F, 0xFF, 0x9F, 0xFC, 0x00, 0x0F, 0xFF, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x7F, 0xFC, 0x07, 0xFF,
  0x1F, 0xFE, 0x03, 0xFF, 0xCF, 0xFF, 0x80, 0xFF, 0xF3, 0xFF, 0xE0, 0x7F,
  0xFC, 0xFF, 0xF0, 0x7F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x20, 0xFF, 0xF8, 0x00, 0x30,
  0x1F, 0xFF, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC6, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x0F,
  0xFC, 0x00, 0x7F, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xFE, 0x7F, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xC7, 0xFF, 0xE0, 0x3F, 0xFF, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xF1, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0xFF, 0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x7F, 0xC7, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x04, 0x00, 0x03, 0xFF,
  0xE0, 0x0E, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xC0, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xF8, 0x00,
  0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0xFF, 0xF7, 0xFF, 0xE0, 0x03, 0xFF, 0xBF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE,
  0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF0,
  0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0,
  0x7F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0x80,
  0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x7F, 0xFC,
  0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x80, 0x00, 0x7F, 0xFD,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xBF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xBF,
  0xFF, 0x00, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0xF0,
  0x1F, 0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x1F, 0xF9,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x1F, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFF, 0x00,
  0x0F, 0xFC, 0x7F, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0xFC, 0x01, 0xFF, 0xDF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x07,
  0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF,
  0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF,
  0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF,
  0x80, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFC,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF8,
  0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFD, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0x81, 0xFF,
  0xF1, 0xFF, 0xF0, 0x3F, 0xFE, 0x7F, 0xFC, 0x07, 0xFF, 0xCF, 0xFF, 0x80,
  0xFF, 0xF9, 0xFF, 0xF0, 0x1F, 0xFF, 0x7F, 0xFC, 0x03, 0xFF, 0xEF, 0xFF,
  0x80, 0x7F, 0xFD, 0xFF, 0xF0, 0x0F, 0xFF, 0xBF, 0xFE, 0x01, 0xFF, 0xE7,
  0xFF, 0x80, 0x7F, 0xFC, 0xFF, 0xF0, 0x0F, 0xFF, 0xBF, 0xFE, 0x01, 0xFF,
  0xF7, 0xFF, 0xC0, 0x3F, 0xFE, 0xFF, 0xF8, 0x0F, 0xFF, 0x9F, 0xFF, 0x01,
  0xFF, 0xF3, 0xFF, 0xE0, 0x7F, 0xFC, 0x7F, 0xFC, 0x0F, 0xFF, 0x87, 0xFF,
  0x83, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0xFF,
  0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0xF8, 0x00, 0x1F, 0xFB, 0xFF, 0xFC, 0x00,
  0x3F, 0xFB, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x00, 0x7F,
  0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x07,
  0xFF, 0xE1, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x03, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF8,
  0x00, 0xFF, 0xF0, 0xFF, 0xC0, 0x1F, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xFE,
  0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0,
  0xFF, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFC, 0x03,
  0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF,
  0xC3, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF8,
  0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFB, 0xFF, 0xC0, 0x07, 0xFF,
  0xBF, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0xE0, 0x00, 0x1C, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0xFF,
  0xC7, 0xFE, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xDF, 0xFE, 0x01, 0xFF,
  0xDF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x08, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0x07, 0xE0, 0x7F, 0xFC, 0x01, 0x80, 0xFF, 0xF8, 0x01,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x84, 0x00,
  0x1F, 0xFF, 0x0E, 0x00, 0x3F, 0xFE, 0x1F, 0x80, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFD, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x0C, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFC, 0x07,
  0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFF,
  0xC3, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF8,
  0x0F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0xC3,
  0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F,
  0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0xC3, 0xFF,
  0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFF,
  0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xE0,
  0x3F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x07,
  0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xBF, 0xF8, 0x03, 0xFF, 0xF9, 0xFF, 0x80, 0x0F, 0xFF, 0x8F, 0xFC, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFB, 0xFF, 0xC0, 0x0F, 0xFF, 0x9F, 0xFE, 0x00, 0x7F, 0xFC, 0xFF,
  0xF0, 0x07, 0xFF, 0xC7, 0xFF, 0x80, 0x3F, 0xFE, 0x3F, 0xFC, 0x03, 0xFF,
  0xE1, 0xFF, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F,
  0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0xFF, 0xF8, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xF8,
  0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x0F, 0xFD,
  0xFF, 0xE0, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xEF,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xBF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFC, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF3, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0x8F, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFE, 0x3F, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xC3, 0xFF,
  0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xF8,
  0x3F, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F,
  0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFC, 0x0F, 0xFF, 0x3F, 0xEF,
  0xF8, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xBF, 0xE7, 0xFF, 0x80, 0xFF, 0xE3,
  0xFE, 0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0x9F, 0xF3, 0xFC, 0xFF, 0xF0, 0x0F,
  0xFE, 0x7F, 0xCF, 0xF3, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0x7F, 0xCF, 0xFE,
  0x00, 0xFF, 0xEF, 0xF9, 0xFF, 0x7F, 0xF8, 0x03, 0xFF, 0xBF, 0xE7, 0xFD,
  0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0x1F, 0xF7, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x81, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0x81, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xE7, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFB, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0xC3, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xBF, 0xFC, 0x00, 0x00, 0x3F, 0xFB, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xBF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x9F, 0xFF, 0xC0, 0x00, 0xDF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xD8,
  0x00, 0x0F, 0xFF, 0x88, 0x00, 0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 23, 51, 20, 0, -50 },
  { 148, 29, 18, 32, 6, -50 },
  { 214, 44, 50, 42, 0, -50 },
  { 489, 36, 57, 38, 2, -53 },
  { 746, 56, 52, 62, 4, -51 },
  { 1110, 48, 52, 48, 0, -51 },
  { 1422, 15, 18, 17, 6, -50 },
  { 1456, 27, 62, 24, 2, -51 },
  { 1666, 27, 62, 24, -5, -51 },
  { 1876, 32, 34, 35, 5, -54 },
  { 2012, 33, 34, 39, 3, -42 },
  { 2153, 18, 18, 20, -4, -9 },
  { 2194, 20, 11, 22, 1, -24 },
  { 2222, 14, 13, 20, 0, -12 },
  { 2245, 39, 52, 31, -3, -51 },
  { 2499, 35, 52, 38, 2, -51 },
  { 2727, 31, 50, 38, 5, -50 },
  { 2921, 38, 51, 38, -2, -51 },
  { 3164, 37, 52, 38, 0, -51 },
  { 3405, 38, 50, 38, 0, -50 },
  { 3643, 37, 51, 38, 1, -50 },
  { 3879, 36, 52, 38, 3, -51 },
  { 4113, 40, 50, 38, 1, -50 },
  { 4363, 37, 52, 38, 1, -51 },
  { 4604, 34, 52, 38, 3, -51 },
  { 4825, 20, 40, 20, 0, -39 },
  { 4925, 24, 48, 20, -4, -39 },
  { 5069, 33, 37, 39, 3, -44 },
  { 5222, 33, 25, 39, 3, -37 },
  { 5326, 33, 37, 39, 3, -44 },
  { 5479, 30, 52, 31, 4, -51 },
  { 5674, 55, 57, 58, 2, -51 },
  { 6066, 43, 50, 44, -4, -50 },
  { 6335, 40, 50, 41, 1, -50 },
  { 6585, 40, 52, 40, 3, -51 },
  { 6845, 42, 50, 44, 1, -50 },
  { 7108, 37, 50, 36, 1, -50 },
  { 7340, 37, 50, 36, 1, -50 },
  { 7572, 42, 52, 45, 3, -51 },
  { 7845, 46, 50, 46, 1, -50 },
  { 8133, 36, 50, 28, -3, -50 },
  { 8358, 36, 66, 24, -11, -50 },
  { 8655, 48, 50, 43, 1, -50 },
  { 8955, 29, 50, 34, 1, -50 },
  { 9137, 60, 50, 59, 1, -50 },
  { 9512, 51, 50, 51, 1, -50 },
  { 9831, 43, 52, 47, 3, -51 },
  { 10111, 39, 50, 40, 1, -50 },
  { 10355, 43, 63, 47, 3, -51 },
  { 10694, 39, 50, 42, 1, -50 },
  { 10938, 37, 52, 35, 0, -51 },
  { 11179, 35, 50, 35, 5, -50 },
  { 11398, 42, 51, 45, 4, -50 },
  { 11666, 40, 50, 41, 6, -50 },
  { 11916, 61, 50, 61, 6, -50 },
  { 12298, 51, 50, 42, -4, -50 },
  { 12617, 39, 50, 39, 6, -50 },
  { 12861, 42, 50, 35, -3, -50 },
  { 13124, 30, 63, 23, -2, -51 },
  { 13361, 18, 52, 31, 7, -51 },
  { 13478, 31, 63, 23, -5, -51 },
  { 13723, 36, 33, 36, -1, -50 },
  { 13872, 32, 8, 30, -7, 5 },
  { 13904, 16, 12, 24, 10, -54 },
  { 13928, 37, 40, 39, 2, -39 },
  { 14113, 37, 54, 39, 0, -53 },
  { 14363, 32, 40, 33, 2, -39 },
  { 14523, 40, 54, 39, 2, -53 },
  { 14793, 34, 40, 38, 2, -39 },
  { 14963, 41, 71, 26, -7, -54 },
  { 15327, 39, 56, 39, 0, -39 },
  { 15600, 38, 53, 40, 0, -53 },
  { 15852, 23, 54, 21, 0, -54 },
  { 16008, 33, 71, 21, -9, -54 },
  { 16301, 44, 53, 40, 0, -53 },
  { 16593, 24, 53, 21, 0, -53 },
  { 16752, 57, 39, 60, 0, -39 },
  { 17030, 38, 39, 40, 0, -39 },
  { 17216, 35, 40, 39, 2, -39 },
  { 17391, 40, 56, 39, -3, -39 },
  { 17671, 37, 56, 39, 2, -39 },
  { 17930, 32, 39, 28, 0, -39 },
  { 18086, 31, 40, 32, 1, -39 },
  { 18241, 27, 47, 29, 3, -46 },
  { 18400, 37, 40, 40, 3, -39 },
  { 18585, 37, 39, 36, 3, -39 },
  { 18766, 54, 39, 54, 4, -39 },
  { 19030, 45, 39, 37, -4, -39 },
  { 19250, 44, 56, 36, -4, -39 },
  { 19558, 35, 39, 32, -2, -39 },
  { 19729, 30, 61, 25, 0, -50 },
  { 19958, 9, 69, 35, 13, -53 },
  { 20036, 29, 61, 25, -4, -50 },
  { 20258, 33, 13, 39, 3, -31 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC70PT7B_H_
