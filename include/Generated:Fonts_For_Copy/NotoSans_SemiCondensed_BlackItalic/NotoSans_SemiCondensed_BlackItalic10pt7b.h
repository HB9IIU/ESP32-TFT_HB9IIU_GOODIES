#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC10PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xA1, 0xB0, 0xFB, 0x3C, 0xA7, 0xDA, 0xFD, 0x4F, 0x00, 0x11,
  0xDE, 0xC3, 0x9F, 0xEC, 0x20, 0xE6, 0xAC, 0xA8, 0xD6, 0x3F, 0x6A, 0xCE,
  0x38, 0xD1, 0xE3, 0xBD, 0xDB, 0x1F, 0x00, 0xE0, 0x36, 0x44, 0xCC, 0xCC,
  0x40, 0x31, 0x11, 0x33, 0x26, 0xC0, 0x2A, 0xFE, 0xB0, 0x21, 0x3E, 0x42,
  0x00, 0x78, 0xE0, 0xF0, 0x18, 0x8C, 0xC6, 0x62, 0x00, 0x3B, 0xD3, 0xBD,
  0xED, 0xC0, 0x3F, 0xB2, 0x66, 0x60, 0x7A, 0xC6, 0x66, 0x7F, 0xC0, 0x7A,
  0xC6, 0xE1, 0xDF, 0xC0, 0x19, 0xCE, 0xBF, 0xFC, 0xC0, 0x3B, 0x1C, 0xF1,
  0xDF, 0xC0, 0x3D, 0x85, 0x3E, 0xDB, 0x67, 0x00, 0x7C, 0x61, 0x8C, 0x31,
  0x8E, 0x00, 0x3B, 0x5E, 0xED, 0xED, 0xC0, 0x7B, 0xD6, 0xF7, 0xDB, 0x80,
  0x2C, 0x0D, 0x80, 0x13, 0x00, 0x06, 0xC0, 0x09, 0xB0, 0x70, 0x80, 0xF8,
  0x3E, 0xC3, 0x86, 0xEC, 0x00, 0xFB, 0x6C, 0x08, 0xC0, 0x3E, 0x63, 0x5D,
  0xF5, 0xEF, 0xF6, 0x44, 0x38, 0x0C, 0x38, 0x51, 0xA3, 0xCF, 0xF9, 0x80,
  0x7D, 0xB6, 0xDE, 0x5B, 0x6F, 0x00, 0x3D, 0x96, 0x10, 0xC1, 0xA7, 0x80,
  0x79, 0xB6, 0xDB, 0x4F, 0xEF, 0x00, 0x7B, 0x18, 0xF4, 0x7B, 0xC0, 0x7B,
  0x18, 0xF4, 0x63, 0x00, 0x3D, 0xD6, 0x17, 0xCD, 0xB7, 0x80, 0x66, 0xC9,
  0xB3, 0xE4, 0xD9, 0xB6, 0x00, 0x79, 0x18, 0xC6, 0x33, 0x80, 0x0C, 0x61,
  0x86, 0x18, 0x43, 0x0C, 0xE0, 0x6E, 0xD9, 0xE3, 0xC5, 0x9B, 0x37, 0x00,
  0x66, 0x66, 0x4F, 0xF0, 0x73, 0xBB, 0x9D, 0xCA, 0xE5, 0xB6, 0xD3, 0x78,
  0x72, 0xED, 0xDA, 0xF5, 0xDB, 0xB3, 0x00, 0x3C, 0xD9, 0x9A, 0x2C, 0xCF,
  0x9E, 0x00, 0x79, 0xB6, 0xDE, 0x73, 0x0C, 0x00, 0x3C, 0xD9, 0x9A, 0x2C,
  0xCF, 0x9E, 0x0C, 0x1C, 0x79, 0xB6, 0xDE, 0x5B, 0x6D, 0xC0, 0x7B, 0x58,
  0xE3, 0x7B, 0xC0, 0xFB, 0x18, 0xC4, 0x63, 0x00, 0xCF, 0x6D, 0xB6, 0x9B,
  0xCF, 0x00, 0xDF, 0x6D, 0x3C, 0xE3, 0x8C, 0x00, 0xDB, 0xED, 0xAE, 0x97,
  0xCF, 0xE7, 0xE3, 0x70, 0x37, 0x36, 0x1C, 0x18, 0x3C, 0x6C, 0xEC, 0xDE,
  0xBC, 0xC6, 0x23, 0x00, 0x7C, 0x63, 0x1C, 0x63, 0xEF, 0x00, 0x76, 0x44,
  0x4C, 0xCC, 0xC0, 0xDB, 0x24, 0x98, 0x38, 0x84, 0x63, 0x10, 0x8C, 0xE0,
  0x11, 0x9E, 0xB8, 0x80, 0xF8, 0xCC, 0x2D, 0xE5, 0xB6, 0xD9, 0xE0, 0x23,
  0x1E, 0xF7, 0xAF, 0x7E, 0x33, 0xD1, 0x8D, 0x38, 0x0C, 0x32, 0xDE, 0x5B,
  0x6D, 0x9E, 0x33, 0xD7, 0xEC, 0xB8, 0x0C, 0x63, 0x9E, 0x30, 0xC2, 0x18,
  0x63, 0x80, 0x2D, 0xE5, 0xB6, 0xD9, 0xE1, 0x3C, 0x23, 0x1E, 0xF6, 0xAF,
  0x7B, 0x2D, 0xB6, 0xB6, 0x13, 0x33, 0x32, 0x66, 0x6C, 0x21, 0x86, 0xDE,
  0x51, 0xCD, 0xB6, 0x2D, 0xB6, 0xB6, 0x7A, 0x7F, 0x6B, 0x5B, 0xDB, 0xDB,
  0x7B, 0xDA, 0xBD, 0xEC, 0x33, 0xD7, 0xBD, 0xB8, 0x73, 0xDE, 0xBD, 0xFB,
  0x10, 0x2D, 0xE5, 0xB6, 0xD9, 0xE1, 0x0C, 0x7B, 0x98, 0x8C, 0x60, 0x3B,
  0x98, 0xEB, 0x70, 0x23, 0xF6, 0x4D, 0x60, 0x6D, 0xB7, 0x96, 0xD9, 0xE0,
  0xCD, 0x65, 0x9C, 0x71, 0x80, 0xB7, 0x6E, 0xD7, 0xED, 0x9B, 0x00, 0x36,
  0x78, 0xE1, 0xC3, 0x9D, 0x80, 0x66, 0x58, 0xB1, 0x43, 0x86, 0x0C, 0x70,
  0x7B, 0xCC, 0xCC, 0x78, 0x32, 0x6E, 0xC4, 0x4E, 0x20, 0xFF, 0xC0, 0x31,
  0x8C, 0x73, 0x11, 0x9C, 0x80, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 7, 3, 0, -7 },
  { 4, 4, 2, 5, 1, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 5, 9, 5, 0, -8 },
  { 17, 8, 7, 9, 1, -7 },
  { 24, 7, 7, 7, 0, -7 },
  { 31, 2, 2, 2, 1, -7 },
  { 32, 4, 9, 3, 0, -7 },
  { 37, 4, 9, 3, -1, -7 },
  { 42, 4, 5, 5, 1, -8 },
  { 45, 5, 5, 6, 0, -6 },
  { 49, 3, 2, 3, -1, -1 },
  { 50, 3, 1, 3, 0, -3 },
  { 51, 2, 2, 3, 0, -2 },
  { 52, 5, 7, 4, 0, -7 },
  { 57, 5, 7, 5, 0, -7 },
  { 62, 4, 7, 5, 1, -7 },
  { 66, 5, 7, 5, 0, -7 },
  { 71, 5, 7, 5, 0, -7 },
  { 76, 5, 7, 5, 0, -7 },
  { 81, 5, 7, 5, 0, -7 },
  { 86, 6, 7, 5, 0, -7 },
  { 92, 6, 7, 5, 0, -7 },
  { 98, 5, 7, 5, 0, -7 },
  { 103, 5, 7, 5, 0, -7 },
  { 108, 3, 6, 3, 0, -6 },
  { 111, 4, 7, 3, -1, -6 },
  { 115, 5, 5, 6, 0, -6 },
  { 119, 5, 3, 6, 0, -5 },
  { 121, 5, 5, 6, 0, -6 },
  { 125, 4, 7, 4, 1, -7 },
  { 129, 8, 8, 8, 0, -7 },
  { 137, 7, 7, 6, -1, -7 },
  { 144, 6, 7, 6, 0, -7 },
  { 150, 6, 7, 6, 0, -7 },
  { 156, 6, 7, 6, 0, -7 },
  { 162, 5, 7, 5, 0, -7 },
  { 167, 5, 7, 5, 0, -7 },
  { 172, 6, 7, 6, 0, -7 },
  { 178, 7, 7, 7, 0, -7 },
  { 185, 5, 7, 4, 0, -7 },
  { 190, 6, 9, 3, -2, -7 },
  { 197, 7, 7, 6, 0, -7 },
  { 204, 4, 7, 5, 0, -7 },
  { 208, 9, 7, 8, 0, -7 },
  { 216, 7, 7, 7, 0, -7 },
  { 223, 7, 7, 7, 0, -7 },
  { 230, 6, 7, 6, 0, -7 },
  { 236, 7, 9, 7, 0, -7 },
  { 244, 6, 7, 6, 0, -7 },
  { 250, 5, 7, 5, 0, -7 },
  { 255, 5, 7, 5, 1, -7 },
  { 260, 6, 7, 6, 1, -7 },
  { 266, 6, 7, 6, 1, -7 },
  { 272, 9, 7, 9, 1, -7 },
  { 280, 8, 7, 6, -1, -7 },
  { 287, 5, 7, 6, 1, -7 },
  { 292, 6, 7, 5, 0, -7 },
  { 298, 4, 9, 3, 0, -7 },
  { 303, 3, 7, 4, 1, -7 },
  { 306, 5, 9, 3, -1, -7 },
  { 312, 5, 5, 5, 0, -7 },
  { 316, 5, 1, 4, -1, 1 },
  { 317, 3, 2, 3, 1, -8 },
  { 318, 6, 6, 6, 0, -6 },
  { 323, 5, 8, 6, 0, -8 },
  { 328, 5, 6, 5, 0, -6 },
  { 332, 6, 8, 6, 0, -8 },
  { 338, 5, 6, 5, 0, -6 },
  { 342, 6, 10, 4, -1, -8 },
  { 350, 6, 8, 6, 0, -6 },
  { 356, 5, 8, 6, 0, -8 },
  { 361, 3, 8, 3, 0, -8 },
  { 364, 4, 10, 3, -1, -8 },
  { 369, 6, 8, 6, 0, -8 },
  { 375, 3, 8, 3, 0, -8 },
  { 378, 8, 6, 9, 0, -6 },
  { 384, 5, 6, 6, 0, -6 },
  { 388, 5, 6, 6, 0, -6 },
  { 392, 5, 8, 6, 0, -6 },
  { 397, 6, 8, 6, 0, -6 },
  { 403, 5, 6, 4, 0, -6 },
  { 407, 5, 6, 5, 0, -6 },
  { 411, 4, 7, 4, 0, -7 },
  { 415, 6, 6, 6, 0, -6 },
  { 420, 6, 6, 5, 0, -6 },
  { 425, 7, 6, 8, 1, -6 },
  { 431, 7, 6, 5, -1, -6 },
  { 437, 7, 8, 5, -1, -6 },
  { 444, 5, 6, 5, 0, -6 },
  { 448, 4, 9, 4, 0, -7 },
  { 453, 1, 10, 5, 2, -8 },
  { 455, 5, 9, 4, -1, -7 },
  { 461, 5, 1, 6, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC10PT7B_H_
