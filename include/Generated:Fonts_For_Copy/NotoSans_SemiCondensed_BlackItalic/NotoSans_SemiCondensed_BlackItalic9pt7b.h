#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC9PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x25, 0x80, 0xFA, 0x29, 0xF7, 0x3E, 0x53, 0xC0, 0x13, 0xD8,
  0xE3, 0x79, 0x88, 0x22, 0x74, 0x7C, 0xEE, 0x55, 0x37, 0x66, 0x11, 0xE7,
  0x9F, 0xFF, 0x6F, 0xC0, 0xE0, 0x32, 0x44, 0xCC, 0xCC, 0x23, 0x33, 0x32,
  0x2C, 0x6D, 0x7A, 0x27, 0xC8, 0x40, 0xE0, 0xE0, 0x70, 0x18, 0x8C, 0x44,
  0x62, 0x00, 0x13, 0xD7, 0xBD, 0xF9, 0x80, 0x7E, 0x66, 0x64, 0x23, 0xD6,
  0x66, 0x63, 0xC0, 0x23, 0xC6, 0xE3, 0x5B, 0xC0, 0x19, 0x95, 0xFF, 0x18,
  0x7B, 0x1C, 0x2B, 0x78, 0x13, 0xD0, 0xED, 0xE9, 0xC0, 0x78, 0xCC, 0x46,
  0x60, 0x13, 0xDE, 0xED, 0x69, 0xC0, 0x23, 0xD7, 0xB7, 0x1B, 0x80, 0x68,
  0x2C, 0x32, 0x00, 0x6C, 0x09, 0xF8, 0xE1, 0x80, 0xF8, 0x3E, 0x87, 0x0E,
  0xEC, 0x00, 0x5C, 0xE9, 0x20, 0x08, 0x6D, 0x7B, 0x5A, 0xB7, 0x92, 0x1C,
  0x1C, 0x73, 0xCF, 0x7F, 0x30, 0x7B, 0x5C, 0xBD, 0xF8, 0x11, 0xF6, 0x10,
  0xC3, 0x27, 0x00, 0x79, 0xB4, 0x92, 0xDB, 0xC0, 0x7B, 0x1C, 0x8C, 0x78,
  0x7B, 0x1C, 0xEC, 0x60, 0x08, 0xF6, 0x17, 0xDB, 0x67, 0x80, 0x6D, 0xB7,
  0x92, 0xDB, 0x60, 0x76, 0x66, 0x4E, 0x33, 0x32, 0x66, 0x6C, 0x6D, 0xE7,
  0x1C, 0xDB, 0x60, 0x66, 0x44, 0xCF, 0x77, 0x76, 0x7A, 0x7E, 0xFE, 0xF6,
  0x76, 0xE9, 0x52, 0xED, 0xDB, 0x00, 0x11, 0xF6, 0xD3, 0xCF, 0x67, 0x00,
  0x7B, 0x5E, 0xEC, 0x60, 0x11, 0xF6, 0xD3, 0xCF, 0x67, 0x04, 0x18, 0x7B,
  0x5E, 0xED, 0x6C, 0x13, 0xD0, 0xC3, 0x5B, 0x80, 0xF4, 0x4C, 0xCC, 0x6D,
  0xB4, 0x96, 0xD9, 0xC0, 0x9D, 0xAD, 0x4E, 0x60, 0x93, 0xB6, 0xB4, 0xFC,
  0xDC, 0xD8, 0x36, 0x78, 0x61, 0xC6, 0x9D, 0x80, 0xDF, 0xB8, 0x8C, 0x60,
  0x79, 0x88, 0xCC, 0x78, 0x76, 0x44, 0x4C, 0x8C, 0xC0, 0xAF, 0x54, 0x33,
  0x13, 0x22, 0x26, 0xE0, 0x33, 0x95, 0x30, 0xF0, 0xD0, 0x6A, 0xF7, 0xA7,
  0x00, 0x63, 0x1E, 0xB5, 0xEB, 0xC0, 0x75, 0xCD, 0x70, 0x08, 0x5E, 0xBD,
  0xE9, 0xC0, 0x72, 0xFD, 0xA7, 0x00, 0x19, 0xCE, 0xE2, 0x11, 0x8C, 0xC0,
  0x6A, 0xF7, 0xA7, 0x1B, 0x80, 0x63, 0x1E, 0xF5, 0xEB, 0x40, 0x65, 0xA5,
  0xB0, 0x31, 0x32, 0x26, 0x66, 0xC0, 0x61, 0x87, 0xD4, 0x73, 0xCD, 0x80,
  0x6D, 0xA5, 0xB0, 0x5E, 0xF5, 0x6E, 0xBD, 0x60, 0x7B, 0xD7, 0xAD, 0x00,
  0x72, 0xF7, 0xA7, 0x00, 0x7A, 0xD7, 0xAF, 0x62, 0x00, 0x6A, 0xF7, 0xA7,
  0x18, 0xC0, 0x57, 0x4C, 0xC0, 0x74, 0x6B, 0xE0, 0x2F, 0x44, 0xC6, 0x7A,
  0xD7, 0xAF, 0x00, 0xDA, 0x9C, 0xC6, 0x00, 0xDA, 0xBD, 0xB3, 0xE7, 0x80,
  0x2C, 0xE3, 0x0E, 0xF8, 0x6C, 0xA3, 0x8C, 0x30, 0x8E, 0x00, 0x73, 0x6D,
  0xE0, 0x36, 0x68, 0x44, 0xC0, 0xFF, 0x80, 0x33, 0x21, 0x26, 0xC0, 0xFC,
  0x80,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 6, 3, 0, -6 },
  { 4, 4, 2, 4, 1, -6 },
  { 5, 6, 6, 5, 0, -6 },
  { 10, 5, 8, 5, 0, -7 },
  { 15, 8, 7, 8, 0, -7 },
  { 22, 6, 7, 6, 0, -7 },
  { 28, 2, 2, 2, 1, -6 },
  { 29, 4, 8, 3, 0, -7 },
  { 33, 4, 8, 3, -1, -7 },
  { 37, 4, 4, 5, 1, -7 },
  { 39, 5, 4, 5, 0, -5 },
  { 42, 2, 2, 3, 0, -1 },
  { 43, 3, 1, 3, 0, -3 },
  { 44, 2, 2, 3, 0, -2 },
  { 45, 5, 7, 4, 0, -7 },
  { 50, 5, 7, 5, 0, -7 },
  { 55, 4, 6, 5, 1, -6 },
  { 58, 5, 7, 5, 0, -7 },
  { 63, 5, 7, 5, 0, -7 },
  { 68, 5, 6, 5, 0, -6 },
  { 72, 5, 6, 5, 0, -6 },
  { 76, 5, 7, 5, 0, -7 },
  { 81, 5, 6, 5, 0, -6 },
  { 85, 5, 7, 5, 0, -7 },
  { 90, 5, 7, 5, 0, -7 },
  { 95, 3, 5, 3, 0, -5 },
  { 97, 4, 6, 3, -1, -5 },
  { 100, 5, 5, 5, 0, -6 },
  { 104, 5, 3, 5, 0, -5 },
  { 106, 5, 5, 5, 0, -6 },
  { 110, 3, 7, 4, 1, -7 },
  { 113, 7, 8, 7, 0, -7 },
  { 120, 6, 6, 6, -1, -6 },
  { 125, 5, 6, 5, 0, -6 },
  { 129, 6, 7, 5, 0, -7 },
  { 135, 6, 6, 6, 0, -6 },
  { 140, 5, 6, 5, 0, -6 },
  { 144, 5, 6, 5, 0, -6 },
  { 148, 6, 7, 6, 0, -7 },
  { 154, 6, 6, 6, 0, -6 },
  { 159, 4, 6, 4, 0, -6 },
  { 162, 4, 8, 3, -1, -6 },
  { 166, 6, 6, 6, 0, -6 },
  { 171, 4, 6, 4, 0, -6 },
  { 174, 8, 6, 8, 0, -6 },
  { 180, 7, 6, 7, 0, -6 },
  { 186, 6, 7, 6, 0, -7 },
  { 192, 5, 6, 5, 0, -6 },
  { 196, 6, 9, 6, 0, -7 },
  { 203, 5, 6, 5, 0, -6 },
  { 207, 5, 7, 5, 0, -7 },
  { 212, 4, 6, 5, 1, -6 },
  { 215, 6, 6, 6, 0, -6 },
  { 220, 5, 6, 5, 1, -6 },
  { 224, 8, 6, 8, 1, -6 },
  { 230, 7, 6, 5, -1, -6 },
  { 236, 5, 6, 5, 1, -6 },
  { 240, 5, 6, 5, 0, -6 },
  { 244, 4, 9, 3, 0, -7 },
  { 249, 2, 7, 4, 1, -7 },
  { 251, 4, 9, 3, -1, -7 },
  { 256, 5, 4, 5, 0, -6 },
  { 259, 4, 1, 4, -1, 1 },
  { 260, 2, 2, 3, 1, -7 },
  { 261, 5, 5, 5, 0, -5 },
  { 265, 5, 7, 5, 0, -7 },
  { 270, 4, 5, 4, 0, -5 },
  { 273, 5, 7, 5, 0, -7 },
  { 278, 5, 5, 5, 0, -5 },
  { 282, 5, 9, 3, -1, -7 },
  { 288, 5, 7, 5, 0, -5 },
  { 293, 5, 7, 5, 0, -7 },
  { 298, 3, 7, 3, 0, -7 },
  { 301, 4, 9, 3, -1, -7 },
  { 306, 6, 7, 5, 0, -7 },
  { 312, 3, 7, 3, 0, -7 },
  { 315, 7, 5, 8, 0, -5 },
  { 320, 5, 5, 5, 0, -5 },
  { 324, 5, 5, 5, 0, -5 },
  { 328, 5, 7, 5, 0, -5 },
  { 333, 5, 7, 5, 0, -5 },
  { 338, 4, 5, 4, 0, -5 },
  { 341, 4, 5, 4, 0, -5 },
  { 344, 4, 6, 4, 0, -6 },
  { 347, 5, 5, 5, 0, -5 },
  { 351, 5, 5, 5, 0, -5 },
  { 355, 7, 5, 7, 0, -5 },
  { 360, 6, 5, 5, -1, -5 },
  { 364, 6, 7, 5, -1, -5 },
  { 370, 4, 5, 4, 0, -5 },
  { 373, 4, 7, 3, 0, -6 },
  { 377, 1, 9, 5, 2, -7 },
  { 379, 4, 7, 3, -1, -6 },
  { 383, 5, 2, 5, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC9PT7B_H_
