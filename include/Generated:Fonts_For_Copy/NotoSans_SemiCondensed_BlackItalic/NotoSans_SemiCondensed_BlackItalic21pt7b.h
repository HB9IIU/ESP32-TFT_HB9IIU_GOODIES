#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC21PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0xF1, 0xE3, 0xC7, 0x8E, 0x1C, 0x78, 0xE0, 0x03, 0x0F,
  0x1E, 0x3C, 0x00, 0x77, 0xFB, 0xB9, 0xDC, 0xEE, 0xE0, 0x07, 0x70, 0x3B,
  0x81, 0x9C, 0x1C, 0xC3, 0xFF, 0xBF, 0xFC, 0x73, 0x03, 0xB8, 0x1D, 0xC7,
  0xFF, 0xBF, 0xFC, 0x77, 0x03, 0x38, 0x39, 0x81, 0xDC, 0x00, 0x01, 0x80,
  0x70, 0x3F, 0x8F, 0xF3, 0xF6, 0x74, 0x0F, 0x81, 0xF8, 0x1F, 0x80, 0xF8,
  0x17, 0x22, 0xE7, 0xFC, 0xFF, 0x3F, 0xC0, 0x40, 0x18, 0x00, 0x3E, 0x0E,
  0x3F, 0x0E, 0x1D, 0xC6, 0x0C, 0xE7, 0x0E, 0x67, 0x07, 0x77, 0x03, 0xBB,
  0xBD, 0xFB, 0xBF, 0x7B, 0xBB, 0x81, 0xDD, 0xC1, 0xCE, 0xE1, 0xC6, 0x70,
  0xE3, 0x70, 0xE1, 0xF8, 0xE0, 0x78, 0x07, 0xC0, 0x3F, 0x81, 0xEF, 0x07,
  0x38, 0x1C, 0xE0, 0x7F, 0x80, 0xF8, 0x0F, 0xCF, 0x7F, 0xBF, 0xDF, 0xEF,
  0x3F, 0x3C, 0x7C, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xEE, 0xE0,
  0x0F, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0,
  0x07, 0x01, 0x86, 0x61, 0xFB, 0xFF, 0xC7, 0xF3, 0xE1, 0xFC, 0x37, 0x84,
  0x80, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x3B, 0xDE, 0xEF, 0x70, 0x7D, 0xFF, 0xC0, 0x6F, 0xFF,
  0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0,
  0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x00, 0x0F,
  0x8F, 0xE3, 0xFD, 0xEF, 0x7B, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xF8, 0xEE,
  0x7B, 0x9E, 0xFF, 0x3F, 0x87, 0xC0, 0x07, 0x8F, 0x8F, 0xCF, 0xEF, 0xF7,
  0x79, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x07,
  0xC1, 0xFE, 0x1F, 0xF0, 0xCF, 0x08, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xE7, 0xFC, 0xFF, 0xC0, 0x1F, 0xC7,
  0xFC, 0x7F, 0x88, 0xF0, 0x1E, 0x07, 0x87, 0xE0, 0xF8, 0x1F, 0xC0, 0x78,
  0x0F, 0x41, 0xEF, 0xFD, 0xFF, 0x3F, 0x80, 0x01, 0xE0, 0x3C, 0x0F, 0x83,
  0xF0, 0xFC, 0x3B, 0x87, 0xF1, 0xDE, 0x73, 0x9F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x78, 0x0E, 0x03, 0xC0, 0x0F, 0xE3, 0xFC, 0x7F, 0x8E, 0x03, 0xC0, 0x7E,
  0x0F, 0xE1, 0xFE, 0x23, 0xC0, 0x78, 0x0F, 0x41, 0xEF, 0xF9, 0xFF, 0x3F,
  0x80, 0x07, 0xE3, 0xF8, 0xFF, 0x3E, 0x07, 0x80, 0xEE, 0x3F, 0xE7, 0xFE,
  0xF3, 0xDE, 0x7B, 0xCE, 0x7B, 0xCF, 0xF8, 0xFE, 0x0F, 0x80, 0x1F, 0xF3,
  0xFF, 0x3F, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0xC3, 0xFC,
  0x7F, 0x9E, 0x73, 0xDE, 0x7F, 0x87, 0xE0, 0xFC, 0x3F, 0xCF, 0x79, 0xC7,
  0x79, 0xE7, 0xFC, 0xFF, 0x0F, 0xC0, 0x1F, 0x0F, 0xE7, 0xFD, 0xEF, 0xF3,
  0xFC, 0xFF, 0x3F, 0xFF, 0x7F, 0xDE, 0xE0, 0x78, 0x3C, 0xFE, 0x3F, 0x0F,
  0x80, 0x18, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x63, 0xCF, 0x3C, 0x0C, 0x3C,
  0x78, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x71, 0xE3, 0x87, 0x1C, 0x38, 0x00,
  0x00, 0xC0, 0xF0, 0xFC, 0xFC, 0xFC, 0x3C, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0,
  0x70, 0x04, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x80,
  0x38, 0x0F, 0x81, 0xF8, 0x0F, 0x80, 0xF1, 0xFD, 0xFC, 0xF8, 0x38, 0x08,
  0x00, 0x3F, 0x3F, 0xDF, 0xEC, 0xF0, 0x78, 0x78, 0x7C, 0x78, 0x38, 0x3C,
  0x00, 0x06, 0x0F, 0x07, 0x83, 0xC0, 0x03, 0xF8, 0x0F, 0xFC, 0x1E, 0x1E,
  0x38, 0x07, 0x73, 0xF7, 0x67, 0xF7, 0xEE, 0x77, 0xEE, 0x67, 0xCC, 0x67,
  0xCC, 0xE6, 0xCF, 0xEE, 0xCF, 0xFC, 0xE7, 0x30, 0xE0, 0x00, 0x7D, 0xE0,
  0x3F, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x77,
  0x07, 0xB8, 0x39, 0xC3, 0xCE, 0x1E, 0x71, 0xFF, 0x8F, 0xFC, 0xFF, 0xF7,
  0x87, 0xF8, 0x3F, 0xC1, 0xE0, 0x1F, 0xE1, 0xFF, 0x1F, 0xF1, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3F, 0xE3, 0xFC, 0x3F, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x7F,
  0xEF, 0xFC, 0xFF, 0x00, 0x0F, 0xE1, 0xFF, 0x3F, 0xE7, 0xC6, 0x78, 0x07,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x08, 0xFF, 0x87,
  0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0xFF, 0x87, 0xFC, 0x39, 0xF3, 0xC7, 0x9E,
  0x3C, 0xF1, 0xE7, 0x8F, 0x38, 0x7B, 0xC7, 0x9E, 0x3C, 0xF7, 0xC7, 0xFE,
  0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x8E, 0x03, 0xC0, 0x78,
  0x0F, 0xF1, 0xFE, 0x3F, 0x8F, 0x01, 0xE0, 0x3C, 0x07, 0xF9, 0xFF, 0x3F,
  0xC0, 0x1F, 0xE3, 0xFC, 0x7F, 0x8E, 0x03, 0xC0, 0x78, 0x0F, 0xF1, 0xFE,
  0x3F, 0x8F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x00, 0x07, 0xF8,
  0xFF, 0x8F, 0xFC, 0x78, 0x47, 0x80, 0x3C, 0x03, 0xCF, 0xDE, 0x7E, 0xF3,
  0xE7, 0xAF, 0x3C, 0x79, 0xE3, 0xCF, 0xFC, 0x3F, 0xE0, 0xFF, 0x00, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x0E, 0x3C, 0x78, 0xF1, 0xE3, 0xFF, 0x8F,
  0xFE, 0x3F, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF3, 0xC3, 0x8F,
  0x1E, 0x00, 0x1F, 0xE3, 0xFC, 0x3F, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0xFE, 0x3F, 0xC0, 0x01,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0xBE, 0x3F, 0x0F, 0x83, 0xC0,
  0x1E, 0x3E, 0x3C, 0xF0, 0x7B, 0xE0, 0xE7, 0x83, 0xDE, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0x81, 0xEF, 0x03, 0xDF, 0x07, 0x9E,
  0x1E, 0x3C, 0x3C, 0x7C, 0x00, 0x1E, 0x0F, 0x07, 0x83, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0x07,
  0xC7, 0xC3, 0xF1, 0xF0, 0xFC, 0x7C, 0x7E, 0x3F, 0x1F, 0x8E, 0xC6, 0xE3,
  0xB3, 0xF8, 0xEC, 0xFE, 0x3B, 0x77, 0x1E, 0xDD, 0xC7, 0xBE, 0xF1, 0xCF,
  0xBC, 0x73, 0xCF, 0x3C, 0xF3, 0x8F, 0x39, 0xE0, 0x1F, 0x0F, 0x1F, 0x0E,
  0x1F, 0x0E, 0x1F, 0x9E, 0x3F, 0x9E, 0x3B, 0x9C, 0x3B, 0x9C, 0x3B, 0xDC,
  0x3B, 0xFC, 0x79, 0xFC, 0x79, 0xF8, 0x71, 0xF8, 0x71, 0xF8, 0xF0, 0xF8,
  0xF0, 0xF0, 0x07, 0xE0, 0xFF, 0x8F, 0xFC, 0x79, 0xF7, 0x87, 0xBC, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0xF7, 0x87, 0xBC, 0x3D, 0xE3, 0xCF, 0xFE, 0x3F,
  0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x1F, 0xF1, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3D, 0xF3, 0xFE, 0x3F, 0xC7, 0xF8, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0xF0, 0x00, 0x07, 0xE0, 0xFF, 0x8F, 0xFC, 0x79, 0xF7, 0x87, 0xBC, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0xF7, 0x87, 0xBC, 0x7D, 0xE3, 0xCF, 0xFE, 0x3F,
  0xE0, 0xFE, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x1F, 0xC1, 0xFE,
  0x1F, 0xF1, 0xCF, 0x3C, 0xF3, 0xCF, 0x3D, 0xF3, 0xFE, 0x3F, 0xC7, 0xFC,
  0x7B, 0xC7, 0xBC, 0x79, 0xEF, 0x1E, 0xF1, 0xF0, 0x0F, 0xC3, 0xFC, 0xFF,
  0x1E, 0x23, 0xC0, 0x78, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF0, 0x1E, 0x63,
  0xCF, 0xF9, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0x3C, 0x0F,
  0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x00,
  0x3C, 0x79, 0xE3, 0xCF, 0x1C, 0x71, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xCF,
  0x1C, 0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xE7, 0x8F, 0xFC, 0x3F, 0xC0, 0xFC,
  0x00, 0xF0, 0xFF, 0x1E, 0xF1, 0xEF, 0x3C, 0xF3, 0xCF, 0x38, 0xF7, 0x8F,
  0x70, 0xFF, 0x0F, 0xE0, 0xEE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x00,
  0xE1, 0xE3, 0xF8, 0x70, 0xEE, 0x3C, 0x7B, 0x8F, 0x1E, 0xE7, 0xCF, 0x39,
  0xF3, 0xCE, 0x7C, 0xE3, 0xBF, 0x78, 0xEF, 0xDC, 0x3F, 0x77, 0x0F, 0xDF,
  0xC3, 0xE7, 0xE0, 0xF9, 0xF8, 0x3E, 0x7C, 0x0F, 0x1F, 0x00, 0x1E, 0x1E,
  0x1E, 0x78, 0x3D, 0xE0, 0x7B, 0xC0, 0xFF, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F, 0x81, 0xEF, 0x07, 0xCF, 0x0F, 0x1E,
  0x3C, 0x3C, 0x00, 0xF1, 0xFF, 0x1E, 0xF3, 0xC7, 0x78, 0x77, 0x87, 0xF0,
  0x7E, 0x07, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFC, 0x03, 0xE0, 0x3E, 0x01, 0xE0,
  0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xFE, 0x7F,
  0xE3, 0xFF, 0x00, 0x0F, 0x87, 0xC3, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38,
  0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x7C, 0x7E, 0x3E,
  0x00, 0xE3, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x78, 0xE3, 0x8E, 0x38, 0xE3,
  0xC0, 0x1F, 0x8F, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x0F,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0xF8, 0x7C, 0x3E, 0x00, 0x03,
  0x00, 0xE0, 0x1E, 0x07, 0xC1, 0xF8, 0x3B, 0x0E, 0x73, 0x8E, 0x71, 0xDC,
  0x1C, 0x7F, 0xFF, 0xEF, 0xF8, 0xF3, 0x8E, 0x1C, 0xE7, 0xFD, 0xFF, 0x3D,
  0xEF, 0x3D, 0xE7, 0xBC, 0xE7, 0x9C, 0xF7, 0x9F, 0xF3, 0xFE, 0x3F, 0x80,
  0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xDC, 0x7F, 0xCF, 0xF9, 0xEF, 0x39,
  0xEF, 0x3D, 0xE7, 0xBC, 0xF7, 0xBC, 0xFF, 0xBF, 0xE7, 0x78, 0x0F, 0x1F,
  0xDF, 0xCF, 0x2F, 0x07, 0x83, 0xC1, 0xC0, 0xF2, 0x7F, 0x3F, 0x8F, 0xC0,
  0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x1D, 0xE3, 0xFE, 0x7F, 0xC7, 0xBC,
  0xF3, 0xCF, 0x3C, 0xF3, 0x8F, 0x38, 0xF7, 0x8F, 0xF8, 0xFF, 0x87, 0xF0,
  0x0F, 0x0F, 0xE7, 0xFD, 0xEF, 0xF3, 0xFF, 0xEF, 0xF3, 0xE0, 0xE0, 0xBF,
  0xCF, 0xF1, 0xF8, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x78, 0x07, 0xE1, 0xFE,
  0x1F, 0xC0, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0xFC, 0x0F, 0x80, 0xF0, 0x00, 0x0E,
  0x71, 0xFF, 0x3F, 0xE3, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xC7, 0x9C, 0x7B,
  0xC7, 0xFC, 0x7F, 0xC3, 0xB8, 0x03, 0x88, 0x78, 0xFF, 0x0F, 0xF0, 0xFC,
  0x00, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xDC, 0x7F, 0xCF, 0xF9, 0xEF,
  0x3D, 0xEF, 0x3D, 0xE7, 0xBC, 0xF7, 0x9C, 0xE7, 0xBC, 0xF7, 0x9E, 0x1E,
  0x3C, 0x78, 0x03, 0xC7, 0x8F, 0x1E, 0x38, 0xF1, 0xE3, 0xC7, 0x8E, 0x3C,
  0x78, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x8F,
  0xC3, 0xF0, 0xF8, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC7,
  0x9E, 0x78, 0xF7, 0x87, 0xF8, 0x3B, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xBC, 0x39, 0xE3, 0xCF, 0x1E, 0x3C, 0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x8F,
  0x1E, 0x38, 0xF1, 0xE3, 0xC7, 0x8E, 0x3C, 0x78, 0x3D, 0xC7, 0x1D, 0xF7,
  0xCF, 0xFF, 0xE7, 0xBE, 0xF3, 0xDE, 0x7B, 0xCF, 0x3D, 0xE7, 0x9E, 0xF3,
  0xCE, 0x79, 0xC7, 0x39, 0xE7, 0xBC, 0xF3, 0xDE, 0x79, 0xE0, 0x3D, 0xC7,
  0x7C, 0xFF, 0x9E, 0xF3, 0xDE, 0xF3, 0xDE, 0x7B, 0xCF, 0x79, 0xCE, 0x7B,
  0xCF, 0x79, 0xE0, 0x0F, 0x0F, 0xE7, 0xFD, 0xEF, 0xF3, 0xFC, 0xFF, 0x3F,
  0xCF, 0xF7, 0xBF, 0xEF, 0xF1, 0xF8, 0x1E, 0xE1, 0xDF, 0x1F, 0xF1, 0xEF,
  0x1C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3D, 0xE3, 0xFE, 0x7F, 0xC7, 0xF8,
  0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x00, 0x1C, 0xE7, 0xFD, 0xFF,
  0x3D, 0xEF, 0x3D, 0xE7, 0xBC, 0xE7, 0x9C, 0xF7, 0x9F, 0xF3, 0xFE, 0x3B,
  0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x00, 0x39, 0x9D, 0xCF, 0xE7,
  0xF3, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x00, 0x0F, 0x0F,
  0xF3, 0xF9, 0xE2, 0x7C, 0x0F, 0x83, 0xF0, 0x3C, 0x87, 0x3F, 0xCF, 0xF3,
  0xF8, 0x1C, 0x1C, 0x3F, 0xFF, 0xFF, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0xF0,
  0xFC, 0xFC, 0x7C, 0x79, 0xEF, 0x3D, 0xE7, 0xB8, 0xE7, 0x3D, 0xE7, 0xBC,
  0xF7, 0x9E, 0xF7, 0x9F, 0xF3, 0xFE, 0x3D, 0xC0, 0xF1, 0xFE, 0x7B, 0xCF,
  0x79, 0xCF, 0x78, 0xEE, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3C,
  0x00, 0xF3, 0xC7, 0xF3, 0xCF, 0xF7, 0xCE, 0xF7, 0xDE, 0xF7, 0xDC, 0xFF,
  0xDC, 0xFF, 0xFC, 0xED, 0xF8, 0xFD, 0xF8, 0xF9, 0xF0, 0xF9, 0xF0, 0xF9,
  0xE0, 0x3E, 0x78, 0xF7, 0x87, 0xBC, 0x3F, 0xC0, 0xFC, 0x07, 0xC0, 0x3E,
  0x03, 0xF0, 0x3F, 0xC1, 0xFE, 0x1E, 0xF1, 0xE3, 0xC0, 0x3C, 0x79, 0xE7,
  0x8F, 0x3C, 0x79, 0xC3, 0xDE, 0x0E, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x03, 0xF0, 0x1F, 0x00, 0xF0,
  0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x91, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xF0,
  0x3C, 0x0F, 0xF1, 0xFE, 0x7F, 0xC0, 0x07, 0x87, 0xC3, 0xC3, 0xC1, 0xE0,
  0xE0, 0x70, 0x78, 0xF8, 0x78, 0x3E, 0x07, 0x03, 0x83, 0xC1, 0xC0, 0xF8,
  0x7C, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1C,
  0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x0F, 0x0F, 0x1F, 0x3C, 0x38,
  0x38, 0x38, 0xF8, 0xF0, 0xE0, 0xFC, 0x7F, 0xF9, 0xFE, 0x0C,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 15, 6, 0, -15 },
  { 15, 9, 5, 10, 2, -15 },
  { 21, 13, 15, 13, 0, -15 },
  { 46, 11, 17, 11, 0, -16 },
  { 70, 17, 15, 18, 1, -15 },
  { 102, 14, 15, 14, 0, -15 },
  { 129, 4, 5, 5, 2, -15 },
  { 132, 8, 18, 7, 1, -15 },
  { 150, 8, 18, 7, -1, -15 },
  { 168, 10, 10, 11, 1, -16 },
  { 181, 10, 11, 12, 1, -13 },
  { 195, 5, 6, 6, -1, -3 },
  { 199, 6, 3, 7, 0, -7 },
  { 202, 4, 4, 6, 0, -4 },
  { 204, 12, 15, 9, -1, -15 },
  { 227, 10, 15, 11, 1, -15 },
  { 246, 9, 15, 11, 2, -15 },
  { 263, 12, 15, 11, -1, -15 },
  { 286, 11, 15, 11, 0, -15 },
  { 307, 11, 15, 11, 0, -15 },
  { 328, 11, 15, 11, 0, -15 },
  { 349, 11, 15, 11, 1, -15 },
  { 370, 12, 15, 11, 0, -15 },
  { 393, 11, 15, 11, 0, -15 },
  { 414, 10, 15, 11, 1, -15 },
  { 433, 6, 12, 6, 0, -12 },
  { 442, 7, 15, 6, -1, -12 },
  { 456, 10, 11, 12, 1, -13 },
  { 470, 10, 7, 12, 1, -11 },
  { 479, 10, 11, 12, 1, -13 },
  { 493, 9, 15, 9, 1, -15 },
  { 510, 16, 17, 17, 1, -15 },
  { 544, 13, 15, 13, -1, -15 },
  { 569, 12, 15, 12, 0, -15 },
  { 592, 12, 15, 12, 1, -15 },
  { 615, 13, 15, 13, 0, -15 },
  { 640, 11, 15, 11, 0, -15 },
  { 661, 11, 15, 11, 0, -15 },
  { 682, 13, 15, 14, 1, -15 },
  { 707, 14, 15, 14, 0, -15 },
  { 734, 11, 15, 9, -1, -15 },
  { 755, 10, 20, 7, -3, -15 },
  { 780, 15, 15, 13, 0, -15 },
  { 809, 9, 15, 10, 0, -15 },
  { 826, 18, 15, 18, 0, -15 },
  { 860, 16, 15, 15, 0, -15 },
  { 890, 13, 15, 14, 1, -15 },
  { 915, 12, 15, 12, 0, -15 },
  { 938, 13, 19, 14, 1, -15 },
  { 969, 12, 15, 13, 0, -15 },
  { 992, 11, 15, 11, 0, -15 },
  { 1013, 10, 15, 11, 2, -15 },
  { 1032, 13, 15, 14, 1, -15 },
  { 1057, 12, 15, 12, 2, -15 },
  { 1080, 18, 15, 18, 2, -15 },
  { 1114, 15, 15, 13, -1, -15 },
  { 1143, 12, 15, 12, 2, -15 },
  { 1166, 13, 15, 11, -1, -15 },
  { 1191, 9, 19, 7, -1, -15 },
  { 1213, 6, 15, 9, 2, -15 },
  { 1225, 9, 19, 7, -1, -15 },
  { 1247, 11, 10, 11, 0, -15 },
  { 1261, 10, 3, 9, -2, 1 },
  { 1265, 5, 3, 7, 3, -16 },
  { 1267, 11, 12, 12, 1, -12 },
  { 1284, 11, 16, 12, 0, -16 },
  { 1306, 9, 12, 10, 1, -12 },
  { 1320, 12, 16, 12, 1, -16 },
  { 1344, 10, 12, 11, 1, -12 },
  { 1359, 12, 21, 8, -2, -16 },
  { 1391, 12, 17, 12, 0, -12 },
  { 1417, 11, 16, 12, 0, -16 },
  { 1439, 7, 16, 6, 0, -16 },
  { 1453, 10, 21, 6, -3, -16 },
  { 1480, 13, 16, 12, 0, -16 },
  { 1506, 7, 16, 6, 0, -16 },
  { 1520, 17, 12, 18, 0, -12 },
  { 1546, 11, 12, 12, 0, -12 },
  { 1563, 10, 12, 12, 1, -12 },
  { 1578, 12, 17, 12, -1, -12 },
  { 1604, 11, 17, 12, 1, -12 },
  { 1628, 9, 12, 9, 0, -12 },
  { 1642, 10, 12, 10, 0, -12 },
  { 1657, 8, 14, 9, 1, -14 },
  { 1671, 11, 12, 12, 1, -12 },
  { 1688, 11, 12, 11, 1, -12 },
  { 1705, 16, 12, 16, 1, -12 },
  { 1729, 13, 12, 11, -1, -12 },
  { 1749, 13, 17, 11, -1, -12 },
  { 1777, 11, 12, 9, -1, -12 },
  { 1794, 9, 18, 7, 0, -15 },
  { 1815, 3, 21, 11, 4, -16 },
  { 1823, 8, 18, 7, -1, -15 },
  { 1841, 10, 4, 12, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC21PT7B_H_
