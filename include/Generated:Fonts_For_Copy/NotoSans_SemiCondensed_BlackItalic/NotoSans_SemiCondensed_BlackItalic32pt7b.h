#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC32PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0x01, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1E, 0x00, 0x7C, 0xFB, 0xE7,
  0xDF, 0x3E, 0xF3, 0xEF, 0x9F, 0x7C, 0xFB, 0xE7, 0x9E, 0x3C, 0x00, 0xF1,
  0xE0, 0x0F, 0x3C, 0x01, 0xF3, 0xC0, 0x1E, 0x3C, 0x01, 0xE7, 0x80, 0x1E,
  0x78, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x07,
  0x8F, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xC1, 0xE7, 0xC0, 0x1E, 0x78, 0x03, 0xE7, 0x80,
  0x3C, 0x78, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x70,
  0x03, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x3F, 0xEE, 0x3E, 0xC2,
  0x3E, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x01, 0xFC, 0x03, 0xFE, 0x83, 0xBE, 0xC3, 0x7C, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF0, 0x3F, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0F, 0x80, 0x3C, 0x1F, 0xE0, 0x3E, 0x0F, 0xF8, 0x1E, 0x0F, 0xFC, 0x1E,
  0x07, 0x9E, 0x1F, 0x07, 0xCF, 0x0F, 0x03, 0xC7, 0x8F, 0x01, 0xE7, 0xCF,
  0x80, 0xF3, 0xEF, 0x80, 0x79, 0xE7, 0x9F, 0x3F, 0xF7, 0x9F, 0xDF, 0xF7,
  0xDF, 0xF7, 0xF3, 0xDF, 0xF9, 0xF3, 0xCF, 0xBC, 0x03, 0xE7, 0x9E, 0x01,
  0xE7, 0xCF, 0x01, 0xE3, 0xE7, 0x81, 0xF1, 0xE3, 0xC0, 0xF0, 0xF3, 0xE0,
  0xF0, 0x7F, 0xE0, 0xF8, 0x3F, 0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07,
  0xCF, 0xC0, 0x3F, 0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xCF, 0xC7, 0xFE, 0x3E, 0x3F, 0xF9, 0xF9,
  0xFF, 0xF7, 0xC7, 0xEF, 0xFF, 0x3F, 0x1F, 0xF8, 0xFC, 0x7F, 0xE3, 0xF0,
  0xFF, 0x0F, 0xF7, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x81, 0xFE, 0x7F, 0x00, 0x7D, 0xF7, 0xDE, 0xFB, 0xEF, 0xBC, 0x01, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07,
  0x80, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0,
  0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x02, 0x00,
  0x03, 0xC0, 0x07, 0x81, 0x1F, 0x07, 0x3C, 0x0F, 0xF8, 0x5F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0x81, 0xFF, 0x07, 0xDF, 0x03, 0x9F,
  0x02, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x1F, 0x8F,
  0x8F, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0x7F, 0xDF, 0xE7, 0xF9, 0xFE,
  0xFF, 0x80, 0x19, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF,
  0x3F, 0x3F, 0x3F, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7C, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0x80,
  0x00, 0x7C, 0x03, 0xF0, 0x3F, 0xC1, 0xFF, 0x1F, 0xF8, 0xFF, 0xEF, 0xFF,
  0x9F, 0xFE, 0x39, 0xF8, 0xC7, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xE3, 0xF0, 0x20, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xF1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x03, 0xFC, 0x07,
  0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x20, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x7F, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x7F, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x40, 0x3F, 0x3E,
  0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07,
  0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xDF, 0x03, 0xDF, 0x83, 0xEF, 0xC3,
  0xE7, 0xE3, 0xE3, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x87, 0xFF,
  0xC1, 0xFF, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x40,
  0x3F, 0x3E, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x80,
  0x00, 0x7F, 0x81, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFC,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0xF8, 0x3E, 0xFE, 0x1F, 0xFF, 0x8F,
  0xFF, 0xCF, 0xFF, 0xE7, 0xF3, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E,
  0x7E, 0x3F, 0x3F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F,
  0x80, 0x1F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xBF, 0x3F, 0x1F, 0x3F, 0x1F, 0x3F, 0x3F, 0x1F, 0xFE, 0x1F,
  0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0x7F, 0xFC, 0xFC, 0xFC, 0xFC,
  0x7C, 0xF8, 0x7E, 0xF8, 0x7C, 0xFC, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F,
  0xF0, 0x1F, 0xE0, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFE, 0x7F, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x7F, 0x7E,
  0x7F, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xBE, 0x1F, 0x7E, 0x00, 0x7C, 0x00,
  0xFC, 0x01, 0xF8, 0xCF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF,
  0x00, 0x07, 0x07, 0xC7, 0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x83, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x00, 0x01, 0xC0,
  0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00,
  0xFF, 0x03, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x0F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFE, 0x3F,
  0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x80, 0x00, 0x0F,
  0xE3, 0xFF, 0x9F, 0xFE, 0xFF, 0xF7, 0xFF, 0x90, 0x7C, 0x03, 0xE0, 0x3F,
  0x03, 0xF0, 0x7F, 0x87, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFE,
  0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0x78, 0x78, 0x7F, 0x3E, 0x78,
  0xFF, 0xCF, 0x3C, 0xFF, 0xE7, 0xBC, 0x7C, 0xE3, 0xDE, 0x78, 0xF1, 0xEE,
  0x3C, 0x78, 0xFF, 0x3E, 0x3C, 0x77, 0x9E, 0x3E, 0x7B, 0xCF, 0x1E, 0x3D,
  0xE7, 0x8F, 0x3C, 0xF3, 0xFF, 0xFE, 0x79, 0xFF, 0xFE, 0x3C, 0x7E, 0xFE,
  0x0F, 0x0C, 0x08, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0C, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x00, 0xFB, 0xE0, 0x0F, 0xBE, 0x01, 0xF3, 0xE0, 0x1F, 0x3E,
  0x03, 0xF3, 0xE0, 0x3E, 0x3E, 0x07, 0xE3, 0xE0, 0x7C, 0x3E, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xF0,
  0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0xFE, 0x03, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0x8F, 0xC3,
  0xF1, 0xF8, 0x7C, 0x7E, 0x1F, 0x8F, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xF0, 0x7E, 0xFF, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F,
  0x1F, 0x8F, 0xC7, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x07,
  0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0x83, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x81, 0xFF,
  0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0xFC, 0xFE, 0x0F, 0xC7, 0xE0, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x0F,
  0xE3, 0xF0, 0xFC, 0x3E, 0x1F, 0xC7, 0xE3, 0xF8, 0x7F, 0xFF, 0x87, 0xFF,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xFF,
  0x83, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFC, 0x0C, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x02, 0x7E, 0x3F, 0xC7, 0xE7, 0xFC, 0x7E, 0x7F, 0xCF, 0xC7,
  0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F,
  0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x03, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x81, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE,
  0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0xE0, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80,
  0xFE, 0x00, 0x07, 0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0x7C, 0x3F, 0x03, 0xF1,
  0xFC, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F, 0x00, 0xFD, 0xF8, 0x03, 0xEF, 0xE0,
  0x1F, 0xBF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xDF, 0xC0, 0x3E, 0x3F,
  0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xE0, 0x7E, 0x1F, 0x81,
  0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF8, 0x07, 0xFF, 0xDF, 0xFF, 0x7F, 0xF9, 0xFF, 0xEF, 0xFF, 0x80, 0x07,
  0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x7F, 0xC0,
  0xFF, 0x8F, 0xFC, 0x1F, 0x78, 0xF7, 0xC1, 0xF7, 0x8F, 0xFC, 0x1F, 0x79,
  0xFF, 0xC1, 0xF7, 0x9E, 0xF8, 0x3F, 0x7B, 0xEF, 0x83, 0xF7, 0xBD, 0xF8,
  0x3E, 0x7F, 0xDF, 0x83, 0xE7, 0xF9, 0xF0, 0x3E, 0x7F, 0x9F, 0x07, 0xE7,
  0xF1, 0xF0, 0x7E, 0x7F, 0x3F, 0x07, 0xC7, 0xF3, 0xF0, 0x7C, 0x7E, 0x3E,
  0x07, 0xC7, 0xE3, 0xE0, 0xFC, 0x7C, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x07,
  0xF0, 0x3E, 0x07, 0xF0, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x7E, 0x0F,
  0xF8, 0x7E, 0x0F, 0xF8, 0x7C, 0x0F, 0xFC, 0x7C, 0x1F, 0x7C, 0x7C, 0x1F,
  0x7C, 0xFC, 0x1F, 0x7C, 0xFC, 0x1F, 0x7E, 0xF8, 0x3F, 0x3E, 0xF8, 0x3F,
  0x3E, 0xF8, 0x3E, 0x3E, 0xF8, 0x3E, 0x3F, 0xF0, 0x3E, 0x1F, 0xF0, 0x7E,
  0x1F, 0xF0, 0x7C, 0x1F, 0xF0, 0x7C, 0x1F, 0xF0, 0x7C, 0x0F, 0xE0, 0x7C,
  0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFC, 0x7F, 0x3F, 0x83, 0xF3, 0xF0,
  0x3F, 0x7F, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E,
  0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0x7E, 0x0F, 0xC7,
  0xE1, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF,
  0x0F, 0xFF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xFB, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF,
  0xC0, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFC, 0x7F, 0x3F, 0x83,
  0xF3, 0xF0, 0x3F, 0x7F, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0,
  0x3F, 0x7E, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0x7E,
  0x0F, 0xC7, 0xE1, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xF3, 0xF0, 0xFC, 0x7C, 0x3E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE7, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFD, 0xF8, 0x3E, 0x7E, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x9F, 0x07, 0xEF, 0xC1, 0xFC, 0x01, 0xFE, 0x03,
  0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFC, 0x30, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x80, 0xFC, 0x30, 0x7E, 0x3F,
  0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x87, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x1F, 0x87, 0xE3, 0xF0,
  0xFC, 0x7C, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3,
  0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3E, 0x0F,
  0xCF, 0xC1, 0xF9, 0xF8, 0x3E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F,
  0x1F, 0x8F, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0,
  0x07, 0xF8, 0x00, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFB, 0xE0, 0x7E,
  0xF8, 0x3F, 0x3E, 0x0F, 0xCF, 0x87, 0xE3, 0xE1, 0xF8, 0xF8, 0xFC, 0x3E,
  0x3F, 0x0F, 0x8F, 0x83, 0xF7, 0xE0, 0xFD, 0xF0, 0x3F, 0xFC, 0x0F, 0xBE,
  0x03, 0xEF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x1F, 0x03, 0xFF, 0x81,
  0xF0, 0x7E, 0xF8, 0x3F, 0x07, 0xEF, 0x83, 0xF0, 0xFC, 0xF8, 0x7F, 0x0F,
  0xCF, 0x87, 0xF0, 0xF8, 0xF8, 0xFF, 0x1F, 0x8F, 0x8F, 0xF1, 0xF0, 0xF8,
  0xFF, 0x3F, 0x0F, 0x9F, 0xF3, 0xF0, 0xF9, 0xFF, 0x3E, 0x0F, 0xBF, 0xF7,
  0xE0, 0xFB, 0xFF, 0x7C, 0x0F, 0xFD, 0xF7, 0xC0, 0xFF, 0xDF, 0xFC, 0x0F,
  0xF9, 0xFF, 0x80, 0xFF, 0x9F, 0xF8, 0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0x1F,
  0xF0, 0x0F, 0xF1, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00,
  0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0xFE, 0x03, 0xF0,
  0xFC, 0x03, 0xF1, 0xF8, 0x01, 0xF3, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xCF, 0xC0, 0x1F, 0xCF,
  0xC0, 0x3F, 0x8F, 0xC0, 0x3F, 0x0F, 0xE0, 0x7F, 0x07, 0xE0, 0xFE, 0x07,
  0xE0, 0xFC, 0x1F, 0xFF, 0x07, 0xEF, 0xC3, 0xF3, 0xF1, 0xFC, 0x7C, 0x7E,
  0x1F, 0x3F, 0x07, 0xEF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01,
  0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x80,
  0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xF8, 0x3C, 0x1E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0x78, 0x3E, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x7F, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x70, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xBC, 0x0F, 0xBC, 0x1F, 0x3E,
  0x1E, 0x1E, 0x3E, 0x1E, 0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x0F, 0x7F, 0xFE,
  0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0xFD, 0xF9, 0xF3, 0xE3, 0xE3, 0xC0,
  0x07, 0xCF, 0x87, 0xF7, 0xC7, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF3, 0xF9,
  0xF9, 0xF8, 0xFC, 0xFC, 0x7C, 0xFC, 0x3E, 0x7E, 0x1F, 0x3F, 0x1F, 0x9F,
  0x8F, 0xCF, 0xC7, 0xC7, 0xE7, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0x7C,
  0x1F, 0x3C, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF,
  0xC7, 0xFF, 0xE3, 0xF3, 0xF1, 0xF1, 0xF9, 0xF8, 0xFC, 0xF8, 0x7E, 0x7C,
  0x3F, 0x3E, 0x1F, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0xFF, 0xC7, 0xFF, 0xE3,
  0xFF, 0xE3, 0xEF, 0xE1, 0xF3, 0xE0, 0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0xCF,
  0xFE, 0x3F, 0xF9, 0xFC, 0x27, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x13, 0xFB, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x79, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF,
  0xC3, 0xFF, 0xF1, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0x8F, 0xC3, 0xE3,
  0xF0, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xC3, 0xF7, 0xF0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x07, 0xF7, 0xC0, 0xF9, 0xE0, 0x01, 0xF8, 0x07, 0xFC,
  0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0x3F, 0x7E, 0x3F, 0x7E, 0x3E, 0x7F, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x18,
  0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xF0,
  0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xE7, 0xC1, 0xFD,
  0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xE7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7C, 0x7E, 0x1F, 0x1F, 0x87, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x7E, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xDF,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x81, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x78, 0x1F, 0xFE,
  0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xF3, 0xF1, 0xF1, 0xF9, 0xF8,
  0xFC, 0xFC, 0x7E, 0x7E, 0x3F, 0x3E, 0x1F, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF,
  0xC7, 0xE7, 0xE3, 0xE3, 0xE1, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0x03, 0xC0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x06, 0x00, 0x00, 0x7E, 0x0F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x1C, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0x78, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x87, 0xF0, 0xF8, 0x7E, 0x1F, 0x8F, 0xC1, 0xF9, 0xF8,
  0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x3F, 0x7C, 0x03, 0xFF, 0xC0, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFE, 0x07, 0xE7,
  0xE0, 0x7E, 0x7E, 0x07, 0xC7, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0x07,
  0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0x0F, 0x1E, 0x0F, 0x03,
  0xDF, 0xCF, 0xE1, 0xF7, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xC7, 0xE7, 0xF3, 0xF1, 0xF1, 0xF8, 0xFC, 0xFC, 0x7E, 0x3F, 0x3F, 0x1F,
  0x8F, 0xCF, 0xC7, 0xC3, 0xE3, 0xE1, 0xF0, 0xF9, 0xF8, 0xFC, 0x7E, 0x7E,
  0x3F, 0x1F, 0x9F, 0x8F, 0xC7, 0xE7, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xFC,
  0xFC, 0x7E, 0x3F, 0x3F, 0x1F, 0x8F, 0xC0, 0x0F, 0x1E, 0x07, 0xBF, 0x87,
  0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFC, 0xFC, 0x7C, 0x7E, 0x7E, 0x3F,
  0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0x87, 0xCF, 0xC7, 0xE7, 0xE3, 0xF3, 0xF1,
  0xF9, 0xF8, 0xF8, 0xF8, 0x7C, 0xFC, 0x7E, 0x7E, 0x3F, 0x00, 0x03, 0xF0,
  0x07, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFF, 0x7E, 0x3F, 0x7E, 0x3F,
  0x7E, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E,
  0xFC, 0xFC, 0xFF, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x03, 0xCF,
  0x80, 0x7B, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xCF,
  0xC1, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F,
  0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x07, 0xEF, 0x80, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xCF, 0x87, 0xF7, 0xC7, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF3, 0xF9,
  0xF9, 0xF8, 0xFC, 0xFC, 0x7C, 0xFC, 0x3E, 0x7E, 0x1F, 0x3F, 0x1F, 0x9F,
  0x8F, 0xCF, 0xCF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC,
  0x1F, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0x1C, 0x3D, 0xF1,
  0xF7, 0xC7, 0xFF, 0x1F, 0xF8, 0x7F, 0xE1, 0xF8, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE3,
  0xF1, 0x87, 0xE1, 0x0F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xC8, 0x1F, 0x9C, 0x3F, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xE0,
  0xFF, 0x80, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0xF3, 0xFF, 0xBF, 0xFB,
  0xFF, 0xDF, 0xFE, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0x80, 0x7E, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xF8,
  0x00, 0x1F, 0x0F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xF3, 0xE1, 0xF1,
  0xF1, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x3F, 0x3E, 0x1F, 0x3F, 0x1F,
  0x9F, 0x8F, 0xCF, 0xCF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F,
  0x7C, 0x1F, 0x3E, 0x00, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x7E, 0xF8, 0x7E,
  0xF8, 0xFC, 0xF8, 0xFC, 0xF9, 0xF8, 0xF9, 0xF8, 0xF9, 0xF0, 0xFB, 0xE0,
  0x7B, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0xF8, 0x7E, 0x1F, 0xF8, 0xFE, 0x3F, 0xF8, 0xFE,
  0x3E, 0xF8, 0xFE, 0x7E, 0xF9, 0xFE, 0x7E, 0xF9, 0xFE, 0x7C, 0xF9, 0xFE,
  0xFC, 0xFB, 0xDE, 0xF8, 0xFB, 0xDF, 0xF8, 0xFF, 0xDF, 0xF0, 0xFF, 0xBD,
  0xF0, 0xFF, 0xBF, 0xE0, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F,
  0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x0F, 0xE3,
  0xF8, 0x3F, 0x3F, 0x81, 0xF9, 0xF8, 0x0F, 0xDF, 0x80, 0x3E, 0xFC, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x7E,
  0xFC, 0x07, 0xE7, 0xE0, 0x7F, 0x1F, 0x87, 0xF0, 0xFC, 0x00, 0x0F, 0x83,
  0xF0, 0xF8, 0x3F, 0x0F, 0x87, 0xE0, 0xF8, 0x7E, 0x0F, 0xCF, 0xC0, 0xFC,
  0xFC, 0x0F, 0xDF, 0x80, 0xFD, 0xF8, 0x0F, 0xDF, 0x00, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F,
  0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF,
  0xF8, 0xFF, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF8,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x3E, 0x01,
  0xF8, 0x0F, 0xC0, 0xFF, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0xFF, 0x0F, 0xF0,
  0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x0F, 0xE0, 0xFE,
  0x07, 0xF0, 0x3F, 0x01, 0xF0, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFE, 0x80, 0x38,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 11, 23, 9, 0, -23 },
  { 33, 13, 8, 15, 3, -23 },
  { 46, 20, 23, 19, 0, -23 },
  { 104, 16, 26, 17, 1, -24 },
  { 156, 25, 23, 28, 2, -23 },
  { 228, 22, 23, 22, 0, -23 },
  { 292, 6, 8, 8, 3, -23 },
  { 298, 12, 28, 11, 1, -23 },
  { 340, 12, 28, 11, -2, -23 },
  { 382, 15, 16, 16, 2, -25 },
  { 412, 16, 15, 18, 1, -19 },
  { 442, 9, 8, 9, -2, -4 },
  { 451, 10, 5, 10, 0, -11 },
  { 458, 6, 6, 9, 0, -6 },
  { 463, 19, 23, 14, -2, -23 },
  { 518, 16, 23, 17, 1, -23 },
  { 564, 14, 23, 17, 2, -23 },
  { 605, 18, 23, 17, -1, -23 },
  { 657, 17, 23, 17, 0, -23 },
  { 706, 17, 23, 17, 0, -23 },
  { 755, 17, 23, 17, 0, -23 },
  { 804, 17, 23, 17, 1, -23 },
  { 853, 18, 23, 17, 1, -23 },
  { 905, 16, 23, 17, 1, -23 },
  { 951, 16, 23, 17, 1, -23 },
  { 997, 9, 18, 9, 0, -18 },
  { 1018, 11, 22, 9, -2, -18 },
  { 1049, 16, 17, 18, 1, -20 },
  { 1083, 16, 11, 18, 1, -17 },
  { 1105, 16, 17, 18, 1, -20 },
  { 1139, 13, 23, 14, 2, -23 },
  { 1177, 25, 26, 26, 1, -23 },
  { 1259, 20, 23, 20, -2, -23 },
  { 1317, 19, 23, 19, 0, -23 },
  { 1372, 19, 23, 18, 1, -23 },
  { 1427, 20, 23, 20, 0, -23 },
  { 1485, 18, 23, 16, 0, -23 },
  { 1537, 17, 23, 16, 0, -23 },
  { 1586, 20, 23, 21, 1, -23 },
  { 1644, 22, 23, 21, 0, -23 },
  { 1708, 16, 23, 13, -1, -23 },
  { 1754, 16, 30, 11, -5, -23 },
  { 1814, 22, 23, 20, 0, -23 },
  { 1878, 14, 23, 15, 0, -23 },
  { 1919, 28, 23, 27, 0, -23 },
  { 2000, 24, 23, 23, 0, -23 },
  { 2069, 20, 23, 22, 1, -23 },
  { 2127, 18, 23, 18, 0, -23 },
  { 2179, 20, 28, 22, 1, -23 },
  { 2249, 18, 23, 19, 0, -23 },
  { 2301, 17, 23, 16, 0, -23 },
  { 2350, 16, 23, 16, 2, -23 },
  { 2396, 19, 23, 21, 2, -23 },
  { 2451, 18, 23, 19, 3, -23 },
  { 2503, 28, 23, 28, 3, -23 },
  { 2584, 24, 23, 19, -2, -23 },
  { 2653, 18, 23, 18, 3, -23 },
  { 2705, 19, 23, 16, -1, -23 },
  { 2760, 14, 28, 11, -1, -23 },
  { 2809, 9, 23, 14, 3, -23 },
  { 2835, 14, 28, 11, -2, -23 },
  { 2884, 16, 15, 16, 0, -23 },
  { 2914, 15, 4, 14, -3, 2 },
  { 2922, 7, 6, 11, 5, -25 },
  { 2928, 17, 18, 18, 1, -18 },
  { 2967, 17, 24, 18, 0, -24 },
  { 3018, 14, 18, 15, 1, -18 },
  { 3050, 18, 24, 18, 1, -24 },
  { 3104, 16, 18, 17, 1, -18 },
  { 3140, 18, 32, 12, -3, -24 },
  { 3212, 18, 26, 18, 0, -18 },
  { 3271, 17, 24, 18, 0, -24 },
  { 3322, 11, 25, 10, 0, -25 },
  { 3357, 15, 33, 10, -4, -25 },
  { 3419, 20, 24, 18, 0, -24 },
  { 3479, 11, 24, 10, 0, -24 },
  { 3512, 26, 18, 27, 0, -18 },
  { 3571, 17, 18, 18, 0, -18 },
  { 3610, 16, 18, 18, 1, -18 },
  { 3646, 19, 26, 18, -2, -18 },
  { 3708, 17, 26, 18, 1, -18 },
  { 3764, 14, 18, 13, 0, -18 },
  { 3796, 15, 18, 15, 0, -18 },
  { 3830, 13, 21, 13, 1, -21 },
  { 3865, 17, 18, 18, 1, -18 },
  { 3904, 16, 18, 16, 2, -18 },
  { 3940, 24, 18, 25, 2, -18 },
  { 3994, 21, 18, 17, -2, -18 },
  { 4042, 20, 26, 16, -2, -18 },
  { 4107, 16, 18, 14, -1, -18 },
  { 4143, 14, 28, 11, 0, -23 },
  { 4192, 4, 31, 16, 6, -24 },
  { 4208, 13, 28, 11, -2, -23 },
  { 4254, 16, 6, 18, 1, -14 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC32PT7B_H_
