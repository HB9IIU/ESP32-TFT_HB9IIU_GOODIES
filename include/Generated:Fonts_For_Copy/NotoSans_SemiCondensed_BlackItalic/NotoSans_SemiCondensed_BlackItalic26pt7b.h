#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC26PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E,
  0x0F, 0x07, 0x80, 0x00, 0x00, 0x40, 0xF0, 0xF8, 0x7C, 0x3C, 0x00, 0x7D,
  0xEF, 0x3D, 0xE7, 0xBD, 0xE7, 0x3C, 0xE7, 0xBC, 0xE0, 0x01, 0xCE, 0x03,
  0xCE, 0x03, 0x9E, 0x03, 0x9C, 0x07, 0x9C, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F,
  0xFF, 0x0F, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0x1C, 0xE0, 0x3D, 0xE0, 0x39, 0xC0, 0x39, 0xC0, 0x7B, 0xC0, 0x00,
  0xC0, 0x04, 0x01, 0xFC, 0x3F, 0xF3, 0xFF, 0x9F, 0xF9, 0xF4, 0x4F, 0xE0,
  0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0x7A, 0x1B, 0xDE,
  0xFC, 0xFF, 0xE7, 0xFE, 0x1F, 0xC0, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x0F,
  0x01, 0xE0, 0xFC, 0x0E, 0x0F, 0xE0, 0xE0, 0xF7, 0x8F, 0x07, 0xBC, 0x70,
  0x39, 0xE7, 0x03, 0xCE, 0x78, 0x1E, 0x73, 0x80, 0xF7, 0xB9, 0xF3, 0xFB,
  0xDF, 0xDF, 0x9D, 0xFE, 0x79, 0xCE, 0x70, 0x1E, 0xF3, 0x81, 0xE7, 0x9C,
  0x0E, 0x3D, 0xE0, 0xF1, 0xEF, 0x0F, 0x0F, 0xF0, 0x70, 0x3F, 0x87, 0x81,
  0xF0, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0x3C,
  0x03, 0xCF, 0x00, 0xF7, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x47, 0xF1, 0xE3,
  0xFE, 0xF9, 0xFF, 0xBE, 0xF9, 0xFF, 0x3E, 0x7F, 0x8F, 0x8F, 0xE3, 0xFF,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFB, 0xF0, 0x7D, 0xE7, 0x9E, 0x71,
  0xCF, 0x00, 0x07, 0xC1, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0,
  0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1,
  0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x80,
  0x07, 0x00, 0x78, 0x47, 0x06, 0x70, 0xFF, 0x7F, 0xFF, 0x3F, 0xF1, 0xFF,
  0x3F, 0x8F, 0xB8, 0x73, 0xC1, 0x38, 0x02, 0x00, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x3D, 0xF7, 0x9E, 0xF3, 0xC0, 0x7F, 0x7F, 0x7E,
  0xFE, 0x23, 0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3E,
  0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x7F, 0x07, 0xFC, 0x7F, 0xE3, 0xEF, 0xBE,
  0x7D, 0xF3, 0xEF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3D, 0xF3, 0xEF, 0x1F,
  0x78, 0xFB, 0xCF, 0x9F, 0xFC, 0xFF, 0xC3, 0xFC, 0x0F, 0xC0, 0x01, 0xE0,
  0x7C, 0x3F, 0x8F, 0xF3, 0xFD, 0xFF, 0x9F, 0xF3, 0xBE, 0x27, 0xC0, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78,
  0x00, 0x01, 0xF0, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0x0F, 0x7C, 0x10, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xE0, 0x1F, 0xFE, 0x7F, 0xF9, 0xFF, 0xCF, 0xFF, 0x00, 0x03,
  0xC0, 0x7F, 0xC1, 0xFF, 0x87, 0xFF, 0x0C, 0x7C, 0x01, 0xF0, 0x07, 0x80,
  0x7C, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x03, 0xE8,
  0x1F, 0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x3C, 0x01,
  0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x83, 0xFE, 0x1E,
  0xF0, 0x73, 0xC3, 0x9F, 0x1E, 0x7C, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80,
  0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFE, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0xF8, 0x3F, 0xF0, 0xFF,
  0xC1, 0xFF, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE8, 0x1F, 0x3F, 0xFC, 0xFF,
  0xE3, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0xE0, 0xFF, 0x87, 0xFE,
  0x3F, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0xF8, 0x7F, 0xF3, 0xFF, 0xCF, 0xDF,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x03, 0xF8, 0x00, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x40, 0xF8,
  0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0x1E, 0x3C, 0x79, 0xF1,
  0xE7, 0x87, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFF, 0x0F, 0xFC, 0x7C, 0xF9,
  0xE3, 0xEF, 0x8F, 0x9F, 0x7C, 0x7F, 0xF1, 0xFF, 0x81, 0xFC, 0x00, 0x07,
  0x80, 0xFF, 0x0F, 0xFC, 0x7F, 0xE7, 0xCF, 0x3E, 0x7D, 0xE3, 0xFF, 0x1F,
  0xF9, 0xFB, 0xFF, 0x9F, 0xFC, 0xFF, 0xE3, 0xDF, 0x00, 0xF0, 0x0F, 0x1F,
  0xF8, 0xFF, 0x87, 0xF8, 0x3F, 0x00, 0x04, 0x1E, 0x3F, 0x3E, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x78, 0xF8, 0xF8, 0xF0, 0x01, 0x01, 0xE0,
  0xFC, 0x3E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x78, 0x3E, 0x00, 0x00, 0x10, 0x07, 0x01,
  0xF0, 0x7F, 0x1F, 0xC7, 0xF0, 0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0xFF, 0x03,
  0xF0, 0x0F, 0x00, 0x30, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x0F, 0x00, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xF0, 0x3F, 0x1F, 0xE7, 0xF8, 0xFE, 0x0F,
  0x80, 0xC0, 0x08, 0x00, 0x07, 0x83, 0xFE, 0x7F, 0xE3, 0xFE, 0x31, 0xF0,
  0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF0, 0x3E, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x10, 0x07, 0x80, 0x7C, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xF0, 0x3E, 0x1E, 0x00, 0xE3, 0xC7, 0xCF,
  0x79, 0xFE, 0x77, 0x3F, 0xE7, 0x73, 0x9E, 0x7E, 0x79, 0xC7, 0xE7, 0x1C,
  0x7E, 0x71, 0xCE, 0xE7, 0x3C, 0xEE, 0x7F, 0xFC, 0xE7, 0xFF, 0xCE, 0x3C,
  0xF0, 0xF0, 0x00, 0x07, 0x80, 0x40, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x0F, 0x78, 0x0F, 0xBC, 0x07, 0x9E, 0x07, 0xCF, 0x03, 0xE7, 0x81,
  0xE3, 0xC1, 0xF1, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x7C, 0x1E,
  0x3E, 0x0F, 0x3E, 0x07, 0xBF, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0xF8, 0x3F,
  0xF8, 0xFF, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x3E, 0x3F, 0xF8,
  0x7F, 0xE0, 0xFF, 0xE1, 0xF7, 0xE3, 0xC7, 0xCF, 0x8F, 0x9F, 0x3F, 0x3F,
  0xFC, 0x7F, 0xF8, 0xFF, 0xE3, 0xFF, 0x00, 0x01, 0xF0, 0x0F, 0xFC, 0x3F,
  0xF8, 0xFF, 0xE3, 0xF1, 0xC7, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x04, 0x3F,
  0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0x80, 0x0F, 0xF8, 0x0F,
  0xFC, 0x1F, 0xFE, 0x1F, 0x7F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1F, 0x3E,
  0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x3E, 0x3C, 0x3E, 0x7C, 0x7E, 0x7C,
  0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC7, 0xFF, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC7, 0xFF, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFF, 0x0F, 0xF8, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x1F,
  0xFE, 0x3F, 0x8C, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0xFE, 0xF9,
  0xFE, 0xF9, 0xFC, 0xF9, 0xFC, 0xF8, 0x7C, 0xF8, 0x7C, 0xFC, 0x7C, 0x7F,
  0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0x87, 0xC3, 0xE1, 0xE0,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x7F,
  0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xF8, 0xF8, 0x3C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x7C, 0x7C, 0x1E, 0x1F, 0x0F,
  0x87, 0xC0, 0x0F, 0xF8, 0x7F, 0xC7, 0xFE, 0x1F, 0xE0, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x7F, 0xC7, 0xFE, 0x3F, 0xE0, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xC0,
  0xF8, 0x00, 0x0F, 0x87, 0xC3, 0xE3, 0xE0, 0xF1, 0xF8, 0x7C, 0xFC, 0x1F,
  0x3E, 0x07, 0xDF, 0x01, 0xFF, 0x80, 0x7B, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81,
  0xF3, 0xE0, 0x7C, 0xFC, 0x1E, 0x1F, 0x0F, 0x87, 0xC0, 0x0F, 0x81, 0xF0,
  0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0x80,
  0x0F, 0xC0, 0xFE, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1,
  0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x07, 0xF1, 0xFE, 0x0F, 0xE3, 0xFC, 0x3F,
  0xCF, 0xF8, 0x7B, 0x9F, 0xF0, 0xF7, 0x3B, 0xC1, 0xEE, 0xF7, 0x83, 0xDD,
  0xCF, 0x0F, 0xBF, 0xBE, 0x1E, 0x7E, 0x7C, 0x3C, 0xFC, 0xF0, 0x79, 0xF1,
  0xE0, 0xF3, 0xE7, 0xC3, 0xE7, 0xCF, 0x80, 0x0F, 0xC1, 0xE1, 0xF8, 0x3C,
  0x3F, 0x0F, 0x8F, 0xE1, 0xF1, 0xFE, 0x3C, 0x3F, 0xC7, 0x87, 0xF8, 0xF0,
  0xFF, 0x3E, 0x3F, 0xF7, 0xC7, 0x9E, 0xF0, 0xF3, 0xDE, 0x1E, 0x7B, 0xC3,
  0xCF, 0xF8, 0xF8, 0xFE, 0x1E, 0x1F, 0xC3, 0xC3, 0xF8, 0x78, 0x7F, 0x0F,
  0x07, 0xE3, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F,
  0xFE, 0x3F, 0x3F, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0x7F,
  0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x1F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xF1, 0xF7, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x1F, 0x3E, 0x7C,
  0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0x83, 0xFC, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFE, 0x3F, 0x3F, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8,
  0x7C, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF,
  0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x1F, 0x3E, 0xFC, 0x7F, 0xF8,
  0xFF, 0xE1, 0xFF, 0x83, 0xDF, 0x0F, 0xBE, 0x1F, 0x3E, 0x3E, 0x7C, 0x7C,
  0xF8, 0xF0, 0xFB, 0xE1, 0xF0, 0x03, 0xE0, 0x3F, 0xF1, 0xFF, 0x87, 0xFE,
  0x3F, 0x30, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xCC, 0x1F, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF,
  0x07, 0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xE0, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0x1F, 0x0F,
  0x1F, 0x1F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0x78, 0x7C, 0xF8, 0x7C,
  0xF8, 0x78, 0xF8, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xC0,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xF7, 0xC3, 0xEF, 0x8F, 0x9F, 0x1F, 0x3E,
  0x3C, 0x7C, 0xF8, 0x79, 0xE0, 0xF7, 0xC1, 0xEF, 0x03, 0xDE, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0xF8, 0x78, 0x3F, 0xF0, 0xF0, 0x7B, 0xE1, 0xE1, 0xF7, 0xC7, 0xC3, 0xEF,
  0x8F, 0x8F, 0x9F, 0x3F, 0x1F, 0x3C, 0x7E, 0x3C, 0x79, 0xFC, 0xF8, 0xF3,
  0xF9, 0xE1, 0xE7, 0x73, 0xC3, 0xDE, 0xEF, 0x87, 0xBD, 0xDE, 0x0F, 0xF3,
  0xBC, 0x1F, 0xE7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x7C, 0x3E,
  0x07, 0xC7, 0xC0, 0x3C, 0xFC, 0x03, 0xEF, 0x80, 0x3F, 0xF0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0xFB, 0xC0, 0x0F, 0xBE, 0x01, 0xF3, 0xE0, 0x3E,
  0x3E, 0x07, 0xE1, 0xF0, 0xFC, 0x1F, 0x00, 0xF8, 0x3F, 0xF0, 0xF9, 0xE3,
  0xF3, 0xE7, 0xC7, 0xDF, 0x0F, 0xBE, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F,
  0xFE, 0x1F, 0xFE, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x7E, 0x0F, 0xE0, 0xFE, 0x00, 0xF3, 0xCF, 0x3C, 0xF3,
  0xC7, 0x1E, 0x79, 0xE7, 0x9E, 0x38, 0xF3, 0xCF, 0x3C, 0xF3, 0xC0, 0x07,
  0xF0, 0x7E, 0x07, 0xE0, 0x9E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0xC0, 0x7E, 0x07, 0xF0, 0x3B, 0xC3, 0xDE, 0x3C,
  0x71, 0xE3, 0x9E, 0x1F, 0xE0, 0xFF, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFB, 0xE7, 0x8F, 0x06, 0x04, 0x7D, 0xE3, 0xFF, 0x9F, 0xFE, 0x7D,
  0xF9, 0xF3, 0xEF, 0x8F, 0x3E, 0x3C, 0xF8, 0xF3, 0xE7, 0xCF, 0x9F, 0x3F,
  0xF8, 0xFF, 0xE3, 0xFF, 0x87, 0xDE, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x7D, 0x81, 0xEF, 0x87, 0xFE, 0x3F, 0xFC, 0xF9,
  0xF3, 0xE7, 0xCF, 0x1F, 0x3C, 0x7D, 0xF1, 0xE7, 0xCF, 0x9F, 0x3E, 0x7F,
  0xF1, 0xFF, 0xCF, 0x7E, 0x3D, 0xF0, 0x03, 0x01, 0xFF, 0x3F, 0xE3, 0xFE,
  0x7C, 0x47, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x4F, 0xF8,
  0xFF, 0x87, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0xCF, 0x87, 0xDE, 0x1F, 0xFC, 0x3F, 0xF8, 0xF9, 0xF1,
  0xF3, 0xE7, 0xC7, 0x8F, 0x8F, 0x1F, 0x1E, 0x3E, 0x7C, 0x7C, 0xF8, 0xFF,
  0xE1, 0xFF, 0xC3, 0xFF, 0x83, 0xEF, 0x00, 0x03, 0x80, 0x7F, 0x0F, 0xFC,
  0x7F, 0xE7, 0xCF, 0xBC, 0x7B, 0xFF, 0xDF, 0xFC, 0xFF, 0xC7, 0x80, 0x3E,
  0x01, 0xF1, 0x8F, 0xFC, 0x3F, 0xE0, 0xFE, 0x00, 0x00, 0x3E, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x3C, 0x01, 0xFF, 0x07, 0xFC, 0x0F,
  0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0x02, 0x1F,
  0x78, 0x7F, 0xF0, 0xFF, 0xE3, 0xEF, 0xC7, 0xCF, 0x9F, 0x1E, 0x3E, 0x3C,
  0x7C, 0x78, 0xF9, 0xF1, 0xF3, 0xE3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x0F,
  0x7C, 0x00, 0xF0, 0x01, 0xE1, 0xCF, 0xC3, 0xFF, 0x07, 0xFC, 0x0F, 0xF0,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7D, 0xC1,
  0xEF, 0x87, 0xFF, 0x3F, 0xFC, 0xFD, 0xF3, 0xE7, 0xCF, 0x9F, 0x3C, 0x7D,
  0xF1, 0xE7, 0xCF, 0x9F, 0x3E, 0x78, 0xF9, 0xE3, 0xCF, 0x8F, 0x3E, 0x7C,
  0x0F, 0x07, 0xC3, 0xE1, 0xE0, 0x00, 0x00, 0x7C, 0x3C, 0x1E, 0x1F, 0x0F,
  0x87, 0xC3, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x3E, 0x1F, 0x00, 0x00,
  0xE0, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x3F, 0x1E, 0x7E, 0x3E, 0x7C, 0x3E, 0xF8, 0x3F, 0xF0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7D, 0xF0, 0x79, 0xF0,
  0x79, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x0F, 0x87, 0xC3, 0xC1, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xF0, 0xF8,
  0x78, 0x3C, 0x3E, 0x1F, 0x00, 0x00, 0x30, 0x60, 0xF7, 0xCF, 0x87, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF3, 0xF7, 0xEF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0x8F, 0x9F, 0x7C, 0x78, 0xFB, 0xE7, 0xC7, 0x9F, 0x3E, 0x3C, 0xF1, 0xF3,
  0xE7, 0x8F, 0x1F, 0x7C, 0x78, 0xFB, 0xE7, 0xC7, 0x80, 0x00, 0x20, 0x7B,
  0xE1, 0xFF, 0xCF, 0xFF, 0x3F, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x1F, 0x7C,
  0x79, 0xF3, 0xE7, 0xCF, 0x9E, 0x3E, 0x78, 0xF3, 0xE3, 0xCF, 0x9F, 0x00,
  0x03, 0x80, 0x7F, 0x07, 0xFC, 0x7F, 0xE7, 0xCF, 0xBC, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xF7, 0xCF, 0xBE, 0x7D, 0xF7, 0xCF, 0xFE, 0x3F, 0xE0, 0xFC,
  0x00, 0x00, 0x30, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xF1, 0xF3, 0xE3, 0xE7,
  0xC7, 0x8F, 0x8F, 0x1F, 0x3E, 0x3C, 0x7C, 0xF8, 0xF9, 0xF1, 0xFF, 0xC3,
  0xFF, 0x8F, 0xFE, 0x1F, 0x78, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x00, 0x06, 0x04, 0x7D, 0xE3, 0xFF, 0x8F, 0xFE,
  0x7D, 0xF9, 0xF3, 0xEF, 0x8F, 0x3E, 0x3C, 0xF8, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x71, 0xEF, 0x1F, 0xE1, 0xFE,
  0x3F, 0xE3, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0x78, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0x01, 0xFF, 0x3F, 0xE3, 0xFE, 0x3C,
  0x23, 0xE0, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0x7C, 0x03, 0xCE, 0x7C, 0xFF,
  0xCF, 0xF8, 0xFF, 0x00, 0x0F, 0x03, 0x81, 0xE1, 0xFF, 0xFF, 0xFF, 0xF3,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x3F, 0xCF, 0xF1, 0xFC,
  0x7F, 0x00, 0x3E, 0x7C, 0xF1, 0xE7, 0xC7, 0x9F, 0x3E, 0x7C, 0xF9, 0xE3,
  0xE7, 0x8F, 0x3E, 0x3C, 0xF9, 0xF3, 0xE7, 0xCF, 0xFF, 0x3F, 0xF8, 0xFF,
  0xE1, 0xF7, 0x80, 0xF8, 0xFF, 0xE3, 0xE7, 0x8F, 0x1E, 0x7C, 0x79, 0xE1,
  0xEF, 0x87, 0xBC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0x3E, 0x00, 0xF8, 0x00, 0xF9, 0xF9, 0xFF, 0x9F, 0x9F, 0x79, 0xF9, 0xE7,
  0xBF, 0xBE, 0x7B, 0xFB, 0xC7, 0xBF, 0xFC, 0x7F, 0xF7, 0x87, 0xF7, 0x78,
  0x7F, 0x7F, 0x07, 0xE7, 0xF0, 0x7E, 0x7F, 0x07, 0xE7, 0xE0, 0x7C, 0x7E,
  0x07, 0xC7, 0xC0, 0x1F, 0x3F, 0x1F, 0x3E, 0x0F, 0x7C, 0x0F, 0xF8, 0x0F,
  0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F,
  0xF0, 0x7C, 0xF0, 0x7C, 0xF8, 0xF8, 0xF8, 0x1F, 0x1F, 0x8F, 0x8F, 0x83,
  0xC7, 0x81, 0xE7, 0xC0, 0xF3, 0xC0, 0x7B, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x7F,
  0xF0, 0x00, 0x20, 0x7C, 0x1F, 0x83, 0xE0, 0xF8, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x07, 0xC3, 0xF8, 0x7C, 0x0F, 0x81, 0xF8, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x81, 0xE0, 0x3F, 0x07, 0xE0, 0x7C, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x04, 0x01, 0xF0, 0x3F, 0x07,
  0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x81, 0xF0,
  0x7E, 0x1F, 0xC3, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x3F, 0x0F, 0xC1,
  0xF8, 0x3C, 0x00, 0x10, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 19, 7, 0, -19 },
  { 23, 11, 7, 12, 2, -19 },
  { 33, 16, 19, 16, 0, -19 },
  { 71, 13, 22, 14, 1, -20 },
  { 107, 21, 19, 23, 1, -19 },
  { 157, 18, 19, 18, 0, -19 },
  { 200, 6, 7, 6, 2, -19 },
  { 206, 10, 23, 9, 1, -19 },
  { 235, 10, 23, 9, -2, -19 },
  { 264, 12, 13, 13, 2, -20 },
  { 284, 12, 13, 14, 1, -16 },
  { 304, 6, 6, 8, -1, -3 },
  { 309, 8, 4, 8, 0, -9 },
  { 313, 5, 5, 8, 0, -5 },
  { 317, 14, 19, 11, -1, -19 },
  { 351, 13, 19, 14, 1, -19 },
  { 382, 11, 19, 14, 2, -19 },
  { 409, 14, 19, 14, -1, -19 },
  { 443, 14, 19, 14, 0, -19 },
  { 477, 14, 19, 14, 0, -19 },
  { 511, 14, 19, 14, 0, -19 },
  { 545, 14, 19, 14, 1, -19 },
  { 579, 14, 19, 14, 1, -19 },
  { 613, 14, 19, 14, 0, -19 },
  { 647, 13, 19, 14, 1, -19 },
  { 678, 8, 15, 8, 0, -15 },
  { 693, 10, 18, 8, -2, -15 },
  { 716, 12, 14, 14, 1, -16 },
  { 737, 12, 9, 14, 1, -14 },
  { 751, 12, 14, 14, 1, -16 },
  { 772, 12, 19, 12, 1, -19 },
  { 801, 20, 21, 22, 1, -19 },
  { 854, 17, 19, 16, -2, -19 },
  { 895, 15, 19, 15, 0, -19 },
  { 931, 15, 19, 15, 1, -19 },
  { 967, 16, 19, 16, 0, -19 },
  { 1005, 14, 19, 13, 0, -19 },
  { 1039, 14, 19, 13, 0, -19 },
  { 1073, 16, 19, 17, 1, -19 },
  { 1111, 18, 19, 17, 0, -19 },
  { 1154, 13, 19, 11, -1, -19 },
  { 1185, 13, 25, 9, -4, -19 },
  { 1226, 18, 19, 16, 0, -19 },
  { 1269, 11, 19, 12, 0, -19 },
  { 1296, 23, 19, 22, 0, -19 },
  { 1351, 19, 19, 19, 0, -19 },
  { 1397, 16, 19, 18, 1, -19 },
  { 1435, 15, 19, 15, 0, -19 },
  { 1471, 16, 23, 18, 1, -19 },
  { 1517, 15, 19, 16, 0, -19 },
  { 1553, 14, 19, 13, 0, -19 },
  { 1587, 13, 19, 13, 2, -19 },
  { 1618, 16, 19, 17, 1, -19 },
  { 1656, 15, 19, 15, 2, -19 },
  { 1692, 23, 19, 22, 2, -19 },
  { 1747, 20, 19, 16, -2, -19 },
  { 1795, 15, 19, 15, 2, -19 },
  { 1831, 16, 19, 13, -1, -19 },
  { 1869, 12, 23, 9, -1, -19 },
  { 1904, 6, 19, 11, 3, -19 },
  { 1919, 12, 23, 9, -2, -19 },
  { 1954, 13, 13, 13, 0, -19 },
  { 1976, 11, 3, 11, -2, 2 },
  { 1981, 6, 4, 9, 4, -20 },
  { 1984, 14, 15, 15, 1, -15 },
  { 2011, 14, 20, 15, 0, -20 },
  { 2046, 12, 15, 12, 1, -15 },
  { 2069, 15, 20, 15, 1, -20 },
  { 2107, 13, 15, 14, 1, -15 },
  { 2132, 15, 26, 10, -3, -20 },
  { 2181, 15, 21, 15, 0, -15 },
  { 2221, 14, 20, 15, 0, -20 },
  { 2256, 9, 20, 8, 0, -20 },
  { 2279, 12, 26, 8, -3, -20 },
  { 2318, 16, 20, 15, 0, -20 },
  { 2358, 9, 20, 8, 0, -20 },
  { 2381, 21, 15, 22, 0, -15 },
  { 2421, 14, 15, 15, 0, -15 },
  { 2448, 13, 15, 15, 1, -15 },
  { 2473, 15, 21, 15, -1, -15 },
  { 2513, 14, 21, 15, 1, -15 },
  { 2550, 12, 15, 11, 0, -15 },
  { 2573, 12, 15, 12, 0, -15 },
  { 2596, 10, 17, 11, 1, -17 },
  { 2618, 14, 14, 15, 1, -14 },
  { 2643, 14, 14, 13, 1, -14 },
  { 2668, 20, 14, 20, 1, -14 },
  { 2703, 16, 14, 14, -1, -14 },
  { 2731, 17, 20, 13, -2, -14 },
  { 2774, 13, 14, 12, -1, -14 },
  { 2797, 11, 23, 9, 0, -19 },
  { 2829, 3, 26, 13, 5, -20 },
  { 2839, 11, 23, 9, -2, -19 },
  { 2871, 13, 5, 14, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC26PT7B_H_
