#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_SemiCondensed_BlackItalic
// Headers: 67

#include "NotoSans_SemiCondensed_BlackItalic6pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic7pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic8pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic9pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic10pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic11pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic12pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic13pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic14pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic15pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic16pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic17pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic18pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic19pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic20pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic21pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic22pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic23pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic24pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic25pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic26pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic27pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic28pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic29pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic30pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic31pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic32pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic33pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic34pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic35pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic36pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic37pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic38pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic39pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic40pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic41pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic42pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic43pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic44pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic45pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic46pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic47pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic48pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic49pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic50pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic51pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic52pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic53pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic54pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic55pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic56pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic57pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic58pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic59pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic60pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic61pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic62pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic63pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic64pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic65pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic66pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic67pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic68pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic69pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic70pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic71pt7b.h"
#include "NotoSans_SemiCondensed_BlackItalic72pt7b.h"
