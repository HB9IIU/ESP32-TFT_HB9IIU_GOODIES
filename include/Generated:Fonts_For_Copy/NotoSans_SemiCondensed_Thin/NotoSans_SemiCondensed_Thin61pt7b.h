#ifndef _NOTOSANS_SEMICONDENSED_THIN61PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin61pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x40, 0x00, 0x00, 0x5F, 0xF0, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0x60, 0x2C, 0x05,
  0x80, 0xB0, 0x16, 0x02, 0x00, 0x04, 0x00, 0x40, 0x00, 0x04, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x40, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x80, 0x00, 0x08, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x80, 0x00, 0x18, 0x00, 0x80, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x10, 0x01, 0x80, 0x00, 0x10, 0x01, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x01, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x20, 0x02, 0x00,
  0x00, 0x20, 0x02, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x40, 0x04, 0x00,
  0x00, 0x40, 0x04, 0x00, 0x00, 0xC0, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x80, 0x0C, 0x00,
  0x00, 0x80, 0x08, 0x00, 0x01, 0x80, 0x08, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x10, 0x00, 0x03, 0x00, 0x10, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x02, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xFF, 0x01, 0xC2, 0x07, 0x06, 0x04, 0x02, 0x18, 0x08, 0x00, 0x60,
  0x10, 0x00, 0xC0, 0x20, 0x03, 0x00, 0x40, 0x06, 0x00, 0x80, 0x0C, 0x01,
  0x00, 0x18, 0x02, 0x00, 0x30, 0x04, 0x00, 0x60, 0x08, 0x00, 0x40, 0x10,
  0x00, 0xC0, 0x20, 0x00, 0xC0, 0x40, 0x01, 0xC0, 0x80, 0x01, 0xC1, 0x00,
  0x00, 0xE2, 0x00, 0x00, 0x74, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x2F, 0x00, 0x00, 0x47, 0x80, 0x00, 0x83, 0x80, 0x01, 0x01, 0x80,
  0x02, 0x01, 0x80, 0x04, 0x01, 0x00, 0x08, 0x03, 0x00, 0x10, 0x06, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x60, 0x02,
  0x00, 0xC0, 0x04, 0x01, 0x80, 0x08, 0x06, 0x00, 0x10, 0x0C, 0x00, 0x20,
  0x73, 0x80, 0x41, 0xC3, 0xFC, 0xBE, 0x00, 0x7F, 0xF0, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x07, 0xE0, 0x00, 0x0C, 0x00, 0x63, 0x80, 0x00, 0x40, 0x06, 0x06, 0x00,
  0x06, 0x00, 0x60, 0x10, 0x00, 0x20, 0x02, 0x00, 0xC0, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x60, 0x01, 0x80, 0x04, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x30, 0x00,
  0x60, 0x01, 0x01, 0x80, 0x03, 0x00, 0x08, 0x08, 0x00, 0x18, 0x00, 0x40,
  0xC0, 0x00, 0xC0, 0x06, 0x04, 0x00, 0x06, 0x00, 0x30, 0x60, 0x70, 0x10,
  0x01, 0x82, 0x0F, 0xE0, 0x80, 0x0C, 0x30, 0xC1, 0x86, 0x00, 0x41, 0x0C,
  0x06, 0x30, 0x02, 0x18, 0x60, 0x18, 0x80, 0x30, 0x86, 0x00, 0xC6, 0x01,
  0x0C, 0x30, 0x02, 0x18, 0x18, 0x61, 0x00, 0x18, 0xF3, 0x86, 0x08, 0x00,
  0xC1, 0xF0, 0x30, 0xC0, 0x06, 0x00, 0x03, 0x06, 0x00, 0x30, 0x00, 0x18,
  0x30, 0x01, 0x80, 0x01, 0x81, 0x80, 0x04, 0x00, 0x0C, 0x0C, 0x00, 0x20,
  0x00, 0x40, 0x60, 0x01, 0x00, 0x06, 0x03, 0x00, 0x18, 0x00, 0x20, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x30, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x03, 0x00,
  0x06, 0x03, 0x00, 0x30, 0x00, 0x1C, 0x30, 0x01, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x10, 0x01, 0x80, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x80, 0x02, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x80, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x04, 0x30, 0x06, 0x00, 0x08, 0xC0, 0x06,
  0x00, 0x33, 0x00, 0x06, 0x00, 0x66, 0x00, 0x06, 0x00, 0x88, 0x00, 0x06,
  0x03, 0x30, 0x00, 0x0C, 0x06, 0x60, 0x00, 0x0C, 0x08, 0xC0, 0x00, 0x0C,
  0x31, 0x80, 0x00, 0x0C, 0x43, 0x00, 0x00, 0x0D, 0x86, 0x00, 0x00, 0x0E,
  0x04, 0x00, 0x00, 0x1C, 0x08, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xD8,
  0x18, 0x00, 0x03, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x38, 0x00, 0x70, 0x30,
  0x3C, 0x03, 0x80, 0x30, 0x1F, 0xFC, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x55, 0x00, 0x40, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80,
  0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80,
  0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x18,
  0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x30,
  0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0,
  0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x18, 0x04,
  0x03, 0xF8, 0x10, 0x7C, 0x3C, 0x47, 0x00, 0x0F, 0xE0, 0x00, 0x04, 0x00,
  0x00, 0x28, 0x00, 0x01, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x60, 0x80, 0x01,
  0x01, 0x00, 0x0C, 0x06, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x18, 0x08, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x08, 0x71, 0x86, 0x18,
  0x61, 0x0C, 0x30, 0xC2, 0x18, 0x61, 0x0C, 0x00, 0xFF, 0xFC, 0x5F, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xC1, 0xC0, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x10, 0x00, 0x04, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x20, 0x00, 0x02,
  0x60, 0x00, 0x02, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01,
  0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01,
  0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x02, 0x20, 0x00, 0x02, 0x30, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x30, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x0C, 0x00, 0x18, 0x06, 0x00, 0x10, 0x07, 0x00, 0x70, 0x03, 0xC0, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x07, 0x00, 0xF0, 0x3B,
  0x07, 0x30, 0xC3, 0x18, 0x37, 0x03, 0xE0, 0x38, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x01, 0xFF, 0x00, 0x0F, 0xC7, 0xC0, 0x1C, 0x00, 0xE0, 0x70, 0x00, 0x30,
  0x20, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0x00, 0x0F, 0xC7, 0xC0, 0x3C, 0x00, 0x60, 0x60, 0x00, 0x30,
  0xC0, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x1F, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x70, 0xF8, 0x01, 0xE0, 0x1F, 0xFF, 0x80,
  0x00, 0xE8, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x05, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x11, 0x80, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x10, 0x03, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x04, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x60, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x8F,
  0xF8, 0x03, 0xFF, 0xFE, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x31, 0x80, 0x01, 0xC3, 0xE0, 0x0E, 0x01, 0xFF,
  0xF8, 0x00, 0x1D, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x78, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x3C, 0x00, 0xC1,
  0xFF, 0xC0, 0xC7, 0x00, 0xE0, 0x8C, 0x00, 0x30, 0x98, 0x00, 0x18, 0xB0,
  0x00, 0x0C, 0xA0, 0x00, 0x04, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x40,
  0x00, 0x02, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x20, 0x00, 0x04, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0E, 0x00, 0x30, 0x07,
  0x00, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xC3, 0xE0, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x30,
  0x00, 0x04, 0x30, 0x00, 0x06, 0x20, 0x00, 0x06, 0x20, 0x00, 0x06, 0x20,
  0x00, 0x02, 0x20, 0x00, 0x06, 0x20, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x07,
  0x00, 0x60, 0x03, 0x81, 0xC0, 0x00, 0xE7, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xC3, 0x80, 0x03, 0x00, 0xE0, 0x0E, 0x00, 0x30, 0x18,
  0x00, 0x18, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x60, 0x00, 0x02, 0x60,
  0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x0C,
  0x00, 0x38, 0x07, 0x00, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xC7, 0xC0, 0x0E, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x30,
  0x00, 0x18, 0x30, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x40,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x07, 0x60,
  0x00, 0x07, 0x20, 0x00, 0x0F, 0x30, 0x00, 0x1B, 0x18, 0x00, 0x33, 0x0C,
  0x00, 0x63, 0x07, 0x87, 0xC3, 0x01, 0xFF, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x20, 0x0F, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0xA0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x05, 0xFF, 0x1C, 0x71, 0xC2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x21, 0xC6, 0x18,
  0x61, 0x8C, 0x30, 0xC3, 0x08, 0x61, 0x84, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0x9F, 0x0C, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x00, 0x63, 0x00, 0x01, 0xFE, 0x00,
  0x31, 0x80, 0x03, 0xEF, 0xC0, 0x08, 0xC0, 0x03, 0x00, 0x60, 0x04, 0xC0,
  0x03, 0x00, 0x30, 0x03, 0x60, 0x03, 0x00, 0x18, 0x01, 0xB0, 0x03, 0x00,
  0x0C, 0x00, 0xD0, 0x01, 0x00, 0x06, 0x00, 0x68, 0x01, 0x80, 0x03, 0x00,
  0x1C, 0x00, 0xC0, 0x01, 0x80, 0x0E, 0x00, 0x40, 0x00, 0xC0, 0x07, 0x00,
  0x20, 0x00, 0x60, 0x03, 0x80, 0x30, 0x00, 0x20, 0x01, 0xC0, 0x18, 0x00,
  0x10, 0x00, 0xE0, 0x0C, 0x00, 0x08, 0x00, 0xF0, 0x06, 0x00, 0x04, 0x00,
  0x78, 0x03, 0x00, 0x06, 0x00, 0x3C, 0x00, 0x80, 0x03, 0x00, 0x1E, 0x00,
  0x40, 0x01, 0x80, 0x09, 0x00, 0x30, 0x01, 0xC0, 0x0C, 0x80, 0x18, 0x00,
  0xB0, 0x06, 0x60, 0x06, 0x00, 0xD8, 0x06, 0x30, 0x03, 0x80, 0xC6, 0x06,
  0x18, 0x00, 0xE1, 0xC1, 0x87, 0x04, 0x00, 0x1F, 0xC0, 0x7E, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x01, 0x01, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x01, 0x00, 0x10, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x10, 0x00, 0x40, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x06, 0x00, 0x03, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x10, 0x00, 0x04, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x18, 0x01, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x60, 0x10, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x06, 0x10, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x80, 0x01, 0xE0, 0x80, 0x00, 0x38, 0x80, 0x00, 0x18,
  0x80, 0x00, 0x0C, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06,
  0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x04, 0x80, 0x00, 0x0C,
  0x80, 0x00, 0x18, 0x80, 0x00, 0x30, 0x80, 0x00, 0xE0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x80, 0x00, 0xF0, 0x80, 0x00, 0x38, 0x80, 0x00, 0x0C,
  0x80, 0x00, 0x06, 0x80, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x18,
  0x80, 0x00, 0x70, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xF3, 0xF8, 0x03, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x04, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x80, 0x03, 0xE0, 0x08, 0x00, 0x07, 0x00, 0x80, 0x00, 0x1C, 0x08, 0x00,
  0x00, 0xE0, 0x80, 0x00, 0x07, 0x08, 0x00, 0x00, 0x30, 0x80, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x00, 0x48, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x00, 0x28, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x02,
  0x80, 0x00, 0x00, 0x28, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x70, 0x80, 0x00, 0x0E, 0x08, 0x00, 0x01,
  0xC0, 0x80, 0x00, 0x38, 0x08, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3E, 0x07, 0xF0, 0x01, 0xC0, 0x00, 0x78, 0x06, 0x00, 0x00, 0x20, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x03, 0x03, 0x80, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x0C, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0xC8, 0x0C, 0x7F, 0xC0,
  0xF0, 0x00, 0x80, 0x00, 0x07, 0x80, 0x00, 0x06, 0x80, 0x00, 0x0C, 0x80,
  0x00, 0x18, 0x80, 0x00, 0x30, 0x80, 0x00, 0x60, 0x80, 0x00, 0xC0, 0x80,
  0x01, 0xC0, 0x80, 0x01, 0x80, 0x80, 0x03, 0x00, 0x80, 0x06, 0x00, 0x80,
  0x0C, 0x00, 0x80, 0x18, 0x00, 0x80, 0x38, 0x00, 0x80, 0x70, 0x00, 0x80,
  0x60, 0x00, 0x80, 0xC0, 0x00, 0x81, 0x80, 0x00, 0x83, 0x00, 0x00, 0x87,
  0x00, 0x00, 0x8D, 0x80, 0x00, 0x9C, 0xC0, 0x00, 0x98, 0xC0, 0x00, 0xB0,
  0x60, 0x00, 0xE0, 0x30, 0x00, 0xC0, 0x30, 0x00, 0x80, 0x18, 0x00, 0x80,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x80, 0x06, 0x00, 0x80, 0x06, 0x00, 0x80,
  0x03, 0x00, 0x80, 0x01, 0x80, 0x80, 0x01, 0x80, 0x80, 0x00, 0xC0, 0x80,
  0x00, 0x60, 0x80, 0x00, 0x60, 0x80, 0x00, 0x30, 0x80, 0x00, 0x18, 0x80,
  0x00, 0x18, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x04, 0x80, 0x00, 0x06, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xD0, 0x00, 0x00, 0x00, 0x5B, 0x00, 0x00,
  0x00, 0x1B, 0x60, 0x00, 0x00, 0x03, 0x64, 0x00, 0x00, 0x00, 0xCC, 0xC0,
  0x00, 0x00, 0x19, 0x98, 0x00, 0x00, 0x02, 0x31, 0x80, 0x00, 0x00, 0xC6,
  0x30, 0x00, 0x00, 0x18, 0xC2, 0x00, 0x00, 0x02, 0x18, 0x60, 0x00, 0x00,
  0xC3, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x80, 0x00, 0x02, 0x0C, 0x18, 0x00,
  0x00, 0xC1, 0x83, 0x00, 0x00, 0x18, 0x30, 0x20, 0x00, 0x06, 0x06, 0x06,
  0x00, 0x00, 0xC0, 0xC0, 0x40, 0x00, 0x10, 0x18, 0x0C, 0x00, 0x06, 0x03,
  0x01, 0x80, 0x00, 0xC0, 0x60, 0x10, 0x00, 0x10, 0x0C, 0x03, 0x00, 0x06,
  0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x04, 0x00, 0x30, 0x06, 0x00, 0xC0,
  0x06, 0x00, 0xC0, 0x18, 0x00, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x02, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x30, 0x01,
  0x80, 0x0C, 0x06, 0x00, 0x30, 0x00, 0x81, 0x80, 0x06, 0x00, 0x18, 0x30,
  0x00, 0xC0, 0x03, 0x04, 0x00, 0x18, 0x00, 0x31, 0x80, 0x03, 0x00, 0x06,
  0x30, 0x00, 0x60, 0x00, 0x44, 0x00, 0x0C, 0x00, 0x0D, 0x80, 0x01, 0x80,
  0x01, 0xB0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x10, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x1C, 0x40, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x38, 0x30, 0x00,
  0x07, 0x03, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0xC0, 0x08, 0x00,
  0x38, 0x01, 0x80, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x30, 0x03, 0x80, 0x02, 0x00, 0x70, 0x00, 0x60, 0x0E, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0xC0, 0x38, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x80, 0xE0, 0x00,
  0x18, 0x1C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x30, 0x70, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x0C, 0xE0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x60, 0x00, 0x07, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x00, 0x81, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x40, 0x30,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x08, 0x00, 0x7C,
  0x20, 0x00, 0x38, 0x80, 0x00, 0x32, 0x00, 0x00, 0x68, 0x00, 0x01, 0xA0,
  0x00, 0x02, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x28, 0x00, 0x01, 0xA0, 0x00, 0x06, 0x80,
  0x00, 0x32, 0x00, 0x01, 0x88, 0x00, 0x1C, 0x20, 0x03, 0xE0, 0xFF, 0xFC,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x3C,
  0x01, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x80, 0x07, 0xC0, 0x80, 0x00, 0xE0,
  0x80, 0x00, 0x30, 0x80, 0x00, 0x18, 0x80, 0x00, 0x18, 0x80, 0x00, 0x0C,
  0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C,
  0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C,
  0x80, 0x00, 0x08, 0x80, 0x00, 0x18, 0x80, 0x00, 0x18, 0x80, 0x00, 0x30,
  0x80, 0x00, 0x60, 0x80, 0x01, 0xC0, 0x80, 0x07, 0x80, 0xFF, 0xFE, 0x00,
  0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x80, 0x0C, 0x00, 0x80, 0x06, 0x00,
  0x80, 0x06, 0x00, 0x80, 0x03, 0x00, 0x80, 0x01, 0x80, 0x80, 0x01, 0x80,
  0x80, 0x00, 0xC0, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x60, 0x80, 0x00, 0x60,
  0x80, 0x00, 0x30, 0x80, 0x00, 0x30, 0x80, 0x00, 0x18, 0x80, 0x00, 0x18,
  0x80, 0x00, 0x0C, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x03,
  0x00, 0xFF, 0xE0, 0x03, 0xE1, 0xFC, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x70, 0xF8, 0x01, 0xE0, 0x3F, 0xFF, 0x80,
  0x01, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x02, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x70, 0x03,
  0xC0, 0x3C, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x43, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x20, 0x60, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x06, 0x02, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x03, 0x00, 0x40, 0x00, 0x08, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00,
  0x01, 0x80, 0x08, 0x00, 0x04, 0x00, 0x20, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0xC0, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x60, 0x01, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x10, 0x02, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x02, 0x01, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x40, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x01, 0x20, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0D, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x98, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x07, 0x80, 0x00, 0x18,
  0x80, 0x00, 0x16, 0x00, 0x00, 0x63, 0x00, 0x00, 0x48, 0x00, 0x01, 0x0C,
  0x00, 0x03, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x30, 0x40,
  0x00, 0x33, 0x00, 0x00, 0x81, 0x80, 0x00, 0x84, 0x00, 0x06, 0x06, 0x00,
  0x06, 0x10, 0x00, 0x18, 0x18, 0x00, 0x18, 0x60, 0x00, 0x60, 0x20, 0x00,
  0x61, 0x80, 0x01, 0x00, 0xC0, 0x01, 0x02, 0x00, 0x0C, 0x03, 0x00, 0x0C,
  0x08, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x10, 0x00, 0xC0,
  0xC0, 0x02, 0x00, 0x60, 0x02, 0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x04,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x08, 0x01, 0x80, 0x60,
  0x04, 0x00, 0x30, 0x04, 0x00, 0x80, 0x30, 0x00, 0xC0, 0x30, 0x02, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x04, 0x03, 0x00, 0x30, 0x08,
  0x00, 0x18, 0x08, 0x00, 0x40, 0x60, 0x00, 0x60, 0x60, 0x01, 0x01, 0x80,
  0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x02, 0x06, 0x00, 0x18, 0x10, 0x00,
  0x0C, 0x10, 0x00, 0x20, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x83, 0x00, 0x00,
  0xC3, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x0C, 0x00, 0x0C, 0x20, 0x00, 0x06,
  0x20, 0x00, 0x11, 0x80, 0x00, 0x18, 0x80, 0x00, 0x46, 0x00, 0x00, 0x66,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x98, 0x00, 0x06, 0x40, 0x00, 0x03, 0x40,
  0x00, 0x1B, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x20, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x30, 0x18, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x20, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x06, 0x00, 0x60, 0x00, 0x40, 0x18,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x01,
  0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x58, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x30, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x06, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x20, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x00, 0x18, 0x00, 0x30, 0x03, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x60, 0x18, 0x00, 0x04, 0x06, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x0C, 0x30,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x80, 0x10,
  0x00, 0x30, 0x03, 0x00, 0x04, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x00, 0x40, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x80, 0x60, 0x00, 0x18,
  0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x98, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x18, 0x0C, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0x80, 0x03, 0x00, 0x30, 0x00, 0x60, 0x04, 0x00, 0x06, 0x01,
  0x80, 0x00, 0xC0, 0x20, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0x23, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0xFC, 0x00, 0x7F, 0xF0,
  0x3C, 0x01, 0xC1, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x03, 0xFF, 0x03,
  0xF8, 0x10, 0xE0, 0x01, 0x38, 0x00, 0x17, 0x00, 0x01, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x7C, 0x00, 0x05, 0xC0, 0x00, 0xD6, 0x00, 0x09, 0x60, 0x03,
  0x13, 0x80, 0xE1, 0x0F, 0xFC, 0x10, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x7E, 0x00, 0xC1, 0xFF, 0xC0, 0xC7, 0x00, 0xE0, 0xCC, 0x00, 0x30, 0xD8,
  0x00, 0x18, 0xD0, 0x00, 0x08, 0xF0, 0x00, 0x0C, 0xE0, 0x00, 0x04, 0xE0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xE0, 0x00, 0x04, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xF0,
  0x00, 0x18, 0x98, 0x00, 0x30, 0x8C, 0x00, 0x70, 0x87, 0x01, 0xC0, 0x83,
  0xFF, 0x80, 0x00, 0x58, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xC0, 0x70,
  0x04, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x78, 0x06, 0x00, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x3E, 0x03, 0x01, 0xFF, 0xC3, 0x03, 0x80, 0x63, 0x0E,
  0x00, 0x33, 0x0C, 0x00, 0x1B, 0x18, 0x00, 0x0F, 0x30, 0x00, 0x05, 0x30,
  0x00, 0x07, 0x20, 0x00, 0x07, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40,
  0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x07, 0x20, 0x00, 0x05, 0x30,
  0x00, 0x0D, 0x18, 0x00, 0x09, 0x18, 0x00, 0x19, 0x0E, 0x00, 0x31, 0x07,
  0x80, 0xE1, 0x01, 0xFF, 0x81, 0x00, 0x18, 0x00, 0x00, 0x3E, 0x00, 0x03,
  0xFF, 0x80, 0x0E, 0x03, 0x80, 0x30, 0x01, 0x80, 0xC0, 0x01, 0x03, 0x00,
  0x03, 0x04, 0x00, 0x02, 0x18, 0x00, 0x06, 0x20, 0x00, 0x04, 0xC0, 0x00,
  0x09, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x34, 0x00, 0x00, 0x68, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x01, 0x01, 0xC0, 0x1E, 0x00, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x7F, 0xC0, 0x70, 0x20, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x01, 0xFF, 0xF0, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC1, 0x07, 0x00, 0x73, 0x0E,
  0x00, 0x1B, 0x0C, 0x00, 0x0B, 0x18, 0x00, 0x0F, 0x30, 0x00, 0x07, 0x30,
  0x00, 0x07, 0x20, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40,
  0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x07, 0x20, 0x00, 0x07, 0x30,
  0x00, 0x0F, 0x18, 0x00, 0x0B, 0x18, 0x00, 0x1B, 0x0E, 0x00, 0x33, 0x07,
  0x80, 0xE3, 0x01, 0xFF, 0x83, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x20, 0x00, 0x38, 0x3C, 0x00, 0xF0, 0x0F, 0xFF, 0xC0, 0x00,
  0xFA, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x3F, 0x03, 0x0F, 0xFE, 0x18, 0xE0, 0x1C, 0xCC, 0x00, 0x66, 0xC0,
  0x01, 0xBC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x04, 0x6F, 0x76, 0x00, 0x00, 0x00, 0x00, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x01, 0x80, 0xF0, 0x1C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x06,
  0x3F, 0x87, 0x80, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x02, 0xC0, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x30,
  0xC0, 0x06, 0x0C, 0x00, 0xC0, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x30,
  0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x08, 0x00, 0xC1, 0x80, 0x0C, 0x30,
  0x00, 0xC7, 0x80, 0x0C, 0xCC, 0x00, 0xD8, 0xC0, 0x0D, 0x06, 0x00, 0xF0,
  0x30, 0x0E, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x80, 0xC0, 0x0C, 0x0C,
  0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x0C, 0x00, 0x18,
  0xC0, 0x00, 0xCC, 0x00, 0x04, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x04, 0x1F, 0xF0, 0x0F, 0xFC, 0x23, 0x80, 0xE0, 0xC0, 0x71,
  0x30, 0x03, 0x0C, 0x00, 0xC9, 0x00, 0x0C, 0xC0, 0x03, 0x58, 0x00, 0x2C,
  0x00, 0x1B, 0x80, 0x01, 0xC0, 0x00, 0x5C, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x30, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x08, 0x00,
  0x07, 0x80, 0x00, 0x40, 0x00, 0x3C, 0x00, 0x02, 0x00, 0x01, 0xE0, 0x00,
  0x10, 0x00, 0x0F, 0x00, 0x00, 0x80, 0x00, 0x78, 0x00, 0x04, 0x00, 0x03,
  0xC0, 0x00, 0x20, 0x00, 0x1E, 0x00, 0x01, 0x00, 0x00, 0xF0, 0x00, 0x08,
  0x00, 0x07, 0x80, 0x00, 0x40, 0x00, 0x3C, 0x00, 0x02, 0x00, 0x01, 0xE0,
  0x00, 0x10, 0x00, 0x0F, 0x00, 0x00, 0x80, 0x00, 0x78, 0x00, 0x04, 0x00,
  0x03, 0xC0, 0x00, 0x20, 0x00, 0x1E, 0x00, 0x01, 0x00, 0x00, 0xF0, 0x00,
  0x08, 0x00, 0x07, 0x80, 0x00, 0x40, 0x00, 0x3C, 0x00, 0x02, 0x00, 0x01,
  0xE0, 0x00, 0x10, 0x00, 0x0F, 0x00, 0x00, 0x80, 0x00, 0x78, 0x00, 0x04,
  0x00, 0x03, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x7E, 0x04, 0x1F, 0xFC,
  0x21, 0xC0, 0x39, 0x18, 0x00, 0xE9, 0x80, 0x03, 0x48, 0x00, 0x0E, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x03, 0x00, 0xC0,
  0x00, 0xC0, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x04, 0x60,
  0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0x48, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x04, 0xC0, 0x00,
  0x06, 0x60, 0x00, 0x03, 0x10, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x86, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0xC0, 0x60, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x07,
  0x01, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x81, 0xFF, 0xC0, 0x87, 0x00, 0xE0, 0x8E, 0x00, 0x30, 0x98, 0x00, 0x18,
  0x98, 0x00, 0x0C, 0xB0, 0x00, 0x0C, 0xA0, 0x00, 0x04, 0xE0, 0x00, 0x06,
  0xE0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x06,
  0xE0, 0x00, 0x04, 0xE0, 0x00, 0x0C, 0xF0, 0x00, 0x0C, 0xD0, 0x00, 0x18,
  0xD8, 0x00, 0x30, 0xCE, 0x00, 0x70, 0xC7, 0x01, 0xC0, 0xC1, 0xFF, 0x80,
  0xC0, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC1,
  0x07, 0x80, 0xE3, 0x0E, 0x00, 0x33, 0x1C, 0x00, 0x1B, 0x18, 0x00, 0x0F,
  0x30, 0x00, 0x07, 0x30, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07,
  0x20, 0x00, 0x07, 0x30, 0x00, 0x0F, 0x10, 0x00, 0x1B, 0x18, 0x00, 0x13,
  0x0C, 0x00, 0x73, 0x07, 0x00, 0xE3, 0x01, 0xFF, 0x83, 0x00, 0x3C, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0xFB, 0x07, 0xFB, 0x18, 0x06, 0x60, 0x0D, 0x80,
  0x1A, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0x0C, 0x00,
  0xE1, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0xC0, 0x00, 0xCF, 0x80,
  0x38, 0x1F, 0xFF, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0xFF, 0xFE, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x81, 0xFF, 0x00, 0x30, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0x70, 0x00, 0x0A, 0xC0, 0x00,
  0xD6, 0x00, 0x0C, 0x98, 0x00, 0xC4, 0x70, 0x1C, 0x21, 0xFF, 0x81, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x33, 0x00,
  0x00, 0x62, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x08, 0x00,
  0x0C, 0x18, 0x00, 0x10, 0x30, 0x00, 0x60, 0x20, 0x00, 0xC0, 0x60, 0x01,
  0x00, 0xC0, 0x06, 0x00, 0x80, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60,
  0x02, 0x00, 0xC0, 0x06, 0x01, 0x00, 0x0C, 0x06, 0x00, 0x08, 0x0C, 0x00,
  0x18, 0x10, 0x00, 0x30, 0x60, 0x00, 0x20, 0xC0, 0x00, 0x61, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x8C, 0x00, 0x01, 0x90, 0x00, 0x03, 0x60, 0x00, 0x02,
  0xC0, 0x00, 0x05, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x03, 0x40, 0x00, 0x70, 0x00, 0x24,
  0x00, 0x05, 0x00, 0x02, 0x60, 0x00, 0xD0, 0x00, 0x66, 0x00, 0x0D, 0x80,
  0x06, 0x20, 0x00, 0x98, 0x00, 0x43, 0x00, 0x18, 0x80, 0x04, 0x30, 0x01,
  0x8C, 0x00, 0xC3, 0x00, 0x10, 0xC0, 0x0C, 0x10, 0x01, 0x04, 0x00, 0x81,
  0x80, 0x30, 0x40, 0x08, 0x18, 0x03, 0x06, 0x01, 0x81, 0x80, 0x20, 0x60,
  0x18, 0x08, 0x06, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x10, 0x0C, 0x04,
  0x03, 0x03, 0x00, 0x40, 0xC0, 0x10, 0x30, 0x04, 0x0C, 0x01, 0x02, 0x00,
  0x60, 0xC0, 0x18, 0x20, 0x06, 0x08, 0x01, 0x86, 0x00, 0x21, 0x80, 0x08,
  0x60, 0x02, 0x18, 0x00, 0x84, 0x00, 0x31, 0x00, 0x0C, 0x40, 0x03, 0x30,
  0x00, 0xCC, 0x00, 0x13, 0x00, 0x04, 0xC0, 0x01, 0x30, 0x00, 0x68, 0x00,
  0x1A, 0x00, 0x06, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x01, 0x80, 0xC0, 0x03,
  0x01, 0x80, 0x0C, 0x01, 0x80, 0x30, 0x01, 0x80, 0x60, 0x03, 0x01, 0x80,
  0x03, 0x02, 0x00, 0x02, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00,
  0x0D, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xD8, 0x00, 0x01, 0x98, 0x00, 0x06, 0x30, 0x00, 0x18, 0x30, 0x00, 0x30,
  0x20, 0x00, 0xC0, 0x60, 0x01, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x00,
  0xC0, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x00, 0x01, 0x86, 0x00, 0x01,
  0x18, 0x00, 0x03, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x0D,
  0x80, 0x00, 0x19, 0x00, 0x00, 0x23, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x84,
  0x00, 0x02, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x10, 0x00, 0x20, 0x30,
  0x00, 0xC0, 0x60, 0x01, 0x80, 0x40, 0x02, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x20, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x04, 0x02,
  0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x10, 0x20, 0x00, 0x30, 0xC0,
  0x00, 0x61, 0x80, 0x00, 0x42, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00,
  0x01, 0x20, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x1F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0x00, 0x1F, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x3F,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x03, 0x80,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xE0,
  0x0F, 0xC0, 0x06, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xBC, 0x7C, 0x00, 0x70,
  0x07, 0x80, 0x70, 0x00, 0xFB, 0xE8, 0x00, 0x1F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Thin61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 3, 44, 13, 5, -44 },
  { 18, 11, 16, 19, 4, -44 },
  { 40, 32, 44, 34, 1, -44 },
  { 216, 23, 50, 31, 3, -46 },
  { 360, 37, 45, 43, 3, -44 },
  { 569, 31, 45, 36, 3, -44 },
  { 744, 2, 16, 10, 4, -44 },
  { 748, 10, 54, 16, 3, -44 },
  { 816, 11, 54, 16, 2, -44 },
  { 891, 22, 21, 29, 3, -46 },
  { 949, 25, 29, 31, 3, -36 },
  { 1040, 6, 15, 11, 2, -7 },
  { 1052, 14, 1, 18, 2, -17 },
  { 1054, 3, 4, 13, 5, -4 },
  { 1056, 18, 44, 20, 1, -44 },
  { 1155, 24, 45, 31, 3, -44 },
  { 1290, 12, 44, 31, 6, -44 },
  { 1356, 24, 44, 31, 3, -44 },
  { 1488, 24, 45, 31, 3, -44 },
  { 1623, 29, 44, 31, 1, -44 },
  { 1783, 23, 45, 31, 4, -44 },
  { 1913, 24, 45, 31, 4, -44 },
  { 2048, 24, 44, 31, 3, -44 },
  { 2180, 24, 45, 31, 3, -44 },
  { 2315, 24, 45, 31, 3, -44 },
  { 2450, 3, 32, 13, 5, -32 },
  { 2462, 6, 40, 12, 2, -32 },
  { 2492, 25, 26, 31, 3, -35 },
  { 2574, 25, 15, 31, 3, -29 },
  { 2621, 25, 26, 31, 3, -35 },
  { 2703, 18, 44, 22, 2, -44 },
  { 2802, 41, 49, 47, 3, -43 },
  { 3054, 31, 44, 31, 0, -44 },
  { 3225, 24, 44, 33, 6, -44 },
  { 3357, 27, 45, 33, 4, -44 },
  { 3509, 28, 44, 37, 6, -44 },
  { 3663, 20, 44, 30, 6, -44 },
  { 3773, 20, 44, 27, 6, -44 },
  { 3883, 31, 45, 39, 4, -44 },
  { 4058, 26, 44, 38, 6, -44 },
  { 4201, 10, 44, 16, 3, -44 },
  { 4256, 13, 55, 13, -5, -44 },
  { 4346, 24, 44, 30, 6, -44 },
  { 4478, 20, 44, 27, 6, -44 },
  { 4588, 35, 44, 47, 6, -44 },
  { 4781, 27, 44, 38, 6, -44 },
  { 4930, 33, 45, 41, 4, -44 },
  { 5116, 22, 44, 31, 6, -44 },
  { 5237, 33, 54, 41, 4, -44 },
  { 5460, 24, 44, 31, 6, -44 },
  { 5592, 24, 45, 30, 3, -44 },
  { 5727, 27, 44, 27, 0, -44 },
  { 5876, 28, 45, 38, 5, -44 },
  { 6034, 30, 44, 30, 0, -44 },
  { 6199, 46, 44, 48, 1, -44 },
  { 6452, 27, 44, 27, 0, -44 },
  { 6601, 27, 44, 27, 0, -44 },
  { 6750, 26, 44, 30, 2, -44 },
  { 6893, 12, 54, 19, 5, -44 },
  { 6974, 18, 44, 20, 1, -44 },
  { 7073, 12, 54, 19, 2, -44 },
  { 7154, 27, 25, 31, 2, -44 },
  { 7239, 24, 1, 24, 0, 6 },
  { 7242, 10, 10, 15, 2, -47 },
  { 7255, 20, 34, 28, 3, -33 },
  { 7340, 24, 47, 32, 5, -46 },
  { 7481, 21, 34, 25, 3, -33 },
  { 7571, 24, 47, 32, 3, -46 },
  { 7712, 23, 34, 29, 3, -33 },
  { 7810, 17, 47, 15, 1, -47 },
  { 7910, 24, 48, 32, 3, -33 },
  { 8054, 21, 46, 31, 5, -46 },
  { 8175, 4, 44, 12, 4, -44 },
  { 8197, 10, 59, 12, -2, -44 },
  { 8271, 20, 46, 25, 5, -46 },
  { 8386, 2, 46, 12, 5, -46 },
  { 8398, 37, 33, 47, 5, -33 },
  { 8551, 21, 33, 31, 5, -33 },
  { 8638, 25, 34, 31, 3, -33 },
  { 8745, 24, 47, 32, 5, -33 },
  { 8886, 24, 47, 32, 3, -33 },
  { 9027, 15, 33, 20, 5, -33 },
  { 9089, 20, 34, 25, 2, -33 },
  { 9174, 15, 41, 17, 1, -40 },
  { 9251, 21, 33, 31, 5, -32 },
  { 9338, 23, 32, 23, 0, -32 },
  { 9430, 36, 32, 38, 1, -32 },
  { 9574, 23, 32, 26, 1, -32 },
  { 9666, 23, 47, 24, 0, -32 },
  { 9802, 19, 32, 23, 2, -32 },
  { 9878, 16, 54, 21, 2, -44 },
  { 9986, 1, 61, 29, 14, -46 },
  { 9994, 17, 54, 21, 2, -44 },
  { 10109, 25, 5, 31, 3, -24 },
};

const GFXfont NotoSans_SemiCondensed_Thin61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin61pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_SEMICONDENSED_THIN61PT7B_H_
