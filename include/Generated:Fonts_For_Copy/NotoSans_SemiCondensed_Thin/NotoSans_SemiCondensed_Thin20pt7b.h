#ifndef _NOTOSANS_SEMICONDENSED_THIN20PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE4, 0x99, 0x99, 0x90, 0x08, 0x81, 0x10, 0x22, 0x04, 0x47,
  0xFE, 0x22, 0x04, 0x40, 0x88, 0x11, 0x1F, 0xF8, 0x44, 0x11, 0x02, 0x20,
  0x44, 0x00, 0x10, 0x7E, 0x90, 0x90, 0x90, 0x90, 0x50, 0x30, 0x1C, 0x12,
  0x11, 0x11, 0x11, 0x92, 0x7C, 0x10, 0x70, 0x48, 0x88, 0x88, 0x88, 0x90,
  0x89, 0x08, 0xA6, 0x8A, 0x95, 0x51, 0x25, 0x10, 0x91, 0x09, 0x11, 0x11,
  0x11, 0x13, 0x0E, 0x18, 0x09, 0x04, 0x21, 0x08, 0x42, 0x09, 0x02, 0x80,
  0xC0, 0x48, 0x21, 0x18, 0x26, 0x06, 0x80, 0xA0, 0x67, 0xE4, 0xF8, 0x29,
  0x49, 0x24, 0x92, 0x48, 0x92, 0x20, 0x89, 0x12, 0x49, 0x24, 0x92, 0x52,
  0x80, 0x10, 0x23, 0x59, 0xC1, 0x84, 0x91, 0x00, 0x08, 0x08, 0x08, 0x08,
  0xFF, 0x08, 0x08, 0x08, 0x08, 0x08, 0xF8, 0xF0, 0x80, 0x04, 0x10, 0x82,
  0x08, 0x41, 0x04, 0x20, 0x84, 0x10, 0x42, 0x00, 0x18, 0x26, 0x42, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x42, 0x3C, 0x35,
  0x91, 0x11, 0x11, 0x11, 0x11, 0x11, 0xFC, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0xFF, 0xFE, 0x02, 0x01, 0x01,
  0x02, 0x06, 0x38, 0x06, 0x01, 0x01, 0x01, 0x01, 0x02, 0xFC, 0x03, 0x00,
  0xC0, 0x50, 0x24, 0x09, 0x04, 0x42, 0x10, 0x84, 0x41, 0x20, 0x47, 0xFC,
  0x04, 0x01, 0x00, 0x40, 0x7E, 0x40, 0x40, 0x40, 0x40, 0xB8, 0x46, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x02, 0xFC, 0x3E, 0x40, 0x40, 0x40, 0x80, 0xBC,
  0xC2, 0x81, 0x81, 0x81, 0x81, 0x41, 0x41, 0x3E, 0xFF, 0x01, 0x02, 0x02,
  0x02, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x7E, 0x41,
  0x81, 0x81, 0x42, 0x24, 0x18, 0x66, 0x81, 0x81, 0x81, 0x81, 0x81, 0x7E,
  0x7C, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x47, 0x39, 0x01, 0x02, 0x02,
  0x04, 0xF8, 0xC0, 0x20, 0x50, 0x00, 0x1A, 0xA0, 0x01, 0x02, 0x0C, 0x30,
  0xC0, 0x60, 0x10, 0x0C, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x40, 0x38,
  0x06, 0x01, 0x02, 0x0C, 0x30, 0xC0, 0xF8, 0x10, 0x41, 0x08, 0x21, 0x08,
  0x41, 0x04, 0x00, 0x01, 0x00, 0x0F, 0xE0, 0xC0, 0x44, 0x00, 0x90, 0x02,
  0x87, 0xCA, 0x21, 0x18, 0x84, 0x62, 0x11, 0x90, 0x86, 0x22, 0x28, 0x8C,
  0xA1, 0xCC, 0x40, 0x01, 0x00, 0x02, 0x00, 0x07, 0xF0, 0x04, 0x03, 0x00,
  0xA0, 0x48, 0x12, 0x04, 0x42, 0x10, 0x84, 0x3F, 0x10, 0x24, 0x09, 0x02,
  0x80, 0x60, 0x10, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x82, 0xFC, 0x82, 0x81,
  0x81, 0x81, 0x81, 0x82, 0xFC, 0x1F, 0x90, 0x10, 0x08, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00, 0xFC, 0xFE, 0x40, 0xA0,
  0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x28, 0x27,
  0xE0, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x3F, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x1F, 0xC0, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x7E, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x00, 0x07, 0x83, 0x08, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x83, 0xF0, 0x06, 0x00, 0xA0, 0x14, 0x02, 0x40, 0x47, 0xF0,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xFF, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x04, 0xE9, 0x24, 0x92, 0x49, 0x25, 0xC0, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x83, 0x84, 0x88, 0x88, 0x90,
  0xA0, 0xE0, 0x90, 0x90, 0x88, 0x84, 0x84, 0x82, 0x81, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x1F, 0xC0, 0x80, 0x38,
  0x03, 0xC0, 0x5C, 0x05, 0xA0, 0x5A, 0x09, 0xA0, 0x99, 0x09, 0x91, 0x18,
  0x91, 0x8A, 0x18, 0xA1, 0x86, 0x18, 0x41, 0x80, 0xC0, 0x70, 0x34, 0x1A,
  0x0C, 0x86, 0x23, 0x11, 0x84, 0xC2, 0x60, 0xB0, 0x38, 0x1C, 0x04, 0x0E,
  0x06, 0x31, 0x01, 0x20, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xA0, 0x14, 0x04, 0x40, 0x87, 0xE0, 0xFD, 0x06, 0x0C, 0x18,
  0x30, 0x61, 0x7C, 0x81, 0x02, 0x04, 0x08, 0x10, 0x00, 0x0E, 0x06, 0x31,
  0x01, 0x20, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xA0, 0x14, 0x04, 0x40, 0x87, 0x60, 0x10, 0x01, 0x00, 0x10, 0xFC, 0x82,
  0x82, 0x82, 0x82, 0x82, 0x84, 0xF8, 0x88, 0x84, 0x84, 0x82, 0x82, 0x81,
  0x7F, 0x80, 0x80, 0x80, 0x80, 0x40, 0x38, 0x04, 0x02, 0x01, 0x01, 0x01,
  0x02, 0xFC, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x13, 0xF0, 0x80, 0x60,
  0x24, 0x09, 0x02, 0x41, 0x08, 0x42, 0x10, 0x84, 0x12, 0x04, 0x81, 0x20,
  0x30, 0x0C, 0x02, 0x00, 0x81, 0x02, 0x83, 0x05, 0x06, 0x0A, 0x14, 0x14,
  0x24, 0x44, 0x48, 0x88, 0x91, 0x12, 0x22, 0x24, 0x28, 0x28, 0x50, 0x50,
  0xA0, 0xC1, 0x40, 0x83, 0x01, 0x02, 0x00, 0x41, 0xA0, 0x88, 0x84, 0x41,
  0x40, 0xA0, 0x20, 0x28, 0x14, 0x11, 0x08, 0x88, 0x24, 0x14, 0x04, 0x80,
  0xA0, 0x90, 0x44, 0x42, 0x21, 0x20, 0x50, 0x30, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0xFF, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20,
  0x20, 0x40, 0x40, 0x80, 0xFF, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0xF0, 0x81, 0x04, 0x08, 0x20, 0x81, 0x04, 0x10, 0x20, 0x82, 0x04,
  0x10, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x49, 0xE0, 0x08, 0x14, 0x24, 0x22,
  0x42, 0x42, 0x81, 0x81, 0xFF, 0x88, 0x80, 0x78, 0x08, 0x08, 0x10, 0x27,
  0xF0, 0xC1, 0x83, 0x0D, 0xE8, 0x81, 0x02, 0x04, 0x0B, 0x98, 0xE0, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0x00, 0x1E, 0xC1, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x80, 0x80, 0xF8, 0x01, 0x01, 0x01, 0x01, 0x3D, 0x43, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x3C, 0x42, 0x82, 0x81,
  0x81, 0xFF, 0x80, 0x80, 0x80, 0x40, 0x3E, 0x3C, 0x82, 0x08, 0xF8, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x00, 0x3D, 0x43, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x02, 0x7C, 0x81,
  0x02, 0x04, 0x0B, 0x98, 0xA0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0x80, 0xC2, 0xAA, 0xAA, 0xA0, 0x30, 0x02, 0x22, 0x22, 0x22, 0x22, 0x22,
  0x22, 0x22, 0xC0, 0x82, 0x08, 0x20, 0x86, 0x29, 0x24, 0xA3, 0x89, 0x24,
  0x8A, 0x28, 0x40, 0xFF, 0xFE, 0xF9, 0xC8, 0x62, 0x84, 0x18, 0x41, 0x84,
  0x18, 0x41, 0x84, 0x18, 0x41, 0x84, 0x18, 0x41, 0x84, 0x10, 0xB9, 0x8A,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x3C, 0x42, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0xB9, 0x8E, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x07, 0xF4, 0x08, 0x10, 0x20, 0x40, 0x3D, 0x43, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x01,
  0x01, 0xBC, 0x88, 0x88, 0x88, 0x88, 0x80, 0x7E, 0x08, 0x20, 0xC0, 0xC0,
  0x81, 0x04, 0x1F, 0x80, 0x42, 0x3E, 0x84, 0x21, 0x08, 0x42, 0x10, 0x43,
  0x80, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0D, 0xE8, 0x81,
  0x82, 0x82, 0x42, 0x44, 0x44, 0x24, 0x28, 0x28, 0x18, 0x10, 0x82, 0x18,
  0x21, 0x46, 0x14, 0x51, 0x45, 0x24, 0x92, 0x28, 0xA2, 0x8A, 0x28, 0xC1,
  0x04, 0x10, 0x40, 0x81, 0x42, 0x22, 0x24, 0x18, 0x08, 0x18, 0x24, 0x24,
  0x42, 0xC1, 0x81, 0x81, 0x42, 0x42, 0x42, 0x24, 0x24, 0x24, 0x18, 0x18,
  0x10, 0x10, 0x10, 0x10, 0x20, 0xC0, 0xFC, 0x10, 0x82, 0x10, 0x82, 0x10,
  0x42, 0x0F, 0xC0, 0x39, 0x08, 0x42, 0x10, 0x88, 0x82, 0x08, 0x42, 0x10,
  0x84, 0x18, 0xFF, 0xFF, 0xF0, 0xC1, 0x08, 0x42, 0x10, 0x84, 0x19, 0x08,
  0x42, 0x10, 0x84, 0xC0, 0x71, 0x8E,
};

const GFXglyph NotoSans_SemiCondensed_Thin20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 14, 4, 2, -14 },
  { 3, 4, 5, 6, 1, -14 },
  { 6, 11, 14, 11, 0, -14 },
  { 26, 8, 16, 10, 1, -15 },
  { 42, 12, 14, 14, 1, -14 },
  { 63, 10, 15, 12, 1, -15 },
  { 82, 1, 5, 3, 1, -14 },
  { 83, 3, 17, 5, 1, -14 },
  { 90, 3, 17, 5, 1, -14 },
  { 97, 7, 7, 9, 1, -15 },
  { 104, 8, 10, 10, 1, -12 },
  { 114, 1, 5, 4, 1, -2 },
  { 115, 4, 1, 6, 1, -6 },
  { 116, 1, 1, 4, 2, -1 },
  { 117, 6, 14, 6, 0, -14 },
  { 128, 8, 15, 10, 1, -15 },
  { 143, 4, 14, 10, 2, -14 },
  { 150, 8, 14, 10, 1, -14 },
  { 164, 8, 14, 10, 1, -14 },
  { 178, 10, 14, 10, 0, -14 },
  { 196, 8, 14, 10, 1, -14 },
  { 210, 8, 14, 10, 1, -14 },
  { 224, 8, 14, 10, 1, -14 },
  { 238, 8, 14, 10, 1, -14 },
  { 252, 8, 14, 10, 1, -14 },
  { 266, 1, 11, 4, 2, -11 },
  { 268, 2, 14, 4, 1, -11 },
  { 272, 8, 9, 10, 1, -12 },
  { 281, 8, 4, 10, 1, -9 },
  { 285, 8, 9, 10, 1, -12 },
  { 294, 6, 14, 7, 1, -14 },
  { 305, 14, 16, 16, 1, -14 },
  { 333, 10, 14, 10, 0, -14 },
  { 351, 8, 14, 11, 2, -14 },
  { 365, 9, 14, 11, 1, -14 },
  { 381, 9, 14, 12, 2, -14 },
  { 397, 7, 14, 10, 2, -14 },
  { 410, 7, 14, 9, 2, -14 },
  { 423, 11, 15, 13, 1, -15 },
  { 444, 9, 14, 13, 2, -14 },
  { 460, 3, 14, 5, 1, -14 },
  { 466, 4, 17, 4, -2, -14 },
  { 475, 8, 14, 10, 2, -14 },
  { 489, 7, 14, 9, 2, -14 },
  { 502, 12, 14, 15, 2, -14 },
  { 523, 9, 14, 13, 2, -14 },
  { 539, 11, 15, 13, 1, -15 },
  { 560, 7, 14, 10, 2, -14 },
  { 573, 11, 18, 13, 1, -15 },
  { 598, 8, 14, 10, 2, -14 },
  { 612, 8, 14, 10, 1, -14 },
  { 626, 9, 14, 9, 0, -14 },
  { 642, 9, 14, 13, 2, -14 },
  { 658, 10, 14, 10, 0, -14 },
  { 676, 15, 14, 16, 0, -14 },
  { 703, 9, 14, 9, 0, -14 },
  { 719, 9, 14, 9, 0, -14 },
  { 735, 8, 14, 10, 1, -14 },
  { 749, 4, 17, 6, 2, -14 },
  { 758, 6, 14, 6, 0, -14 },
  { 769, 3, 17, 6, 1, -14 },
  { 776, 8, 8, 10, 1, -14 },
  { 784, 8, 1, 8, 0, 2 },
  { 785, 3, 3, 5, 1, -15 },
  { 787, 7, 11, 9, 1, -11 },
  { 797, 7, 15, 11, 2, -15 },
  { 811, 7, 11, 8, 1, -11 },
  { 821, 8, 15, 11, 1, -15 },
  { 836, 8, 11, 10, 1, -11 },
  { 847, 6, 15, 5, 0, -15 },
  { 859, 8, 16, 10, 1, -11 },
  { 875, 7, 15, 10, 2, -15 },
  { 889, 2, 14, 4, 1, -14 },
  { 893, 4, 19, 4, -1, -14 },
  { 903, 6, 15, 8, 2, -15 },
  { 915, 1, 15, 4, 1, -15 },
  { 917, 12, 11, 15, 2, -11 },
  { 934, 7, 11, 10, 2, -11 },
  { 944, 8, 11, 10, 1, -11 },
  { 955, 7, 16, 10, 2, -11 },
  { 969, 8, 16, 10, 1, -11 },
  { 985, 4, 11, 7, 2, -11 },
  { 991, 6, 11, 8, 1, -11 },
  { 1000, 5, 13, 6, 0, -13 },
  { 1009, 7, 11, 10, 2, -11 },
  { 1019, 8, 11, 8, 0, -11 },
  { 1030, 12, 11, 12, 0, -11 },
  { 1047, 8, 11, 8, 0, -11 },
  { 1058, 8, 16, 8, 0, -11 },
  { 1074, 6, 11, 8, 1, -11 },
  { 1083, 5, 17, 7, 1, -14 },
  { 1094, 1, 20, 10, 4, -15 },
  { 1097, 5, 17, 7, 1, -14 },
  { 1108, 8, 2, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_Thin20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin20pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_SEMICONDENSED_THIN20PT7B_H_
