#ifndef _NOTOSANS_SEMICONDENSED_THIN22PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF1, 0xB6, 0xDB, 0x40, 0x08, 0x81, 0x10, 0x42, 0x08, 0x41,
  0x11, 0xFF, 0xC4, 0x40, 0x88, 0x21, 0x04, 0x23, 0xFF, 0x11, 0x02, 0x20,
  0x44, 0x10, 0x82, 0x10, 0x08, 0x1C, 0x6B, 0x88, 0x88, 0x88, 0x88, 0x48,
  0x30, 0x0C, 0x0B, 0x09, 0x09, 0x09, 0x09, 0x8B, 0x7C, 0x08, 0x30, 0x22,
  0x42, 0x21, 0x11, 0x08, 0x88, 0x48, 0x42, 0x42, 0x14, 0xD0, 0xA9, 0x4A,
  0x89, 0x94, 0x41, 0x22, 0x09, 0x10, 0x88, 0x84, 0x44, 0x42, 0x22, 0x0E,
  0x1C, 0x04, 0x41, 0x04, 0x20, 0x82, 0x10, 0x44, 0x05, 0x00, 0xC0, 0x28,
  0x08, 0x86, 0x08, 0xC0, 0xA8, 0x0D, 0x01, 0x10, 0x51, 0xF1, 0xFC, 0x12,
  0x24, 0x48, 0x88, 0x88, 0x88, 0x88, 0x84, 0x42, 0x30, 0x84, 0x42, 0x22,
  0x11, 0x11, 0x11, 0x12, 0x22, 0x24, 0x80, 0x08, 0x08, 0x08, 0xEB, 0x1C,
  0x18, 0x24, 0x42, 0x08, 0x04, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x20, 0x10,
  0x08, 0x04, 0x00, 0x5A, 0x80, 0xF8, 0x80, 0x02, 0x04, 0x10, 0x20, 0x81,
  0x02, 0x08, 0x10, 0x20, 0x81, 0x04, 0x08, 0x10, 0x40, 0x1E, 0x10, 0x90,
  0x48, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x14, 0x0A,
  0x09, 0x04, 0x7C, 0x13, 0x59, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x3C,
  0x61, 0x00, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x02, 0x02, 0x02,
  0x01, 0x01, 0x01, 0x01, 0xFF, 0x7E, 0x40, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x08, 0x78, 0x02, 0x00, 0x80, 0x20, 0x10, 0x08, 0x04, 0x05, 0xFC, 0x01,
  0x00, 0x20, 0x0A, 0x02, 0x40, 0x48, 0x11, 0x04, 0x20, 0x84, 0x20, 0x84,
  0x11, 0x02, 0x7F, 0xF0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x7F, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x60, 0xCC, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x05, 0xFC, 0x0F, 0x18, 0x08, 0x08, 0x04, 0x04, 0x02, 0x79, 0x42,
  0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0A, 0x05, 0x04, 0x7C, 0xFF, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80,
  0x80, 0x40, 0x40, 0x3E, 0x20, 0x90, 0x50, 0x14, 0x0A, 0x08, 0x88, 0x38,
  0x36, 0x20, 0xA0, 0x30, 0x18, 0x0C, 0x05, 0x04, 0x7C, 0x3C, 0x21, 0x20,
  0x50, 0x28, 0x0C, 0x06, 0x03, 0x01, 0x41, 0x9F, 0x40, 0x20, 0x20, 0x10,
  0x08, 0x08, 0xF8, 0xC0, 0x10, 0x50, 0x00, 0x05, 0xA8, 0x00, 0x81, 0x83,
  0x06, 0x04, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x0C, 0x18, 0x30,
  0x60, 0x40, 0x00, 0xF8, 0x10, 0x41, 0x04, 0x10, 0x82, 0x30, 0x82, 0x10,
  0x00, 0x00, 0x18, 0x03, 0xC0, 0x18, 0x60, 0x40, 0x21, 0x00, 0x24, 0x00,
  0x48, 0x7C, 0x61, 0x08, 0xC4, 0x11, 0x88, 0x23, 0x10, 0x46, 0x21, 0x0C,
  0x42, 0x18, 0x4A, 0x48, 0x63, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x1F,
  0xC0, 0x04, 0x00, 0x80, 0x28, 0x05, 0x00, 0x90, 0x22, 0x04, 0x40, 0x84,
  0x20, 0x87, 0xF0, 0x82, 0x20, 0x24, 0x04, 0x80, 0xA0, 0x0C, 0x01, 0xFC,
  0x41, 0xA0, 0x50, 0x18, 0x0C, 0x0A, 0x05, 0xFC, 0x83, 0x40, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x05, 0xFC, 0x0F, 0xC4, 0x02, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x7F, 0xFC, 0x20, 0xC8, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0xA0, 0x28, 0x13, 0xF8, 0xFF, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x7F, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x7F, 0xFF,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x0F, 0xE1, 0x01, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x81, 0xF8, 0x01, 0x80, 0x14, 0x01, 0x40, 0x14, 0x01,
  0x30, 0x10, 0xFE, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07,
  0xFF, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xF4,
  0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x4F, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x45, 0xC0, 0x80, 0xC0, 0xA0, 0x90,
  0x88, 0x84, 0x82, 0x81, 0x40, 0xD0, 0x44, 0x22, 0x10, 0x88, 0x24, 0x12,
  0x05, 0x01, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x7F, 0x80, 0x0C, 0x00, 0x70, 0x07, 0x80, 0x3A, 0x02,
  0xD0, 0x16, 0x81, 0x32, 0x09, 0x90, 0x4C, 0x44, 0x62, 0x23, 0x11, 0x18,
  0x50, 0xC2, 0x86, 0x18, 0x30, 0x41, 0x80, 0x60, 0x1C, 0x06, 0x81, 0xA0,
  0x64, 0x19, 0x06, 0x21, 0x84, 0x61, 0x18, 0x26, 0x09, 0x81, 0x60, 0x38,
  0x0E, 0x01, 0x0F, 0x83, 0x04, 0x20, 0x24, 0x01, 0x40, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01, 0x40, 0x14, 0x02, 0x20,
  0x61, 0xF8, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x8E, 0xF0,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x0F, 0x83, 0x04, 0x20, 0x24, 0x01,
  0x40, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01,
  0x40, 0x14, 0x02, 0x20, 0x61, 0xE8, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04,
  0xFC, 0x41, 0x20, 0x50, 0x28, 0x14, 0x0A, 0x05, 0x04, 0xFC, 0x44, 0x21,
  0x10, 0x88, 0x24, 0x0A, 0x05, 0x01, 0x3F, 0x20, 0x20, 0x10, 0x08, 0x04,
  0x01, 0x00, 0x60, 0x0E, 0x00, 0x80, 0x20, 0x10, 0x08, 0x04, 0x05, 0xFC,
  0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x14, 0x08, 0xFC, 0x80, 0x30, 0x05, 0x01, 0x20, 0x24, 0x04, 0x81,
  0x08, 0x21, 0x04, 0x21, 0x02, 0x20, 0x44, 0x09, 0x00, 0xA0, 0x14, 0x03,
  0x00, 0x20, 0x80, 0x80, 0xA0, 0x40, 0x50, 0x20, 0x48, 0x28, 0x24, 0x14,
  0x11, 0x0A, 0x08, 0x84, 0x88, 0x44, 0x44, 0x22, 0x22, 0x09, 0x11, 0x04,
  0x85, 0x02, 0x82, 0x81, 0x41, 0x40, 0x60, 0xA0, 0x20, 0x20, 0x10, 0x10,
  0x40, 0x50, 0x22, 0x10, 0x84, 0x12, 0x04, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x01, 0x20, 0x88, 0x21, 0x10, 0x24, 0x0A, 0x01, 0x80, 0x60, 0x24, 0x09,
  0x04, 0x21, 0x08, 0x81, 0x20, 0x50, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0xFF, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10,
  0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0xFF, 0xF8, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x80, 0x81, 0x02, 0x02,
  0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0x81, 0x01, 0xF1, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x08, 0x06, 0x05, 0x02,
  0x42, 0x21, 0x09, 0x05, 0x01, 0x80, 0x80, 0xFF, 0x80, 0x88, 0x90, 0x3C,
  0x84, 0x08, 0x10, 0x23, 0xD8, 0xC1, 0x83, 0x06, 0x0B, 0xF0, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x82, 0xFC, 0x1F, 0x20, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x40, 0x40, 0x3E, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0xF5, 0x86, 0x81,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x83, 0x3E, 0x80, 0x1C,
  0x62, 0x41, 0x81, 0x81, 0xFF, 0x80, 0x80, 0x80, 0x40, 0x40, 0x3F, 0x1E,
  0x40, 0x81, 0x02, 0x1F, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x1E, 0xB0, 0xD0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x50, 0x67, 0xD0, 0x08, 0x04, 0x02, 0x02, 0x7E, 0x00, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0xCF, 0xFF, 0x11, 0x00, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0xE0, 0x81, 0x02, 0x04, 0x08, 0x10, 0x61, 0x44, 0x91,
  0x42, 0x86, 0x89, 0x11, 0x21, 0x42, 0x82, 0xFF, 0xFF, 0x80, 0xB8, 0xF6,
  0x28, 0x60, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x30, 0x41, 0x82,
  0x0C, 0x10, 0x60, 0x83, 0x04, 0x10, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x1E, 0x30, 0x90, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xA0, 0x50, 0x47, 0xC0, 0xBC, 0xC2, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC2, 0xBC, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x1E, 0xB0, 0xD0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x50, 0x67, 0xD0, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xBE, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x00, 0x7D, 0x06, 0x04, 0x08, 0x0C, 0x07, 0x01,
  0x02, 0x04, 0x0F, 0xE0, 0x20, 0x8F, 0xC8, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0xF0, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0B, 0xF0, 0x81, 0x81, 0x41, 0x42, 0x42, 0x22, 0x24, 0x24, 0x14, 0x18,
  0x18, 0x08, 0x82, 0x0C, 0x18, 0x50, 0xC2, 0x86, 0x14, 0x48, 0xA2, 0x48,
  0x92, 0x45, 0x12, 0x28, 0x50, 0xC3, 0x04, 0x08, 0x20, 0x40, 0x40, 0xA0,
  0x88, 0x84, 0x41, 0x40, 0x40, 0x20, 0x28, 0x22, 0x11, 0x10, 0x58, 0x30,
  0x81, 0x81, 0x41, 0x41, 0x42, 0x22, 0x22, 0x24, 0x14, 0x14, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x10, 0xE0, 0xFE, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10,
  0x40, 0x82, 0x07, 0xF0, 0x0C, 0xC2, 0x08, 0x20, 0x82, 0x08, 0x23, 0x04,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x81, 0xC0, 0xFF, 0xFF, 0xFC, 0xC0, 0x82,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x31, 0x04, 0x10, 0x41, 0x04, 0x10, 0x8E,
  0x00, 0x70, 0xC7, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Thin22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 16, 5, 2, -16 },
  { 3, 3, 6, 7, 2, -16 },
  { 6, 11, 16, 12, 1, -16 },
  { 28, 8, 18, 11, 1, -17 },
  { 46, 13, 16, 16, 1, -16 },
  { 72, 11, 16, 13, 1, -16 },
  { 94, 1, 6, 4, 1, -16 },
  { 95, 4, 19, 6, 1, -16 },
  { 105, 4, 19, 6, 1, -16 },
  { 115, 8, 8, 10, 1, -17 },
  { 123, 9, 10, 11, 1, -13 },
  { 135, 2, 5, 4, 1, -2 },
  { 137, 5, 1, 7, 1, -6 },
  { 138, 1, 1, 5, 2, -1 },
  { 139, 7, 16, 7, 0, -16 },
  { 153, 9, 16, 11, 1, -16 },
  { 171, 4, 16, 11, 2, -16 },
  { 179, 9, 16, 11, 1, -16 },
  { 197, 9, 16, 11, 1, -16 },
  { 215, 11, 16, 11, 0, -16 },
  { 237, 9, 16, 11, 1, -16 },
  { 255, 9, 16, 11, 1, -16 },
  { 273, 9, 16, 11, 1, -16 },
  { 291, 9, 16, 11, 1, -16 },
  { 309, 9, 16, 11, 1, -16 },
  { 327, 1, 12, 5, 2, -12 },
  { 329, 2, 15, 4, 1, -12 },
  { 333, 9, 10, 11, 1, -13 },
  { 345, 9, 5, 11, 1, -10 },
  { 351, 9, 10, 11, 1, -13 },
  { 363, 6, 16, 8, 1, -16 },
  { 375, 15, 18, 17, 1, -16 },
  { 409, 11, 16, 11, 0, -16 },
  { 431, 9, 16, 12, 2, -16 },
  { 449, 10, 16, 12, 1, -16 },
  { 469, 10, 16, 13, 2, -16 },
  { 489, 7, 16, 11, 2, -16 },
  { 503, 8, 16, 10, 2, -16 },
  { 519, 12, 16, 14, 1, -16 },
  { 543, 10, 16, 14, 2, -16 },
  { 563, 4, 16, 6, 1, -16 },
  { 571, 5, 20, 5, -2, -16 },
  { 584, 9, 16, 11, 2, -16 },
  { 602, 7, 16, 10, 2, -16 },
  { 616, 13, 16, 17, 2, -16 },
  { 642, 10, 16, 14, 2, -16 },
  { 662, 12, 16, 15, 1, -16 },
  { 686, 8, 16, 11, 2, -16 },
  { 702, 12, 20, 15, 1, -16 },
  { 732, 9, 16, 11, 2, -16 },
  { 750, 9, 16, 11, 1, -16 },
  { 768, 10, 16, 10, 0, -16 },
  { 788, 10, 16, 14, 2, -16 },
  { 808, 11, 16, 11, 0, -16 },
  { 830, 17, 16, 17, 0, -16 },
  { 864, 10, 16, 10, 0, -16 },
  { 884, 10, 16, 10, 0, -16 },
  { 904, 9, 16, 11, 1, -16 },
  { 922, 4, 19, 7, 2, -16 },
  { 932, 7, 16, 7, 0, -16 },
  { 946, 4, 19, 7, 1, -16 },
  { 956, 9, 9, 11, 1, -16 },
  { 967, 9, 1, 9, 0, 2 },
  { 969, 3, 4, 5, 1, -17 },
  { 971, 7, 12, 10, 1, -12 },
  { 982, 8, 17, 12, 2, -17 },
  { 999, 8, 12, 9, 1, -12 },
  { 1011, 9, 17, 12, 1, -17 },
  { 1031, 8, 12, 11, 1, -12 },
  { 1043, 7, 17, 6, 0, -17 },
  { 1058, 9, 17, 12, 1, -12 },
  { 1078, 8, 17, 11, 2, -17 },
  { 1095, 1, 16, 4, 2, -16 },
  { 1097, 4, 21, 4, -1, -16 },
  { 1108, 7, 17, 9, 2, -17 },
  { 1123, 1, 17, 4, 2, -17 },
  { 1126, 13, 12, 17, 2, -12 },
  { 1146, 8, 12, 11, 2, -12 },
  { 1158, 9, 12, 11, 1, -12 },
  { 1172, 8, 17, 12, 2, -12 },
  { 1189, 9, 17, 12, 1, -12 },
  { 1209, 5, 12, 7, 2, -12 },
  { 1217, 7, 12, 9, 1, -12 },
  { 1228, 6, 14, 6, 0, -14 },
  { 1239, 7, 12, 11, 2, -12 },
  { 1250, 8, 12, 8, 0, -12 },
  { 1262, 13, 12, 14, 0, -12 },
  { 1282, 9, 12, 9, 0, -12 },
  { 1296, 8, 17, 9, 0, -12 },
  { 1313, 7, 12, 8, 1, -12 },
  { 1324, 6, 19, 7, 1, -16 },
  { 1339, 1, 22, 11, 5, -17 },
  { 1342, 6, 19, 7, 1, -16 },
  { 1357, 9, 2, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_Thin22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin22pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_SEMICONDENSED_THIN22PT7B_H_
