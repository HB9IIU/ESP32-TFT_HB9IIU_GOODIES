#ifndef _NOTOSANS_SEMICONDENSED_THIN56PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin56pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xC0, 0x00, 0x00, 0xFB, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x00, 0x08, 0x01, 0x00,
  0x00, 0x40, 0x08, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01,
  0x00, 0x20, 0x00, 0x08, 0x01, 0x00, 0x00, 0x40, 0x08, 0x00, 0x02, 0x00,
  0x40, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x08, 0x01, 0x80,
  0x00, 0x40, 0x08, 0x03, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x01,
  0x80, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x40, 0x0C, 0x00, 0x02, 0x00,
  0x40, 0x00, 0x10, 0x02, 0x00, 0x00, 0x80, 0x10, 0x00, 0x0C, 0x00, 0x80,
  0x00, 0x60, 0x0C, 0x00, 0x02, 0x00, 0x60, 0x00, 0x10, 0x02, 0x00, 0x00,
  0x80, 0x10, 0x00, 0x04, 0x00, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0x00,
  0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0x80, 0x18, 0x00, 0x04, 0x00, 0x80,
  0x00, 0x20, 0x04, 0x00, 0x03, 0x00, 0x20, 0x00, 0x18, 0x03, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x20, 0x04, 0x00, 0x01, 0x00,
  0x20, 0x00, 0x18, 0x01, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x7F, 0xF8, 0x07, 0x10,
  0xF0, 0xE0, 0x80, 0x84, 0x04, 0x00, 0x60, 0x20, 0x06, 0x01, 0x00, 0x30,
  0x08, 0x01, 0x80, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x03, 0x00, 0x80,
  0x18, 0x04, 0x00, 0x40, 0x20, 0x03, 0x01, 0x00, 0x0C, 0x08, 0x00, 0x30,
  0x40, 0x00, 0xE2, 0x00, 0x01, 0xD0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x27, 0x00, 0x01, 0x0C, 0x00, 0x08, 0x38, 0x00, 0x40, 0x60, 0x02,
  0x03, 0x00, 0x10, 0x0C, 0x00, 0x80, 0x60, 0x04, 0x03, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x40, 0x08, 0x06, 0x00, 0x40, 0x30, 0x02, 0x01, 0x00, 0x10,
  0x18, 0x00, 0x81, 0x98, 0x04, 0x18, 0xFC, 0x27, 0x80, 0xFF, 0xF0, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x18, 0x01, 0x86, 0x00, 0x04, 0x00, 0xC0,
  0xC0, 0x03, 0x00, 0x60, 0x10, 0x00, 0x80, 0x10, 0x06, 0x00, 0x60, 0x04,
  0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x30, 0x10,
  0x00, 0x80, 0x0C, 0x0C, 0x00, 0x20, 0x03, 0x02, 0x00, 0x0C, 0x00, 0xC1,
  0x80, 0x03, 0x00, 0x30, 0x40, 0x00, 0xC0, 0x0C, 0x30, 0x30, 0x30, 0x02,
  0x08, 0x3F, 0x0C, 0x00, 0x86, 0x18, 0x61, 0x00, 0x21, 0x0C, 0x0C, 0x60,
  0x18, 0xC2, 0x01, 0x98, 0x04, 0x21, 0x80, 0x63, 0x03, 0x18, 0x40, 0x08,
  0xE1, 0x86, 0x10, 0x02, 0x0F, 0xC1, 0x0C, 0x00, 0xC0, 0x80, 0xC3, 0x00,
  0x30, 0x00, 0x20, 0xC0, 0x0C, 0x00, 0x18, 0x30, 0x03, 0x00, 0x04, 0x0C,
  0x00, 0xC0, 0x03, 0x03, 0x00, 0x30, 0x00, 0x80, 0xC0, 0x0C, 0x00, 0x60,
  0x30, 0x03, 0x00, 0x10, 0x0C, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x06, 0x01, 0x80,
  0x30, 0x01, 0x80, 0x40, 0x08, 0x00, 0x30, 0x30, 0x06, 0x00, 0x06, 0x18,
  0x01, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0C, 0x01, 0x00, 0x00,
  0x40, 0x0C, 0x00, 0x06, 0x00, 0x20, 0x00, 0x20, 0x01, 0x80, 0x01, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x60, 0x00, 0x40, 0x03, 0x00, 0x02, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x02, 0x00, 0x60, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x06, 0x00, 0x00, 0x04,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x20, 0x00, 0x03, 0x01, 0x80, 0x06,
  0x30, 0x06, 0x00, 0x23, 0x00, 0x18, 0x01, 0x10, 0x00, 0x60, 0x19, 0x80,
  0x01, 0x80, 0x8C, 0x00, 0x04, 0x04, 0x40, 0x00, 0x30, 0x62, 0x00, 0x00,
  0xC2, 0x10, 0x00, 0x03, 0x30, 0x80, 0x00, 0x0D, 0x06, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x01, 0x80, 0x80, 0x00, 0x1E, 0x06, 0x00, 0x01, 0x98, 0x18,
  0x00, 0x18, 0x60, 0x60, 0x01, 0x81, 0x81, 0xC0, 0x38, 0x04, 0x07, 0xFF,
  0x00, 0x38, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xAA, 0xA0, 0x01, 0x81,
  0x80, 0x80, 0xC0, 0x40, 0x60, 0x60, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x06,
  0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x60,
  0x10, 0x08, 0x06, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80,
  0x40, 0x30, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18,
  0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60,
  0x18, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0,
  0x20, 0x18, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x0C, 0x02, 0x03, 0xF8, 0x20, 0xF0, 0xE2, 0x78, 0x01, 0xF8, 0x00,
  0x06, 0x00, 0x00, 0xD0, 0x00, 0x09, 0x80, 0x01, 0x08, 0x00, 0x30, 0x40,
  0x06, 0x06, 0x00, 0x40, 0x30, 0x08, 0x01, 0x81, 0x80, 0x08, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x18, 0xC6, 0x23, 0x18, 0xC4, 0x63, 0x10, 0x8C, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x07, 0xFC, 0x00, 0x70, 0x18, 0x03, 0x00, 0x30, 0x08,
  0x00, 0x60, 0x60, 0x00, 0x81, 0x00, 0x03, 0x0C, 0x00, 0x04, 0x20, 0x00,
  0x19, 0x80, 0x00, 0x66, 0x00, 0x00, 0x90, 0x00, 0x02, 0x40, 0x00, 0x0D,
  0x00, 0x00, 0x34, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xD0, 0x00, 0x03, 0x40, 0x00, 0x0D, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x98, 0x00, 0x02, 0x60, 0x00, 0x18, 0x80, 0x00, 0x63, 0x00, 0x01,
  0x04, 0x00, 0x0C, 0x18, 0x00, 0x20, 0x30, 0x01, 0x80, 0xE0, 0x0C, 0x00,
  0xC0, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x1C, 0x06,
  0x81, 0x90, 0xE2, 0x30, 0x4C, 0x0F, 0x01, 0x40, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x00, 0x1F, 0xF8, 0x01, 0xC0, 0x38, 0x1C,
  0x00, 0x30, 0x40, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x3F,
  0xF8, 0x03, 0xC0, 0x38, 0x1C, 0x00, 0x30, 0xC0, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x88, 0x00, 0x0C, 0x3C, 0x00, 0xE0, 0x3F, 0xFE,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x40, 0x00, 0x00, 0x68, 0x00, 0x00, 0x09, 0x00, 0x00, 0x03, 0x20,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x10, 0x80, 0x00, 0x06, 0x10, 0x00, 0x01,
  0x82, 0x00, 0x00, 0x20, 0x40, 0x00, 0x0C, 0x08, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x40, 0x20, 0x00, 0x18, 0x04, 0x00, 0x06, 0x00, 0x80, 0x00, 0x80,
  0x10, 0x00, 0x30, 0x02, 0x00, 0x04, 0x00, 0x40, 0x01, 0x80, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x08, 0x00, 0x20, 0x03, 0x00, 0x04, 0x00, 0xC0, 0x00,
  0x80, 0x10, 0x00, 0x10, 0x06, 0x00, 0x02, 0x01, 0x80, 0x00, 0x40, 0x20,
  0x00, 0x08, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xE1, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x47, 0xF8, 0x03, 0xFF, 0xF8, 0x18, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x40, 0x00, 0xC3, 0xC0,
  0x1C, 0x07, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF,
  0xC0, 0x0E, 0x01, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x10, 0x01, 0x07, 0xFE, 0x04, 0x70, 0x0C, 0x13,
  0x00, 0x08, 0xD8, 0x00, 0x13, 0x40, 0x00, 0x6E, 0x00, 0x00, 0xB8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x50, 0x00, 0x01,
  0x40, 0x00, 0x05, 0x00, 0x00, 0x14, 0x00, 0x00, 0x58, 0x00, 0x01, 0x60,
  0x00, 0x0C, 0x80, 0x00, 0x33, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x18, 0x00,
  0x18, 0x20, 0x00, 0xC0, 0xC0, 0x06, 0x01, 0xC0, 0x30, 0x01, 0xFF, 0x80,
  0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFC, 0x00, 0xE0,
  0x1C, 0x07, 0x00, 0x18, 0x10, 0x00, 0x30, 0xC0, 0x00, 0x42, 0x00, 0x01,
  0x98, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x26, 0x00, 0x01, 0x98,
  0x00, 0x06, 0x20, 0x00, 0x18, 0xC0, 0x00, 0x41, 0x00, 0x03, 0x06, 0x00,
  0x18, 0x0E, 0x00, 0xC0, 0x0C, 0x0E, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xFC, 0x00, 0x0E, 0x1C, 0x00, 0xE0, 0x1C, 0x06, 0x00, 0x18, 0x30,
  0x00, 0x30, 0x80, 0x00, 0x66, 0x00, 0x01, 0x90, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xD0, 0x00, 0x02, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0xC1, 0x80, 0x06, 0x03, 0x80, 0x70, 0x03, 0xFF, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0xF8, 0x00, 0xE0, 0x38, 0x06, 0x00, 0x30,
  0x30, 0x00, 0x60, 0x80, 0x01, 0x86, 0x00, 0x03, 0x10, 0x00, 0x0C, 0xC0,
  0x00, 0x13, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xA0, 0x00, 0x02, 0x80, 0x00,
  0x0A, 0x00, 0x00, 0x28, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xD0, 0x00, 0x07, 0x60, 0x00, 0x3C, 0xC0,
  0x01, 0xB1, 0x80, 0x0C, 0xC3, 0x00, 0xE3, 0x07, 0xFE, 0x08, 0x01, 0x80,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x10, 0x07, 0x00, 0x3F, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xB0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0xC0, 0x18, 0xCE, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0xC6, 0x23, 0x18, 0xC4, 0x63, 0x10, 0x8C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x7F, 0xF0, 0xE0, 0x38, 0x80,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x00, 0x04,
  0x30, 0x00, 0xFF, 0xC0, 0x19, 0x80, 0x0E, 0x03, 0x00, 0x66, 0x00, 0x60,
  0x04, 0x00, 0x98, 0x01, 0x00, 0x10, 0x02, 0x40, 0x0C, 0x00, 0x40, 0x0B,
  0x00, 0x60, 0x01, 0x00, 0x2C, 0x01, 0x80, 0x04, 0x00, 0xF0, 0x04, 0x00,
  0x10, 0x03, 0xC0, 0x10, 0x00, 0xC0, 0x0F, 0x00, 0xC0, 0x03, 0x00, 0x3C,
  0x03, 0x00, 0x0C, 0x00, 0xE0, 0x0C, 0x00, 0x30, 0x03, 0x80, 0x30, 0x00,
  0xC0, 0x0B, 0x00, 0xC0, 0x03, 0x00, 0x2C, 0x03, 0x00, 0x0C, 0x00, 0xB0,
  0x0C, 0x00, 0x70, 0x06, 0xC0, 0x10, 0x01, 0x40, 0x13, 0x00, 0x60, 0x05,
  0x00, 0xC4, 0x00, 0x80, 0x24, 0x03, 0x10, 0x03, 0x01, 0x88, 0x18, 0x60,
  0x07, 0xFC, 0x3F, 0xC1, 0x80, 0x07, 0xC0, 0x3C, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x05, 0x00, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x88, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x20, 0x60, 0x00, 0x02, 0x06, 0x00, 0x00, 0x60, 0x20, 0x00, 0x04,
  0x03, 0x00, 0x00, 0x40, 0x30, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x80, 0x18,
  0x00, 0x08, 0x01, 0x80, 0x01, 0x80, 0x08, 0x00, 0x10, 0x00, 0xC0, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x02, 0x00, 0x06, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x40, 0x00, 0x30, 0x04, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x10, 0x08, 0x00, 0x01, 0x00, 0x80, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x04,
  0x20, 0x00, 0x00, 0x42, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x01,
  0x80, 0x7F, 0x83, 0x00, 0x03, 0x86, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x98,
  0x00, 0x01, 0x30, 0x00, 0x02, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80,
  0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x98, 0x00,
  0x01, 0x30, 0x00, 0x06, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x61, 0x80, 0x03,
  0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x0B,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x1B, 0x00,
  0x00, 0x36, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x18, 0x00, 0x1C, 0x30, 0x03,
  0xF0, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xC0, 0x07,
  0x80, 0x3C, 0x03, 0x00, 0x02, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x0E, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFC, 0x00,
  0x30, 0x0F, 0xE0, 0x0C, 0x00, 0x1E, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x18, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x70,
  0x0C, 0x07, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xEC, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xB0, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x0E, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x01, 0x10, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x42, 0x00, 0x00, 0x02,
  0x18, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x81, 0xC0, 0x00, 0x04, 0x07,
  0x00, 0x00, 0x20, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0x84, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x21, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x0C, 0xFF, 0x0F,
  0x80, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x33, 0x00, 0x00, 0xC6, 0x00, 0x03,
  0x0C, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x30, 0x00, 0x60, 0x60, 0x01, 0x80,
  0xC0, 0x06, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x06, 0x01, 0x80, 0x0C,
  0x07, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x60, 0xC0, 0x00, 0xC3,
  0x00, 0x01, 0x8E, 0x00, 0x03, 0x36, 0x00, 0x06, 0x64, 0x00, 0x0D, 0x8C,
  0x00, 0x1E, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60,
  0x18, 0x00, 0x60, 0x30, 0x00, 0x40, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0xC1,
  0x80, 0x00, 0x83, 0x00, 0x01, 0x86, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x18,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFD,
  0x00, 0x00, 0x00, 0x5E, 0xC0, 0x00, 0x00, 0x2F, 0x60, 0x00, 0x00, 0x37,
  0x90, 0x00, 0x00, 0x13, 0xCC, 0x00, 0x00, 0x19, 0xE6, 0x00, 0x00, 0x0C,
  0xF1, 0x00, 0x00, 0x04, 0x78, 0xC0, 0x00, 0x06, 0x3C, 0x20, 0x00, 0x02,
  0x1E, 0x10, 0x00, 0x01, 0x0F, 0x0C, 0x00, 0x01, 0x87, 0x82, 0x00, 0x00,
  0x83, 0xC1, 0x80, 0x00, 0xC1, 0xE0, 0xC0, 0x00, 0x60, 0xF0, 0x20, 0x00,
  0x20, 0x78, 0x18, 0x00, 0x30, 0x3C, 0x04, 0x00, 0x18, 0x1E, 0x02, 0x00,
  0x08, 0x0F, 0x01, 0x80, 0x0C, 0x07, 0x80, 0x40, 0x04, 0x03, 0xC0, 0x30,
  0x06, 0x01, 0xE0, 0x18, 0x03, 0x00, 0xF0, 0x04, 0x01, 0x00, 0x78, 0x03,
  0x01, 0x80, 0x3C, 0x01, 0x80, 0xC0, 0x1E, 0x00, 0x40, 0x40, 0x0F, 0x00,
  0x30, 0x60, 0x07, 0x80, 0x08, 0x20, 0x03, 0xC0, 0x06, 0x30, 0x01, 0xE0,
  0x03, 0x18, 0x00, 0xF0, 0x00, 0x88, 0x00, 0x78, 0x00, 0x6C, 0x00, 0x3C,
  0x00, 0x36, 0x00, 0x1E, 0x00, 0x0A, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x01, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3D, 0x00, 0x00, 0x1E, 0xC0, 0x00, 0x0F, 0x20,
  0x00, 0x07, 0x98, 0x00, 0x03, 0xC6, 0x00, 0x01, 0xE1, 0x00, 0x00, 0xF0,
  0xC0, 0x00, 0x78, 0x20, 0x00, 0x3C, 0x18, 0x00, 0x1E, 0x06, 0x00, 0x0F,
  0x03, 0x00, 0x07, 0x80, 0xC0, 0x03, 0xC0, 0x20, 0x01, 0xE0, 0x18, 0x00,
  0xF0, 0x06, 0x00, 0x78, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x1E, 0x00, 0x20,
  0x0F, 0x00, 0x18, 0x07, 0x80, 0x04, 0x03, 0xC0, 0x03, 0x01, 0xE0, 0x00,
  0xC0, 0xF0, 0x00, 0x20, 0x78, 0x00, 0x18, 0x3C, 0x00, 0x04, 0x1E, 0x00,
  0x03, 0x0F, 0x00, 0x00, 0xC7, 0x80, 0x00, 0x23, 0xC0, 0x00, 0x19, 0xE0,
  0x00, 0x04, 0xF0, 0x00, 0x03, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x02, 0x40,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x04, 0x30, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x01, 0x00, 0x60, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x02, 0x00, 0x00, 0xFF, 0xF8, 0x06, 0x03, 0xF8, 0x30, 0x00, 0x61,
  0x80, 0x01, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x1B, 0x00, 0x00, 0x58, 0x00,
  0x02, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x58, 0x00, 0x02, 0xC0, 0x00,
  0x36, 0x00, 0x01, 0x30, 0x00, 0x19, 0x80, 0x01, 0x8C, 0x00, 0x38, 0x60,
  0x7F, 0x03, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0x80, 0x3C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x01, 0x20,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x00, 0x60, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0xFF, 0xF8, 0x03, 0x01, 0xFC,
  0x0C, 0x00, 0x1C, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x23, 0x00, 0x00, 0xCC,
  0x00, 0x01, 0x30, 0x00, 0x04, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00,
  0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0x30, 0x00, 0x0C, 0xC0, 0x00, 0x23, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x30,
  0x00, 0xE0, 0xC0, 0x1E, 0x03, 0xFF, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x02,
  0x00, 0xC0, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x00, 0xC0,
  0xC0, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0,
  0x00, 0x43, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x30, 0x00, 0x0C, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x10, 0x00,
  0x1F, 0xFF, 0x03, 0xC0, 0x1E, 0x30, 0x00, 0x23, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x32, 0x00, 0x03, 0x1E, 0x00, 0x70, 0x7F, 0xFE, 0x00, 0x06, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x40, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x98, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x40, 0x60, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x42, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x08, 0x10, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x10, 0x18, 0x00, 0x01, 0x00, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x20, 0x04, 0x00, 0x06, 0x00, 0x60, 0x00, 0x40, 0x06, 0x00,
  0x04, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80,
  0x01, 0x00, 0x18, 0x00, 0x10, 0x01, 0x80, 0x01, 0x80, 0x10, 0x00, 0x08,
  0x03, 0x00, 0x00, 0x80, 0x30, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x40, 0x60,
  0x00, 0x04, 0x06, 0x00, 0x00, 0x60, 0x40, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x03, 0x08, 0x00, 0x00, 0x11, 0x80, 0x00, 0x01, 0x18,
  0x00, 0x00, 0x19, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x00, 0x00, 0x34, 0x00, 0x00, 0xC0,
  0x00, 0x09, 0x80, 0x00, 0x78, 0x00, 0x06, 0x60, 0x00, 0x1E, 0x00, 0x01,
  0x88, 0x00, 0x04, 0x80, 0x00, 0x62, 0x00, 0x01, 0x20, 0x00, 0x10, 0xC0,
  0x00, 0xCC, 0x00, 0x0C, 0x30, 0x00, 0x33, 0x00, 0x03, 0x04, 0x00, 0x08,
  0x40, 0x00, 0xC1, 0x00, 0x02, 0x10, 0x00, 0x20, 0x60, 0x01, 0x86, 0x00,
  0x18, 0x18, 0x00, 0x61, 0x80, 0x06, 0x02, 0x00, 0x10, 0x20, 0x01, 0x80,
  0x80, 0x04, 0x08, 0x00, 0x40, 0x30, 0x03, 0x03, 0x00, 0x30, 0x0C, 0x00,
  0xC0, 0xC0, 0x0C, 0x01, 0x00, 0x20, 0x10, 0x02, 0x00, 0x40, 0x08, 0x04,
  0x00, 0x80, 0x18, 0x06, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x00, 0x80, 0x40, 0x18, 0x04, 0x00, 0x20, 0x10, 0x02, 0x01, 0x00, 0x0C,
  0x0C, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x30, 0x30, 0x00, 0x40, 0x80,
  0x0C, 0x08, 0x00, 0x10, 0x20, 0x01, 0x02, 0x00, 0x06, 0x18, 0x00, 0x61,
  0x80, 0x01, 0x86, 0x00, 0x18, 0x60, 0x00, 0x21, 0x80, 0x06, 0x10, 0x00,
  0x08, 0x40, 0x00, 0x84, 0x00, 0x03, 0x30, 0x00, 0x33, 0x00, 0x00, 0xCC,
  0x00, 0x0C, 0xC0, 0x00, 0x13, 0x00, 0x03, 0x20, 0x00, 0x04, 0x80, 0x00,
  0x48, 0x00, 0x01, 0xA0, 0x00, 0x16, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x18, 0x00, 0x01, 0x04, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x18,
  0x00, 0x60, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x00, 0x80, 0x30, 0x00,
  0x60, 0x10, 0x00, 0x10, 0x18, 0x00, 0x0C, 0x08, 0x00, 0x02, 0x0C, 0x00,
  0x01, 0x84, 0x00, 0x00, 0x46, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x41, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x20, 0x30, 0x00, 0x30, 0x18, 0x00, 0x10, 0x06, 0x00, 0x18,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x20, 0x0C, 0x00, 0x18, 0x04,
  0x00, 0x04, 0x06, 0x00, 0x03, 0x02, 0x00, 0x00, 0x83, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x11, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0x40, 0x00, 0x03, 0x60, 0x00, 0x02, 0x20, 0x00, 0x06, 0x30, 0x00, 0x04,
  0x10, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x10,
  0x0C, 0x00, 0x30, 0x04, 0x00, 0x30, 0x06, 0x00, 0x60, 0x02, 0x00, 0x60,
  0x03, 0x00, 0x40, 0x01, 0x00, 0xC0, 0x01, 0x80, 0x80, 0x00, 0x81, 0x80,
  0x00, 0xC1, 0x00, 0x00, 0x43, 0x00, 0x00, 0x62, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x07, 0xFF, 0xFF, 0xE0,
  0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xE0, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x63, 0x00, 0x00, 0x63, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0xC1, 0x80, 0x01, 0x80, 0x80, 0x01, 0x00, 0xC0, 0x03, 0x00,
  0x40, 0x02, 0x00, 0x60, 0x06, 0x00, 0x20, 0x04, 0x00, 0x30, 0x0C, 0x00,
  0x10, 0x08, 0x00, 0x18, 0x18, 0x00, 0x08, 0x10, 0x00, 0x0C, 0x30, 0x00,
  0x04, 0x20, 0x00, 0x06, 0x60, 0x00, 0x02, 0x40, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x02, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x01, 0xFE, 0x01, 0xF8, 0xE0, 0x60,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x0F, 0xC0, 0x7F, 0xF8, 0x3C, 0x01, 0x1C, 0x00, 0x26, 0x00,
  0x05, 0x80, 0x00, 0xB0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x40, 0x00, 0xE8, 0x00, 0x15, 0x80, 0x06, 0x98, 0x01,
  0x91, 0x80, 0x62, 0x1F, 0xF0, 0x40, 0x20, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0xFF, 0x02, 0x1E, 0x1C, 0x11,
  0x80, 0x38, 0x98, 0x00, 0x65, 0x80, 0x03, 0x28, 0x00, 0x0D, 0xC0, 0x00,
  0x6C, 0x00, 0x01, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x2C, 0x00, 0x03, 0x70, 0x00, 0x1A,
  0x80, 0x01, 0x96, 0x00, 0x08, 0x98, 0x01, 0xC4, 0x70, 0x1C, 0x21, 0xFF,
  0x80, 0x00, 0x40, 0x00, 0x00, 0x7F, 0x80, 0x7C, 0x3C, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x06, 0x03, 0xFF, 0x80, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x03, 0xF8, 0x30, 0x38, 0x38, 0xC3,
  0x80, 0x33, 0x18, 0x00, 0x6C, 0x40, 0x00, 0xB3, 0x00, 0x01, 0xC8, 0x00,
  0x07, 0x60, 0x00, 0x1D, 0x00, 0x00, 0x34, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x34, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x60, 0x00, 0x1D,
  0x80, 0x00, 0x73, 0x00, 0x03, 0xC4, 0x00, 0x09, 0x18, 0x00, 0x44, 0x38,
  0x06, 0x10, 0x3F, 0xF0, 0x40, 0x1E, 0x00, 0x01, 0xFE, 0x00, 0x1C, 0x38,
  0x03, 0x80, 0x70, 0x30, 0x00, 0x81, 0x80, 0x06, 0x18, 0x00, 0x10, 0x80,
  0x00, 0xCC, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x20, 0x70, 0x07, 0x00,
  0xFF, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x7E, 0x01, 0xFF, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x1F, 0xF0, 0xFF, 0xF0, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x01, 0xFE, 0x0C, 0x1F, 0x1E,
  0x30, 0xE0, 0x0C, 0xC6, 0x00, 0x1B, 0x10, 0x00, 0x3C, 0xC0, 0x00, 0x72,
  0x00, 0x01, 0xD8, 0x00, 0x03, 0x40, 0x00, 0x0D, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x34, 0x00, 0x01, 0xD8, 0x00,
  0x07, 0x20, 0x00, 0x1C, 0xC0, 0x00, 0xB1, 0x80, 0x06, 0xC7, 0x00, 0x33,
  0x0E, 0x01, 0x8C, 0x0F, 0xFC, 0x30, 0x02, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x61,
  0xE0, 0x07, 0x00, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x03, 0xF8, 0x21, 0xE3, 0xC4, 0x60, 0x0C, 0x90, 0x00,
  0xD4, 0x00, 0x0B, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0xFF, 0x80, 0x00, 0x01, 0x24, 0x92, 0x49, 0x24, 0x92,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x80, 0xC0, 0xCF, 0xC1, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x68, 0x00, 0x32, 0x00, 0x18, 0x80, 0x04, 0x20, 0x03, 0x08,
  0x01, 0x82, 0x00, 0xC0, 0x80, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x02, 0x06,
  0x00, 0x83, 0x00, 0x21, 0x80, 0x08, 0x70, 0x02, 0x24, 0x00, 0x99, 0x80,
  0x2C, 0x20, 0x0E, 0x0C, 0x03, 0x01, 0x80, 0x80, 0x20, 0x20, 0x0C, 0x08,
  0x01, 0x82, 0x00, 0x20, 0x80, 0x0C, 0x20, 0x01, 0x08, 0x00, 0x62, 0x00,
  0x0C, 0x80, 0x01, 0x20, 0x00, 0x68, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x83, 0xF8, 0x03, 0xF8, 0x47, 0x8E, 0x07, 0x8E, 0x26, 0x01,
  0x86, 0x01, 0x96, 0x00, 0x66, 0x00, 0x6A, 0x00, 0x16, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x81, 0xFC, 0x10, 0xE0, 0xE2, 0x30,
  0x06, 0x48, 0x00, 0x6A, 0x00, 0x05, 0x40, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x00, 0x07, 0x0F, 0x00,
  0x38, 0x03, 0x80, 0xC0, 0x01, 0x81, 0x00, 0x03, 0x06, 0x00, 0x03, 0x08,
  0x00, 0x02, 0x30, 0x00, 0x06, 0x40, 0x00, 0x0C, 0x80, 0x00, 0x0B, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x58, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x48, 0x00, 0x01, 0x98, 0x00, 0x03,
  0x30, 0x00, 0x04, 0x20, 0x00, 0x18, 0x60, 0x00, 0x20, 0x60, 0x00, 0xC0,
  0x60, 0x03, 0x00, 0x70, 0x1C, 0x00, 0x7F, 0xE0, 0x00, 0x04, 0x00, 0x00,
  0x81, 0xFE, 0x04, 0x3C, 0x3C, 0x23, 0x00, 0x71, 0x30, 0x00, 0xCB, 0x00,
  0x06, 0x50, 0x00, 0x1B, 0x80, 0x00, 0x58, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x58, 0x00, 0x02, 0xE0, 0x00, 0x35, 0x00, 0x03, 0x2C, 0x00, 0x19, 0x30,
  0x01, 0x88, 0xE0, 0x38, 0x41, 0xFF, 0x02, 0x00, 0x80, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFE, 0x0C, 0x1F, 0x1E, 0x30, 0xE0,
  0x0C, 0xC6, 0x00, 0x1B, 0x30, 0x00, 0x2C, 0xC0, 0x00, 0xF6, 0x00, 0x01,
  0xD8, 0x00, 0x07, 0x40, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x34, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x60,
  0x00, 0x3C, 0xC0, 0x00, 0xB3, 0x00, 0x06, 0xC6, 0x00, 0x33, 0x0E, 0x03,
  0x8C, 0x0F, 0xFC, 0x30, 0x07, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x83, 0xFC, 0x3D, 0xE6, 0x01, 0x20, 0x0A, 0x00,
  0x50, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x00, 0x03, 0xFE, 0x03, 0xC3, 0xF1, 0x80, 0x08,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0A, 0x00, 0x06, 0xF0, 0x07, 0x0F, 0xFF,
  0x00, 0x38, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x07, 0xFF, 0xFF, 0xF8, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x10, 0x3F, 0x80, 0x20, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x56, 0x00, 0x0D, 0x20, 0x00,
  0x93, 0x00, 0x11, 0x1C, 0x06, 0x10, 0xFF, 0xC1, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xD0, 0x00, 0x06, 0xC0, 0x00, 0x26, 0x00, 0x03,
  0x10, 0x00, 0x18, 0xC0, 0x00, 0x86, 0x00, 0x0C, 0x10, 0x00, 0x60, 0xC0,
  0x02, 0x06, 0x00, 0x30, 0x10, 0x01, 0x80, 0xC0, 0x08, 0x06, 0x00, 0xC0,
  0x10, 0x06, 0x00, 0xC0, 0x20, 0x06, 0x03, 0x00, 0x10, 0x18, 0x00, 0xC0,
  0x80, 0x06, 0x0C, 0x00, 0x10, 0x60, 0x00, 0xC2, 0x00, 0x06, 0x30, 0x00,
  0x11, 0x80, 0x00, 0xC8, 0x00, 0x06, 0xC0, 0x00, 0x16, 0x00, 0x00, 0xA0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x80, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x68, 0x00, 0x38, 0x00, 0x24, 0x00,
  0x16, 0x00, 0x13, 0x00, 0x0B, 0x00, 0x19, 0x80, 0x0C, 0x80, 0x0C, 0x40,
  0x06, 0x40, 0x04, 0x20, 0x02, 0x30, 0x02, 0x18, 0x03, 0x08, 0x03, 0x0C,
  0x01, 0x84, 0x01, 0x82, 0x00, 0x83, 0x00, 0x81, 0x00, 0x41, 0x80, 0x40,
  0xC0, 0x60, 0x40, 0x60, 0x60, 0x30, 0x20, 0x30, 0x10, 0x10, 0x18, 0x10,
  0x08, 0x18, 0x04, 0x08, 0x06, 0x0C, 0x02, 0x0C, 0x01, 0x04, 0x01, 0x86,
  0x00, 0x82, 0x00, 0xC2, 0x00, 0x63, 0x00, 0x21, 0x00, 0x31, 0x80, 0x11,
  0x80, 0x08, 0x80, 0x0C, 0xC0, 0x04, 0xC0, 0x06, 0x40, 0x03, 0x60, 0x01,
  0x20, 0x01, 0xA0, 0x00, 0xB0, 0x00, 0x50, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x1B, 0x00, 0x01, 0x8C, 0x00, 0x18, 0x20, 0x00, 0xC1, 0x80, 0x0C, 0x06,
  0x00, 0x40, 0x10, 0x06, 0x00, 0xC0, 0x60, 0x02, 0x03, 0x00, 0x18, 0x30,
  0x00, 0x61, 0x00, 0x01, 0x18, 0x00, 0x0D, 0x80, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x58, 0x00, 0x06, 0x40, 0x00, 0x63, 0x00,
  0x02, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x01, 0x80, 0x18, 0x04, 0x01, 0x80,
  0x30, 0x08, 0x00, 0xC0, 0xC0, 0x06, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x46,
  0x00, 0x03, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x26, 0x00,
  0x01, 0x98, 0x00, 0x06, 0x20, 0x00, 0x10, 0xC0, 0x00, 0xC3, 0x00, 0x03,
  0x04, 0x00, 0x08, 0x18, 0x00, 0x60, 0x60, 0x01, 0x80, 0x80, 0x04, 0x03,
  0x00, 0x30, 0x0C, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x60, 0x18, 0x01, 0x80,
  0x60, 0x02, 0x01, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x20, 0x00, 0x40, 0x80,
  0x01, 0x86, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x33, 0x00, 0x00,
  0x48, 0x00, 0x01, 0x20, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x0F, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1E,
  0x00, 0xF8, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x3F, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x7E, 0x00, 0xF0, 0x00, 0x3F, 0x80,
  0x02, 0xE1, 0xE0, 0x07, 0x00, 0xF0, 0x34, 0x00, 0x7F, 0xC0, 0x00, 0x1C,
  0x00,
};

const GFXglyph NotoSans_SemiCondensed_Thin56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 40, 12, 4, -40 },
  { 16, 9, 14, 17, 4, -40 },
  { 32, 29, 40, 32, 1, -40 },
  { 177, 21, 46, 28, 3, -43 },
  { 298, 34, 42, 40, 3, -41 },
  { 477, 29, 42, 33, 3, -41 },
  { 630, 2, 14, 9, 4, -40 },
  { 634, 9, 49, 14, 3, -40 },
  { 690, 10, 49, 14, 2, -40 },
  { 752, 20, 20, 26, 3, -43 },
  { 802, 23, 26, 28, 3, -33 },
  { 877, 5, 13, 10, 2, -6 },
  { 886, 13, 2, 17, 2, -16 },
  { 890, 3, 3, 11, 4, -3 },
  { 892, 16, 40, 18, 1, -40 },
  { 972, 22, 42, 28, 3, -41 },
  { 1088, 11, 40, 28, 5, -40 },
  { 1143, 22, 41, 28, 3, -41 },
  { 1256, 22, 42, 28, 3, -41 },
  { 1372, 27, 40, 28, 1, -40 },
  { 1507, 21, 41, 28, 4, -40 },
  { 1615, 22, 42, 28, 3, -41 },
  { 1731, 22, 40, 28, 3, -40 },
  { 1841, 22, 42, 28, 3, -41 },
  { 1957, 22, 42, 28, 3, -41 },
  { 2073, 3, 30, 11, 4, -30 },
  { 2085, 5, 37, 11, 2, -30 },
  { 2109, 23, 24, 28, 3, -32 },
  { 2178, 23, 13, 28, 3, -26 },
  { 2216, 23, 24, 28, 3, -32 },
  { 2285, 16, 41, 20, 2, -41 },
  { 2367, 38, 45, 44, 3, -40 },
  { 2581, 28, 40, 28, 0, -40 },
  { 2721, 23, 40, 31, 5, -40 },
  { 2836, 26, 42, 30, 3, -41 },
  { 2973, 26, 40, 34, 5, -40 },
  { 3103, 19, 40, 27, 5, -40 },
  { 3198, 19, 40, 25, 5, -40 },
  { 3293, 29, 42, 36, 3, -41 },
  { 3446, 25, 40, 35, 5, -40 },
  { 3571, 9, 40, 15, 3, -40 },
  { 3616, 11, 50, 12, -4, -40 },
  { 3685, 23, 40, 28, 5, -40 },
  { 3800, 19, 40, 25, 5, -40 },
  { 3895, 33, 40, 43, 5, -40 },
  { 4060, 25, 40, 35, 5, -40 },
  { 4185, 31, 42, 37, 3, -41 },
  { 4348, 21, 40, 28, 5, -40 },
  { 4453, 31, 51, 37, 3, -41 },
  { 4651, 22, 40, 29, 5, -40 },
  { 4761, 21, 42, 27, 3, -41 },
  { 4872, 25, 40, 25, 0, -40 },
  { 4997, 25, 41, 35, 5, -40 },
  { 5126, 28, 40, 28, 0, -40 },
  { 5266, 42, 40, 44, 1, -40 },
  { 5476, 25, 40, 25, 0, -40 },
  { 5601, 24, 40, 24, 0, -40 },
  { 5721, 23, 40, 27, 2, -40 },
  { 5836, 11, 49, 17, 5, -40 },
  { 5904, 16, 40, 18, 1, -40 },
  { 5984, 11, 49, 17, 2, -40 },
  { 6052, 24, 23, 28, 2, -40 },
  { 6121, 22, 2, 22, 0, 5 },
  { 6127, 9, 9, 13, 2, -43 },
  { 6138, 19, 31, 26, 2, -30 },
  { 6212, 21, 44, 29, 5, -43 },
  { 6328, 19, 31, 23, 3, -30 },
  { 6402, 22, 44, 29, 3, -43 },
  { 6523, 21, 31, 27, 3, -30 },
  { 6605, 16, 43, 14, 1, -43 },
  { 6691, 22, 44, 29, 3, -30 },
  { 6812, 19, 43, 29, 5, -43 },
  { 6915, 3, 40, 11, 4, -40 },
  { 6930, 9, 54, 11, -2, -40 },
  { 6991, 18, 43, 23, 5, -43 },
  { 7088, 1, 43, 11, 5, -43 },
  { 7094, 33, 30, 43, 5, -30 },
  { 7218, 19, 30, 29, 5, -30 },
  { 7290, 23, 31, 29, 3, -30 },
  { 7380, 21, 43, 29, 5, -30 },
  { 7493, 22, 43, 29, 3, -30 },
  { 7612, 13, 30, 19, 5, -30 },
  { 7661, 18, 31, 23, 2, -30 },
  { 7731, 13, 38, 16, 1, -37 },
  { 7793, 20, 31, 29, 4, -30 },
  { 7871, 21, 30, 21, 0, -30 },
  { 7950, 33, 30, 35, 1, -30 },
  { 8074, 21, 30, 23, 1, -30 },
  { 8153, 22, 44, 22, 0, -30 },
  { 8274, 17, 30, 21, 2, -30 },
  { 8338, 15, 49, 19, 2, -40 },
  { 8430, 1, 57, 27, 13, -43 },
  { 8438, 15, 49, 19, 2, -40 },
  { 8530, 23, 5, 28, 3, -22 },
};

const GFXfont NotoSans_SemiCondensed_Thin56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin56pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_SEMICONDENSED_THIN56PT7B_H_
