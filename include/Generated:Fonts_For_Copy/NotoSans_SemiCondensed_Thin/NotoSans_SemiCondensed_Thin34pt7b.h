#ifndef _NOTOSANS_SEMICONDENSED_THIN34PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xC3, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x84, 0x01,
  0x04, 0x01, 0x02, 0x00, 0x81, 0x00, 0x40, 0x80, 0x20, 0x40, 0x10, 0x40,
  0x08, 0x20, 0xFF, 0xFF, 0x04, 0x08, 0x02, 0x04, 0x01, 0x02, 0x00, 0x82,
  0x00, 0x41, 0x00, 0x40, 0x80, 0x20, 0x41, 0xFF, 0xFE, 0x08, 0x10, 0x04,
  0x08, 0x02, 0x08, 0x02, 0x04, 0x01, 0x02, 0x00, 0x81, 0x00, 0x40, 0x80,
  0x20, 0x40, 0x02, 0x00, 0x10, 0x07, 0xF0, 0x44, 0x64, 0x20, 0x41, 0x02,
  0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x30, 0x80, 0xC4, 0x01, 0x20, 0x07,
  0x00, 0x0E, 0x00, 0x4C, 0x02, 0x30, 0x10, 0x80, 0x82, 0x04, 0x10, 0x20,
  0x81, 0x08, 0x08, 0x40, 0x44, 0xF3, 0xC0, 0x70, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x06, 0x60, 0x10, 0x42, 0x02, 0x08, 0x10, 0x20, 0x81, 0x02,
  0x08, 0x10, 0x40, 0x81, 0x04, 0x08, 0x10, 0x80, 0x81, 0x08, 0x08, 0x11,
  0x00, 0x81, 0x11, 0xC8, 0x12, 0x62, 0x81, 0x24, 0x14, 0x24, 0x81, 0x66,
  0x48, 0x11, 0x08, 0x81, 0x00, 0x88, 0x10, 0x10, 0x81, 0x01, 0x08, 0x10,
  0x20, 0x81, 0x02, 0x08, 0x10, 0x20, 0x81, 0x04, 0x04, 0x10, 0x40, 0x42,
  0x08, 0x03, 0xC0, 0x07, 0x00, 0x04, 0x60, 0x04, 0x08, 0x04, 0x04, 0x02,
  0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x10, 0x40, 0x0C, 0x60,
  0x02, 0x60, 0x00, 0xC0, 0x00, 0xA0, 0x01, 0x88, 0x01, 0x06, 0x02, 0x81,
  0x02, 0x80, 0x41, 0x40, 0x10, 0xA0, 0x04, 0x90, 0x01, 0x48, 0x00, 0xC4,
  0x00, 0x61, 0x00, 0x68, 0xC0, 0x42, 0x1F, 0xC0, 0x80, 0xFF, 0x80, 0x0C,
  0x41, 0x08, 0x21, 0x04, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x04, 0x10, 0x40, 0x81, 0x04, 0x0C, 0xC0, 0x82, 0x04,
  0x10, 0x20, 0x82, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x20, 0x82, 0x10, 0x42, 0x08, 0xC0, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x82, 0x17, 0x2E, 0x0F, 0x00, 0x60, 0x09, 0x01, 0x08, 0x10, 0x82,
  0x04, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0xFF, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x24, 0x94, 0x94, 0xFF, 0xC0, 0x00, 0xC0,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x02, 0x00, 0x03, 0x00, 0xC6, 0x08, 0x08, 0x40, 0x24, 0x01,
  0x20, 0x0A, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x80,
  0x14, 0x01, 0x20, 0x08, 0x80, 0x82, 0x0C, 0x0F, 0xC0, 0x06, 0x14, 0x4B,
  0x18, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x07, 0x01, 0xC6, 0x30, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0xFF, 0xF8, 0x0F,
  0x03, 0x86, 0x20, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x01, 0x81, 0xF8, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00,
  0x50, 0x0C, 0x7F, 0xC0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x50, 0x00, 0x90,
  0x00, 0x90, 0x01, 0x10, 0x02, 0x10, 0x02, 0x10, 0x04, 0x10, 0x0C, 0x10,
  0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x10, 0x40, 0x10, 0x40, 0x10,
  0x80, 0x10, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x3F, 0xF1, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x30, 0x1E, 0x70, 0x00, 0x60,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x0A, 0x01, 0x8F, 0xF0, 0x01, 0xC0, 0x30, 0x82, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x21,
  0xF1, 0x30, 0x4A, 0x01, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x80, 0x14, 0x00, 0xA0, 0x04, 0x80, 0x42, 0x06, 0x0F, 0xC0,
  0xFF, 0xF8, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x03, 0x00, 0xC6, 0x08, 0x0C, 0x80, 0x24, 0x01, 0x20,
  0x05, 0x00, 0x28, 0x02, 0x40, 0x11, 0x01, 0x04, 0x10, 0x1B, 0x00, 0x70,
  0x0C, 0x60, 0x80, 0x88, 0x02, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x05, 0x00, 0x44, 0x06, 0x1F, 0xC0, 0x07, 0x01, 0xC6, 0x18,
  0x08, 0x80, 0x48, 0x01, 0x40, 0x0A, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x34, 0x01, 0xA0, 0x14, 0xC3, 0x20, 0xE1, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x7F,
  0x00, 0xC0, 0x00, 0xC0, 0x24, 0x00, 0x00, 0x00, 0x00, 0x09, 0x25, 0x25,
  0x00, 0x00, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0x00, 0x08, 0x38, 0xC0,
  0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x18, 0x04,
  0x06, 0x01, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0xFF, 0x00, 0x06, 0x01, 0x80, 0x30,
  0x00, 0x80, 0xC0, 0x00, 0x83, 0x00, 0x00, 0x84, 0x00, 0x01, 0x10, 0x00,
  0x01, 0x20, 0x3F, 0x82, 0x40, 0x81, 0x05, 0x02, 0x02, 0x06, 0x04, 0x04,
  0x0C, 0x10, 0x08, 0x18, 0x20, 0x10, 0x30, 0x40, 0x20, 0x60, 0x80, 0x80,
  0xC1, 0x01, 0x02, 0x82, 0x02, 0x05, 0x04, 0x06, 0x0A, 0x04, 0x14, 0x24,
  0x07, 0xC7, 0x84, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x02, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x80, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x24, 0x00, 0x22, 0x00, 0x11, 0x00,
  0x08, 0x80, 0x08, 0x20, 0x04, 0x10, 0x02, 0x08, 0x02, 0x02, 0x01, 0x01,
  0x00, 0x80, 0x80, 0x80, 0x20, 0x7F, 0xF0, 0x20, 0x08, 0x20, 0x02, 0x10,
  0x01, 0x08, 0x00, 0x88, 0x00, 0x24, 0x00, 0x12, 0x00, 0x0A, 0x00, 0x03,
  0x00, 0x01, 0xFF, 0xC2, 0x00, 0xC8, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00,
  0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x48, 0x06, 0x3F, 0xF0, 0x80,
  0x32, 0x00, 0x28, 0x00, 0xA0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0A, 0x00, 0x68, 0x03, 0x3F, 0xF0, 0x00, 0xE0, 0x06, 0x1C,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x06, 0x01, 0x03, 0xFE, 0xFF, 0xC0, 0x80, 0x30, 0x80,
  0x08, 0x80, 0x04, 0x80, 0x04, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80, 0x04, 0x80,
  0x08, 0x80, 0x10, 0x80, 0x60, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F,
  0xFE, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0xFF, 0xE8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x00, 0x38, 0x00, 0xE1, 0xE0,
  0xC0, 0x08, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x0F, 0xF8, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x14,
  0x00, 0x05, 0x00, 0x01, 0x20, 0x00, 0x48, 0x00, 0x11, 0x00, 0x04, 0x30,
  0x03, 0x03, 0xFF, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x9F, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x5F, 0x00, 0x80, 0x0A, 0x00, 0x48, 0x02,
  0x20, 0x10, 0x80, 0x82, 0x06, 0x08, 0x30, 0x20, 0x80, 0x84, 0x02, 0x20,
  0x09, 0x80, 0x29, 0x00, 0xE4, 0x03, 0x08, 0x08, 0x10, 0x20, 0x40, 0x80,
  0x82, 0x03, 0x08, 0x04, 0x20, 0x08, 0x80, 0x32, 0x00, 0x48, 0x00, 0xA0,
  0x03, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x07, 0xFF, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xA0, 0x00, 0x3A, 0x00, 0x05, 0xA0, 0x00, 0x59, 0x00,
  0x09, 0x90, 0x00, 0x99, 0x00, 0x09, 0x88, 0x01, 0x18, 0x80, 0x11, 0x84,
  0x01, 0x18, 0x40, 0x21, 0x84, 0x02, 0x18, 0x20, 0x41, 0x82, 0x04, 0x18,
  0x20, 0x41, 0x81, 0x08, 0x18, 0x10, 0x81, 0x80, 0x88, 0x18, 0x09, 0x01,
  0x80, 0x90, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x03,
  0x80, 0x06, 0x80, 0x0D, 0x00, 0x19, 0x00, 0x32, 0x00, 0x62, 0x00, 0xC2,
  0x01, 0x84, 0x03, 0x04, 0x06, 0x08, 0x0C, 0x08, 0x18, 0x08, 0x30, 0x10,
  0x60, 0x10, 0xC0, 0x21, 0x80, 0x23, 0x00, 0x66, 0x00, 0x4C, 0x00, 0x58,
  0x00, 0xB0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x01, 0xE0, 0x00, 0xC3, 0x80,
  0x20, 0x08, 0x08, 0x00, 0x82, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x12,
  0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x02, 0x80, 0x00, 0x50,
  0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x22, 0x00, 0x08, 0x40, 0x03, 0x04,
  0x00, 0x40, 0x40, 0x30, 0x07, 0xF8, 0x00, 0xFF, 0x84, 0x03, 0x20, 0x05,
  0x00, 0x28, 0x01, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x14, 0x00, 0xA0,
  0x05, 0x00, 0x48, 0x1C, 0x7E, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x01, 0xE0,
  0x00, 0xC3, 0x80, 0x20, 0x08, 0x08, 0x00, 0x82, 0x00, 0x08, 0x80, 0x01,
  0x10, 0x00, 0x12, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x02,
  0x80, 0x00, 0x50, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x22, 0x00, 0x08,
  0x40, 0x03, 0x04, 0x00, 0x40, 0x40, 0x30, 0x07, 0xF8, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0xFF, 0xC2, 0x00, 0x88, 0x01, 0x20, 0x04, 0x80, 0x0A, 0x00, 0x28, 0x00,
  0xA0, 0x02, 0x80, 0x12, 0x00, 0x48, 0x02, 0x20, 0x10, 0xFF, 0x82, 0x04,
  0x08, 0x10, 0x20, 0x20, 0x80, 0xC2, 0x01, 0x08, 0x02, 0x20, 0x08, 0x80,
  0x12, 0x00, 0x48, 0x00, 0xA0, 0x03, 0x07, 0x00, 0xC3, 0x98, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x50, 0x04, 0xFF, 0xC0, 0xFF,
  0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x14, 0x00, 0x2C,
  0x00, 0x8C, 0x02, 0x07, 0xF8, 0x80, 0x01, 0xA0, 0x00, 0x90, 0x00, 0x48,
  0x00, 0x22, 0x00, 0x21, 0x00, 0x10, 0x80, 0x08, 0x40, 0x08, 0x10, 0x04,
  0x08, 0x02, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x80, 0x10,
  0x40, 0x08, 0x20, 0x04, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x48, 0x00,
  0x14, 0x00, 0x0A, 0x00, 0x06, 0x00, 0x01, 0x00, 0x80, 0x08, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x48, 0x02, 0x80, 0x24, 0x01, 0x40, 0x12,
  0x01, 0x20, 0x09, 0x00, 0x90, 0x08, 0x40, 0x44, 0x04, 0x20, 0x22, 0x02,
  0x10, 0x21, 0x01, 0x08, 0x10, 0x81, 0x02, 0x08, 0x20, 0x81, 0x04, 0x10,
  0x40, 0x84, 0x08, 0x20, 0x42, 0x04, 0x20, 0x11, 0x01, 0x10, 0x08, 0x80,
  0x88, 0x04, 0x80, 0x44, 0x02, 0x40, 0x24, 0x00, 0xA0, 0x0A, 0x00, 0x50,
  0x05, 0x00, 0x28, 0x02, 0x80, 0x18, 0x00, 0x80, 0x04, 0x00, 0x40, 0x40,
  0x06, 0x40, 0x08, 0x80, 0x20, 0x80, 0x41, 0x01, 0x01, 0x06, 0x01, 0x08,
  0x02, 0x20, 0x02, 0x40, 0x05, 0x00, 0x06, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x50, 0x01, 0x10, 0x02, 0x20, 0x08, 0x20, 0x10, 0x20, 0x40, 0x40, 0x80,
  0x42, 0x00, 0x88, 0x00, 0x90, 0x01, 0x40, 0x01, 0x80, 0x06, 0x80, 0x09,
  0x00, 0x11, 0x00, 0x42, 0x00, 0x82, 0x02, 0x04, 0x04, 0x04, 0x10, 0x08,
  0x20, 0x08, 0x80, 0x11, 0x00, 0x24, 0x00, 0x28, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x7F, 0xFC, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFF,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0F,
  0xE0, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x10,
  0x04, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x03, 0xFE, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x1F, 0xE0, 0x01, 0x80, 0x05,
  0x00, 0x09, 0x00, 0x22, 0x00, 0x42, 0x01, 0x04, 0x02, 0x04, 0x08, 0x08,
  0x10, 0x08, 0x40, 0x10, 0x80, 0x12, 0x00, 0x2C, 0x00, 0x20, 0xFF, 0xF8,
  0xC1, 0x82, 0x04, 0x0C, 0x1F, 0xC2, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x07, 0xF1, 0x81, 0x60, 0x14, 0x01, 0x40, 0x18,
  0x01, 0x40, 0x34, 0x03, 0x60, 0x53, 0xF9, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x9F, 0xC5, 0x01, 0x30,
  0x05, 0x80, 0x28, 0x01, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0B, 0x00, 0x58, 0x04, 0xA0, 0x64,
  0xFE, 0x00, 0x0F, 0xE2, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x30, 0x03, 0xFC, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x1F, 0xC9, 0x81, 0x50, 0x06, 0x80, 0x38, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x05, 0x00, 0x68, 0x03, 0x20, 0x28, 0xFE, 0x40, 0x1F, 0xC3,
  0x06, 0x60, 0x24, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0xFF, 0xF8,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x11,
  0xFE, 0x03, 0xC2, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0xFF,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x1F, 0xC9,
  0x81, 0x50, 0x06, 0x80, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x05, 0x00, 0x68, 0x03,
  0x20, 0x28, 0xFE, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x40, 0x21, 0xFE, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x9F, 0xCA, 0x06, 0xC0, 0x2C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x74, 0x01, 0x55, 0x55,
  0x55, 0x55, 0x40, 0x08, 0xC2, 0x00, 0x00, 0x01, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x22, 0xF0,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x50, 0x12, 0x04, 0x41, 0x88, 0x21, 0x08, 0x22, 0x04, 0x80, 0xA8, 0x14,
  0x83, 0x10, 0x41, 0x08, 0x21, 0x02, 0x20, 0x24, 0x04, 0x80, 0x50, 0x04,
  0xFF, 0xFF, 0xFF, 0xC0, 0x9F, 0x0F, 0xCA, 0x09, 0x82, 0xC0, 0x50, 0x18,
  0x06, 0x01, 0x80, 0x20, 0x18, 0x02, 0x01, 0x80, 0x20, 0x18, 0x02, 0x01,
  0x80, 0x20, 0x18, 0x02, 0x01, 0x80, 0x20, 0x18, 0x02, 0x01, 0x80, 0x20,
  0x18, 0x02, 0x01, 0x80, 0x20, 0x18, 0x02, 0x01, 0x80, 0x20, 0x18, 0x02,
  0x01, 0x9F, 0xCA, 0x06, 0xC0, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x0F, 0xC0, 0xC0, 0x84, 0x01, 0x10, 0x02, 0x80,
  0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x02, 0x80, 0x0A, 0x00, 0x24, 0x00, 0x90, 0x04, 0x20, 0x20, 0x7F, 0x00,
  0x9F, 0xC5, 0x81, 0x30, 0x05, 0x80, 0x28, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0B, 0x00,
  0x58, 0x06, 0xA0, 0x64, 0xFE, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x00, 0x1F, 0xC9, 0x81, 0x50, 0x06,
  0x80, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0D, 0x00, 0x68, 0x05, 0x20, 0x28, 0xFE,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x9F, 0xA0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1F, 0xE4, 0x05, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x4F, 0xF0, 0x10, 0x08, 0x04,
  0x02, 0x0F, 0xF8, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x7C, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x05, 0x40, 0x93,
  0xF1, 0x80, 0x0A, 0x00, 0x90, 0x04, 0x80, 0x24, 0x02, 0x10, 0x10, 0x80,
  0x84, 0x08, 0x10, 0x40, 0x82, 0x04, 0x20, 0x11, 0x00, 0x88, 0x04, 0x80,
  0x14, 0x00, 0xA0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x20, 0x0A, 0x01, 0x80,
  0x90, 0x0C, 0x04, 0x80, 0xA0, 0x22, 0x04, 0x81, 0x10, 0x24, 0x10, 0x82,
  0x20, 0x84, 0x11, 0x04, 0x10, 0x84, 0x20, 0x84, 0x22, 0x04, 0x41, 0x10,
  0x22, 0x08, 0x80, 0x90, 0x24, 0x05, 0x01, 0x40, 0x28, 0x0A, 0x01, 0x40,
  0x30, 0x06, 0x01, 0x80, 0x20, 0x08, 0x00, 0x80, 0x14, 0x02, 0x20, 0x62,
  0x04, 0x10, 0x81, 0x08, 0x09, 0x00, 0x60, 0x06, 0x00, 0x60, 0x09, 0x00,
  0x90, 0x10, 0x81, 0x04, 0x20, 0x44, 0x02, 0x40, 0x28, 0x01, 0x80, 0x0A,
  0x00, 0x50, 0x04, 0x80, 0x22, 0x01, 0x10, 0x10, 0x80, 0x82, 0x04, 0x10,
  0x40, 0x82, 0x02, 0x10, 0x11, 0x00, 0x88, 0x02, 0x40, 0x14, 0x00, 0xA0,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x18, 0x07, 0x80, 0x00, 0x7F, 0xE0, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x1F, 0xFC, 0x03, 0x82, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x83, 0x80, 0x60,
  0x10, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x80, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x04, 0x02, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x10,
  0x06, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x02, 0x01, 0x0F, 0x00, 0xFE, 0x06, 0x07, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Thin34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 1, 24, 7, 3, -24 },
  { 4, 6, 9, 11, 2, -24 },
  { 11, 17, 24, 19, 1, -24 },
  { 62, 13, 28, 17, 2, -26 },
  { 108, 20, 25, 24, 2, -25 },
  { 171, 17, 25, 20, 2, -25 },
  { 225, 1, 9, 6, 2, -24 },
  { 227, 6, 29, 9, 2, -24 },
  { 249, 6, 29, 9, 1, -24 },
  { 271, 12, 12, 16, 2, -26 },
  { 289, 14, 16, 17, 2, -20 },
  { 317, 3, 8, 6, 1, -4 },
  { 320, 8, 1, 10, 1, -10 },
  { 321, 1, 2, 7, 3, -2 },
  { 322, 10, 24, 11, 1, -24 },
  { 352, 13, 25, 17, 2, -25 },
  { 393, 7, 24, 17, 3, -24 },
  { 414, 13, 25, 17, 2, -25 },
  { 455, 13, 25, 17, 2, -25 },
  { 496, 16, 24, 17, 1, -24 },
  { 544, 13, 24, 17, 2, -24 },
  { 583, 13, 25, 17, 2, -25 },
  { 624, 13, 24, 17, 2, -24 },
  { 663, 13, 25, 17, 2, -25 },
  { 704, 13, 25, 17, 2, -25 },
  { 745, 1, 18, 7, 3, -18 },
  { 748, 3, 22, 7, 1, -18 },
  { 757, 14, 15, 17, 2, -20 },
  { 784, 14, 8, 17, 2, -16 },
  { 798, 14, 15, 17, 2, -20 },
  { 825, 10, 25, 12, 1, -25 },
  { 857, 23, 27, 26, 2, -24 },
  { 935, 17, 24, 17, 0, -24 },
  { 986, 14, 24, 19, 3, -24 },
  { 1028, 15, 25, 18, 2, -25 },
  { 1075, 16, 24, 21, 3, -24 },
  { 1123, 12, 24, 17, 3, -24 },
  { 1159, 12, 24, 15, 3, -24 },
  { 1195, 18, 25, 22, 2, -25 },
  { 1252, 15, 24, 21, 3, -24 },
  { 1297, 5, 24, 9, 2, -24 },
  { 1312, 7, 30, 7, -3, -24 },
  { 1339, 14, 24, 17, 3, -24 },
  { 1381, 11, 24, 15, 3, -24 },
  { 1414, 20, 24, 26, 3, -24 },
  { 1474, 15, 24, 21, 3, -24 },
  { 1519, 19, 25, 23, 2, -25 },
  { 1579, 13, 24, 17, 3, -24 },
  { 1618, 19, 31, 23, 2, -25 },
  { 1692, 14, 24, 17, 3, -24 },
  { 1734, 13, 25, 17, 2, -25 },
  { 1775, 15, 24, 15, 0, -24 },
  { 1820, 15, 24, 21, 3, -24 },
  { 1865, 17, 24, 17, 0, -24 },
  { 1916, 25, 24, 27, 1, -24 },
  { 1991, 15, 24, 15, 0, -24 },
  { 2036, 15, 24, 15, 0, -24 },
  { 2081, 14, 24, 16, 1, -24 },
  { 2123, 7, 29, 11, 3, -24 },
  { 2149, 10, 24, 11, 1, -24 },
  { 2179, 7, 29, 11, 1, -24 },
  { 2205, 15, 13, 17, 1, -24 },
  { 2230, 13, 1, 13, 0, 3 },
  { 2232, 6, 5, 8, 1, -26 },
  { 2236, 12, 18, 16, 1, -18 },
  { 2263, 13, 26, 18, 3, -26 },
  { 2306, 11, 18, 14, 2, -18 },
  { 2331, 13, 26, 18, 2, -26 },
  { 2374, 12, 18, 16, 2, -18 },
  { 2401, 10, 26, 9, 0, -26 },
  { 2434, 13, 26, 18, 2, -18 },
  { 2477, 12, 26, 17, 3, -26 },
  { 2516, 2, 25, 7, 2, -25 },
  { 2523, 5, 33, 7, -1, -25 },
  { 2544, 11, 26, 14, 3, -26 },
  { 2580, 1, 26, 7, 3, -26 },
  { 2584, 20, 18, 26, 3, -18 },
  { 2629, 12, 18, 17, 3, -18 },
  { 2656, 14, 18, 17, 2, -18 },
  { 2688, 13, 26, 18, 3, -18 },
  { 2731, 13, 26, 18, 2, -18 },
  { 2774, 8, 18, 11, 3, -18 },
  { 2792, 11, 18, 14, 1, -18 },
  { 2817, 9, 22, 9, 0, -22 },
  { 2842, 12, 18, 17, 3, -18 },
  { 2869, 13, 18, 13, 0, -18 },
  { 2899, 21, 18, 21, 0, -18 },
  { 2947, 12, 18, 14, 1, -18 },
  { 2974, 13, 26, 13, 0, -18 },
  { 3017, 11, 18, 13, 1, -18 },
  { 3042, 9, 29, 12, 1, -24 },
  { 3075, 1, 34, 16, 8, -26 },
  { 3080, 9, 29, 12, 1, -24 },
  { 3113, 14, 2, 17, 2, -13 },
};

const GFXfont NotoSans_SemiCondensed_Thin34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin34pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_SEMICONDENSED_THIN34PT7B_H_
