#ifndef _NOTOSANS_SEMICONDENSED_THIN51PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin51pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x00,
  0x00, 0x1B, 0xF0, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x00, 0x30, 0x04, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x80, 0x20, 0x00, 0x10, 0x04, 0x00, 0x02, 0x00, 0x80, 0x00, 0x40, 0x10,
  0x00, 0x18, 0x02, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x40, 0x18, 0x00, 0x08,
  0x02, 0x00, 0x01, 0x00, 0x40, 0x1F, 0xFF, 0xFF, 0xF0, 0x0C, 0x01, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x20, 0x0C, 0x00, 0x04, 0x01, 0x00, 0x00, 0x80,
  0x20, 0x00, 0x10, 0x04, 0x00, 0x06, 0x00, 0x80, 0x00, 0xC0, 0x10, 0x00,
  0x10, 0x06, 0x00, 0x02, 0x00, 0x80, 0x00, 0x40, 0x10, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0x00, 0x40, 0x00, 0x60, 0x08, 0x00, 0x0C, 0x03, 0x00, 0x01,
  0x00, 0x60, 0x00, 0x20, 0x08, 0x00, 0x04, 0x01, 0x00, 0x00, 0x80, 0x20,
  0x00, 0x30, 0x04, 0x00, 0x06, 0x01, 0x80, 0x00, 0x80, 0x30, 0x00, 0x10,
  0x04, 0x00, 0x02, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x01, 0xFE, 0x00, 0xFD, 0xF8, 0x61, 0x83, 0x18, 0x30, 0x02, 0x06,
  0x00, 0xC0, 0xC0, 0x10, 0x18, 0x02, 0x03, 0x00, 0x40, 0x60, 0x08, 0x0C,
  0x01, 0x01, 0x80, 0x30, 0x30, 0x02, 0x06, 0x00, 0x60, 0xC0, 0x06, 0x18,
  0x00, 0x33, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x33,
  0x80, 0x06, 0x18, 0x00, 0xC1, 0x80, 0x18, 0x18, 0x03, 0x01, 0x00, 0x60,
  0x30, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x03, 0x00, 0xC0,
  0x40, 0x18, 0x08, 0x03, 0x03, 0x40, 0x60, 0xCF, 0x0C, 0xE0, 0x7F, 0xF0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x73, 0x80, 0x02, 0x00, 0x81, 0x00, 0x0C, 0x03, 0x03, 0x00,
  0x10, 0x04, 0x02, 0x00, 0x60, 0x18, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x03,
  0x00, 0x40, 0x08, 0x04, 0x00, 0x80, 0x10, 0x18, 0x01, 0x00, 0x20, 0x20,
  0x02, 0x00, 0x40, 0xC0, 0x04, 0x00, 0x81, 0x00, 0x08, 0x01, 0x06, 0x00,
  0x10, 0x02, 0x08, 0x00, 0x20, 0x04, 0x30, 0x00, 0x40, 0x08, 0x41, 0xF0,
  0xC0, 0x30, 0x8C, 0x31, 0x80, 0x62, 0x10, 0x31, 0x00, 0x84, 0x60, 0x23,
  0x03, 0x18, 0x80, 0x62, 0x04, 0x21, 0x00, 0x47, 0x38, 0xC6, 0x00, 0x83,
  0xC1, 0x0C, 0x01, 0x00, 0x06, 0x18, 0x02, 0x00, 0x08, 0x20, 0x06, 0x00,
  0x30, 0x40, 0x0C, 0x00, 0x40, 0x80, 0x18, 0x01, 0x81, 0x00, 0x30, 0x02,
  0x03, 0x00, 0x40, 0x0C, 0x06, 0x00, 0x80, 0x10, 0x0C, 0x01, 0x00, 0x60,
  0x08, 0x02, 0x00, 0x80, 0x10, 0x0C, 0x01, 0x00, 0x30, 0x10, 0x04, 0x00,
  0x20, 0x20, 0x08, 0x00, 0x60, 0x80, 0x30, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x40, 0x20, 0x00,
  0x30, 0x04, 0x00, 0x08, 0x01, 0x00, 0x06, 0x00, 0x60, 0x01, 0x00, 0x18,
  0x00, 0x40, 0x06, 0x00, 0x10, 0x01, 0x80, 0x06, 0x00, 0x60, 0x00, 0x80,
  0x10, 0x00, 0x20, 0x0C, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x20, 0xC0, 0x00, 0x04, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x30, 0x80, 0x00, 0x18, 0x10, 0x00, 0x08, 0x06,
  0x00, 0x66, 0x00, 0xC0, 0x13, 0x00, 0x18, 0x04, 0xC0, 0x03, 0x01, 0x20,
  0x00, 0x40, 0xC8, 0x00, 0x08, 0x22, 0x00, 0x03, 0x18, 0x80, 0x00, 0x64,
  0x20, 0x00, 0x0F, 0x08, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x24, 0x18, 0x00, 0x19, 0x83, 0x00, 0x18, 0x30, 0x60, 0x1C, 0x06, 0x0F,
  0xFC, 0x00, 0xC0, 0x10, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0x81, 0x80, 0x80,
  0x80, 0xC0, 0x40, 0x60, 0x20, 0x10, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01,
  0x00, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x0C, 0x02,
  0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0x40, 0x30, 0xC0, 0x30,
  0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x03, 0x00, 0x80, 0x60,
  0x30, 0x08, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01,
  0x01, 0x80, 0x80, 0x40, 0x60, 0x20, 0x30, 0x30, 0x10, 0x18, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x08, 0x04, 0x07, 0xC1, 0x0F, 0x1C, 0x4E, 0x00, 0xFC, 0x00, 0x0C,
  0x00, 0x04, 0x80, 0x03, 0x30, 0x00, 0x84, 0x00, 0x40, 0x80, 0x30, 0x30,
  0x18, 0x06, 0x04, 0x00, 0x80, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x11,
  0x33, 0x32, 0x26, 0x44, 0x48, 0x80, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x70, 0xE0,
  0x0C, 0x03, 0x01, 0x80, 0x18, 0x10, 0x00, 0x82, 0x00, 0x0C, 0x20, 0x00,
  0x46, 0x00, 0x06, 0x40, 0x00, 0x64, 0x00, 0x02, 0x40, 0x00, 0x2C, 0x00,
  0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02,
  0xC0, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x26, 0x00, 0x06, 0x60, 0x00,
  0x42, 0x00, 0x04, 0x30, 0x00, 0x81, 0x80, 0x18, 0x08, 0x01, 0x00, 0x60,
  0x60, 0x03, 0xFC, 0x00, 0x01, 0xC0, 0xF0, 0x6C, 0x33, 0x38, 0xD8, 0x3C,
  0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x03, 0xF0, 0x03, 0xC3, 0x81, 0xC0, 0x18, 0x20, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0F, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0xF9, 0xF0, 0x38, 0x01,
  0x8E, 0x00, 0x0C, 0x40, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x80, 0x00, 0xCF, 0x00, 0x30, 0x1F,
  0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x40, 0x00, 0x03, 0x40, 0x00, 0x02, 0x40, 0x00, 0x04,
  0x40, 0x00, 0x0C, 0x40, 0x00, 0x08, 0x40, 0x00, 0x10, 0x40, 0x00, 0x30,
  0x40, 0x00, 0x20, 0x40, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x40, 0x00, 0x80,
  0x40, 0x01, 0x80, 0x40, 0x03, 0x00, 0x40, 0x02, 0x00, 0x40, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x40, 0x18, 0x00, 0x40, 0x10, 0x00,
  0x40, 0x20, 0x00, 0x40, 0x60, 0x00, 0x40, 0x40, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xC3, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x61, 0xE0, 0x07, 0xFF, 0xE0, 0x20,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x88, 0x00, 0x38, 0xE0, 0x06, 0x03, 0xFF,
  0x80, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0x1C, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x3F, 0xE0, 0xC6, 0x03, 0x0D, 0x80,
  0x0C, 0x90, 0x00, 0x4A, 0x00, 0x06, 0xE0, 0x00, 0x2C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x14,
  0x00, 0x01, 0x40, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x22, 0x00, 0x02,
  0x30, 0x00, 0x61, 0x00, 0x04, 0x08, 0x00, 0x80, 0x60, 0x38, 0x03, 0xFE,
  0x00, 0x02, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x01, 0xF8, 0x00,
  0xF9, 0xE0, 0x18, 0x01, 0x83, 0x00, 0x08, 0x20, 0x00, 0x46, 0x00, 0x04,
  0x40, 0x00, 0x64, 0x00, 0x06, 0x40, 0x00, 0x64, 0x00, 0x06, 0x60, 0x00,
  0x66, 0x00, 0x04, 0x20, 0x00, 0xC1, 0x00, 0x18, 0x18, 0x03, 0x00, 0x60,
  0x60, 0x03, 0x98, 0x00, 0x0E, 0x00, 0x03, 0xB8, 0x00, 0x60, 0xE0, 0x18,
  0x03, 0x03, 0x00, 0x18, 0x60, 0x00, 0xC4, 0x00, 0x06, 0xC0, 0x00, 0x2C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x02, 0x40, 0x00, 0x66, 0x00, 0x04, 0x30, 0x01,
  0x81, 0xC0, 0x30, 0x07, 0xFE, 0x00, 0x04, 0x00, 0x03, 0xF0, 0x00, 0xE3,
  0xC0, 0x18, 0x07, 0x03, 0x00, 0x10, 0x60, 0x01, 0x84, 0x00, 0x0C, 0xC0,
  0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x68, 0x00, 0x02, 0x80, 0x00, 0x28,
  0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x40, 0x00, 0xB2, 0x00, 0x1A, 0x30, 0x03,
  0x20, 0xE1, 0xE2, 0x03, 0xF0, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x7F, 0xE0, 0x00, 0x60, 0x00, 0xDF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xDF, 0x00, 0x31, 0xCE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0xC6, 0x31, 0x88, 0x46,
  0x21, 0x08, 0x84, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x1F, 0x81, 0xF3, 0xC2, 0x00, 0xE0, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x08, 0x01, 0x80,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x0C, 0x10,
  0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x00, 0x62, 0x00, 0x1F, 0xC0, 0x19,
  0x80, 0x1E, 0x1C, 0x02, 0x40, 0x0C, 0x03, 0x00, 0x90, 0x06, 0x00, 0xC0,
  0x3C, 0x01, 0x00, 0x30, 0x0F, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x20, 0x02,
  0x00, 0x60, 0x18, 0x00, 0x80, 0x18, 0x06, 0x00, 0x20, 0x06, 0x01, 0x00,
  0x08, 0x01, 0x80, 0x40, 0x02, 0x00, 0x60, 0x10, 0x00, 0x80, 0x38, 0x04,
  0x00, 0x20, 0x0E, 0x01, 0x00, 0x18, 0x03, 0x80, 0x60, 0x06, 0x00, 0xA0,
  0x18, 0x01, 0x80, 0x28, 0x02, 0x00, 0xF0, 0x1B, 0x00, 0xC0, 0x24, 0x0C,
  0xC0, 0x18, 0x31, 0x86, 0x10, 0x03, 0xF8, 0x3F, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x01,
  0xE0, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x48, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x02, 0x10, 0x00, 0x00, 0x84, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x10, 0x20, 0x00, 0x04, 0x08, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x80, 0x40, 0x00, 0x20, 0x10, 0x00, 0x18, 0x06, 0x00, 0x04, 0x00, 0x80,
  0x01, 0x00, 0x20, 0x00, 0xC0, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x18, 0x01, 0xFF, 0xFE, 0x00, 0x40, 0x00, 0x80, 0x30,
  0x00, 0x30, 0x08, 0x00, 0x04, 0x02, 0x00, 0x01, 0x01, 0x80, 0x00, 0x60,
  0x40, 0x00, 0x08, 0x10, 0x00, 0x02, 0x0C, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x04, 0x60, 0x00, 0x01, 0x90, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x08, 0x00, 0x78, 0x80, 0x00,
  0xC8, 0x00, 0x04, 0x80, 0x00, 0x68, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00,
  0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80,
  0x00, 0x68, 0x00, 0x0C, 0x80, 0x01, 0x88, 0x00, 0x70, 0xFF, 0xFC, 0x08,
  0x07, 0xE0, 0x80, 0x01, 0x88, 0x00, 0x0C, 0x80, 0x00, 0x68, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x28, 0x00,
  0x06, 0x80, 0x00, 0xC8, 0x00, 0x18, 0x80, 0x0F, 0x0F, 0xFF, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0xF8, 0xF8, 0x07, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x07, 0xFF, 0xC0, 0x00, 0x40,
  0x00, 0xFF, 0xFC, 0x01, 0x00, 0x1E, 0x02, 0x00, 0x07, 0x04, 0x00, 0x03,
  0x08, 0x00, 0x03, 0x10, 0x00, 0x02, 0x20, 0x00, 0x06, 0x40, 0x00, 0x04,
  0x80, 0x00, 0x0D, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x14, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x05, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x34, 0x00, 0x00, 0x48, 0x00, 0x01,
  0x90, 0x00, 0x02, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x30, 0x80, 0x00, 0xC1,
  0x00, 0x07, 0x02, 0x00, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x3F, 0xFF, 0xD0, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0x0F, 0xC0, 0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x40, 0x00, 0x00, 0x50, 0x00, 0x00, 0x14, 0x00, 0x00, 0x05, 0x80,
  0x00, 0x01, 0x20, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x11, 0x00, 0x00, 0x04,
  0x60, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x41, 0x80, 0x00, 0x10, 0x38, 0x00,
  0x04, 0x03, 0x80, 0x0F, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0xFF, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x1B, 0xBC, 0x7C, 0x00, 0x80,
  0x00, 0x78, 0x00, 0x0C, 0x80, 0x01, 0x88, 0x00, 0x10, 0x80, 0x03, 0x08,
  0x00, 0x60, 0x80, 0x0C, 0x08, 0x01, 0x80, 0x80, 0x30, 0x08, 0x06, 0x00,
  0x80, 0x40, 0x08, 0x0C, 0x00, 0x81, 0x80, 0x08, 0x30, 0x00, 0x86, 0x00,
  0x08, 0xE0, 0x00, 0x9B, 0x00, 0x09, 0x10, 0x00, 0xB1, 0x80, 0x0E, 0x0C,
  0x00, 0xC0, 0xC0, 0x08, 0x06, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0x80,
  0x18, 0x08, 0x00, 0x80, 0x80, 0x0C, 0x08, 0x00, 0x60, 0x80, 0x02, 0x08,
  0x00, 0x30, 0x80, 0x01, 0x88, 0x00, 0x08, 0x80, 0x00, 0xC8, 0x00, 0x06,
  0x80, 0x00, 0x28, 0x00, 0x03, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x1F, 0xFF, 0xF0, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x40, 0x00, 0x00,
  0x5B, 0x00, 0x00, 0x02, 0xC8, 0x00, 0x00, 0x36, 0x40, 0x00, 0x01, 0x33,
  0x00, 0x00, 0x19, 0x88, 0x00, 0x00, 0xCC, 0x60, 0x00, 0x04, 0x63, 0x00,
  0x00, 0x63, 0x08, 0x00, 0x02, 0x18, 0x60, 0x00, 0x10, 0xC1, 0x00, 0x01,
  0x86, 0x08, 0x00, 0x08, 0x30, 0x60, 0x00, 0xC1, 0x81, 0x00, 0x06, 0x0C,
  0x08, 0x00, 0x20, 0x60, 0x60, 0x03, 0x03, 0x01, 0x00, 0x10, 0x18, 0x0C,
  0x00, 0x80, 0xC0, 0x20, 0x0C, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02,
  0x01, 0x80, 0x20, 0x30, 0x0C, 0x01, 0x01, 0x00, 0x60, 0x0C, 0x18, 0x03,
  0x00, 0x20, 0x80, 0x18, 0x01, 0x84, 0x00, 0xC0, 0x04, 0x60, 0x06, 0x00,
  0x22, 0x00, 0x30, 0x01, 0x90, 0x01, 0x80, 0x05, 0x80, 0x0C, 0x00, 0x28,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x68, 0x00, 0x01, 0xB0, 0x00, 0x06, 0x60,
  0x00, 0x18, 0x80, 0x00, 0x63, 0x00, 0x01, 0x84, 0x00, 0x06, 0x18, 0x00,
  0x18, 0x20, 0x00, 0x60, 0x40, 0x01, 0x81, 0x80, 0x06, 0x02, 0x00, 0x18,
  0x0C, 0x00, 0x60, 0x10, 0x01, 0x80, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x01,
  0x00, 0x60, 0x06, 0x01, 0x80, 0x08, 0x06, 0x00, 0x30, 0x18, 0x00, 0x60,
  0x60, 0x00, 0x81, 0x80, 0x03, 0x06, 0x00, 0x04, 0x18, 0x00, 0x18, 0x60,
  0x00, 0x31, 0x80, 0x00, 0x46, 0x00, 0x01, 0x98, 0x00, 0x02, 0x60, 0x00,
  0x0D, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x60,
  0x00, 0x60, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x10, 0x00, 0x00,
  0x83, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x46, 0x00, 0x00, 0x06, 0x40,
  0x00, 0x00, 0x64, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x42, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x18, 0x08, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x20, 0x07,
  0x00, 0x0C, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0xF8, 0x20, 0x03, 0x88, 0x00, 0x32, 0x00, 0x06, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x02, 0x80, 0x01, 0xA0, 0x00, 0xC8, 0x01, 0xE3, 0xFF, 0xE0, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x60,
  0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x10, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x0C, 0x20, 0x00, 0x00, 0x46, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00,
  0x64, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x26, 0x00, 0x00, 0x06,
  0x20, 0x00, 0x00, 0x42, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x18, 0x08, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x60, 0xFF, 0xF8, 0x08, 0x00, 0xE0, 0x80, 0x03, 0x08, 0x00,
  0x18, 0x80, 0x00, 0xC8, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80,
  0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x48,
  0x00, 0x0C, 0x80, 0x00, 0x88, 0x00, 0x18, 0x80, 0x03, 0x08, 0x00, 0xE0,
  0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x80, 0x30, 0x08, 0x03, 0x00, 0x80, 0x18,
  0x08, 0x00, 0x80, 0x80, 0x0C, 0x08, 0x00, 0x40, 0x80, 0x06, 0x08, 0x00,
  0x20, 0x80, 0x03, 0x08, 0x00, 0x10, 0x80, 0x01, 0x88, 0x00, 0x0C, 0x80,
  0x00, 0xC8, 0x00, 0x06, 0x80, 0x00, 0x28, 0x00, 0x03, 0x01, 0xFE, 0x01,
  0xF1, 0xFC, 0x60, 0x01, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x60, 0x03, 0x87, 0xFF,
  0xC0, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x60, 0x00,
  0x06, 0x20, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x0C, 0x00,
  0x30, 0x07, 0x00, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0x90, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x18, 0x20, 0x00, 0x08, 0x10,
  0x00, 0x04, 0x0C, 0x00, 0x06, 0x02, 0x00, 0x03, 0x01, 0x00, 0x01, 0x00,
  0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x10, 0x00, 0x40, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0xC0, 0x08, 0x00, 0x60, 0x0C,
  0x00, 0x10, 0x04, 0x00, 0x08, 0x02, 0x00, 0x06, 0x03, 0x00, 0x01, 0x01,
  0x00, 0x00, 0x80, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x08,
  0x20, 0x00, 0x06, 0x30, 0x00, 0x01, 0x10, 0x00, 0x00, 0x88, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0D, 0x00, 0x00, 0xC0, 0x00,
  0x34, 0x00, 0x03, 0x00, 0x00, 0x98, 0x00, 0x1E, 0x00, 0x02, 0x60, 0x00,
  0x48, 0x00, 0x18, 0x80, 0x01, 0x20, 0x00, 0x62, 0x00, 0x04, 0x80, 0x01,
  0x0C, 0x00, 0x33, 0x00, 0x04, 0x30, 0x00, 0xCC, 0x00, 0x30, 0x40, 0x02,
  0x10, 0x00, 0xC1, 0x00, 0x08, 0x40, 0x02, 0x06, 0x00, 0x61, 0x80, 0x08,
  0x18, 0x01, 0x86, 0x00, 0x60, 0x20, 0x04, 0x08, 0x01, 0x80, 0x80, 0x10,
  0x20, 0x04, 0x03, 0x00, 0xC0, 0xC0, 0x10, 0x0C, 0x03, 0x03, 0x00, 0xC0,
  0x10, 0x08, 0x04, 0x03, 0x00, 0x40, 0x20, 0x10, 0x08, 0x01, 0x81, 0x80,
  0x60, 0x20, 0x06, 0x06, 0x01, 0x81, 0x80, 0x08, 0x10, 0x02, 0x06, 0x00,
  0x20, 0x40, 0x08, 0x10, 0x00, 0xC3, 0x00, 0x30, 0x40, 0x03, 0x0C, 0x00,
  0xC3, 0x00, 0x04, 0x20, 0x01, 0x08, 0x00, 0x10, 0x80, 0x04, 0x20, 0x00,
  0x66, 0x00, 0x18, 0x80, 0x01, 0x98, 0x00, 0x66, 0x00, 0x02, 0x40, 0x00,
  0x90, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x34, 0x00, 0x0D, 0x00, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x30,
  0x40, 0x00, 0x40, 0xC0, 0x01, 0x80, 0x80, 0x02, 0x01, 0x80, 0x0C, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x60, 0x03, 0x00, 0x80, 0x02, 0x03, 0x00, 0x06,
  0x0C, 0x00, 0x04, 0x10, 0x00, 0x0C, 0x60, 0x00, 0x08, 0x80, 0x00, 0x1B,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xA0,
  0x00, 0x03, 0x60, 0x00, 0x04, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x20, 0x80,
  0x00, 0xC1, 0x80, 0x01, 0x01, 0x00, 0x04, 0x03, 0x00, 0x18, 0x02, 0x00,
  0x20, 0x06, 0x00, 0xC0, 0x06, 0x01, 0x00, 0x04, 0x06, 0x00, 0x0C, 0x08,
  0x00, 0x08, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x11, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x26, 0x00, 0x01, 0x88, 0x00,
  0x04, 0x30, 0x00, 0x30, 0x40, 0x00, 0x81, 0x80, 0x06, 0x02, 0x00, 0x18,
  0x0C, 0x00, 0x40, 0x10, 0x03, 0x00, 0x60, 0x08, 0x00, 0x80, 0x60, 0x02,
  0x01, 0x00, 0x04, 0x0C, 0x00, 0x10, 0x20, 0x00, 0x61, 0x80, 0x00, 0x84,
  0x00, 0x03, 0x30, 0x00, 0x04, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xC0,
  0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0xFF, 0xC0, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x07, 0xFF, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x1A,
  0x00, 0x00, 0x4C, 0x00, 0x03, 0x10, 0x00, 0x08, 0x60, 0x00, 0x40, 0x80,
  0x03, 0x03, 0x00, 0x08, 0x04, 0x00, 0x60, 0x18, 0x01, 0x00, 0x20, 0x0C,
  0x00, 0xC0, 0x20, 0x01, 0x01, 0x80, 0x06, 0x04, 0x00, 0x08, 0x30, 0x00,
  0x30, 0x80, 0x00, 0x46, 0x00, 0x01, 0x90, 0x00, 0x02, 0xC0, 0x00, 0x0C,
  0xFF, 0xFF, 0xF0, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x01, 0x07,
  0xFC, 0x1E, 0x03, 0x04, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x0F, 0xF8, 0x3C, 0x04, 0x70, 0x02, 0x60, 0x01, 0x60, 0x00, 0xA0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x06,
  0x80, 0x05, 0x60, 0x06, 0x98, 0x06, 0x47, 0xFC, 0x20, 0x30, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC3, 0xFE, 0x0C, 0xE0, 0x30, 0xD8, 0x01,
  0x8D, 0x00, 0x0C, 0xE0, 0x00, 0x4A, 0x00, 0x06, 0xE0, 0x00, 0x2C, 0x00,
  0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x2E, 0x00, 0x06,
  0xA0, 0x00, 0x4B, 0x00, 0x0C, 0x98, 0x01, 0x88, 0xC0, 0x70, 0x87, 0xFC,
  0x00, 0x06, 0x00, 0x01, 0xFF, 0x03, 0x80, 0xC3, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0xC0, 0xFF,
  0xC0, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x03, 0xFC, 0x30,
  0xE0, 0x73, 0x18, 0x01, 0xB3, 0x00, 0x0B, 0x20, 0x00, 0x76, 0x00, 0x07,
  0x40, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0x40,
  0x00, 0x74, 0x00, 0x07, 0x60, 0x00, 0x73, 0x00, 0x0B, 0x10, 0x01, 0xB0,
  0xC0, 0x73, 0x07, 0xFC, 0x30, 0x06, 0x00, 0x03, 0xFC, 0x01, 0xC0, 0xC0,
  0x60, 0x0C, 0x18, 0x00, 0xC2, 0x00, 0x08, 0xC0, 0x01, 0x90, 0x00, 0x12,
  0x00, 0x02, 0xC0, 0x00, 0x58, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x41, 0xC0, 0x38, 0x0F, 0xFC, 0x00,
  0x38, 0x00, 0x00, 0xFC, 0x0E, 0x10, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0xFF,
  0xE0, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x03,
  0xFE, 0x21, 0xC0, 0x64, 0x60, 0x06, 0x98, 0x00, 0x52, 0x00, 0x06, 0xC0,
  0x00, 0xD0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x14, 0x00,
  0x06, 0x80, 0x00, 0xD8, 0x00, 0x39, 0x80, 0x05, 0x18, 0x01, 0xA1, 0x80,
  0xE4, 0x1F, 0xF0, 0x80, 0x20, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x64, 0x00, 0x18, 0xF0, 0x0E, 0x03, 0xFF, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC3,
  0xFC, 0x33, 0x81, 0xCD, 0x80, 0x1B, 0x40, 0x02, 0xE0, 0x00, 0xE8, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x04,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x03,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x86, 0xFC, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x36, 0x00, 0x33, 0x00, 0x31, 0x80, 0x10, 0xC0, 0x10, 0x60,
  0x18, 0x30, 0x18, 0x18, 0x18, 0x0C, 0x08, 0x06, 0x08, 0x03, 0x0C, 0x01,
  0x8C, 0x00, 0xCF, 0x00, 0x64, 0x80, 0x34, 0x20, 0x1C, 0x18, 0x0E, 0x04,
  0x06, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x20, 0xC0, 0x18, 0x60, 0x04, 0x30,
  0x03, 0x18, 0x00, 0xCC, 0x00, 0x26, 0x00, 0x1B, 0x00, 0x06, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x87, 0xF8, 0x0F, 0xF1,
  0x18, 0x18, 0x70, 0x72, 0x60, 0x19, 0x80, 0x35, 0x80, 0x12, 0x00, 0x2A,
  0x00, 0x38, 0x00, 0x58, 0x00, 0x30, 0x00, 0xF0, 0x00, 0x60, 0x01, 0xE0,
  0x00, 0x80, 0x01, 0xC0, 0x01, 0x00, 0x03, 0x80, 0x02, 0x00, 0x07, 0x00,
  0x04, 0x00, 0x0E, 0x00, 0x08, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x38, 0x00,
  0x20, 0x00, 0x70, 0x00, 0x40, 0x00, 0xE0, 0x00, 0x80, 0x01, 0xC0, 0x01,
  0x00, 0x03, 0x80, 0x02, 0x00, 0x07, 0x00, 0x04, 0x00, 0x0E, 0x00, 0x08,
  0x00, 0x1C, 0x00, 0x10, 0x00, 0x38, 0x00, 0x20, 0x00, 0x70, 0x00, 0x40,
  0x00, 0xE0, 0x00, 0x80, 0x01, 0xC0, 0x01, 0x00, 0x03, 0x80, 0x02, 0x00,
  0x07, 0x00, 0x04, 0x00, 0x08, 0x83, 0xFC, 0x23, 0x81, 0xC9, 0x80, 0x1A,
  0x40, 0x02, 0xA0, 0x00, 0xE8, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x04, 0x03, 0xFE, 0x00, 0xE0, 0x30, 0x18,
  0x01, 0x83, 0x00, 0x0C, 0x20, 0x00, 0x66, 0x00, 0x02, 0x40, 0x00, 0x2C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x40, 0x00, 0x26, 0x00,
  0x06, 0x20, 0x00, 0x63, 0x00, 0x0C, 0x18, 0x01, 0x80, 0xC0, 0x30, 0x07,
  0xFE, 0x00, 0x02, 0x00, 0x83, 0xFE, 0x08, 0x60, 0x30, 0x88, 0x01, 0x89,
  0x00, 0x0C, 0xB0, 0x00, 0x4A, 0x00, 0x06, 0xE0, 0x00, 0x2C, 0x00, 0x02,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x2E, 0x00, 0x06, 0xE0,
  0x00, 0x4D, 0x00, 0x0C, 0xD8, 0x01, 0x8C, 0xE0, 0x70, 0xC3, 0xFC, 0x0C,
  0x06, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x21, 0xC0, 0xE4, 0x60,
  0x06, 0x98, 0x00, 0x52, 0x00, 0x0E, 0xC0, 0x00, 0xD0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x06, 0x80, 0x00, 0xD8, 0x00,
  0x39, 0x00, 0x05, 0x10, 0x01, 0x23, 0x80, 0xC4, 0x1F, 0xF0, 0x80, 0x20,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x87, 0xF8, 0xC0, 0x98, 0x0D, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x0F, 0xFE, 0x18, 0x07,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x80, 0x06, 0xE0, 0x0C,
  0x3F, 0xF8, 0x03, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x0F, 0xFF, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x7F, 0x00, 0x80, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x15, 0x00, 0x0D, 0x60, 0x06, 0x4E, 0x03, 0x11, 0xFF, 0x04, 0x04, 0x00,
  0xC0, 0x00, 0x28, 0x00, 0x0D, 0x00, 0x01, 0x30, 0x00, 0x22, 0x00, 0x0C,
  0x40, 0x01, 0x0C, 0x00, 0x20, 0x80, 0x0C, 0x10, 0x01, 0x03, 0x00, 0x20,
  0x20, 0x0C, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x0C, 0x01, 0x01, 0x00,
  0x30, 0x20, 0x02, 0x0C, 0x00, 0x41, 0x00, 0x0C, 0x20, 0x00, 0x8C, 0x00,
  0x11, 0x00, 0x03, 0x20, 0x00, 0x2C, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x90, 0x00, 0xE0, 0x02, 0x40, 0x06, 0x80, 0x09,
  0x00, 0x12, 0x00, 0x66, 0x00, 0x4C, 0x01, 0x08, 0x03, 0x10, 0x04, 0x20,
  0x08, 0x40, 0x10, 0xC0, 0x21, 0x00, 0xC3, 0x00, 0x86, 0x02, 0x04, 0x06,
  0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x60, 0x40, 0xC1, 0x80, 0x83, 0x01,
  0x04, 0x02, 0x08, 0x04, 0x10, 0x08, 0x20, 0x10, 0x40, 0x31, 0x80, 0x63,
  0x00, 0x46, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40, 0x0C, 0x80,
  0x1B, 0x00, 0x36, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x02,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x6C, 0x00, 0x18, 0xC0, 0x02, 0x08, 0x00, 0x81, 0x80, 0x30, 0x18,
  0x04, 0x01, 0x01, 0x80, 0x30, 0x60, 0x02, 0x08, 0x00, 0x63, 0x00, 0x06,
  0x40, 0x00, 0x58, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x28, 0x00, 0x0D,
  0x80, 0x01, 0x18, 0x00, 0x61, 0x00, 0x18, 0x30, 0x02, 0x02, 0x00, 0xC0,
  0x60, 0x10, 0x06, 0x04, 0x00, 0x41, 0x80, 0x0C, 0x20, 0x00, 0xCC, 0x00,
  0x0B, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x34, 0x00, 0x02, 0x60, 0x00, 0x62,
  0x00, 0x06, 0x20, 0x00, 0x43, 0x00, 0x0C, 0x10, 0x00, 0x81, 0x00, 0x08,
  0x18, 0x01, 0x80, 0x80, 0x10, 0x08, 0x01, 0x00, 0xC0, 0x30, 0x04, 0x02,
  0x00, 0x40, 0x20, 0x06, 0x06, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x30,
  0xC0, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x98, 0x00, 0x09, 0x00, 0x00,
  0x90, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0xF8, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x01, 0x80, 0x78, 0x01,
  0xC0, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x78, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x30, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x01, 0xC0, 0x3C, 0x00, 0x1F, 0xC0, 0x05, 0xC1, 0xC0, 0x3C,
  0x01, 0xC3, 0xA0, 0x01, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Thin51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 36, 11, 4, -36 },
  { 15, 8, 13, 16, 4, -36 },
  { 28, 27, 36, 29, 1, -36 },
  { 150, 19, 42, 26, 3, -39 },
  { 250, 31, 38, 36, 3, -37 },
  { 398, 26, 38, 30, 3, -37 },
  { 522, 1, 13, 9, 4, -36 },
  { 524, 9, 44, 13, 2, -36 },
  { 574, 9, 44, 13, 2, -36 },
  { 624, 18, 18, 24, 3, -39 },
  { 665, 22, 24, 26, 2, -30 },
  { 731, 4, 13, 9, 2, -6 },
  { 738, 12, 2, 15, 2, -15 },
  { 741, 3, 3, 10, 4, -3 },
  { 743, 15, 36, 17, 1, -36 },
  { 811, 20, 37, 26, 3, -37 },
  { 904, 10, 36, 26, 5, -36 },
  { 949, 19, 37, 26, 3, -37 },
  { 1037, 20, 38, 26, 2, -37 },
  { 1132, 24, 37, 26, 1, -37 },
  { 1243, 20, 37, 26, 3, -36 },
  { 1336, 20, 38, 26, 3, -37 },
  { 1431, 20, 36, 26, 3, -36 },
  { 1521, 20, 38, 26, 3, -37 },
  { 1616, 20, 38, 26, 3, -37 },
  { 1711, 3, 27, 10, 4, -27 },
  { 1722, 5, 34, 10, 2, -27 },
  { 1744, 22, 22, 26, 2, -29 },
  { 1805, 22, 12, 26, 2, -24 },
  { 1838, 22, 22, 26, 2, -29 },
  { 1899, 15, 37, 18, 2, -37 },
  { 1969, 34, 41, 40, 3, -36 },
  { 2144, 26, 36, 26, 0, -36 },
  { 2261, 20, 36, 28, 5, -36 },
  { 2351, 23, 38, 28, 3, -37 },
  { 2461, 23, 36, 31, 5, -36 },
  { 2565, 17, 36, 25, 5, -36 },
  { 2642, 17, 36, 22, 5, -36 },
  { 2719, 26, 38, 33, 3, -37 },
  { 2843, 22, 36, 32, 5, -36 },
  { 2942, 8, 36, 13, 3, -36 },
  { 2978, 10, 45, 11, -4, -36 },
  { 3035, 20, 36, 25, 5, -36 },
  { 3125, 17, 36, 23, 5, -36 },
  { 3202, 29, 36, 39, 5, -36 },
  { 3333, 22, 36, 32, 5, -36 },
  { 3432, 28, 38, 34, 3, -37 },
  { 3565, 18, 36, 26, 5, -36 },
  { 3646, 28, 46, 34, 3, -37 },
  { 3807, 20, 36, 26, 5, -36 },
  { 3897, 19, 38, 25, 3, -37 },
  { 3988, 22, 36, 23, 0, -36 },
  { 4087, 24, 37, 32, 4, -36 },
  { 4198, 25, 36, 25, 0, -36 },
  { 4311, 38, 36, 40, 1, -36 },
  { 4482, 23, 36, 23, 0, -36 },
  { 4586, 22, 36, 22, 0, -36 },
  { 4685, 21, 36, 25, 2, -36 },
  { 4780, 10, 44, 16, 4, -36 },
  { 4835, 15, 36, 17, 1, -36 },
  { 4903, 10, 44, 16, 1, -36 },
  { 4958, 22, 21, 26, 2, -37 },
  { 5016, 20, 1, 20, 0, 5 },
  { 5019, 8, 8, 12, 2, -39 },
  { 5027, 17, 28, 23, 2, -27 },
  { 5087, 20, 40, 27, 4, -39 },
  { 5187, 17, 28, 21, 3, -27 },
  { 5247, 20, 40, 27, 3, -39 },
  { 5347, 19, 28, 25, 3, -27 },
  { 5414, 14, 39, 13, 1, -39 },
  { 5483, 19, 39, 27, 3, -27 },
  { 5576, 18, 39, 26, 4, -39 },
  { 5664, 2, 37, 10, 4, -37 },
  { 5674, 8, 49, 10, -2, -37 },
  { 5723, 17, 39, 21, 4, -39 },
  { 5806, 2, 39, 10, 4, -39 },
  { 5816, 31, 27, 39, 4, -27 },
  { 5921, 18, 27, 26, 4, -27 },
  { 5982, 20, 28, 26, 3, -27 },
  { 6052, 20, 39, 27, 4, -27 },
  { 6150, 19, 39, 27, 3, -27 },
  { 6243, 12, 27, 17, 4, -27 },
  { 6284, 16, 28, 21, 2, -27 },
  { 6340, 12, 35, 14, 1, -34 },
  { 6393, 18, 28, 26, 4, -27 },
  { 6456, 19, 27, 19, 0, -27 },
  { 6521, 30, 27, 32, 1, -27 },
  { 6623, 19, 27, 21, 1, -27 },
  { 6688, 20, 39, 20, 0, -27 },
  { 6786, 16, 27, 20, 2, -27 },
  { 6840, 13, 44, 17, 2, -36 },
  { 6912, 2, 52, 24, 11, -39 },
  { 6925, 14, 44, 17, 2, -36 },
  { 7002, 22, 4, 26, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_Thin51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin51pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_SEMICONDENSED_THIN51PT7B_H_
