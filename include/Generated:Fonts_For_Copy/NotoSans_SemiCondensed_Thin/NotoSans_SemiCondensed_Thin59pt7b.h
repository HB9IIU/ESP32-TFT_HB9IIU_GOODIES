#ifndef _NOTOSANS_SEMICONDENSED_THIN59PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin59pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x00, 0x00, 0x07, 0xFC, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x04,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x00, 0x00, 0x20, 0x02, 0x00,
  0x00, 0x40, 0x04, 0x00, 0x00, 0x80, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x10, 0x01, 0x00, 0x00,
  0x20, 0x02, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03,
  0x00, 0x30, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x80, 0x00, 0x10,
  0x01, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x03, 0x00, 0x20, 0x00, 0x06, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x80, 0x00, 0x10, 0x03, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x01, 0x80, 0x10, 0x00, 0x03, 0x00, 0x20, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x08, 0x00, 0x80, 0x00, 0x10, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x10, 0x00, 0x02, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x40, 0x00, 0x08, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x01, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x20, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xC0, 0x38, 0xC3, 0xE1,
  0x83, 0x01, 0x0C, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x00, 0xC0, 0x0C, 0x03,
  0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00,
  0x30, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x0E,
  0x0C, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xDE, 0x00, 0x03, 0x1C, 0x00, 0x0C, 0x1C,
  0x00, 0x30, 0x38, 0x00, 0xC0, 0x60, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00,
  0x30, 0x04, 0x00, 0xC0, 0x10, 0x03, 0x00, 0x40, 0x0C, 0x01, 0x00, 0x30,
  0x04, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x33,
  0x80, 0xC3, 0x8F, 0xF3, 0x7C, 0x03, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0x80, 0x18, 0x30, 0x00, 0x30, 0x03, 0x01, 0x80, 0x03,
  0x00, 0x20, 0x08, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x18, 0x00, 0xC0, 0x06, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0x06, 0x02, 0x00, 0x0C, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x06,
  0x04, 0x00, 0x0C, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0x06, 0x08, 0x00, 0x0C,
  0x00, 0x41, 0x81, 0xE0, 0x40, 0x04, 0x10, 0x7F, 0x04, 0x00, 0xC3, 0x0C,
  0x18, 0x60, 0x0C, 0x31, 0x80, 0xC6, 0x00, 0xC6, 0x10, 0x06, 0x20, 0x18,
  0x63, 0x00, 0x63, 0x01, 0x8C, 0x30, 0x02, 0x18, 0x30, 0xC2, 0x00, 0x20,
  0xFE, 0x08, 0x20, 0x03, 0x03, 0x81, 0x82, 0x00, 0x30, 0x00, 0x10, 0x60,
  0x03, 0x00, 0x03, 0x06, 0x00, 0x30, 0x00, 0x20, 0x60, 0x03, 0x00, 0x06,
  0x06, 0x00, 0x30, 0x00, 0x40, 0x60, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x30,
  0x00, 0x80, 0x20, 0x03, 0x00, 0x18, 0x02, 0x00, 0x30, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x30, 0x03, 0x00, 0x20, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x60, 0x06, 0x00, 0x18, 0x04, 0x00, 0xC0, 0x01, 0x80, 0xC0,
  0x0C, 0x00, 0x0C, 0x18, 0x01, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x80, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x10, 0x00, 0xC0, 0x00,
  0xC0, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x20, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x04, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x02, 0x1C, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x08, 0xC0,
  0x0C, 0x00, 0x66, 0x00, 0x18, 0x01, 0x98, 0x00, 0x30, 0x04, 0x40, 0x00,
  0xC0, 0x13, 0x00, 0x01, 0x80, 0xCC, 0x00, 0x03, 0x02, 0x30, 0x00, 0x06,
  0x18, 0xC0, 0x00, 0x0C, 0x43, 0x00, 0x00, 0x1B, 0x0C, 0x00, 0x00, 0x28,
  0x30, 0x00, 0x00, 0xE0, 0x40, 0x00, 0x03, 0x81, 0x80, 0x00, 0x1B, 0x06,
  0x00, 0x00, 0xC6, 0x0C, 0x00, 0x06, 0x08, 0x18, 0x00, 0x30, 0x30, 0x38,
  0x07, 0x80, 0x60, 0x3F, 0xF8, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xC0, 0x60, 0x30, 0x08, 0x06, 0x03, 0x00, 0xC0, 0x60,
  0x18, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x60,
  0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18,
  0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0,
  0x30, 0x06, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x08,
  0x04, 0x01, 0xF8, 0x20, 0x78, 0xF1, 0x1E, 0x00, 0x7B, 0x80, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x24, 0x00, 0x02, 0x10, 0x00, 0x30, 0xC0, 0x03,
  0x03, 0x00, 0x30, 0x08, 0x01, 0x00, 0x60, 0x18, 0x01, 0x80, 0x80, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x18, 0xC6,
  0x31, 0x88, 0xC6, 0x31, 0x18, 0xC4, 0x23, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0xDF, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03,
  0xFF, 0x00, 0x0C, 0x03, 0x00, 0x30, 0x03, 0x00, 0xC0, 0x03, 0x03, 0x00,
  0x03, 0x06, 0x00, 0x06, 0x18, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x40, 0x00,
  0x08, 0x80, 0x00, 0x13, 0x00, 0x00, 0x36, 0x00, 0x00, 0x68, 0x00, 0x00,
  0xD0, 0x00, 0x01, 0xA0, 0x00, 0x01, 0x40, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x05, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x14, 0x00, 0x00, 0x28, 0x00, 0x00, 0xD8, 0x00,
  0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x04, 0x40, 0x00, 0x08, 0x80, 0x00,
  0x31, 0x80, 0x00, 0x61, 0x00, 0x00, 0x83, 0x00, 0x03, 0x02, 0x00, 0x04,
  0x06, 0x00, 0x18, 0x06, 0x00, 0x60, 0x07, 0x03, 0x80, 0x03, 0xFC, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x07, 0x01, 0xD0, 0x39, 0x06, 0x10, 0xC1,
  0x38, 0x1E, 0x01, 0x40, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x78, 0x00, 0x0F, 0xFE, 0x00,
  0x78, 0x07, 0x03, 0x80, 0x03, 0x02, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x70, 0x07, 0x03, 0x80, 0x03, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x80, 0x00, 0x61, 0xF0, 0x07, 0x80, 0x7F,
  0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x48, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x10, 0x80, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x04, 0x08, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x18, 0x08, 0x00, 0x01, 0x00, 0x80, 0x00, 0x30, 0x08, 0x00, 0x06, 0x00,
  0x80, 0x00, 0x60, 0x08, 0x00, 0x0C, 0x00, 0x80, 0x01, 0x80, 0x08, 0x00,
  0x18, 0x00, 0x80, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00,
  0x08, 0x00, 0xC0, 0x00, 0x80, 0x08, 0x00, 0x08, 0x01, 0x80, 0x00, 0x80,
  0x30, 0x00, 0x08, 0x02, 0x00, 0x00, 0x80, 0x60, 0x00, 0x08, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xF0, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x9F, 0xF8, 0x07, 0xF0, 0xF8,
  0x08, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x30, 0xF0, 0x07,
  0x80, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0xE0, 0x07, 0x80, 0x20, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0xFC, 0x02, 0x0F,
  0xFE, 0x04, 0x70, 0x07, 0x09, 0xC0, 0x03, 0x16, 0x00, 0x03, 0x28, 0x00,
  0x06, 0x70, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x0B, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x09, 0x00, 0x00, 0x13,
  0x00, 0x00, 0x66, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x0C,
  0x00, 0x18, 0x0C, 0x00, 0x60, 0x0E, 0x03, 0x80, 0x0F, 0xFE, 0x00, 0x01,
  0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x1C, 0x03, 0x80,
  0x60, 0x01, 0x81, 0x80, 0x01, 0x86, 0x00, 0x01, 0x0C, 0x00, 0x03, 0x10,
  0x00, 0x06, 0x60, 0x00, 0x04, 0xC0, 0x00, 0x09, 0x80, 0x00, 0x11, 0x00,
  0x00, 0x22, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x0C, 0x00,
  0x0C, 0x0C, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x07, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1D, 0xE0, 0x00, 0xE0, 0xE0, 0x03, 0x00, 0x70,
  0x0C, 0x00, 0x30, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x68, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x1C, 0x00,
  0x30, 0x1E, 0x01, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xFE, 0x00, 0x38, 0x07, 0x00, 0xC0, 0x03, 0x03, 0x00, 0x03,
  0x06, 0x00, 0x06, 0x18, 0x00, 0x06, 0x30, 0x00, 0x04, 0x40, 0x00, 0x0D,
  0x80, 0x00, 0x1B, 0x00, 0x00, 0x16, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x76, 0x00, 0x00, 0xA4, 0x00,
  0x03, 0x4C, 0x00, 0x0D, 0x8C, 0x00, 0x33, 0x0E, 0x01, 0xC6, 0x0F, 0xFF,
  0x0C, 0x03, 0xF0, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x40, 0x1C, 0x00, 0xFF,
  0xE0, 0x00, 0x3C, 0x00, 0x00, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0D, 0xF0, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x61, 0x86, 0x18, 0x43, 0x0C, 0x30, 0x86, 0x18, 0x41, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0xFC, 0x38, 0x07, 0x10,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x3F, 0xC0, 0x04, 0x30, 0x00, 0xFB, 0xF0, 0x06, 0x20,
  0x01, 0x80, 0x30, 0x06, 0x60, 0x03, 0x00, 0x30, 0x02, 0x60, 0x06, 0x00,
  0x30, 0x02, 0x60, 0x04, 0x00, 0x30, 0x03, 0x40, 0x0C, 0x00, 0x30, 0x03,
  0xC0, 0x08, 0x00, 0x30, 0x03, 0xC0, 0x18, 0x00, 0x30, 0x03, 0xC0, 0x18,
  0x00, 0x20, 0x03, 0xC0, 0x18, 0x00, 0x20, 0x03, 0xC0, 0x18, 0x00, 0x20,
  0x03, 0xC0, 0x10, 0x00, 0x20, 0x03, 0xC0, 0x10, 0x00, 0x20, 0x03, 0xC0,
  0x10, 0x00, 0x60, 0x02, 0xC0, 0x18, 0x00, 0x60, 0x02, 0xC0, 0x18, 0x00,
  0x60, 0x06, 0xC0, 0x18, 0x00, 0x60, 0x06, 0xC0, 0x08, 0x00, 0xF0, 0x04,
  0x40, 0x0C, 0x00, 0xB0, 0x0C, 0x40, 0x06, 0x01, 0x90, 0x18, 0x60, 0x07,
  0x07, 0x18, 0x38, 0x60, 0x01, 0xFC, 0x0F, 0xE0, 0x20, 0x00, 0x20, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0x20, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x01, 0x02, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x20,
  0x10, 0x00, 0x00, 0x80, 0x40, 0x00, 0x06, 0x01, 0x80, 0x00, 0x10, 0x06,
  0x00, 0x00, 0x40, 0x08, 0x00, 0x03, 0x00, 0x30, 0x00, 0x08, 0x00, 0xC0,
  0x00, 0x20, 0x01, 0x00, 0x01, 0x80, 0x06, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x04, 0x00,
  0x00, 0x80, 0x30, 0x00, 0x03, 0x00, 0x80, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x10, 0x18, 0x00, 0x00, 0x60, 0x40, 0x00, 0x01, 0x81, 0x00, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x00, 0x30, 0xFF, 0xFE, 0x01, 0x00, 0x1F, 0x82, 0x00, 0x03, 0x84,
  0x00, 0x01, 0x88, 0x00, 0x01, 0x90, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x40,
  0x00, 0x06, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x28, 0x00, 0x00, 0xD0, 0x00, 0x01, 0xA0, 0x00, 0x02, 0x40, 0x00,
  0x0C, 0x80, 0x00, 0x31, 0x00, 0x00, 0xC2, 0x00, 0x07, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x10, 0x00, 0x1C, 0x20, 0x00, 0x0E, 0x40, 0x00, 0x0C,
  0x80, 0x00, 0x0D, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x28, 0x00,
  0x00, 0xD0, 0x00, 0x03, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x70, 0x80, 0x1F,
  0x81, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x07,
  0x00, 0x1C, 0x07, 0x00, 0x01, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x40, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0x80, 0xFF, 0xFC, 0x00, 0x10, 0x03, 0xF0, 0x02, 0x00, 0x07,
  0x80, 0x40, 0x00, 0x1C, 0x08, 0x00, 0x01, 0xC1, 0x00, 0x00, 0x18, 0x20,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x18, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x48, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x14, 0x00, 0x00, 0x02,
  0x80, 0x00, 0x00, 0x50, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0x10, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x18, 0x40, 0x00, 0x03, 0x08, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x30, 0x20,
  0x00, 0x1C, 0x04, 0x00, 0x0E, 0x00, 0x80, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0x80, 0x07, 0x80, 0x38, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x0C, 0x01, 0xE0, 0x03, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x7F, 0xC0, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0xC1, 0xCF, 0xF0,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x32, 0x00, 0x00, 0xC4, 0x00, 0x03, 0x88,
  0x00, 0x06, 0x10, 0x00, 0x18, 0x20, 0x00, 0x60, 0x40, 0x01, 0x80, 0x80,
  0x06, 0x01, 0x00, 0x18, 0x02, 0x00, 0x70, 0x04, 0x00, 0xC0, 0x08, 0x03,
  0x00, 0x10, 0x0C, 0x00, 0x20, 0x30, 0x00, 0x40, 0xC0, 0x00, 0x83, 0x80,
  0x01, 0x0E, 0x00, 0x02, 0x1C, 0x00, 0x04, 0x6C, 0x00, 0x09, 0x98, 0x00,
  0x16, 0x18, 0x00, 0x38, 0x18, 0x00, 0x60, 0x30, 0x00, 0x80, 0x30, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x60, 0x08, 0x00, 0xC0, 0x10,
  0x00, 0xC0, 0x20, 0x00, 0xC0, 0x40, 0x01, 0x80, 0x80, 0x01, 0x81, 0x00,
  0x01, 0x82, 0x00, 0x03, 0x04, 0x00, 0x03, 0x08, 0x00, 0x03, 0x10, 0x00,
  0x06, 0x20, 0x00, 0x06, 0x40, 0x00, 0x04, 0x80, 0x00, 0x0D, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x1F, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x80, 0x00, 0x00, 0x0F, 0xB0, 0x00,
  0x00, 0x02, 0xEC, 0x00, 0x00, 0x01, 0xB9, 0x00, 0x00, 0x00, 0x6E, 0x60,
  0x00, 0x00, 0x13, 0x98, 0x00, 0x00, 0x0C, 0xE2, 0x00, 0x00, 0x03, 0x38,
  0xC0, 0x00, 0x00, 0x8E, 0x10, 0x00, 0x00, 0x63, 0x86, 0x00, 0x00, 0x10,
  0xE1, 0x80, 0x00, 0x0C, 0x38, 0x20, 0x00, 0x03, 0x0E, 0x0C, 0x00, 0x00,
  0x83, 0x83, 0x00, 0x00, 0x60, 0xE0, 0x40, 0x00, 0x18, 0x38, 0x18, 0x00,
  0x04, 0x0E, 0x02, 0x00, 0x03, 0x03, 0x80, 0xC0, 0x00, 0x80, 0xE0, 0x30,
  0x00, 0x60, 0x38, 0x04, 0x00, 0x18, 0x0E, 0x01, 0x80, 0x04, 0x03, 0x80,
  0x60, 0x03, 0x00, 0xE0, 0x08, 0x00, 0xC0, 0x38, 0x03, 0x00, 0x20, 0x0E,
  0x00, 0xC0, 0x18, 0x03, 0x80, 0x18, 0x06, 0x00, 0xE0, 0x06, 0x03, 0x00,
  0x38, 0x00, 0x80, 0xC0, 0x0E, 0x00, 0x30, 0x20, 0x03, 0x80, 0x0C, 0x18,
  0x00, 0xE0, 0x01, 0x06, 0x00, 0x38, 0x00, 0x61, 0x00, 0x0E, 0x00, 0x18,
  0xC0, 0x03, 0x80, 0x02, 0x30, 0x00, 0xE0, 0x00, 0xC8, 0x00, 0x38, 0x00,
  0x16, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x30, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x06, 0x60,
  0x00, 0x03, 0x10, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x18, 0x10, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x10, 0x00,
  0x60, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x10, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01,
  0x80, 0x60, 0x00, 0x60, 0x30, 0x00, 0x10, 0x18, 0x00, 0x0C, 0x0C, 0x00,
  0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0,
  0x00, 0x0C, 0x60, 0x00, 0x02, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x06, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x02,
  0x80, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x04,
  0x60, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x08,
  0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x01, 0x80,
  0x00, 0xE0, 0x0F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x05, 0x00, 0x00,
  0xFF, 0xF8, 0x04, 0x01, 0xF8, 0x20, 0x00, 0x71, 0x00, 0x01, 0xC8, 0x00,
  0x07, 0x40, 0x00, 0x1A, 0x00, 0x00, 0x50, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x14, 0x00, 0x01, 0xA0,
  0x00, 0x0D, 0x00, 0x00, 0xC8, 0x00, 0x0C, 0x40, 0x01, 0xC2, 0x03, 0xF8,
  0x1F, 0xFE, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xE0, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x06, 0x00, 0x00, 0xE0, 0x0C,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x02, 0x80,
  0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x08, 0x30,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x00,
  0xE0, 0x0F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x05, 0xB0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0xFF,
  0xFC, 0x01, 0x00, 0x7E, 0x02, 0x00, 0x07, 0x04, 0x00, 0x03, 0x08, 0x00,
  0x03, 0x10, 0x00, 0x06, 0x20, 0x00, 0x06, 0x40, 0x00, 0x0C, 0x80, 0x00,
  0x19, 0x00, 0x00, 0x32, 0x00, 0x00, 0x24, 0x00, 0x00, 0x48, 0x00, 0x01,
  0x90, 0x00, 0x03, 0x20, 0x00, 0x06, 0x40, 0x00, 0x0C, 0x80, 0x00, 0x31,
  0x00, 0x00, 0x62, 0x00, 0x01, 0x84, 0x00, 0x06, 0x08, 0x00, 0x38, 0x10,
  0x07, 0xC0, 0x3F, 0xFE, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00,
  0x18, 0x02, 0x00, 0x10, 0x04, 0x00, 0x30, 0x08, 0x00, 0x30, 0x10, 0x00,
  0x60, 0x20, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x80, 0x00, 0xC1, 0x00, 0x01,
  0x82, 0x00, 0x01, 0x84, 0x00, 0x03, 0x08, 0x00, 0x03, 0x10, 0x00, 0x02,
  0x20, 0x00, 0x06, 0x40, 0x00, 0x06, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x0C,
  0x00, 0x3F, 0x00, 0x07, 0xFF, 0xE0, 0x1C, 0x00, 0xF0, 0xE0, 0x00, 0x23,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x80, 0x00, 0x61, 0xE0, 0x03,
  0x80, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x68, 0x00, 0x00, 0x09, 0x80, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00,
  0x04, 0xC0, 0x00, 0x00, 0x62, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x10, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x18, 0x06, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x60,
  0x06, 0x00, 0x03, 0x00, 0x10, 0x00, 0x10, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x10, 0x01, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x10, 0x04, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x10, 0x10, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x10,
  0x40, 0x00, 0x00, 0x86, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x11, 0x00,
  0x00, 0x00, 0x98, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x34, 0x00, 0x00, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x36, 0x00, 0x00, 0xF0, 0x00, 0x02, 0x20, 0x00, 0x0F,
  0x00, 0x00, 0x62, 0x00, 0x00, 0xD0, 0x00, 0x06, 0x30, 0x00, 0x09, 0x80,
  0x00, 0x63, 0x00, 0x01, 0x98, 0x00, 0x04, 0x10, 0x00, 0x19, 0x80, 0x00,
  0xC1, 0x00, 0x01, 0x88, 0x00, 0x0C, 0x18, 0x00, 0x10, 0xC0, 0x00, 0xC1,
  0x80, 0x03, 0x0C, 0x00, 0x08, 0x08, 0x00, 0x30, 0xC0, 0x01, 0x80, 0x80,
  0x03, 0x04, 0x00, 0x18, 0x0C, 0x00, 0x20, 0x60, 0x01, 0x80, 0xC0, 0x02,
  0x06, 0x00, 0x10, 0x04, 0x00, 0x60, 0x60, 0x03, 0x00, 0x40, 0x06, 0x02,
  0x00, 0x30, 0x06, 0x00, 0x40, 0x30, 0x02, 0x00, 0x60, 0x04, 0x03, 0x00,
  0x20, 0x02, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x60,
  0x03, 0x00, 0x80, 0x18, 0x04, 0x00, 0x30, 0x08, 0x01, 0x80, 0xC0, 0x01,
  0x01, 0x80, 0x18, 0x0C, 0x00, 0x10, 0x18, 0x00, 0x80, 0xC0, 0x01, 0x81,
  0x00, 0x0C, 0x08, 0x00, 0x18, 0x10, 0x00, 0xC1, 0x80, 0x00, 0x83, 0x00,
  0x0C, 0x18, 0x00, 0x08, 0x30, 0x00, 0x41, 0x80, 0x00, 0xC2, 0x00, 0x06,
  0x10, 0x00, 0x0C, 0x20, 0x00, 0x63, 0x00, 0x00, 0x46, 0x00, 0x06, 0x30,
  0x00, 0x04, 0x60, 0x00, 0x23, 0x00, 0x00, 0x64, 0x00, 0x02, 0x20, 0x00,
  0x06, 0x40, 0x00, 0x36, 0x00, 0x00, 0x2C, 0x00, 0x03, 0x60, 0x00, 0x02,
  0xC0, 0x00, 0x16, 0x00, 0x00, 0x38, 0x00, 0x01, 0x40, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30,
  0x60, 0x00, 0x08, 0x0C, 0x00, 0x06, 0x01, 0x00, 0x01, 0x00, 0x60, 0x00,
  0xC0, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x0C, 0x00, 0x18,
  0x03, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x06, 0x08, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x18, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x01, 0x00, 0x00, 0x80, 0x60,
  0x00, 0x60, 0x08, 0x00, 0x10, 0x03, 0x00, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x18, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x06, 0x04, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x80, 0x00, 0x06,
  0x60, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x10, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x04,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x20, 0x00, 0x30, 0x0C, 0x00, 0x0C,
  0x01, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x30, 0x00, 0xC0, 0x08, 0x00, 0x10, 0x06, 0x00, 0x06, 0x01, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x04, 0x18, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x20, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xFF, 0xF0, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0xFF,
  0xE0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x07, 0xFF, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x31, 0x00, 0x00, 0x08, 0x60, 0x00, 0x06, 0x08, 0x00, 0x01, 0x03, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x20, 0x18, 0x00, 0x18, 0x02, 0x00, 0x0C, 0x00,
  0xC0, 0x03, 0x00, 0x10, 0x01, 0x80, 0x06, 0x00, 0x60, 0x00, 0x80, 0x30,
  0x00, 0x30, 0x0C, 0x00, 0x04, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x0C, 0x20, 0x00, 0x03, 0x18, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0xF8,
  0x01, 0xFF, 0xE0, 0xF0, 0x0E, 0x08, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0xF8, 0x0F, 0xFF,
  0x07, 0x80, 0x23, 0x80, 0x04, 0xC0, 0x00, 0xB0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0xE0, 0x00, 0x5C, 0x00, 0x1A, 0xC0, 0x06, 0x4E, 0x03, 0x88,
  0xFF, 0xC1, 0x01, 0x80, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x0F, 0x80, 0x20, 0xFF, 0xE0,
  0x43, 0x80, 0xE0, 0x8C, 0x00, 0x61, 0x30, 0x00, 0x62, 0xC0, 0x00, 0x65,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60,
  0x00, 0x02, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB8, 0x00, 0x02, 0x50, 0x00, 0x0C,
  0xB0, 0x00, 0x31, 0x20, 0x00, 0x62, 0x70, 0x03, 0x84, 0x30, 0x1E, 0x08,
  0x3F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x03,
  0x80, 0x30, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70,
  0x1F, 0xFE, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x07, 0xC0, 0x40, 0x7F, 0xE0,
  0x83, 0x80, 0x71, 0x0C, 0x00, 0x32, 0x30, 0x00, 0x24, 0x60, 0x00, 0x69,
  0x80, 0x00, 0x52, 0x00, 0x00, 0xEC, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xA0,
  0x00, 0x03, 0x40, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x98, 0x00, 0x05,
  0x30, 0x00, 0x1A, 0x30, 0x00, 0x64, 0x30, 0x01, 0x88, 0x38, 0x0E, 0x10,
  0x3F, 0xF8, 0x20, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFE, 0x00,
  0x70, 0x1C, 0x03, 0x80, 0x18, 0x18, 0x00, 0x30, 0x60, 0x00, 0x43, 0x00,
  0x01, 0x8C, 0x00, 0x02, 0x60, 0x00, 0x09, 0x80, 0x00, 0x34, 0x00, 0x00,
  0xD0, 0x00, 0x03, 0x40, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x20, 0x78, 0x07, 0x80, 0x7F, 0xF8, 0x00, 0x1C,
  0x00, 0x00, 0x7F, 0x80, 0xF9, 0xC0, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x03, 0xFF, 0xE0, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0x84, 0x1C, 0x03, 0x88, 0x60, 0x01,
  0x91, 0x80, 0x01, 0x22, 0x00, 0x01, 0x4C, 0x00, 0x03, 0x90, 0x00, 0x03,
  0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xD0, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00,
  0x0E, 0xC0, 0x00, 0x14, 0xC0, 0x00, 0x29, 0x80, 0x00, 0xD1, 0x80, 0x03,
  0x61, 0x80, 0x0C, 0xC1, 0xC0, 0x71, 0x80, 0xFF, 0xC3, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x31, 0x00, 0x00, 0xC1, 0x80, 0x03, 0x83, 0xF0, 0x3C, 0x00, 0xFF,
  0xE0, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x3E, 0x02, 0x0F, 0xFE, 0x10, 0xC0, 0x38, 0x8C, 0x00, 0xE4, 0x80,
  0x03, 0x2C, 0x00, 0x0D, 0x40, 0x00, 0x6E, 0x00, 0x01, 0x60, 0x00, 0x0B,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x5F, 0xB0, 0x00, 0x00, 0x06, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0x80, 0x01, 0x01, 0xC0, 0xE0, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x18, 0x0D, 0x1C, 0xFC, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x34, 0x00,
  0x0C, 0x80, 0x03, 0x10, 0x00, 0xC2, 0x00, 0x30, 0x40, 0x04, 0x08, 0x01,
  0x81, 0x00, 0x60, 0x20, 0x18, 0x04, 0x06, 0x00, 0x80, 0x80, 0x10, 0x30,
  0x02, 0x0C, 0x00, 0x43, 0x80, 0x08, 0xD8, 0x01, 0x11, 0x80, 0x26, 0x30,
  0x05, 0x83, 0x00, 0xE0, 0x20, 0x18, 0x06, 0x02, 0x00, 0x60, 0x40, 0x0C,
  0x08, 0x00, 0xC1, 0x00, 0x08, 0x20, 0x01, 0x84, 0x00, 0x18, 0x80, 0x01,
  0x10, 0x00, 0x32, 0x00, 0x02, 0x40, 0x00, 0x68, 0x00, 0x06, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x78, 0x10, 0xFF, 0xC0, 0x7F,
  0xE2, 0x38, 0x1C, 0x1C, 0x0E, 0x4C, 0x00, 0xC6, 0x00, 0x6B, 0x00, 0x19,
  0x80, 0x0D, 0x40, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x7C, 0x04, 0x1F, 0xFC, 0x21, 0x80, 0x71, 0x18, 0x00, 0xC9, 0x80,
  0x06, 0x58, 0x00, 0x1A, 0x80, 0x00, 0xDC, 0x00, 0x02, 0xC0, 0x00, 0x16,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x1E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0x30,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x02, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x20, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x08,
  0x18, 0x00, 0x18, 0x0E, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x18, 0x00, 0x00, 0x7C, 0x01, 0x07, 0xFF, 0x02, 0x1C, 0x07, 0x04,
  0x60, 0x03, 0x09, 0x80, 0x03, 0x12, 0x00, 0x03, 0x2C, 0x00, 0x06, 0x50,
  0x00, 0x06, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xB0, 0x00, 0x01, 0x60, 0x00, 0x06,
  0xE0, 0x00, 0x0D, 0x40, 0x00, 0x12, 0x80, 0x00, 0x65, 0x80, 0x00, 0x89,
  0x80, 0x03, 0x11, 0x80, 0x0C, 0x21, 0xC0, 0x70, 0x41, 0xFF, 0x80, 0x80,
  0x70, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x04, 0x1C, 0x03,
  0x88, 0x60, 0x03, 0x11, 0x80, 0x03, 0x22, 0x00, 0x03, 0x4C, 0x00, 0x03,
  0x90, 0x00, 0x07, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xD0, 0x00, 0x01, 0xA0, 0x00,
  0x03, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x14, 0xC0, 0x00, 0x79, 0x80, 0x00,
  0xB1, 0x80, 0x03, 0x61, 0x80, 0x0C, 0xC1, 0xC0, 0x71, 0x81, 0xFF, 0x83,
  0x00, 0x38, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0xE2, 0x0F, 0xF8, 0xE0, 0x26, 0x00,
  0x90, 0x02, 0xC0, 0x0A, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x00, 0xF8, 0x00, 0xFF, 0xF8, 0x70, 0x03, 0x98, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0D, 0x80, 0x03,
  0xBC, 0x00, 0xE1, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0xFF, 0xFC,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x1C, 0x10, 0x3F, 0xC0, 0x18, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x05, 0xC0,
  0x00, 0xD6, 0x00, 0x09, 0x30, 0x03, 0x13, 0x80, 0xE1, 0x0F, 0xFC, 0x10,
  0x0E, 0x00, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x36, 0x00, 0x00, 0x98, 0x00,
  0x06, 0x20, 0x00, 0x18, 0xC0, 0x00, 0x43, 0x00, 0x03, 0x04, 0x00, 0x0C,
  0x18, 0x00, 0x20, 0x60, 0x01, 0x80, 0x80, 0x06, 0x03, 0x00, 0x10, 0x0C,
  0x00, 0xC0, 0x10, 0x03, 0x00, 0x60, 0x08, 0x01, 0x80, 0x60, 0x02, 0x01,
  0x80, 0x0C, 0x04, 0x00, 0x30, 0x30, 0x00, 0x40, 0xC0, 0x01, 0x82, 0x00,
  0x06, 0x18, 0x00, 0x08, 0x60, 0x00, 0x31, 0x00, 0x00, 0xC4, 0x00, 0x01,
  0x30, 0x00, 0x04, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x0C, 0x00,
  0x09, 0x00, 0x03, 0x80, 0x01, 0x20, 0x00, 0x50, 0x00, 0x66, 0x00, 0x0B,
  0x00, 0x0C, 0xC0, 0x03, 0x20, 0x01, 0x08, 0x00, 0x64, 0x00, 0x21, 0x00,
  0x08, 0xC0, 0x0C, 0x30, 0x01, 0x18, 0x01, 0x86, 0x00, 0x61, 0x00, 0x20,
  0x40, 0x08, 0x20, 0x04, 0x08, 0x01, 0x06, 0x01, 0x81, 0x80, 0x60, 0xC0,
  0x30, 0x30, 0x0C, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x60, 0x60,
  0x30, 0x30, 0x0C, 0x0C, 0x02, 0x06, 0x01, 0x81, 0x00, 0x40, 0x80, 0x10,
  0x20, 0x0C, 0x10, 0x03, 0x0C, 0x01, 0x86, 0x00, 0x61, 0x80, 0x10, 0xC0,
  0x04, 0x20, 0x03, 0x10, 0x00, 0x8C, 0x00, 0x62, 0x00, 0x19, 0x80, 0x04,
  0xC0, 0x03, 0x20, 0x00, 0x98, 0x00, 0x24, 0x00, 0x1A, 0x00, 0x05, 0x80,
  0x03, 0x40, 0x00, 0xF0, 0x00, 0x28, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x60, 0x00, 0x1C, 0xC0,
  0x00, 0x63, 0x00, 0x03, 0x06, 0x00, 0x08, 0x0C, 0x00, 0x60, 0x30, 0x03,
  0x00, 0x60, 0x0C, 0x00, 0x80, 0x60, 0x03, 0x01, 0x00, 0x06, 0x0C, 0x00,
  0x18, 0x60, 0x00, 0x31, 0x00, 0x00, 0x4C, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0x30, 0x00, 0x0C, 0x40,
  0x00, 0x61, 0x80, 0x01, 0x83, 0x00, 0x0C, 0x04, 0x00, 0x20, 0x18, 0x01,
  0x80, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x81, 0x80, 0x02, 0x04, 0x00,
  0x0C, 0x30, 0x00, 0x19, 0x80, 0x00, 0x6C, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x09, 0x80, 0x00, 0x31, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x86, 0x00, 0x03, 0x04, 0x00, 0x04, 0x0C, 0x00, 0x08, 0x18, 0x00, 0x30,
  0x10, 0x00, 0x40, 0x30, 0x00, 0x80, 0x60, 0x03, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x30, 0x01, 0x00, 0x40, 0x03, 0x00, 0x80, 0x06,
  0x03, 0x00, 0x04, 0x04, 0x00, 0x0C, 0x08, 0x00, 0x18, 0x30, 0x00, 0x10,
  0x40, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0x44, 0x00, 0x00, 0xD8,
  0x00, 0x01, 0xB0, 0x00, 0x01, 0x40, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x04, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0x00, 0x78, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0x70, 0x70, 0x01, 0xC0, 0x1E, 0x07, 0x80, 0x07,
  0xFC, 0x00, 0x00, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Thin59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 3, 42, 13, 5, -42 },
  { 17, 10, 15, 18, 4, -42 },
  { 36, 31, 42, 33, 1, -42 },
  { 199, 22, 48, 30, 3, -45 },
  { 331, 36, 44, 42, 3, -43 },
  { 529, 30, 44, 35, 3, -43 },
  { 694, 2, 15, 10, 4, -42 },
  { 698, 10, 51, 15, 3, -42 },
  { 762, 11, 51, 15, 2, -42 },
  { 833, 21, 21, 28, 3, -45 },
  { 889, 24, 27, 30, 3, -34 },
  { 970, 5, 15, 11, 2, -7 },
  { 980, 14, 2, 18, 2, -17 },
  { 984, 3, 3, 12, 5, -3 },
  { 986, 17, 42, 19, 1, -42 },
  { 1076, 23, 44, 30, 3, -43 },
  { 1203, 12, 42, 30, 5, -42 },
  { 1266, 23, 43, 30, 3, -43 },
  { 1390, 23, 44, 30, 3, -43 },
  { 1517, 28, 42, 30, 1, -42 },
  { 1664, 22, 43, 30, 4, -42 },
  { 1783, 23, 44, 30, 4, -43 },
  { 1910, 23, 42, 30, 3, -42 },
  { 2031, 23, 44, 30, 3, -43 },
  { 2158, 23, 44, 30, 3, -43 },
  { 2285, 3, 31, 12, 5, -31 },
  { 2297, 6, 39, 12, 2, -31 },
  { 2327, 24, 26, 30, 3, -34 },
  { 2405, 24, 14, 30, 3, -28 },
  { 2447, 24, 26, 30, 3, -34 },
  { 2525, 17, 43, 21, 2, -43 },
  { 2617, 40, 48, 46, 3, -42 },
  { 2857, 30, 42, 30, 0, -42 },
  { 3015, 23, 42, 32, 6, -42 },
  { 3136, 26, 44, 32, 4, -43 },
  { 3279, 27, 42, 36, 6, -42 },
  { 3421, 19, 42, 29, 6, -42 },
  { 3521, 19, 42, 26, 6, -42 },
  { 3621, 30, 44, 38, 4, -43 },
  { 3786, 25, 42, 37, 6, -42 },
  { 3918, 9, 42, 15, 3, -42 },
  { 3966, 12, 52, 13, -5, -42 },
  { 4044, 23, 42, 29, 6, -42 },
  { 4165, 19, 42, 26, 6, -42 },
  { 4265, 34, 42, 45, 6, -42 },
  { 4444, 25, 42, 37, 6, -42 },
  { 4576, 32, 44, 39, 4, -43 },
  { 4752, 21, 42, 30, 6, -42 },
  { 4863, 32, 53, 39, 4, -43 },
  { 5075, 23, 42, 30, 6, -42 },
  { 5196, 23, 44, 29, 3, -43 },
  { 5323, 26, 42, 26, 0, -42 },
  { 5460, 27, 43, 37, 5, -42 },
  { 5606, 29, 42, 29, 0, -42 },
  { 5759, 44, 42, 46, 1, -42 },
  { 5990, 26, 42, 26, 0, -42 },
  { 6127, 26, 42, 26, 0, -42 },
  { 6264, 25, 42, 29, 2, -42 },
  { 6396, 12, 51, 18, 5, -42 },
  { 6473, 17, 42, 19, 1, -42 },
  { 6563, 11, 51, 18, 2, -42 },
  { 6634, 26, 24, 30, 2, -42 },
  { 6712, 23, 2, 23, 0, 5 },
  { 6718, 10, 9, 14, 2, -45 },
  { 6730, 19, 33, 27, 3, -32 },
  { 6809, 23, 46, 31, 5, -45 },
  { 6942, 20, 33, 24, 3, -32 },
  { 7025, 23, 46, 31, 3, -45 },
  { 7158, 22, 33, 28, 3, -32 },
  { 7249, 17, 45, 15, 1, -45 },
  { 7345, 23, 46, 31, 3, -32 },
  { 7478, 21, 45, 30, 5, -45 },
  { 7597, 3, 43, 12, 4, -43 },
  { 7614, 9, 57, 12, -2, -43 },
  { 7679, 19, 45, 24, 5, -45 },
  { 7786, 1, 45, 11, 5, -45 },
  { 7792, 35, 32, 45, 5, -32 },
  { 7932, 21, 32, 30, 5, -32 },
  { 8016, 24, 33, 30, 3, -32 },
  { 8115, 23, 46, 31, 5, -32 },
  { 8248, 23, 46, 31, 3, -32 },
  { 8381, 14, 32, 20, 5, -32 },
  { 8437, 19, 33, 24, 2, -32 },
  { 8516, 14, 40, 16, 1, -39 },
  { 8586, 20, 32, 30, 5, -31 },
  { 8666, 22, 31, 22, 0, -31 },
  { 8752, 35, 31, 37, 1, -31 },
  { 8888, 22, 31, 25, 1, -31 },
  { 8974, 23, 45, 23, 0, -31 },
  { 9104, 19, 31, 23, 2, -31 },
  { 9178, 16, 51, 20, 2, -42 },
  { 9280, 2, 60, 28, 13, -45 },
  { 9295, 16, 51, 20, 2, -42 },
  { 9397, 24, 5, 30, 3, -23 },
};

const GFXfont NotoSans_SemiCondensed_Thin59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin59pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_SEMICONDENSED_THIN59PT7B_H_
