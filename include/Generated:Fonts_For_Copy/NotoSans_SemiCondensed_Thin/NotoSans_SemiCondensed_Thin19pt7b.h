#ifndef _NOTOSANS_SEMICONDENSED_THIN19PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE4, 0x99, 0x99, 0x90, 0x08, 0x82, 0x20, 0x90, 0x24, 0x7F,
  0xC4, 0x41, 0x10, 0x44, 0x11, 0x3F, 0xF2, 0x20, 0x88, 0x22, 0x08, 0x80,
  0x38, 0xAE, 0x44, 0x89, 0x12, 0x1C, 0x0C, 0x16, 0x24, 0x48, 0x91, 0x3F,
  0x84, 0x00, 0x60, 0x89, 0x08, 0x89, 0x08, 0x90, 0x89, 0x08, 0xA4, 0x8B,
  0xA9, 0x52, 0x65, 0x10, 0x91, 0x09, 0x11, 0x11, 0x11, 0x22, 0x0E, 0x38,
  0x11, 0x04, 0x21, 0x08, 0x44, 0x0A, 0x01, 0x01, 0xA0, 0x88, 0x61, 0x28,
  0x2A, 0x04, 0x82, 0x9F, 0x10, 0xF8, 0x25, 0x29, 0x24, 0x92, 0x49, 0x12,
  0x20, 0x91, 0x22, 0x49, 0x24, 0x92, 0x92, 0x80, 0x10, 0x23, 0xF8, 0x82,
  0x88, 0x80, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0xF0,
  0xF0, 0x80, 0x04, 0x10, 0x82, 0x08, 0x41, 0x08, 0x20, 0x84, 0x10, 0x42,
  0x00, 0x3C, 0x42, 0x42, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82,
  0x82, 0x42, 0x3C, 0x17, 0x91, 0x11, 0x11, 0x11, 0x11, 0x11, 0x79, 0x08,
  0x08, 0x10, 0x20, 0x41, 0x02, 0x08, 0x20, 0x81, 0x04, 0x1F, 0xC0, 0x79,
  0x0C, 0x08, 0x10, 0x20, 0x4F, 0x02, 0x02, 0x04, 0x08, 0x10, 0x3F, 0x80,
  0x02, 0x01, 0x01, 0x81, 0x40, 0xA0, 0x90, 0x88, 0x44, 0x42, 0x21, 0x2F,
  0xE0, 0x40, 0x20, 0x10, 0x7E, 0x40, 0x40, 0x40, 0x80, 0x80, 0x7C, 0x02,
  0x01, 0x01, 0x01, 0x02, 0x02, 0xFC, 0x1E, 0x20, 0x40, 0x40, 0x80, 0x98,
  0xE6, 0x82, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0xFF, 0x02, 0x02, 0x02,
  0x04, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x3C, 0x42,
  0x82, 0x82, 0x82, 0x44, 0x38, 0x24, 0x42, 0x81, 0x81, 0x81, 0x82, 0x7C,
  0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xA3, 0x3A, 0x04, 0x08, 0x10, 0x5F,
  0x00, 0x80, 0x40, 0x80, 0xF0, 0x03, 0x0C, 0x30, 0x40, 0xC0, 0x30, 0x0C,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x18, 0x06, 0x03, 0x0C,
  0x30, 0xC0, 0xF0, 0x42, 0x10, 0x84, 0x44, 0x42, 0x10, 0x00, 0x20, 0x1F,
  0xC1, 0x01, 0x10, 0x04, 0x8E, 0x18, 0x88, 0xC4, 0x46, 0x42, 0x32, 0x11,
  0x90, 0x8C, 0x44, 0xA1, 0xD8, 0x80, 0x04, 0x00, 0x10, 0x00, 0x7E, 0x00,
  0x08, 0x03, 0x00, 0xC0, 0x50, 0x12, 0x04, 0x82, 0x20, 0x84, 0x3F, 0x10,
  0x44, 0x09, 0x02, 0x80, 0xA0, 0x10, 0xF9, 0x0E, 0x0C, 0x18, 0x30, 0x7F,
  0x42, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0x80, 0x0F, 0x18, 0x50, 0x08, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x08, 0x02, 0x00, 0xFC, 0xF8,
  0x86, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82,
  0xFC, 0xFE, 0x08, 0x20, 0x82, 0x0F, 0xE0, 0x82, 0x08, 0x20, 0x83, 0xF0,
  0xFE, 0x08, 0x20, 0x82, 0x08, 0x3F, 0x82, 0x08, 0x20, 0x82, 0x00, 0x0F,
  0x8C, 0x14, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x1F, 0x80, 0x60, 0x18,
  0x05, 0x01, 0x20, 0x47, 0xF0, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xE9, 0x24, 0x92, 0x49, 0x25,
  0xC0, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x83, 0x0A,
  0x14, 0x49, 0x14, 0x38, 0x50, 0x91, 0x12, 0x24, 0x28, 0x30, 0x40, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0xF0, 0x80, 0x30,
  0x06, 0x01, 0xE0, 0x3C, 0x0B, 0x41, 0x68, 0x2D, 0x09, 0x91, 0x32, 0x46,
  0x28, 0xC5, 0x18, 0xC3, 0x08, 0x40, 0x81, 0x81, 0x81, 0xC1, 0xA1, 0xA1,
  0x91, 0x89, 0x89, 0x85, 0x85, 0x83, 0x81, 0x81, 0x1F, 0x04, 0x11, 0x01,
  0x40, 0x28, 0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x20,
  0x24, 0x08, 0x7E, 0x00, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x61, 0x7C, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x00, 0x1F, 0x04, 0x11, 0x01, 0x40, 0x28, 0x05,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x20, 0x24, 0x08, 0x7A,
  0x00, 0x80, 0x08, 0x01, 0x80, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x61, 0x7C,
  0x91, 0x12, 0x14, 0x28, 0x30, 0x40, 0x3E, 0x82, 0x04, 0x08, 0x10, 0x18,
  0x0E, 0x02, 0x04, 0x08, 0x10, 0x3F, 0x80, 0xFF, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x7E, 0x80,
  0xC0, 0x60, 0x28, 0x14, 0x12, 0x08, 0x84, 0x44, 0x22, 0x09, 0x05, 0x02,
  0x80, 0x80, 0x40, 0x81, 0x03, 0x02, 0x05, 0x0C, 0x12, 0x14, 0x24, 0x28,
  0x48, 0x50, 0x89, 0x22, 0x12, 0x24, 0x24, 0x48, 0x48, 0xA0, 0x61, 0x40,
  0xC1, 0x81, 0x82, 0x01, 0x04, 0x00, 0x81, 0x41, 0x42, 0x22, 0x24, 0x14,
  0x08, 0x08, 0x14, 0x24, 0x22, 0x42, 0x41, 0x81, 0x81, 0x81, 0x41, 0x42,
  0x22, 0x24, 0x14, 0x18, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFE, 0x02,
  0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0xFF,
  0xF2, 0x49, 0x24, 0x92, 0x49, 0x24, 0xE0, 0x82, 0x04, 0x10, 0x20, 0x82,
  0x04, 0x10, 0x40, 0x82, 0x04, 0x10, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x49,
  0xE0, 0x10, 0x18, 0x28, 0x24, 0x44, 0x42, 0x82, 0x81, 0xFE, 0x91, 0x80,
  0x78, 0x10, 0x41, 0x3D, 0x18, 0x61, 0x85, 0xF0, 0x81, 0x02, 0x04, 0x0F,
  0xD0, 0xA0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x5F, 0x00, 0x3D, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x40, 0xF0, 0x02, 0x04, 0x08, 0x13, 0xE8, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x2F, 0xC0, 0x3C, 0x86, 0x0C, 0x1F, 0xF0, 0x20,
  0x40, 0x40, 0x7C, 0x1C, 0x82, 0x08, 0x23, 0xC2, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x00, 0x3E, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x42, 0x7C,
  0x08, 0x10, 0x30, 0xDE, 0x00, 0x82, 0x08, 0x20, 0xFA, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x10, 0xCF, 0xFC, 0x24, 0x02, 0x49, 0x24, 0x92, 0x49,
  0x27, 0x00, 0x82, 0x08, 0x20, 0x8A, 0x49, 0x28, 0xC2, 0x89, 0x24, 0x8A,
  0x10, 0xFF, 0xFC, 0xFB, 0xD0, 0x86, 0x10, 0xC2, 0x18, 0x43, 0x08, 0x61,
  0x0C, 0x21, 0x84, 0x30, 0x84, 0xFA, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x10, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0xFD,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x85, 0xF2, 0x04, 0x08, 0x10, 0x00,
  0x3E, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0xFC, 0x08, 0x10, 0x20,
  0x40, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x7E, 0x08, 0x20, 0x60, 0x60, 0x41,
  0x07, 0xE0, 0x42, 0x11, 0xF4, 0x21, 0x08, 0x42, 0x10, 0x83, 0x80, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x42, 0xFC, 0x83, 0x05, 0x0A, 0x24,
  0x44, 0x8A, 0x14, 0x10, 0x20, 0x82, 0x18, 0x62, 0x46, 0x24, 0x52, 0x49,
  0x24, 0x94, 0x29, 0x43, 0x0C, 0x10, 0x81, 0x08, 0x42, 0x84, 0x90, 0xC1,
  0x03, 0x09, 0x12, 0x43, 0x84, 0x83, 0x05, 0x0A, 0x24, 0x44, 0x8A, 0x14,
  0x10, 0x20, 0x40, 0x82, 0x04, 0x30, 0x00, 0xFC, 0x20, 0x84, 0x20, 0x84,
  0x10, 0x83, 0xF0, 0x19, 0x10, 0x84, 0x21, 0x08, 0x82, 0x10, 0x84, 0x21,
  0x04, 0x18, 0xFF, 0xFF, 0xE0, 0x83, 0x08, 0x42, 0x10, 0x84, 0x19, 0x08,
  0x42, 0x10, 0x84, 0xC0, 0x60, 0x9F,
};

const GFXglyph NotoSans_SemiCondensed_Thin19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 14, 4, 2, -14 },
  { 3, 4, 5, 6, 1, -14 },
  { 6, 10, 14, 11, 0, -14 },
  { 24, 7, 15, 10, 1, -14 },
  { 38, 12, 14, 14, 1, -14 },
  { 59, 10, 14, 11, 1, -14 },
  { 77, 1, 5, 3, 1, -14 },
  { 78, 3, 17, 5, 1, -14 },
  { 85, 3, 17, 5, 1, -14 },
  { 92, 7, 6, 9, 1, -14 },
  { 98, 8, 9, 10, 1, -11 },
  { 107, 1, 4, 3, 1, -2 },
  { 108, 4, 1, 6, 1, -6 },
  { 109, 1, 1, 4, 1, -1 },
  { 110, 6, 14, 6, 0, -14 },
  { 121, 8, 14, 10, 1, -14 },
  { 135, 4, 14, 10, 2, -14 },
  { 142, 7, 14, 10, 1, -14 },
  { 155, 7, 14, 10, 1, -14 },
  { 168, 9, 14, 10, 0, -14 },
  { 184, 8, 14, 10, 1, -14 },
  { 198, 8, 14, 10, 1, -14 },
  { 212, 8, 14, 10, 1, -14 },
  { 226, 8, 14, 10, 1, -14 },
  { 240, 7, 14, 10, 1, -14 },
  { 253, 1, 10, 4, 1, -10 },
  { 255, 1, 12, 4, 1, -10 },
  { 257, 8, 8, 10, 1, -11 },
  { 265, 8, 5, 10, 1, -9 },
  { 270, 8, 8, 10, 1, -11 },
  { 278, 5, 14, 7, 1, -14 },
  { 287, 13, 15, 15, 1, -13 },
  { 312, 10, 14, 10, 0, -14 },
  { 330, 7, 14, 10, 2, -14 },
  { 343, 9, 14, 10, 1, -14 },
  { 359, 8, 14, 12, 2, -14 },
  { 373, 6, 14, 9, 2, -14 },
  { 384, 6, 14, 8, 2, -14 },
  { 395, 10, 14, 12, 1, -14 },
  { 413, 8, 14, 12, 2, -14 },
  { 427, 3, 14, 5, 1, -14 },
  { 433, 4, 17, 4, -2, -14 },
  { 442, 7, 14, 9, 2, -14 },
  { 455, 6, 14, 8, 2, -14 },
  { 466, 11, 14, 15, 2, -14 },
  { 486, 8, 14, 12, 2, -14 },
  { 500, 11, 14, 13, 1, -14 },
  { 520, 7, 14, 10, 2, -14 },
  { 533, 11, 17, 13, 1, -14 },
  { 557, 7, 14, 10, 2, -14 },
  { 570, 7, 14, 9, 1, -14 },
  { 583, 8, 14, 8, 0, -14 },
  { 597, 8, 14, 12, 2, -14 },
  { 611, 9, 14, 9, 0, -14 },
  { 627, 15, 14, 15, 0, -14 },
  { 654, 8, 14, 8, 0, -14 },
  { 668, 8, 14, 8, 0, -14 },
  { 682, 8, 14, 9, 1, -14 },
  { 696, 3, 17, 6, 2, -14 },
  { 703, 6, 14, 6, 0, -14 },
  { 714, 3, 17, 6, 1, -14 },
  { 721, 8, 8, 10, 1, -14 },
  { 729, 7, 1, 7, 0, 1 },
  { 730, 3, 3, 5, 1, -15 },
  { 732, 6, 10, 9, 1, -10 },
  { 740, 7, 14, 10, 2, -14 },
  { 753, 6, 10, 8, 1, -10 },
  { 761, 7, 14, 10, 1, -14 },
  { 774, 7, 10, 9, 1, -10 },
  { 783, 6, 15, 5, 0, -15 },
  { 795, 7, 15, 10, 1, -10 },
  { 809, 6, 14, 10, 2, -14 },
  { 820, 1, 14, 4, 1, -14 },
  { 822, 3, 19, 4, -1, -14 },
  { 830, 6, 14, 8, 2, -14 },
  { 841, 1, 14, 4, 1, -14 },
  { 843, 11, 10, 15, 2, -10 },
  { 857, 6, 10, 10, 2, -10 },
  { 865, 8, 10, 10, 1, -10 },
  { 875, 7, 14, 10, 2, -10 },
  { 888, 7, 14, 10, 1, -10 },
  { 901, 4, 10, 6, 2, -10 },
  { 906, 6, 10, 8, 1, -10 },
  { 914, 5, 13, 5, 0, -13 },
  { 923, 7, 10, 10, 1, -10 },
  { 932, 7, 10, 7, 0, -10 },
  { 941, 12, 10, 12, 0, -10 },
  { 956, 7, 10, 8, 0, -10 },
  { 965, 7, 15, 7, 0, -10 },
  { 979, 6, 10, 7, 1, -10 },
  { 987, 5, 17, 6, 1, -14 },
  { 998, 1, 19, 9, 4, -14 },
  { 1001, 5, 17, 6, 1, -14 },
  { 1012, 8, 2, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_Thin19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin19pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_SEMICONDENSED_THIN19PT7B_H_
