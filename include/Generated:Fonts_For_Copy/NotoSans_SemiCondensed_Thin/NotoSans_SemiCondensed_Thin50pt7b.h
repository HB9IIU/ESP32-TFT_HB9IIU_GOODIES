#ifndef _NOTOSANS_SEMICONDENSED_THIN50PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin50pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x00,
  0x00, 0x1B, 0xF0, 0xC0, 0xA0, 0x50, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x81,
  0x40, 0xA0, 0x50, 0x28, 0x14, 0x08, 0x00, 0x30, 0x0C, 0x00, 0x08, 0x02,
  0x00, 0x02, 0x00, 0x80, 0x00, 0x80, 0x20, 0x00, 0x20, 0x08, 0x00, 0x08,
  0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x00, 0x40, 0x00, 0x40, 0x10, 0x00,
  0x10, 0x04, 0x00, 0x04, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xC0, 0x20, 0x08, 0x00, 0x08, 0x02, 0x00, 0x02, 0x00, 0x80, 0x00, 0x80,
  0x20, 0x00, 0x20, 0x18, 0x00, 0x18, 0x06, 0x00, 0x04, 0x01, 0x00, 0x01,
  0x00, 0x40, 0x00, 0x40, 0x10, 0x00, 0x10, 0x04, 0x03, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x30, 0x00, 0x20, 0x08, 0x00, 0x08, 0x02,
  0x00, 0x02, 0x00, 0x80, 0x00, 0x80, 0x20, 0x00, 0x60, 0x18, 0x00, 0x18,
  0x06, 0x00, 0x04, 0x01, 0x00, 0x01, 0x00, 0x40, 0x00, 0x40, 0x10, 0x00,
  0x10, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x03, 0xFE,
  0x01, 0xC8, 0x78, 0x61, 0x01, 0x18, 0x20, 0x06, 0x04, 0x00, 0x80, 0x80,
  0x10, 0x10, 0x02, 0x02, 0x00, 0x40, 0x40, 0x08, 0x08, 0x01, 0x01, 0x00,
  0x30, 0x20, 0x03, 0x04, 0x00, 0x30, 0x80, 0x03, 0x10, 0x00, 0x3A, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x01, 0x38, 0x00, 0x21, 0x80, 0x04, 0x0C,
  0x00, 0x80, 0x80, 0x10, 0x18, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x06,
  0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0xC0, 0x10, 0x12,
  0x02, 0x0C, 0x78, 0x47, 0x03, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x1F, 0x80, 0x03, 0x00, 0xC3, 0x00, 0x08,
  0x06, 0x04, 0x00, 0x60, 0x10, 0x18, 0x01, 0x00, 0xC0, 0x20, 0x04, 0x03,
  0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0x80, 0x20, 0x0C, 0x06, 0x00, 0x80,
  0x30, 0x10, 0x02, 0x00, 0x40, 0xC0, 0x08, 0x01, 0x02, 0x00, 0x20, 0x04,
  0x18, 0x00, 0x80, 0x10, 0x40, 0x02, 0x00, 0xC3, 0x00, 0x08, 0x03, 0x08,
  0x3C, 0x20, 0x0C, 0x63, 0x98, 0xC0, 0x21, 0x08, 0x13, 0x00, 0x8C, 0x40,
  0x64, 0x06, 0x21, 0x00, 0x98, 0x11, 0x8C, 0x02, 0x30, 0xC4, 0x20, 0x0C,
  0x7C, 0x10, 0x80, 0x30, 0x00, 0x82, 0x00, 0xC0, 0x02, 0x08, 0x01, 0x00,
  0x18, 0x20, 0x04, 0x00, 0x40, 0x80, 0x10, 0x03, 0x02, 0x00, 0x40, 0x08,
  0x08, 0x01, 0x00, 0x60, 0x20, 0x0C, 0x01, 0x00, 0x80, 0x30, 0x0C, 0x03,
  0x00, 0x80, 0x20, 0x0C, 0x02, 0x01, 0x80, 0x10, 0x18, 0x04, 0x00, 0x60,
  0x40, 0x30, 0x00, 0xC3, 0x00, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x01, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0x06, 0x00, 0x03, 0x00, 0x80, 0x01, 0x00, 0x60,
  0x01, 0x80, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x0C, 0x00, 0x80, 0x02, 0x00, 0xC0, 0x01, 0x00,
  0x40, 0x00, 0x40, 0x60, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x02,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x01, 0x00, 0x13, 0x00, 0x40, 0x09, 0x00, 0x10, 0x0D,
  0x80, 0x0C, 0x04, 0x80, 0x03, 0x02, 0x40, 0x00, 0xC3, 0x20, 0x00, 0x21,
  0x10, 0x00, 0x09, 0x88, 0x00, 0x02, 0x84, 0x00, 0x01, 0xC2, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0xD8, 0x60, 0x00, 0xC4, 0x18, 0x00, 0xC1, 0x06, 0x01,
  0xC0, 0xC1, 0xFF, 0x80, 0x30, 0x0C, 0x00, 0x00, 0xD5, 0x55, 0x55, 0x40,
  0x01, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08,
  0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x04, 0x02, 0x01, 0x80, 0xC0,
  0x20, 0x10, 0x0C, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x06, 0x01, 0x00,
  0xC0, 0x30, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04,
  0x03, 0x01, 0x80, 0x40, 0x20, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08,
  0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30,
  0x10, 0x18, 0x18, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x0C, 0x08, 0x0D, 0xE2, 0x1C, 0x0E, 0xB8,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x04, 0x80, 0x02, 0x30, 0x01, 0x04, 0x00,
  0xC0, 0x80, 0x20, 0x10, 0x10, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x01,
  0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x13, 0x33, 0x22, 0x26,
  0x44, 0xC8, 0xFF, 0xE0, 0xFC, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x03, 0xF8, 0x00, 0xC1,
  0xC0, 0x20, 0x0C, 0x08, 0x00, 0xC3, 0x00, 0x08, 0x40, 0x01, 0x98, 0x00,
  0x12, 0x00, 0x02, 0x40, 0x00, 0x68, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x05, 0x00, 0x01,
  0xA0, 0x00, 0x24, 0x00, 0x04, 0xC0, 0x00, 0x88, 0x00, 0x31, 0x80, 0x04,
  0x10, 0x01, 0x83, 0x00, 0x60, 0x38, 0x18, 0x01, 0xFE, 0x00, 0x00, 0xC0,
  0x70, 0x3C, 0x33, 0x18, 0xCC, 0x3E, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x07, 0xF8, 0x07, 0x81, 0x81,
  0x80, 0x08, 0x20, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFC, 0x01,
  0xC0, 0x70, 0x70, 0x01, 0x8C, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC8, 0x00, 0x18, 0xF0, 0x03,
  0x03, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x40, 0x00, 0x03, 0x40, 0x00, 0x02, 0x40, 0x00, 0x06, 0x40,
  0x00, 0x0C, 0x40, 0x00, 0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x30, 0x40,
  0x00, 0x20, 0x40, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x40, 0x00, 0x80, 0x40,
  0x01, 0x80, 0x40, 0x01, 0x00, 0x40, 0x02, 0x00, 0x40, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x40, 0x18, 0x00, 0x40, 0x10, 0x00, 0x40,
  0x30, 0x00, 0x40, 0x60, 0x00, 0x40, 0x40, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xE0, 0x70, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01,
  0x90, 0x00, 0x63, 0x80, 0x38, 0x1F, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x7F,
  0xC0, 0x1C, 0x04, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC1, 0xF8, 0x0C,
  0x78, 0xF0, 0x8C, 0x01, 0x89, 0x00, 0x0C, 0xA0, 0x00, 0x4E, 0x00, 0x06,
  0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x02, 0x40, 0x00, 0x26, 0x00,
  0x02, 0x20, 0x00, 0x63, 0x00, 0x04, 0x10, 0x00, 0xC1, 0x80, 0x18, 0x0E,
  0x03, 0x00, 0x3F, 0xE0, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFC, 0x01,
  0xC0, 0xC0, 0x60, 0x06, 0x18, 0x00, 0x46, 0x00, 0x0C, 0x80, 0x00, 0x90,
  0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x09, 0x80, 0x01, 0x30,
  0x00, 0x63, 0x00, 0x18, 0x30, 0x06, 0x03, 0x01, 0x80, 0x38, 0xE0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x1C, 0x70, 0x06, 0x03, 0x03, 0x00, 0x18, 0x40,
  0x01, 0x90, 0x00, 0x16, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x1A, 0x00,
  0x02, 0x60, 0x00, 0xC6, 0x00, 0x30, 0x70, 0x1C, 0x03, 0xFE, 0x00, 0x04,
  0x00, 0x03, 0xFC, 0x00, 0xE0, 0x60, 0x18, 0x01, 0x01, 0x00, 0x08, 0x20,
  0x00, 0xC2, 0x00, 0x04, 0x60, 0x00, 0x64, 0x00, 0x02, 0x40, 0x00, 0x24,
  0x00, 0x03, 0x40, 0x00, 0x3C, 0x00, 0x03, 0x40, 0x00, 0x14, 0x00, 0x03,
  0x40, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x32, 0x00, 0x05, 0x30, 0x00,
  0xD1, 0x80, 0x19, 0x0E, 0x07, 0x10, 0x3F, 0xC3, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x1C, 0x03, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x7D, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x11, 0xCE, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0xC6, 0x31, 0x08, 0xC6, 0x21,
  0x18, 0x80, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x04,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x1F, 0xE1, 0xE0, 0x71, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x02,
  0x18, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x7F, 0xC0,
  0x24, 0x00, 0xE0, 0x20, 0x1A, 0x00, 0xC0, 0x10, 0x0F, 0x00, 0x40, 0x08,
  0x03, 0x80, 0x60, 0x04, 0x01, 0x80, 0x20, 0x02, 0x00, 0xC0, 0x30, 0x01,
  0x00, 0x60, 0x10, 0x00, 0x80, 0x30, 0x08, 0x00, 0xC0, 0x18, 0x04, 0x00,
  0x60, 0x0C, 0x02, 0x00, 0x30, 0x06, 0x01, 0x00, 0x18, 0x03, 0x00, 0x80,
  0x0C, 0x01, 0x80, 0x40, 0x06, 0x01, 0xC0, 0x30, 0x07, 0x00, 0xA0, 0x18,
  0x02, 0x80, 0x58, 0x06, 0x03, 0x40, 0x4C, 0x01, 0x83, 0x30, 0x62, 0x00,
  0x7F, 0x0F, 0xE1, 0x00, 0x04, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x01, 0x20, 0x00, 0x01, 0x90, 0x00, 0x00, 0x8C, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x61, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x10, 0x20, 0x00,
  0x18, 0x10, 0x00, 0x08, 0x0C, 0x00, 0x04, 0x06, 0x00, 0x06, 0x01, 0x00,
  0x02, 0x00, 0xC0, 0x01, 0x00, 0x60, 0x01, 0x80, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x60, 0x01, 0x00, 0x3F, 0xFF, 0x80, 0x10, 0x00,
  0x60, 0x18, 0x00, 0x10, 0x08, 0x00, 0x08, 0x04, 0x00, 0x06, 0x06, 0x00,
  0x01, 0x02, 0x00, 0x00, 0x81, 0x00, 0x00, 0x61, 0x80, 0x00, 0x10, 0x80,
  0x00, 0x08, 0x40, 0x00, 0x06, 0x60, 0x00, 0x01, 0x20, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x10, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x80,
  0x03, 0x88, 0x00, 0x08, 0x80, 0x00, 0xC8, 0x00, 0x04, 0x80, 0x00, 0x68,
  0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x68, 0x00, 0x06,
  0x80, 0x00, 0x48, 0x00, 0x0C, 0x80, 0x01, 0x88, 0x00, 0x30, 0x80, 0x7E,
  0x0F, 0xFF, 0xC0, 0x80, 0x07, 0x08, 0x00, 0x0C, 0x80, 0x00, 0x48, 0x00,
  0x06, 0x80, 0x00, 0x28, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x02, 0x80, 0x00, 0x28,
  0x00, 0x04, 0x80, 0x00, 0xC8, 0x00, 0x18, 0x80, 0x0E, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x01, 0xE0, 0x3C, 0x06, 0x00, 0x10, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x30, 0x03, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x02, 0x00, 0x1C, 0x04, 0x00, 0x0E, 0x08, 0x00,
  0x06, 0x10, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x0C, 0x80, 0x00,
  0x09, 0x00, 0x00, 0x12, 0x00, 0x00, 0x34, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x50, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x40, 0x00, 0x02, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x50,
  0x00, 0x00, 0xA0, 0x00, 0x01, 0x40, 0x00, 0x02, 0x80, 0x00, 0x0D, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x24, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x90, 0x00,
  0x06, 0x20, 0x00, 0x08, 0x40, 0x00, 0x30, 0x80, 0x01, 0xC1, 0x00, 0x06,
  0x02, 0x00, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF, 0xA0, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xE8, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3C, 0x03, 0xC0,
  0x18, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x03,
  0x20, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x03, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x1E, 0x00, 0x3C, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFE, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x47, 0xF0, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x1B, 0xFC,
  0x38, 0x00, 0x80, 0x00, 0x68, 0x00, 0x0C, 0x80, 0x00, 0x88, 0x00, 0x18,
  0x80, 0x03, 0x08, 0x00, 0x60, 0x80, 0x0C, 0x08, 0x01, 0x80, 0x80, 0x30,
  0x08, 0x02, 0x00, 0x80, 0x60, 0x08, 0x0C, 0x00, 0x81, 0x80, 0x08, 0x30,
  0x00, 0x86, 0x00, 0x08, 0xC0, 0x00, 0x8E, 0x00, 0x09, 0xB0, 0x00, 0xB1,
  0x00, 0x0E, 0x18, 0x00, 0xC0, 0xC0, 0x08, 0x04, 0x00, 0x80, 0x60, 0x08,
  0x03, 0x00, 0x80, 0x10, 0x08, 0x01, 0x80, 0x80, 0x0C, 0x08, 0x00, 0x40,
  0x80, 0x06, 0x08, 0x00, 0x20, 0x80, 0x03, 0x08, 0x00, 0x18, 0x80, 0x00,
  0x88, 0x00, 0x0C, 0x80, 0x00, 0x68, 0x00, 0x03, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7A, 0x00,
  0x00, 0x07, 0xD8, 0x00, 0x00, 0x2E, 0x40, 0x00, 0x03, 0x72, 0x00, 0x00,
  0x13, 0x98, 0x00, 0x00, 0x9C, 0x40, 0x00, 0x0C, 0xE2, 0x00, 0x00, 0x47,
  0x18, 0x00, 0x02, 0x38, 0x40, 0x00, 0x31, 0xC3, 0x00, 0x01, 0x0E, 0x08,
  0x00, 0x18, 0x70, 0x40, 0x00, 0xC3, 0x83, 0x00, 0x04, 0x1C, 0x08, 0x00,
  0x60, 0xE0, 0x40, 0x02, 0x07, 0x03, 0x00, 0x10, 0x38, 0x08, 0x01, 0x81,
  0xC0, 0x60, 0x08, 0x0E, 0x01, 0x00, 0x40, 0x70, 0x08, 0x06, 0x03, 0x80,
  0x60, 0x20, 0x1C, 0x01, 0x03, 0x00, 0xE0, 0x08, 0x10, 0x07, 0x00, 0x60,
  0x80, 0x38, 0x01, 0x0C, 0x01, 0xC0, 0x0C, 0x40, 0x0E, 0x00, 0x62, 0x00,
  0x70, 0x01, 0x30, 0x03, 0x80, 0x0D, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xA0, 0x00, 0x0E, 0xC0, 0x00, 0x39,
  0x80, 0x00, 0xE2, 0x00, 0x03, 0x8C, 0x00, 0x0E, 0x10, 0x00, 0x38, 0x60,
  0x00, 0xE0, 0xC0, 0x03, 0x81, 0x00, 0x0E, 0x06, 0x00, 0x38, 0x08, 0x00,
  0xE0, 0x30, 0x03, 0x80, 0x40, 0x0E, 0x00, 0x80, 0x38, 0x03, 0x00, 0xE0,
  0x04, 0x03, 0x80, 0x18, 0x0E, 0x00, 0x20, 0x38, 0x00, 0x40, 0xE0, 0x01,
  0x83, 0x80, 0x02, 0x0E, 0x00, 0x0C, 0x38, 0x00, 0x10, 0xE0, 0x00, 0x63,
  0x80, 0x00, 0xCE, 0x00, 0x01, 0x38, 0x00, 0x06, 0xE0, 0x00, 0x0B, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x7F,
  0xC0, 0x00, 0x38, 0x0F, 0x00, 0x0C, 0x00, 0x30, 0x02, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x30, 0x30, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x04, 0x20, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x20,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x09, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x62, 0x00, 0x00, 0x08,
  0x60, 0x00, 0x01, 0x04, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x18, 0x0C, 0x00,
  0x06, 0x00, 0xC0, 0x01, 0x80, 0x0E, 0x00, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x40, 0x00, 0xFF, 0xC0, 0x3F, 0xFE, 0x08, 0x00, 0xE2, 0x00, 0x0C,
  0x80, 0x01, 0xA0, 0x00, 0x28, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0A, 0x00, 0x06, 0x80, 0x01, 0x20, 0x00, 0xC8, 0x00, 0xE3, 0xFF, 0xE0,
  0xFF, 0x80, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0x0C, 0x00, 0x30, 0x02, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x30, 0x30, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x08, 0x60, 0x00, 0x01, 0x04, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18,
  0x0C, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x80, 0x06, 0x08, 0x00, 0x30, 0x80, 0x01, 0x88, 0x00, 0x08, 0x80,
  0x00, 0xC8, 0x00, 0x0C, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x48,
  0x00, 0x04, 0x80, 0x00, 0xC8, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x18,
  0x80, 0x03, 0x08, 0x00, 0x60, 0x80, 0x38, 0x0F, 0xFE, 0x00, 0x80, 0x60,
  0x08, 0x03, 0x00, 0x80, 0x10, 0x08, 0x01, 0x80, 0x80, 0x08, 0x08, 0x00,
  0xC0, 0x80, 0x04, 0x08, 0x00, 0x60, 0x80, 0x02, 0x08, 0x00, 0x30, 0x80,
  0x01, 0x08, 0x00, 0x18, 0x80, 0x00, 0xC8, 0x00, 0x04, 0x80, 0x00, 0x68,
  0x00, 0x03, 0x03, 0xFE, 0x01, 0xC0, 0x78, 0xE0, 0x01, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x63, 0x00,
  0x38, 0x3F, 0xFC, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0A, 0x00, 0x00, 0x14, 0x00, 0x00, 0x68, 0x00, 0x00, 0x98,
  0x00, 0x01, 0x18, 0x00, 0x06, 0x10, 0x00, 0x18, 0x30, 0x00, 0x60, 0x18,
  0x03, 0x80, 0x1F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x90, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x66, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x18, 0x60, 0x00, 0x08, 0x10, 0x00, 0x04,
  0x08, 0x00, 0x06, 0x06, 0x00, 0x02, 0x01, 0x00, 0x01, 0x00, 0x80, 0x01,
  0x80, 0x60, 0x00, 0x80, 0x10, 0x00, 0x40, 0x08, 0x00, 0x60, 0x06, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x18, 0x00, 0x60, 0x08, 0x00, 0x10,
  0x04, 0x00, 0x08, 0x06, 0x00, 0x06, 0x02, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x60, 0x80, 0x00, 0x30, 0x40, 0x00, 0x08, 0x60, 0x00,
  0x04, 0x20, 0x00, 0x03, 0x10, 0x00, 0x00, 0x98, 0x00, 0x00, 0x48, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x50, 0x00,
  0x1C, 0x00, 0x06, 0x80, 0x00, 0xA0, 0x00, 0x36, 0x00, 0x05, 0x00, 0x01,
  0x30, 0x00, 0x2C, 0x00, 0x08, 0x80, 0x03, 0x60, 0x00, 0xC4, 0x00, 0x19,
  0x00, 0x06, 0x30, 0x00, 0x88, 0x00, 0x21, 0x80, 0x04, 0x60, 0x01, 0x04,
  0x00, 0x63, 0x00, 0x18, 0x20, 0x03, 0x08, 0x00, 0x81, 0x80, 0x10, 0x40,
  0x04, 0x0C, 0x00, 0x83, 0x00, 0x20, 0x20, 0x0C, 0x18, 0x03, 0x01, 0x00,
  0x60, 0x40, 0x10, 0x0C, 0x02, 0x02, 0x00, 0x80, 0x60, 0x10, 0x18, 0x04,
  0x01, 0x01, 0x80, 0xC0, 0x60, 0x08, 0x0C, 0x02, 0x02, 0x00, 0x60, 0x40,
  0x10, 0x10, 0x03, 0x02, 0x00, 0xC1, 0x80, 0x08, 0x30, 0x06, 0x0C, 0x00,
  0x41, 0x80, 0x10, 0x40, 0x03, 0x08, 0x00, 0x82, 0x00, 0x18, 0x40, 0x04,
  0x30, 0x00, 0x42, 0x00, 0x31, 0x80, 0x02, 0x30, 0x00, 0x88, 0x00, 0x19,
  0x00, 0x04, 0x40, 0x00, 0xC8, 0x00, 0x26, 0x00, 0x02, 0x40, 0x01, 0xB0,
  0x00, 0x16, 0x00, 0x05, 0x00, 0x00, 0xE0, 0x00, 0x28, 0x00, 0x07, 0x00,
  0x01, 0x40, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x0C, 0x80, 0x00, 0x63, 0x00, 0x01, 0x06, 0x00, 0x0C, 0x08,
  0x00, 0x20, 0x30, 0x01, 0x80, 0x40, 0x04, 0x01, 0x80, 0x30, 0x02, 0x00,
  0x80, 0x0C, 0x06, 0x00, 0x10, 0x30, 0x00, 0x60, 0x80, 0x00, 0x86, 0x00,
  0x03, 0x10, 0x00, 0x04, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x4C, 0x00, 0x03, 0x10,
  0x00, 0x08, 0x60, 0x00, 0x60, 0x80, 0x01, 0x03, 0x00, 0x08, 0x04, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x30, 0x0C, 0x00, 0x40, 0x20, 0x01, 0x81, 0x80,
  0x02, 0x04, 0x00, 0x0C, 0x30, 0x00, 0x11, 0x80, 0x00, 0x64, 0x00, 0x00,
  0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x24, 0x00, 0x01, 0x98,
  0x00, 0x04, 0x20, 0x00, 0x30, 0xC0, 0x00, 0x81, 0x00, 0x06, 0x06, 0x00,
  0x10, 0x08, 0x00, 0x40, 0x30, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x60,
  0x02, 0x01, 0x00, 0x0C, 0x0C, 0x00, 0x10, 0x20, 0x00, 0x61, 0x80, 0x00,
  0x84, 0x00, 0x02, 0x30, 0x00, 0x04, 0x80, 0x00, 0x16, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x07, 0xFF, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x12, 0x00, 0x00, 0xCC, 0x00,
  0x02, 0x10, 0x00, 0x18, 0x60, 0x00, 0x40, 0x80, 0x02, 0x03, 0x00, 0x08,
  0x04, 0x00, 0x40, 0x18, 0x03, 0x00, 0x20, 0x08, 0x00, 0xC0, 0x60, 0x01,
  0x01, 0x00, 0x06, 0x0C, 0x00, 0x08, 0x20, 0x00, 0x31, 0x80, 0x00, 0x44,
  0x00, 0x01, 0xB0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0xC0, 0x60, 0x30, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x01, 0xF0, 0x0F, 0xDE, 0x0C, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x07, 0xF8, 0x3F, 0x04, 0x70, 0x02,
  0x60, 0x01, 0x60, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0A, 0x80, 0x05, 0x60, 0x04, 0x98, 0x0C, 0x47,
  0xFC, 0x20, 0x20, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x1F, 0x80, 0x87, 0x8E,
  0x08, 0xC0, 0x30, 0x90, 0x01, 0x8B, 0x00, 0x0C, 0xA0, 0x00, 0x4E, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0x80,
  0x00, 0x28, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x28,
  0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x06,
  0xC0, 0x00, 0x4A, 0x00, 0x0C, 0xB0, 0x00, 0x89, 0x80, 0x10, 0x8C, 0x06,
  0x08, 0x7F, 0xC0, 0x00, 0x40, 0x00, 0x00, 0xFC, 0x03, 0xC7, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x01, 0x03, 0xFF,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0xFC, 0x10, 0x71, 0xE2, 0x38, 0x06, 0x44,
  0x00, 0x69, 0x00, 0x05, 0x60, 0x00, 0xE8, 0x00, 0x0D, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x40, 0x00, 0x6C, 0x00, 0x14, 0x80,
  0x02, 0x98, 0x00, 0x91, 0xC0, 0x62, 0x0F, 0xF8, 0x40, 0x10, 0x00, 0x01,
  0xF0, 0x01, 0xC7, 0x00, 0xC0, 0x60, 0x40, 0x04, 0x30, 0x01, 0x98, 0x00,
  0x24, 0x00, 0x0D, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x43, 0x00, 0x60, 0x7F, 0xF0,
  0x01, 0x80, 0x01, 0xFC, 0x0C, 0x10, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0xFF,
  0xE0, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x01, 0xF8, 0x00,
  0xF3, 0xC4, 0x60, 0x0C, 0x98, 0x00, 0xD2, 0x00, 0x0A, 0xC0, 0x00, 0xD0,
  0x00, 0x1A, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x06, 0x80,
  0x00, 0xD8, 0x00, 0x29, 0x00, 0x0D, 0x10, 0x03, 0x23, 0x80, 0xC4, 0x1F,
  0xF0, 0x80, 0x60, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x44, 0x00,
  0x30, 0xF8, 0x1C, 0x03, 0xFE, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x07, 0xE0, 0x87, 0x9E, 0x23,
  0x00, 0xC9, 0x00, 0x12, 0x80, 0x06, 0xA0, 0x00, 0xB0, 0x00, 0x2C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02,
  0x02, 0x02, 0x06, 0x8C, 0xF8, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x06, 0x80, 0x0C, 0x80, 0x08, 0x80,
  0x10, 0x80, 0x30, 0x80, 0x60, 0x80, 0xC0, 0x80, 0x80, 0x81, 0x00, 0x83,
  0x00, 0x86, 0x00, 0x8E, 0x00, 0x89, 0x00, 0x91, 0x80, 0xA0, 0x80, 0xE0,
  0xC0, 0xC0, 0x60, 0x80, 0x20, 0x80, 0x30, 0x80, 0x10, 0x80, 0x18, 0x80,
  0x0C, 0x80, 0x04, 0x80, 0x06, 0x80, 0x02, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x0F, 0xC2, 0x3C,
  0xE0, 0xF3, 0xC9, 0x80, 0xC6, 0x01, 0xAC, 0x01, 0x90, 0x02, 0xA0, 0x02,
  0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x70, 0x00, 0x40,
  0x01, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x04, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x40, 0x01, 0x80, 0x01, 0x00, 0x06, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x40, 0x01, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x10, 0x00, 0x60, 0x00, 0x40, 0x01, 0x80, 0x01,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x18, 0x00, 0x10, 0x00, 0x60, 0x00, 0x40,
  0x01, 0x80, 0x01, 0x00, 0x06, 0x00, 0x04, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x40, 0x01, 0xF8, 0x21, 0xC7, 0x88, 0xC0, 0x32, 0x40, 0x06, 0xA0, 0x01,
  0xA8, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x01, 0xF8, 0x00, 0x71, 0xE0, 0x18, 0x03, 0x01, 0x00, 0x18,
  0x20, 0x00, 0xC6, 0x00, 0x04, 0x40, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00,
  0x28, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x2C, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x06, 0x60, 0x00, 0x43,
  0x00, 0x0C, 0x18, 0x01, 0x80, 0xC0, 0x70, 0x07, 0xFC, 0x00, 0x04, 0x00,
  0x01, 0xF8, 0x08, 0x78, 0xE0, 0x8C, 0x03, 0x09, 0x80, 0x18, 0xB0, 0x00,
  0xCA, 0x00, 0x04, 0xE0, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00,
  0x02, 0xC0, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x2C,
  0x00, 0x02, 0xC0, 0x00, 0x6A, 0x00, 0x04, 0xA0, 0x00, 0xCB, 0x00, 0x08,
  0x98, 0x01, 0x88, 0xC0, 0x70, 0x87, 0xFC, 0x0C, 0x04, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0xF3, 0xC4, 0x70, 0x0C, 0x98, 0x00, 0xD2,
  0x00, 0x0A, 0xC0, 0x01, 0xD0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x06, 0x80, 0x01, 0xD8, 0x00, 0x29, 0x00, 0x0D, 0x30,
  0x03, 0x23, 0x80, 0xC4, 0x1F, 0xF0, 0x80, 0x20, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x01,
  0xE8, 0x7F, 0x98, 0x09, 0x00, 0xA0, 0x0A, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x00, 0x03, 0xF8, 0x1E, 0x3F, 0x30, 0x02, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x06, 0xE0, 0x0C, 0x7F, 0xF8, 0x01, 0x00,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x0F, 0xFF,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x07, 0xF0, 0x08, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0D, 0x00, 0x0A, 0xC0, 0x09, 0x30, 0x1C, 0x8F, 0xF8, 0x40, 0x40,
  0x00, 0xC0, 0x00, 0x68, 0x00, 0x09, 0x00, 0x01, 0x30, 0x00, 0x62, 0x00,
  0x08, 0x40, 0x01, 0x0C, 0x00, 0x60, 0x80, 0x08, 0x10, 0x01, 0x03, 0x00,
  0x60, 0x20, 0x08, 0x04, 0x01, 0x00, 0xC0, 0x60, 0x08, 0x08, 0x01, 0x01,
  0x00, 0x30, 0x60, 0x02, 0x08, 0x00, 0x41, 0x00, 0x0C, 0x60, 0x00, 0x88,
  0x00, 0x11, 0x00, 0x03, 0x60, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xE0,
  0x00, 0x08, 0x00, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01,
  0xC0, 0x06, 0x80, 0x0B, 0x00, 0x24, 0x00, 0x48, 0x01, 0x30, 0x02, 0x40,
  0x08, 0x80, 0x32, 0x00, 0xC4, 0x01, 0x18, 0x04, 0x20, 0x08, 0x40, 0x21,
  0x80, 0xC2, 0x01, 0x04, 0x04, 0x18, 0x18, 0x20, 0x20, 0x40, 0x81, 0x01,
  0x02, 0x04, 0x0C, 0x18, 0x10, 0x20, 0x20, 0x80, 0xC3, 0x01, 0x04, 0x02,
  0x10, 0x08, 0x60, 0x10, 0x80, 0x62, 0x00, 0xC4, 0x01, 0x10, 0x06, 0x60,
  0x09, 0x80, 0x12, 0x00, 0x6C, 0x00, 0x90, 0x01, 0x40, 0x06, 0x80, 0x0A,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC4, 0x00, 0x30, 0xC0, 0x04, 0x0C, 0x01, 0x80,
  0x80, 0x20, 0x18, 0x0C, 0x01, 0x03, 0x00, 0x30, 0x40, 0x03, 0x18, 0x00,
  0x22, 0x00, 0x06, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x6C, 0x00, 0x08, 0x80, 0x03, 0x18, 0x00, 0xC1, 0x00, 0x10, 0x30, 0x06,
  0x03, 0x00, 0x80, 0x20, 0x20, 0x06, 0x0C, 0x00, 0x41, 0x00, 0x04, 0x60,
  0x00, 0xD8, 0x00, 0x0C, 0xC0, 0x00, 0x28, 0x00, 0x0D, 0x80, 0x01, 0x10,
  0x00, 0x22, 0x00, 0x0C, 0x60, 0x01, 0x04, 0x00, 0x20, 0x80, 0x0C, 0x18,
  0x01, 0x01, 0x00, 0x20, 0x20, 0x0C, 0x06, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x0C, 0x01, 0x81, 0x00, 0x10, 0x20, 0x02, 0x0C, 0x00, 0x61, 0x00, 0x04,
  0x20, 0x00, 0x8C, 0x00, 0x19, 0x00, 0x01, 0x20, 0x00, 0x2C, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x08, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x38, 0x07, 0xC0, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x78, 0x03,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x78, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0x07, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x30, 0x01, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x3C, 0x01, 0xE0, 0x18, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x0F, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x01, 0xDF, 0x00, 0x70, 0x0E, 0x07, 0x00, 0x1F, 0xC0,
  0x00, 0x10, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Thin50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 36, 11, 4, -36 },
  { 15, 9, 13, 16, 3, -36 },
  { 30, 26, 36, 28, 1, -36 },
  { 147, 19, 41, 25, 3, -38 },
  { 245, 30, 37, 36, 3, -36 },
  { 384, 25, 37, 29, 3, -36 },
  { 500, 2, 13, 8, 3, -36 },
  { 504, 9, 44, 13, 2, -36 },
  { 554, 9, 44, 13, 2, -36 },
  { 604, 18, 17, 24, 3, -38 },
  { 643, 21, 23, 25, 2, -29 },
  { 704, 4, 12, 9, 2, -6 },
  { 710, 11, 1, 15, 2, -14 },
  { 712, 2, 3, 10, 4, -3 },
  { 713, 14, 36, 16, 1, -36 },
  { 776, 19, 36, 25, 3, -36 },
  { 862, 10, 36, 25, 5, -36 },
  { 907, 19, 36, 25, 3, -36 },
  { 993, 20, 37, 25, 2, -36 },
  { 1086, 24, 36, 25, 1, -36 },
  { 1194, 19, 37, 25, 3, -36 },
  { 1282, 20, 37, 25, 3, -36 },
  { 1375, 19, 36, 25, 3, -36 },
  { 1461, 19, 37, 25, 3, -36 },
  { 1549, 20, 37, 25, 2, -36 },
  { 1642, 2, 27, 10, 4, -27 },
  { 1649, 5, 33, 10, 2, -27 },
  { 1670, 21, 22, 25, 2, -29 },
  { 1728, 21, 11, 25, 2, -23 },
  { 1757, 21, 22, 25, 2, -29 },
  { 1815, 15, 36, 18, 1, -36 },
  { 1883, 33, 41, 39, 3, -36 },
  { 2053, 25, 36, 25, 0, -36 },
  { 2166, 20, 36, 27, 5, -36 },
  { 2256, 23, 37, 27, 3, -36 },
  { 2363, 23, 36, 31, 5, -36 },
  { 2467, 17, 36, 24, 5, -36 },
  { 2544, 17, 36, 22, 5, -36 },
  { 2621, 26, 37, 32, 3, -36 },
  { 2742, 22, 36, 31, 5, -36 },
  { 2841, 7, 36, 13, 3, -36 },
  { 2873, 10, 45, 11, -4, -36 },
  { 2930, 20, 36, 25, 5, -36 },
  { 3020, 16, 36, 22, 5, -36 },
  { 3092, 29, 36, 38, 5, -36 },
  { 3223, 22, 36, 31, 5, -36 },
  { 3322, 27, 37, 33, 3, -36 },
  { 3447, 18, 36, 25, 5, -36 },
  { 3528, 27, 45, 33, 3, -36 },
  { 3680, 20, 36, 26, 5, -36 },
  { 3770, 19, 37, 24, 3, -36 },
  { 3858, 22, 36, 22, 0, -36 },
  { 3957, 23, 37, 31, 4, -36 },
  { 4064, 25, 36, 25, 0, -36 },
  { 4177, 37, 36, 39, 1, -36 },
  { 4344, 22, 36, 22, 0, -36 },
  { 4443, 22, 36, 22, 0, -36 },
  { 4542, 21, 36, 24, 2, -36 },
  { 4637, 10, 44, 16, 4, -36 },
  { 4692, 14, 36, 16, 1, -36 },
  { 4755, 10, 44, 16, 1, -36 },
  { 4810, 22, 20, 25, 2, -36 },
  { 4865, 20, 1, 20, 0, 5 },
  { 4868, 8, 8, 12, 2, -38 },
  { 4876, 17, 28, 23, 2, -27 },
  { 4936, 20, 39, 26, 4, -38 },
  { 5034, 16, 28, 21, 3, -27 },
  { 5090, 19, 39, 26, 3, -38 },
  { 5183, 18, 28, 24, 3, -27 },
  { 5246, 14, 38, 13, 1, -38 },
  { 5313, 19, 39, 26, 3, -27 },
  { 5406, 18, 38, 26, 4, -38 },
  { 5492, 2, 36, 10, 4, -36 },
  { 5501, 8, 48, 10, -2, -36 },
  { 5549, 16, 38, 20, 4, -38 },
  { 5625, 2, 38, 10, 4, -38 },
  { 5635, 30, 27, 38, 4, -27 },
  { 5737, 18, 27, 26, 4, -27 },
  { 5798, 20, 28, 26, 3, -27 },
  { 5868, 20, 39, 26, 4, -27 },
  { 5966, 19, 39, 26, 3, -27 },
  { 6059, 12, 27, 17, 4, -27 },
  { 6100, 16, 28, 20, 2, -27 },
  { 6156, 12, 34, 14, 1, -33 },
  { 6207, 17, 27, 26, 4, -26 },
  { 6265, 19, 26, 19, 0, -26 },
  { 6327, 29, 26, 31, 1, -26 },
  { 6422, 19, 26, 21, 1, -26 },
  { 6484, 19, 38, 19, 0, -26 },
  { 6575, 15, 26, 19, 2, -26 },
  { 6624, 13, 44, 17, 2, -36 },
  { 6696, 2, 50, 24, 11, -38 },
  { 6709, 13, 44, 17, 2, -36 },
  { 6781, 21, 5, 25, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_Thin50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin50pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_SEMICONDENSED_THIN50PT7B_H_
