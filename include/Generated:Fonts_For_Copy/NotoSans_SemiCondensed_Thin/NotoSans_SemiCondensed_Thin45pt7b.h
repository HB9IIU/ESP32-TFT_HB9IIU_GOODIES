#ifndef _NOTOSANS_SEMICONDENSED_THIN45PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin45pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x00, 0x2F, 0xC3, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x00, 0x40, 0x20, 0x00,
  0x80, 0x40, 0x01, 0x00, 0x80, 0x02, 0x01, 0x00, 0x0C, 0x06, 0x00, 0x10,
  0x08, 0x00, 0x20, 0x10, 0x00, 0x40, 0x20, 0x00, 0x80, 0x40, 0x01, 0x00,
  0x80, 0xFF, 0xFF, 0xF8, 0x08, 0x04, 0x00, 0x10, 0x08, 0x00, 0x20, 0x10,
  0x00, 0x40, 0x20, 0x00, 0x80, 0x40, 0x03, 0x01, 0x80, 0x04, 0x02, 0x00,
  0x08, 0x04, 0x00, 0x10, 0x08, 0x00, 0x20, 0x10, 0x1F, 0xFF, 0xFF, 0x80,
  0x80, 0xC0, 0x03, 0x01, 0x00, 0x04, 0x02, 0x00, 0x08, 0x04, 0x00, 0x10,
  0x08, 0x00, 0x20, 0x10, 0x00, 0x40, 0x20, 0x01, 0x80, 0xC0, 0x02, 0x01,
  0x00, 0x04, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x7C, 0x01, 0xF7,
  0xC1, 0x08, 0x31, 0x04, 0x01, 0x02, 0x00, 0x81, 0x00, 0xC0, 0x80, 0x60,
  0x40, 0x30, 0x20, 0x18, 0x10, 0x04, 0x08, 0x03, 0x04, 0x00, 0xC2, 0x00,
  0x31, 0x00, 0x06, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x13, 0x80, 0x08,
  0x60, 0x04, 0x18, 0x02, 0x06, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40,
  0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x08, 0x02, 0x0D, 0xC1, 0x1C,
  0x3F, 0xF8, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x40, 0x30, 0xC0, 0x08, 0x02, 0x04, 0x00,
  0x80, 0x40, 0x60, 0x18, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x30, 0x04,
  0x02, 0x02, 0x00, 0xC0, 0x20, 0x60, 0x0C, 0x02, 0x04, 0x00, 0xC0, 0x20,
  0xC0, 0x0C, 0x02, 0x08, 0x00, 0xC0, 0x20, 0x80, 0x04, 0x02, 0x10, 0x70,
  0x40, 0x21, 0x19, 0x84, 0x02, 0x23, 0x04, 0x40, 0x62, 0x20, 0x62, 0x04,
  0x46, 0x02, 0x30, 0xC4, 0x40, 0x21, 0xF8, 0x84, 0x02, 0x04, 0x08, 0x40,
  0x20, 0x01, 0x84, 0x03, 0x00, 0x10, 0x40, 0x30, 0x03, 0x04, 0x03, 0x00,
  0x20, 0x40, 0x30, 0x06, 0x04, 0x03, 0x00, 0x40, 0x40, 0x20, 0x0C, 0x04,
  0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x06, 0x02, 0x01, 0x00, 0x20, 0x40,
  0x10, 0x03, 0x0C, 0x02, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x10, 0x10, 0x00, 0x40, 0x30, 0x00, 0x80, 0x20, 0x03, 0x00, 0x40,
  0x06, 0x00, 0xC0, 0x0C, 0x01, 0x00, 0x08, 0x02, 0x00, 0x10, 0x04, 0x00,
  0x20, 0x18, 0x00, 0x20, 0x20, 0x00, 0x60, 0x80, 0x00, 0x42, 0x00, 0x00,
  0x58, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x60,
  0x80, 0x09, 0x80, 0x80, 0x26, 0x00, 0x80, 0x48, 0x01, 0x80, 0x90, 0x01,
  0x83, 0x60, 0x01, 0x84, 0xC0, 0x01, 0x09, 0x80, 0x01, 0x23, 0x00, 0x01,
  0xC2, 0x00, 0x01, 0x04, 0x00, 0x07, 0x0C, 0x00, 0x13, 0x0C, 0x00, 0x42,
  0x0C, 0x03, 0x02, 0x0F, 0xF8, 0x02, 0xEA, 0xAA, 0xA8, 0x03, 0x06, 0x04,
  0x08, 0x18, 0x10, 0x10, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0x40,
  0x40, 0x40, 0x60, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x06, 0x03,
  0xC0, 0x40, 0x20, 0x30, 0x10, 0x18, 0x08, 0x08, 0x04, 0x04, 0x04, 0x06,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x08, 0x08, 0x18, 0x10, 0x30,
  0x20, 0x40, 0xC0, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x81, 0x02, 0xF1, 0x1F, 0x0F, 0x60, 0x01, 0x80, 0x02, 0x80, 0x06,
  0x40, 0x04, 0x60, 0x08, 0x20, 0x10, 0x10, 0x30, 0x08, 0x00, 0x08, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x03, 0xFF,
  0xFF, 0x80, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x32,
  0x22, 0x64, 0x44, 0xC8, 0x80, 0xFF, 0xC0, 0xBC, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00,
  0x01, 0xC0, 0x07, 0xFC, 0x06, 0x03, 0x06, 0x00, 0x82, 0x00, 0x23, 0x00,
  0x19, 0x00, 0x04, 0x80, 0x02, 0xC0, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x90, 0x00, 0x48, 0x00, 0x26,
  0x00, 0x21, 0x00, 0x10, 0x40, 0x10, 0x10, 0x10, 0x07, 0xF0, 0x00, 0x01,
  0x81, 0xC1, 0xA3, 0x13, 0x0B, 0x07, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01,
  0x80, 0x03, 0xFE, 0x03, 0x00, 0xC1, 0x80, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xC0, 0x07, 0xFE, 0x03, 0x00, 0x63, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x33,
  0x80, 0x38, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x40, 0x00, 0x1A, 0x00, 0x00, 0x90, 0x00, 0x08, 0x80, 0x00, 0xC4, 0x00,
  0x04, 0x20, 0x00, 0x41, 0x00, 0x06, 0x08, 0x00, 0x20, 0x40, 0x02, 0x02,
  0x00, 0x30, 0x10, 0x01, 0x00, 0x80, 0x18, 0x04, 0x00, 0x80, 0x20, 0x08,
  0x01, 0x00, 0xC0, 0x08, 0x04, 0x00, 0x40, 0x40, 0x02, 0x06, 0x00, 0x10,
  0x20, 0x00, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x3F, 0xFE, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0xFF, 0x81, 0x80,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x24, 0x00, 0x33, 0x00, 0x60, 0xFF,
  0xE0, 0x00, 0x18, 0x00, 0xFF, 0x81, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x0F, 0x02, 0x3C, 0xF1, 0x30, 0x0C, 0xA0,
  0x03, 0x70, 0x00, 0xB0, 0x00, 0x78, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x50, 0x00, 0x28, 0x00,
  0x16, 0x00, 0x11, 0x00, 0x08, 0x40, 0x08, 0x30, 0x18, 0x07, 0xF8, 0x00,
  0x40, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x01, 0xFF, 0x00, 0x80, 0x60, 0x40, 0x04, 0x20,
  0x01, 0x88, 0x00, 0x26, 0x00, 0x09, 0x80, 0x02, 0x60, 0x00, 0x88, 0x00,
  0x22, 0x00, 0x18, 0xC0, 0x04, 0x18, 0x03, 0x03, 0x01, 0x00, 0x71, 0x80,
  0x07, 0x80, 0x01, 0xF0, 0x01, 0x87, 0x01, 0x80, 0x60, 0xC0, 0x0C, 0x20,
  0x01, 0x98, 0x00, 0x24, 0x00, 0x05, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x14, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0xC8, 0x00, 0x23, 0x00, 0x10,
  0x60, 0x18, 0x07, 0xFC, 0x00, 0x00, 0x80, 0x01, 0xFE, 0x01, 0x80, 0xC0,
  0xC0, 0x08, 0x20, 0x03, 0x10, 0x00, 0x44, 0x00, 0x19, 0x00, 0x02, 0xC0,
  0x00, 0xB0, 0x00, 0x28, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x34, 0x00, 0x0D, 0x00, 0x03, 0x60, 0x01, 0x48, 0x00, 0x91, 0x80, 0x64,
  0x3F, 0xE3, 0x01, 0xC0, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x3F, 0xE0, 0x01, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x2F, 0x33, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x22, 0x26, 0x44, 0x4C, 0x88, 0x00, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x10, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x01, 0xFF, 0x8C, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x06, 0x02, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x04,
  0x10, 0x00, 0x00, 0x08, 0x40, 0x07, 0xE0, 0x18, 0x80, 0x38, 0x70, 0x13,
  0x00, 0xC0, 0x60, 0x24, 0x03, 0x00, 0x80, 0x48, 0x04, 0x01, 0x00, 0xD0,
  0x18, 0x02, 0x01, 0xA0, 0x20, 0x04, 0x03, 0xC0, 0x40, 0x08, 0x07, 0x80,
  0x80, 0x10, 0x0F, 0x01, 0x00, 0x20, 0x1E, 0x02, 0x00, 0x40, 0x2C, 0x04,
  0x00, 0x80, 0x58, 0x08, 0x03, 0x00, 0x90, 0x10, 0x06, 0x01, 0x20, 0x30,
  0x0C, 0x04, 0x40, 0x20, 0x24, 0x18, 0x80, 0x60, 0x8C, 0x61, 0x80, 0x3E,
  0x0F, 0x81, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x30, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x50, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x40,
  0x00, 0x04, 0x40, 0x00, 0x08, 0x80, 0x00, 0x11, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x82, 0x00, 0x01, 0x04, 0x00, 0x04, 0x0C, 0x00, 0x08, 0x08, 0x00,
  0x10, 0x10, 0x00, 0x40, 0x30, 0x00, 0x80, 0x20, 0x01, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x08, 0x00, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x80,
  0x02, 0x01, 0x00, 0x04, 0x04, 0x00, 0x0C, 0x08, 0x00, 0x08, 0x10, 0x00,
  0x10, 0x40, 0x00, 0x30, 0x80, 0x00, 0x21, 0x00, 0x00, 0x44, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0xB0, 0x00, 0x01, 0x40, 0x00, 0x03, 0xFF, 0xF8, 0x20,
  0x03, 0x88, 0x00, 0x32, 0x00, 0x06, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x06,
  0x80, 0x01, 0x20, 0x01, 0x88, 0x0F, 0xC3, 0xFF, 0xE0, 0x80, 0x07, 0x20,
  0x00, 0x68, 0x00, 0x0A, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x02,
  0x80, 0x01, 0xA0, 0x00, 0xC8, 0x01, 0xE3, 0xFF, 0xC0, 0x00, 0x0C, 0x00,
  0x0F, 0xFE, 0x03, 0x00, 0x30, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x04, 0x00,
  0xF0, 0x20, 0x00, 0xC1, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x40, 0x00, 0x32,
  0x00, 0x00, 0x90, 0x00, 0x06, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00,
  0x05, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x06, 0x80,
  0x00, 0x24, 0x00, 0x03, 0x20, 0x00, 0x11, 0x00, 0x01, 0x88, 0x00, 0x18,
  0x40, 0x03, 0x02, 0x00, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x00, 0x0E, 0x80, 0x01,
  0xFF, 0xF0, 0x0E, 0x00, 0x38, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x40, 0x00, 0x02, 0x80, 0x00, 0x04, 0x80,
  0x00, 0x09, 0x80, 0x00, 0x11, 0x00, 0x00, 0x21, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x81, 0xC0, 0x07, 0x00, 0xFF, 0xF0, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x7F, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x4C, 0x71, 0xF0, 0x80, 0x00, 0xE0,
  0x00, 0x48, 0x00, 0x32, 0x00, 0x18, 0x80, 0x0C, 0x20, 0x06, 0x08, 0x01,
  0x02, 0x00, 0x80, 0x80, 0x60, 0x20, 0x30, 0x08, 0x18, 0x02, 0x0C, 0x00,
  0x86, 0x00, 0x21, 0x00, 0x08, 0xE0, 0x02, 0x4C, 0x00, 0xB1, 0x00, 0x38,
  0x60, 0x0C, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x60, 0x20, 0x08, 0x08, 0x01,
  0x02, 0x00, 0x60, 0x80, 0x08, 0x20, 0x01, 0x08, 0x00, 0x62, 0x00, 0x08,
  0x80, 0x03, 0x20, 0x00, 0x68, 0x00, 0x0A, 0x00, 0x03, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3A, 0x00, 0x00, 0x0E, 0x80, 0x00, 0x05, 0xB0, 0x00,
  0x01, 0x64, 0x00, 0x00, 0xD9, 0x00, 0x00, 0x26, 0x20, 0x00, 0x09, 0x88,
  0x00, 0x06, 0x63, 0x00, 0x01, 0x18, 0x40, 0x00, 0x46, 0x10, 0x00, 0x31,
  0x86, 0x00, 0x08, 0x60, 0x80, 0x02, 0x18, 0x20, 0x01, 0x06, 0x04, 0x00,
  0x41, 0x81, 0x00, 0x30, 0x60, 0x60, 0x08, 0x18, 0x08, 0x02, 0x06, 0x02,
  0x01, 0x81, 0x80, 0xC0, 0x40, 0x60, 0x10, 0x10, 0x18, 0x04, 0x08, 0x06,
  0x00, 0x82, 0x01, 0x80, 0x21, 0x80, 0x60, 0x0C, 0x40, 0x18, 0x01, 0x10,
  0x06, 0x00, 0x4C, 0x01, 0x80, 0x1A, 0x00, 0x60, 0x02, 0x80, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x1A, 0x00, 0x01, 0x90, 0x00, 0x19, 0x80, 0x01, 0x88, 0x00, 0x18, 0xC0,
  0x01, 0x84, 0x00, 0x18, 0x20, 0x01, 0x83, 0x00, 0x18, 0x10, 0x01, 0x81,
  0x80, 0x18, 0x08, 0x01, 0x80, 0x40, 0x18, 0x06, 0x01, 0x80, 0x20, 0x18,
  0x03, 0x01, 0x80, 0x10, 0x18, 0x00, 0x81, 0x80, 0x0C, 0x18, 0x00, 0x41,
  0x80, 0x06, 0x18, 0x00, 0x21, 0x80, 0x01, 0x18, 0x00, 0x11, 0x80, 0x00,
  0x98, 0x00, 0x0D, 0x80, 0x00, 0x58, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x01, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x80, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x60, 0x00,
  0x06, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x60, 0x00, 0x04, 0x20, 0x00,
  0x04, 0x10, 0x00, 0x08, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x07, 0x00,
  0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x40, 0x0E, 0x20, 0x01, 0x90, 0x00,
  0x68, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x28, 0x00, 0x14, 0x00, 0x1A, 0x00, 0x09,
  0x00, 0x0C, 0x80, 0x18, 0x7F, 0xF0, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xFF, 0x80, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x30,
  0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x60, 0x00, 0x06,
  0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x60, 0x00, 0x06, 0x20, 0x00, 0x04,
  0x10, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x07, 0x00, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0xFF, 0xE0, 0x20, 0x07, 0x08, 0x00, 0x62, 0x00, 0x0C,
  0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x1A, 0x00, 0x06, 0x80, 0x01, 0xA0,
  0x00, 0x68, 0x00, 0x1A, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x88, 0x00,
  0x62, 0x00, 0x30, 0xFF, 0xF0, 0x3F, 0xF0, 0x08, 0x06, 0x02, 0x00, 0x80,
  0x80, 0x30, 0x20, 0x04, 0x08, 0x01, 0x82, 0x00, 0x20, 0x80, 0x04, 0x20,
  0x01, 0x08, 0x00, 0x22, 0x00, 0x0C, 0x80, 0x01, 0x20, 0x00, 0x68, 0x00,
  0x0A, 0x00, 0x03, 0x00, 0x70, 0x01, 0xFF, 0xC1, 0x80, 0x18, 0xC0, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x33, 0x00, 0x38, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0x40, 0x00, 0x34, 0x00, 0x02,
  0x20, 0x00, 0x63, 0x00, 0x0C, 0x1C, 0x03, 0x80, 0x7F, 0xE0, 0x80, 0x00,
  0x05, 0x00, 0x00, 0x34, 0x00, 0x00, 0x90, 0x00, 0x02, 0x20, 0x00, 0x18,
  0x80, 0x00, 0x42, 0x00, 0x01, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x20, 0x40,
  0x00, 0x81, 0x80, 0x06, 0x02, 0x00, 0x10, 0x08, 0x00, 0x40, 0x30, 0x03,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x06, 0x01, 0x80, 0x08, 0x04, 0x00,
  0x20, 0x10, 0x00, 0xC0, 0x40, 0x01, 0x02, 0x00, 0x04, 0x08, 0x00, 0x18,
  0x20, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x03, 0x10, 0x00, 0x04, 0x80,
  0x00, 0x12, 0x00, 0x00, 0x48, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0x80, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x24, 0x00,
  0x1C, 0x00, 0x09, 0x00, 0x05, 0x00, 0x06, 0x40, 0x01, 0x40, 0x01, 0x18,
  0x00, 0x58, 0x00, 0x42, 0x00, 0x32, 0x00, 0x10, 0x80, 0x08, 0x80, 0x0C,
  0x20, 0x02, 0x20, 0x02, 0x0C, 0x00, 0x8C, 0x00, 0x81, 0x00, 0x61, 0x00,
  0x60, 0x40, 0x10, 0x40, 0x18, 0x10, 0x04, 0x10, 0x04, 0x06, 0x01, 0x06,
  0x01, 0x00, 0x80, 0xC0, 0x80, 0xC0, 0x20, 0x20, 0x20, 0x30, 0x08, 0x08,
  0x08, 0x08, 0x03, 0x02, 0x03, 0x02, 0x00, 0x41, 0x80, 0x41, 0x80, 0x10,
  0x40, 0x10, 0x60, 0x04, 0x10, 0x04, 0x10, 0x01, 0x84, 0x01, 0x84, 0x00,
  0x23, 0x00, 0x23, 0x00, 0x08, 0x80, 0x08, 0x80, 0x02, 0x20, 0x02, 0x20,
  0x00, 0xC8, 0x00, 0xC8, 0x00, 0x16, 0x00, 0x16, 0x00, 0x05, 0x80, 0x05,
  0x00, 0x01, 0x40, 0x01, 0x40, 0x00, 0x70, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x02, 0x00, 0x60, 0x00, 0x22, 0x00, 0x06, 0x10,
  0x00, 0x41, 0x00, 0x08, 0x08, 0x00, 0x80, 0xC0, 0x10, 0x04, 0x03, 0x00,
  0x60, 0x20, 0x02, 0x06, 0x00, 0x30, 0x40, 0x01, 0x0C, 0x00, 0x18, 0x80,
  0x00, 0x90, 0x00, 0x0D, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x0D, 0x00, 0x00, 0x98, 0x00, 0x10, 0x80, 0x01, 0x0C, 0x00, 0x20,
  0x40, 0x06, 0x06, 0x00, 0x40, 0x20, 0x0C, 0x01, 0x00, 0x80, 0x10, 0x18,
  0x00, 0x81, 0x00, 0x08, 0x20, 0x00, 0x46, 0x00, 0x06, 0x40, 0x00, 0x2C,
  0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x02, 0x60, 0x00, 0x42, 0x00, 0x04,
  0x20, 0x00, 0x81, 0x00, 0x08, 0x10, 0x01, 0x80, 0x80, 0x10, 0x08, 0x03,
  0x00, 0xC0, 0x20, 0x04, 0x06, 0x00, 0x60, 0x40, 0x02, 0x0C, 0x00, 0x30,
  0x80, 0x01, 0x08, 0x00, 0x19, 0x00, 0x00, 0x90, 0x00, 0x0A, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFE, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x40, 0x03, 0xFF, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x07, 0xFE, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x02, 0xC0, 0x00, 0xC8, 0x00, 0x11, 0x80, 0x04, 0x10,
  0x00, 0x83, 0x00, 0x20, 0x20, 0x04, 0x06, 0x01, 0x00, 0x40, 0x20, 0x0C,
  0x08, 0x00, 0x83, 0x00, 0x18, 0x40, 0x01, 0x18, 0x00, 0x22, 0x00, 0x02,
  0xC0, 0x00, 0x50, 0x00, 0x04, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x0F, 0xF0, 0x70, 0x30, 0x80, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x1F, 0xF1, 0xC0, 0x26, 0x00, 0x58, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0xA8, 0x01, 0x58, 0x0C, 0x8F, 0xF1,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x21, 0xFC, 0x13,
  0x81, 0x8B, 0x00, 0x65, 0x00, 0x13, 0x00, 0x05, 0x80, 0x02, 0xC0, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x3C,
  0x00, 0x16, 0x00, 0x0B, 0x80, 0x09, 0x40, 0x0C, 0x98, 0x0C, 0x47, 0xF8,
  0x00, 0x01, 0xFE, 0x0E, 0x04, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x81, 0xFF, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x3F, 0x84, 0x38,
  0x31, 0x18, 0x02, 0x44, 0x00, 0x52, 0x00, 0x1C, 0x80, 0x03, 0x40, 0x00,
  0xD0, 0x00, 0x34, 0x00, 0x05, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x50, 0x00, 0x14, 0x00, 0x0D, 0x00,
  0x03, 0x40, 0x00, 0xC8, 0x00, 0x32, 0x00, 0x14, 0x40, 0x09, 0x0C, 0x06,
  0x41, 0xFE, 0x10, 0x03, 0xF8, 0x07, 0x06, 0x06, 0x01, 0x82, 0x00, 0x62,
  0x00, 0x11, 0x00, 0x09, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00,
  0x50, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x04, 0x0F, 0xFC, 0x01, 0xFC, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x0F,
  0xFC, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x03, 0xF8, 0x43, 0x81, 0x91, 0x80,
  0x34, 0xC0, 0x05, 0x20, 0x00, 0xD8, 0x00, 0x34, 0x00, 0x0D, 0x00, 0x03,
  0x40, 0x00, 0x50, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0xD0, 0x00, 0x34, 0x00,
  0x0C, 0x80, 0x05, 0x30, 0x01, 0x44, 0x00, 0x90, 0xC0, 0x64, 0x1F, 0xE1,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x20, 0x03, 0x0F, 0x87, 0x00, 0x3F,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x87, 0xF0, 0x9C,
  0x18, 0xB0, 0x04, 0xA0, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0x80, 0x02, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xFC, 0x00, 0x00,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x0E, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x06, 0x09, 0x33, 0xC0, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0xE0, 0x06, 0x80, 0x32, 0x00, 0x88,
  0x04, 0x20, 0x20, 0x81, 0x82, 0x0C, 0x08, 0x20, 0x21, 0x00, 0x8C, 0x02,
  0x58, 0x0B, 0x20, 0x28, 0x40, 0xC1, 0x02, 0x02, 0x08, 0x0C, 0x20, 0x10,
  0x80, 0x22, 0x00, 0xC8, 0x01, 0x20, 0x06, 0x80, 0x0A, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x8F, 0xE0, 0x7F, 0x13, 0x06, 0x18, 0x32, 0x80,
  0x64, 0x03, 0x60, 0x05, 0x00, 0x2C, 0x00, 0xA0, 0x07, 0x00, 0x08, 0x00,
  0xE0, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x87, 0xF0, 0x9C, 0x18, 0xB0, 0x04, 0xA0, 0x06, 0xC0, 0x02, 0xC0,
  0x02, 0x80, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x03, 0xF8, 0x01, 0xC0, 0xC0, 0x60, 0x0C, 0x08, 0x00, 0xC2, 0x00,
  0x08, 0xC0, 0x01, 0x90, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00,
  0x0B, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xD0, 0x00,
  0x12, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x09, 0x80, 0x03, 0x10, 0x00,
  0x43, 0x00, 0x18, 0x30, 0x06, 0x03, 0x01, 0x80, 0x3F, 0xE0, 0x87, 0xF0,
  0x46, 0x06, 0x24, 0x01, 0x94, 0x00, 0x4E, 0x00, 0x16, 0x00, 0x0B, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0x58, 0x00, 0x2A, 0x00, 0x25, 0x80, 0x32, 0x60, 0x31, 0x1F,
  0xE0, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x00, 0x03,
  0xF8, 0x43, 0x83, 0x11, 0x80, 0x24, 0xC0, 0x05, 0x20, 0x01, 0x58, 0x00,
  0x34, 0x00, 0x0D, 0x00, 0x03, 0x40, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x05, 0x00, 0x03, 0x40,
  0x00, 0xD0, 0x00, 0x34, 0x00, 0x0C, 0x80, 0x05, 0x20, 0x01, 0x44, 0x00,
  0x91, 0x80, 0x44, 0x1F, 0xE1, 0x00, 0x80, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x87, 0xE6, 0x0B, 0x02, 0x80, 0xC0, 0x30, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x0F, 0xF0,
  0xC0, 0x36, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x2C, 0x01, 0x9F, 0xF8, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x0F,
  0xFC, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x08, 0x03, 0xF0, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x03, 0x40, 0x03, 0x40, 0x05,
  0x20, 0x05, 0x30, 0x19, 0x0F, 0xF1, 0x80, 0x00, 0xA0, 0x00, 0xD0, 0x00,
  0x48, 0x00, 0x22, 0x00, 0x31, 0x00, 0x10, 0x80, 0x08, 0x60, 0x0C, 0x10,
  0x04, 0x08, 0x02, 0x06, 0x03, 0x01, 0x01, 0x00, 0x80, 0x80, 0x60, 0xC0,
  0x10, 0x40, 0x08, 0x20, 0x06, 0x30, 0x01, 0x10, 0x00, 0x88, 0x00, 0x6C,
  0x00, 0x14, 0x00, 0x0A, 0x00, 0x07, 0x00, 0x01, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x28, 0x03, 0x40, 0x0A,
  0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x30, 0x08, 0x80, 0x44, 0x06, 0x20,
  0x31, 0x01, 0x08, 0x08, 0x40, 0x43, 0x02, 0x08, 0x10, 0x41, 0x82, 0x0C,
  0x10, 0x40, 0x82, 0x04, 0x10, 0x30, 0x81, 0x84, 0x04, 0x20, 0x23, 0x01,
  0x18, 0x08, 0x80, 0x44, 0x02, 0x20, 0x09, 0x00, 0xD8, 0x02, 0x40, 0x14,
  0x00, 0xB0, 0x05, 0x00, 0x28, 0x01, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0x60, 0xC0, 0x01, 0x30, 0x01, 0x88, 0x01, 0x86, 0x00, 0x81,
  0x00, 0xC0, 0x40, 0x40, 0x30, 0x40, 0x08, 0x60, 0x02, 0x20, 0x01, 0x30,
  0x00, 0x50, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0A, 0x00, 0x09, 0x80, 0x0C,
  0x40, 0x04, 0x10, 0x04, 0x0C, 0x06, 0x02, 0x02, 0x00, 0x83, 0x00, 0x61,
  0x00, 0x11, 0x00, 0x0D, 0x80, 0x03, 0xC0, 0x00, 0xA0, 0x00, 0x50, 0x00,
  0x6C, 0x00, 0x22, 0x00, 0x11, 0x00, 0x18, 0xC0, 0x08, 0x20, 0x04, 0x10,
  0x06, 0x0C, 0x02, 0x02, 0x01, 0x01, 0x01, 0x80, 0xC0, 0x80, 0x20, 0x40,
  0x10, 0x60, 0x0C, 0x20, 0x02, 0x10, 0x01, 0x18, 0x00, 0xC8, 0x00, 0x24,
  0x00, 0x16, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x4C, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x3F, 0xFF, 0x00, 0xE0, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x40, 0x08, 0x01, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x30, 0x02, 0x00, 0x40,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x38, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF0, 0x01, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x80, 0x07, 0x01, 0x80, 0x30,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x01, 0x80,
  0xF0, 0x00, 0x1E, 0x00, 0x0C, 0x78, 0x06, 0x01, 0xC3, 0x40, 0x0F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Thin45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 2, 32, 10, 4, -32 },
  { 9, 8, 11, 14, 3, -32 },
  { 20, 23, 32, 25, 1, -32 },
  { 112, 17, 37, 23, 2, -34 },
  { 191, 28, 33, 32, 2, -33 },
  { 307, 23, 33, 26, 2, -33 },
  { 402, 2, 11, 8, 3, -32 },
  { 405, 8, 39, 12, 2, -32 },
  { 444, 8, 39, 12, 2, -32 },
  { 483, 16, 16, 21, 3, -34 },
  { 515, 19, 20, 23, 2, -26 },
  { 563, 4, 11, 8, 2, -5 },
  { 569, 10, 1, 14, 2, -13 },
  { 571, 2, 3, 9, 4, -3 },
  { 572, 13, 32, 15, 1, -32 },
  { 624, 17, 33, 23, 3, -33 },
  { 695, 9, 32, 23, 4, -32 },
  { 731, 18, 33, 23, 2, -33 },
  { 806, 18, 33, 23, 2, -33 },
  { 881, 21, 32, 23, 1, -32 },
  { 965, 17, 32, 23, 3, -32 },
  { 1033, 17, 34, 23, 3, -33 },
  { 1106, 18, 32, 23, 2, -32 },
  { 1178, 18, 33, 23, 2, -33 },
  { 1253, 18, 34, 23, 2, -33 },
  { 1330, 2, 24, 9, 4, -24 },
  { 1336, 4, 30, 9, 2, -24 },
  { 1351, 19, 20, 23, 2, -26 },
  { 1399, 19, 10, 23, 2, -21 },
  { 1423, 19, 20, 23, 2, -26 },
  { 1471, 14, 33, 16, 1, -33 },
  { 1529, 31, 36, 35, 2, -32 },
  { 1669, 23, 32, 23, 0, -32 },
  { 1761, 18, 32, 25, 4, -32 },
  { 1833, 20, 33, 24, 3, -33 },
  { 1916, 21, 32, 28, 4, -32 },
  { 2000, 15, 32, 22, 4, -32 },
  { 2060, 15, 32, 20, 4, -32 },
  { 2120, 23, 33, 29, 3, -33 },
  { 2215, 20, 32, 28, 4, -32 },
  { 2295, 7, 32, 12, 2, -32 },
  { 2323, 10, 40, 10, -4, -32 },
  { 2373, 18, 32, 22, 4, -32 },
  { 2445, 15, 32, 20, 4, -32 },
  { 2505, 26, 32, 35, 4, -32 },
  { 2609, 20, 32, 28, 4, -32 },
  { 2689, 24, 33, 30, 3, -33 },
  { 2788, 17, 32, 23, 4, -32 },
  { 2856, 24, 41, 30, 3, -33 },
  { 2979, 18, 32, 23, 4, -32 },
  { 3051, 18, 33, 22, 2, -33 },
  { 3126, 20, 32, 20, 0, -32 },
  { 3206, 20, 32, 28, 4, -32 },
  { 3286, 22, 32, 22, 0, -32 },
  { 3374, 34, 32, 35, 1, -32 },
  { 3510, 20, 32, 20, 0, -32 },
  { 3590, 20, 32, 20, 0, -32 },
  { 3670, 19, 32, 22, 1, -32 },
  { 3746, 9, 39, 14, 4, -32 },
  { 3790, 13, 32, 15, 1, -32 },
  { 3842, 9, 39, 14, 1, -32 },
  { 3886, 19, 18, 23, 2, -32 },
  { 3929, 18, 1, 18, 0, 4 },
  { 3932, 7, 7, 11, 2, -34 },
  { 3939, 15, 24, 21, 2, -24 },
  { 3984, 17, 34, 24, 4, -34 },
  { 4057, 15, 24, 19, 2, -24 },
  { 4102, 18, 34, 24, 2, -34 },
  { 4179, 17, 24, 22, 2, -24 },
  { 4230, 14, 34, 11, 0, -34 },
  { 4290, 18, 35, 24, 2, -24 },
  { 4369, 16, 34, 23, 4, -34 },
  { 4437, 3, 32, 9, 3, -32 },
  { 4449, 7, 43, 9, -1, -32 },
  { 4487, 14, 34, 18, 4, -34 },
  { 4547, 1, 34, 9, 4, -34 },
  { 4552, 27, 24, 34, 4, -24 },
  { 4633, 16, 24, 23, 4, -24 },
  { 4681, 19, 24, 23, 2, -24 },
  { 4738, 17, 34, 24, 4, -24 },
  { 4811, 18, 34, 24, 2, -24 },
  { 4888, 10, 24, 15, 4, -24 },
  { 4918, 14, 24, 18, 2, -24 },
  { 4960, 10, 30, 13, 1, -30 },
  { 4998, 16, 24, 23, 3, -24 },
  { 5046, 17, 24, 17, 0, -24 },
  { 5097, 26, 24, 28, 1, -24 },
  { 5175, 17, 24, 19, 1, -24 },
  { 5226, 17, 35, 17, 0, -24 },
  { 5301, 14, 24, 17, 2, -24 },
  { 5343, 11, 39, 15, 2, -32 },
  { 5397, 1, 45, 21, 10, -34 },
  { 5403, 12, 39, 15, 2, -32 },
  { 5462, 19, 4, 23, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_Thin45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin45pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_SEMICONDENSED_THIN45PT7B_H_
