#ifndef _NOTOSANS_SEMICONDENSED_THIN48PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin48pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF5, 0x55, 0x55, 0x50, 0x03, 0xF0, 0xC1, 0xE0,
  0xF0, 0x58, 0x2C, 0x16, 0x0B, 0x05, 0x82, 0xC1, 0x20, 0x90, 0x48, 0x20,
  0x00, 0x20, 0x18, 0x00, 0x10, 0x08, 0x00, 0x18, 0x04, 0x00, 0x0C, 0x02,
  0x00, 0x04, 0x01, 0x00, 0x02, 0x01, 0x80, 0x01, 0x00, 0xC0, 0x00, 0x80,
  0x40, 0x00, 0xC0, 0x20, 0x00, 0x60, 0x10, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF0, 0x08, 0x06, 0x00, 0x04, 0x02, 0x00, 0x06, 0x01, 0x00, 0x03,
  0x00, 0x80, 0x01, 0x00, 0x40, 0x00, 0x80, 0x20, 0x00, 0x40, 0x30, 0x00,
  0x20, 0x10, 0x00, 0x30, 0x08, 0x00, 0x18, 0x04, 0x03, 0xFF, 0xFF, 0xF8,
  0x04, 0x01, 0x00, 0x02, 0x01, 0x80, 0x01, 0x00, 0x80, 0x00, 0x80, 0x40,
  0x00, 0xC0, 0x20, 0x00, 0x40, 0x10, 0x00, 0x20, 0x08, 0x00, 0x10, 0x0C,
  0x00, 0x08, 0x06, 0x00, 0x04, 0x02, 0x00, 0x06, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x07, 0xE0, 0x07, 0xAF, 0x81, 0x84, 0x18, 0x60,
  0x80, 0x18, 0x10, 0x02, 0x02, 0x00, 0x40, 0x40, 0x08, 0x08, 0x03, 0x01,
  0x00, 0x20, 0x20, 0x04, 0x04, 0x00, 0xC0, 0x80, 0x08, 0x10, 0x00, 0xC2,
  0x00, 0x0C, 0x40, 0x00, 0x68, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x04,
  0xE0, 0x00, 0x86, 0x00, 0x10, 0x60, 0x02, 0x06, 0x00, 0x40, 0x40, 0x08,
  0x0C, 0x01, 0x01, 0x80, 0x20, 0x30, 0x04, 0x06, 0x00, 0x80, 0x80, 0x10,
  0x10, 0x02, 0x04, 0x80, 0x41, 0x8E, 0x08, 0xE0, 0x7F, 0xF0, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x30, 0x18, 0x30, 0x01, 0x00, 0x80, 0x80, 0x18, 0x0C, 0x06,
  0x00, 0x80, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x06,
  0x00, 0x80, 0x20, 0x20, 0x04, 0x01, 0x03, 0x00, 0x20, 0x08, 0x10, 0x01,
  0x00, 0x41, 0x80, 0x08, 0x02, 0x08, 0x00, 0x40, 0x10, 0x40, 0x02, 0x00,
  0x84, 0x1E, 0x10, 0x04, 0x23, 0x18, 0x80, 0x62, 0x30, 0x26, 0x02, 0x11,
  0x01, 0x10, 0x11, 0x08, 0x04, 0xC1, 0x88, 0xC0, 0x23, 0xB8, 0xC4, 0x01,
  0x07, 0x04, 0x20, 0x08, 0x00, 0x61, 0x00, 0x60, 0x02, 0x08, 0x03, 0x00,
  0x30, 0x40, 0x18, 0x01, 0x02, 0x00, 0xC0, 0x18, 0x10, 0x06, 0x00, 0x80,
  0x80, 0x20, 0x0C, 0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x01, 0x80,
  0x40, 0x20, 0x04, 0x06, 0x01, 0x00, 0x30, 0x20, 0x10, 0x00, 0xC3, 0x01,
  0x80, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xEE, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x80, 0x60, 0x00, 0x80, 0x10, 0x00, 0x40, 0x0C, 0x00, 0x20, 0x06,
  0x00, 0x10, 0x03, 0x00, 0x08, 0x01, 0x80, 0x04, 0x00, 0x80, 0x03, 0x00,
  0x40, 0x00, 0x80, 0x60, 0x00, 0x60, 0x60, 0x00, 0x10, 0x60, 0x00, 0x04,
  0x60, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x02, 0x00, 0x03, 0x00, 0x80, 0x11, 0x00, 0x60, 0x09,
  0x80, 0x18, 0x0C, 0x80, 0x06, 0x04, 0x40, 0x01, 0x82, 0x20, 0x00, 0x42,
  0x30, 0x00, 0x11, 0x08, 0x00, 0x0D, 0x04, 0x00, 0x03, 0x82, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0xA0, 0x40, 0x00, 0x88, 0x30, 0x01, 0x82, 0x0E, 0x01,
  0x81, 0x81, 0xFF, 0x00, 0x60, 0xFF, 0xFD, 0x55, 0x03, 0x81, 0x01, 0x81,
  0x80, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0xC0,
  0x60, 0x10, 0x08, 0x04, 0x03, 0x01, 0x80, 0x40, 0x20, 0x18, 0x04, 0x03,
  0x00, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0xC0, 0x60, 0x20, 0x30,
  0x10, 0x08, 0x08, 0x0C, 0x04, 0x06, 0x06, 0x02, 0x02, 0x03, 0x03, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x03,
  0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x60,
  0x40, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x04, 0x04, 0x07, 0xC2, 0x1C, 0x3D, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x90, 0x00, 0x44, 0x00, 0x41, 0x00, 0x40, 0xC0, 0x60, 0x20, 0x60, 0x08,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x0F, 0xFF, 0xFF, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x33, 0x22, 0x26, 0x44, 0x4C,
  0x80, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xE7, 0x80, 0x20, 0x18,
  0x08, 0x01, 0x83, 0x00, 0x10, 0x40, 0x03, 0x18, 0x00, 0x22, 0x00, 0x04,
  0x40, 0x00, 0xD8, 0x00, 0x0B, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x05,
  0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0E,
  0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x14,
  0x00, 0x02, 0x80, 0x00, 0x58, 0x00, 0x09, 0x00, 0x03, 0x20, 0x00, 0x44,
  0x00, 0x08, 0xC0, 0x01, 0x08, 0x00, 0x41, 0x80, 0x08, 0x18, 0x02, 0x01,
  0x81, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0xC0, 0x50, 0x64, 0x31, 0x18, 0x58,
  0x1C, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x01, 0xF0, 0x01, 0xF7, 0x80, 0xE0, 0x18, 0x30, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xF0, 0x01, 0xF7, 0xC0, 0xC0, 0x0C, 0x60, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x04, 0x80, 0x01, 0x9C, 0x00, 0xC0, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x48, 0x00, 0x01, 0x10, 0x00, 0x06, 0x20, 0x00, 0x08, 0x40, 0x00,
  0x20, 0x80, 0x00, 0xC1, 0x00, 0x01, 0x02, 0x00, 0x04, 0x04, 0x00, 0x18,
  0x08, 0x00, 0x20, 0x10, 0x00, 0xC0, 0x20, 0x03, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x18, 0x01, 0x00, 0x20, 0x02, 0x00, 0x80, 0x04, 0x03, 0x00, 0x08,
  0x04, 0x00, 0x10, 0x10, 0x00, 0x20, 0x60, 0x00, 0x40, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x3F, 0xFF, 0x84, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x1F,
  0xFE, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x44, 0x00, 0x18, 0xE0, 0x0C, 0x07, 0xFF, 0x00, 0x00,
  0x3E, 0x00, 0x3E, 0xF0, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0xFE, 0x04, 0x70,
  0x70, 0x98, 0x03, 0x16, 0x00, 0x32, 0x80, 0x03, 0x60, 0x00, 0x2C, 0x00,
  0x05, 0x80, 0x00, 0xA0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xA0, 0x00, 0x24, 0x00, 0x04, 0xC0, 0x00, 0x88, 0x00,
  0x31, 0x80, 0x04, 0x18, 0x01, 0x01, 0x80, 0xC0, 0x1F, 0xF0, 0x00, 0x30,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x01, 0xF0,
  0x01, 0xFF, 0x80, 0x60, 0x18, 0x18, 0x00, 0x86, 0x00, 0x18, 0x80, 0x01,
  0x10, 0x00, 0x22, 0x00, 0x06, 0x40, 0x00, 0xC8, 0x00, 0x11, 0x00, 0x02,
  0x30, 0x00, 0xC3, 0x00, 0x10, 0x30, 0x04, 0x03, 0x03, 0x00, 0x39, 0xC0,
  0x01, 0xE0, 0x00, 0x7E, 0x00, 0x38, 0x70, 0x0C, 0x03, 0x03, 0x00, 0x30,
  0xC0, 0x03, 0x30, 0x00, 0x34, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0A,
  0x00, 0x01, 0xC0, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xB0, 0x00, 0x32,
  0x00, 0x04, 0x20, 0x01, 0x03, 0x00, 0xC0, 0x3F, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0xF7, 0x80, 0x60, 0x18, 0x08, 0x00, 0x82, 0x00, 0x18, 0xC0, 0x01,
  0x10, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x58, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x1A, 0x00, 0x03,
  0x60, 0x00, 0x64, 0x00, 0x14, 0xC0, 0x06, 0x8C, 0x01, 0x90, 0xF3, 0xC2,
  0x03, 0xE0, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0xFF, 0xC0, 0x01, 0x80, 0x00,
  0xBF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x13, 0x31, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x32, 0x22, 0x64, 0x44, 0xC8, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x01, 0xFB, 0xE1, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x08, 0x10, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00,
  0x06, 0x60, 0x07, 0xFC, 0x02, 0x40, 0x0C, 0x04, 0x02, 0xC0, 0x10, 0x04,
  0x02, 0xC0, 0x30, 0x04, 0x03, 0x80, 0x60, 0x04, 0x03, 0x80, 0x40, 0x04,
  0x03, 0x80, 0x40, 0x04, 0x01, 0x80, 0x40, 0x04, 0x01, 0x80, 0xC0, 0x0C,
  0x01, 0x80, 0xC0, 0x0C, 0x03, 0x80, 0xC0, 0x0C, 0x03, 0x80, 0xC0, 0x0C,
  0x03, 0x80, 0xC0, 0x0C, 0x02, 0x80, 0x40, 0x0C, 0x02, 0x80, 0x40, 0x14,
  0x06, 0x80, 0x60, 0x14, 0x04, 0xC0, 0x30, 0x26, 0x0C, 0xC0, 0x1D, 0xC3,
  0xF8, 0x40, 0x07, 0x01, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x06,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x14, 0x00, 0x00, 0x24, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x42, 0x00, 0x00, 0x43, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x81, 0x80, 0x00, 0x80, 0x80, 0x01, 0x80, 0x80,
  0x01, 0x00, 0xC0, 0x01, 0x00, 0xC0, 0x03, 0x00, 0x40, 0x02, 0x00, 0x40,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x20, 0x04, 0x00, 0x20, 0x07, 0xFF, 0xF0,
  0x0C, 0x00, 0x10, 0x08, 0x00, 0x10, 0x08, 0x00, 0x18, 0x18, 0x00, 0x08,
  0x10, 0x00, 0x08, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x20, 0x00, 0x04,
  0x20, 0x00, 0x06, 0x60, 0x00, 0x02, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xFF, 0xF8, 0x10, 0x01, 0xC2, 0x00, 0x0C, 0x40, 0x00,
  0xC8, 0x00, 0x09, 0x00, 0x01, 0xA0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00,
  0x50, 0x00, 0x0A, 0x00, 0x03, 0x40, 0x00, 0x48, 0x00, 0x19, 0x00, 0x02,
  0x20, 0x01, 0x87, 0xFF, 0xC0, 0xFF, 0xFC, 0x10, 0x00, 0xE2, 0x00, 0x06,
  0x40, 0x00, 0x68, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x28, 0x00, 0x05,
  0x00, 0x01, 0xA0, 0x00, 0x64, 0x00, 0x18, 0x80, 0x1E, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0x80, 0x03, 0xF7, 0xF0, 0x18, 0x00, 0x81, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x60, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x04, 0x00, 0xF0, 0x20, 0x00, 0xC1, 0x00, 0x03, 0x08,
  0x00, 0x04, 0x40, 0x00, 0x32, 0x00, 0x00, 0x90, 0x00, 0x06, 0x80, 0x00,
  0x14, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x0D,
  0x00, 0x00, 0x48, 0x00, 0x06, 0x40, 0x00, 0x62, 0x00, 0x06, 0x10, 0x00,
  0xE0, 0x80, 0x3C, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xFF, 0xFE, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x7F, 0x00, 0x70, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x40, 0x00, 0x01, 0xA0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x07, 0x00, 0x01, 0x80, 0xE0, 0x03, 0xC0, 0x1F, 0xFF,
  0x00, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0xFE, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x11,
  0xFC, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x30, 0x08, 0x06, 0x83, 0x3F, 0x80, 0x80, 0x00, 0xD0, 0x00, 0x32, 0x00,
  0x0C, 0x40, 0x03, 0x08, 0x00, 0xC1, 0x00, 0x10, 0x20, 0x06, 0x04, 0x01,
  0x80, 0x80, 0x60, 0x10, 0x18, 0x02, 0x06, 0x00, 0x41, 0x80, 0x08, 0x20,
  0x01, 0x0C, 0x00, 0x23, 0x00, 0x04, 0xF0, 0x00, 0xB2, 0x00, 0x14, 0x60,
  0x03, 0x06, 0x00, 0x40, 0x40, 0x08, 0x0C, 0x01, 0x00, 0xC0, 0x20, 0x08,
  0x04, 0x01, 0x80, 0x80, 0x18, 0x10, 0x01, 0x02, 0x00, 0x30, 0x40, 0x02,
  0x08, 0x00, 0x21, 0x00, 0x06, 0x20, 0x00, 0x44, 0x00, 0x04, 0x80, 0x00,
  0xD0, 0x00, 0x0C, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x5A, 0x00, 0x00, 0x0B,
  0x60, 0x00, 0x03, 0x64, 0x00, 0x00, 0x4C, 0x80, 0x00, 0x09, 0x98, 0x00,
  0x03, 0x31, 0x00, 0x00, 0x46, 0x20, 0x00, 0x18, 0xC6, 0x00, 0x02, 0x18,
  0x40, 0x00, 0x43, 0x0C, 0x00, 0x18, 0x60, 0x80, 0x02, 0x0C, 0x10, 0x00,
  0x41, 0x83, 0x00, 0x18, 0x30, 0x20, 0x02, 0x06, 0x04, 0x00, 0x40, 0xC0,
  0xC0, 0x18, 0x18, 0x08, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x10,
  0x0C, 0x02, 0x02, 0x01, 0x80, 0x60, 0xC0, 0x30, 0x04, 0x10, 0x06, 0x00,
  0x82, 0x00, 0xC0, 0x18, 0xC0, 0x18, 0x01, 0x10, 0x03, 0x00, 0x26, 0x00,
  0x60, 0x02, 0x80, 0x0C, 0x00, 0x50, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00,
  0x80, 0x04, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3A, 0x00, 0x01, 0xC8, 0x00, 0x0E, 0x60, 0x00, 0x71, 0x00, 0x03, 0x8C,
  0x00, 0x1C, 0x20, 0x00, 0xE0, 0x80, 0x07, 0x06, 0x00, 0x38, 0x10, 0x01,
  0xC0, 0xC0, 0x0E, 0x02, 0x00, 0x70, 0x08, 0x03, 0x80, 0x60, 0x1C, 0x01,
  0x00, 0xE0, 0x0C, 0x07, 0x00, 0x20, 0x38, 0x01, 0x81, 0xC0, 0x06, 0x0E,
  0x00, 0x10, 0x70, 0x00, 0xC3, 0x80, 0x02, 0x1C, 0x00, 0x18, 0xE0, 0x00,
  0x67, 0x00, 0x01, 0x38, 0x00, 0x0D, 0xC0, 0x00, 0x2E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x30, 0x03, 0x00, 0x10, 0x00, 0x30, 0x08, 0x00, 0x04,
  0x04, 0x00, 0x00, 0x83, 0x00, 0x00, 0x30, 0x80, 0x00, 0x04, 0x60, 0x00,
  0x01, 0x90, 0x00, 0x00, 0x24, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x90, 0x00, 0x00, 0x24, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x04, 0x20, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x81, 0x80, 0x00,
  0x60, 0x30, 0x00, 0x30, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x1C, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xF0, 0x40, 0x0E, 0x20, 0x01, 0x90, 0x00, 0x68, 0x00,
  0x14, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x04,
  0x80, 0x06, 0x40, 0x0C, 0x3F, 0xF8, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x30, 0x03,
  0x80, 0x10, 0x00, 0x30, 0x08, 0x00, 0x04, 0x04, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x04, 0x60, 0x00, 0x01, 0x90, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x90, 0x00, 0x00, 0x24, 0x00, 0x00, 0x19, 0x80, 0x00, 0x04, 0x20, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x30, 0x00, 0x30, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0xFF,
  0xF0, 0x10, 0x03, 0x82, 0x00, 0x18, 0x40, 0x01, 0x88, 0x00, 0x11, 0x00,
  0x03, 0x20, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00,
  0x02, 0x40, 0x00, 0xC8, 0x00, 0x19, 0x00, 0x02, 0x20, 0x00, 0xC4, 0x00,
  0x30, 0x80, 0x0C, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x40, 0x30, 0x08, 0x02,
  0x01, 0x00, 0x60, 0x20, 0x04, 0x04, 0x00, 0xC0, 0x80, 0x08, 0x10, 0x01,
  0x82, 0x00, 0x10, 0x40, 0x03, 0x08, 0x00, 0x31, 0x00, 0x02, 0x20, 0x00,
  0x64, 0x00, 0x04, 0x80, 0x00, 0xD0, 0x00, 0x0C, 0x00, 0xF8, 0x00, 0xFB,
  0xF0, 0x30, 0x01, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x01, 0x9C, 0x00, 0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x14, 0x00, 0x00, 0xD0, 0x00, 0x02, 0x60, 0x00, 0x08, 0x80, 0x00,
  0x63, 0x00, 0x03, 0x06, 0x00, 0x18, 0x0E, 0x01, 0xC0, 0x0F, 0xFC, 0x00,
  0xC0, 0x00, 0x03, 0x40, 0x00, 0x02, 0x40, 0x00, 0x06, 0x60, 0x00, 0x04,
  0x20, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x08, 0x10, 0x00, 0x08,
  0x10, 0x00, 0x18, 0x10, 0x00, 0x10, 0x18, 0x00, 0x10, 0x08, 0x00, 0x30,
  0x08, 0x00, 0x20, 0x0C, 0x00, 0x20, 0x04, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x06, 0x00, 0x40, 0x02, 0x00, 0xC0, 0x02, 0x00, 0x80, 0x03, 0x00, 0x80,
  0x01, 0x00, 0x80, 0x01, 0x01, 0x80, 0x01, 0x81, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x83, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x42, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x24, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x34, 0x00,
  0x06, 0x00, 0x02, 0x40, 0x00, 0xE0, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x06,
  0x60, 0x00, 0xB0, 0x00, 0x62, 0x00, 0x09, 0x00, 0x04, 0x20, 0x00, 0x90,
  0x00, 0x42, 0x00, 0x19, 0x00, 0x0C, 0x30, 0x01, 0x18, 0x00, 0xC1, 0x00,
  0x10, 0x80, 0x08, 0x10, 0x01, 0x08, 0x00, 0x81, 0x00, 0x30, 0x80, 0x18,
  0x18, 0x02, 0x0C, 0x01, 0x80, 0x80, 0x20, 0x40, 0x10, 0x08, 0x02, 0x04,
  0x01, 0x00, 0x80, 0x60, 0x40, 0x30, 0x0C, 0x04, 0x06, 0x03, 0x00, 0x40,
  0x40, 0x20, 0x20, 0x04, 0x04, 0x02, 0x02, 0x00, 0x40, 0xC0, 0x20, 0x60,
  0x06, 0x08, 0x03, 0x04, 0x00, 0x20, 0x80, 0x10, 0x40, 0x02, 0x08, 0x01,
  0x04, 0x00, 0x21, 0x80, 0x10, 0xC0, 0x03, 0x10, 0x01, 0x88, 0x00, 0x11,
  0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x88, 0x00, 0x13, 0x00, 0x09, 0x80,
  0x01, 0xA0, 0x00, 0xD0, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00,
  0x50, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x60, 0x00, 0x19, 0x80, 0x01, 0x84, 0x00, 0x08, 0x30,
  0x00, 0xC0, 0x80, 0x04, 0x06, 0x00, 0x60, 0x10, 0x02, 0x00, 0xC0, 0x20,
  0x02, 0x03, 0x00, 0x18, 0x10, 0x00, 0x41, 0x80, 0x01, 0x08, 0x00, 0x0C,
  0xC0, 0x00, 0x24, 0x00, 0x01, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x16, 0x00, 0x01, 0x90, 0x00, 0x08, 0x40, 0x00, 0xC3,
  0x00, 0x04, 0x08, 0x00, 0x40, 0x60, 0x06, 0x01, 0x00, 0x20, 0x0C, 0x03,
  0x00, 0x20, 0x10, 0x01, 0x81, 0x80, 0x04, 0x08, 0x00, 0x30, 0xC0, 0x00,
  0x8C, 0x00, 0x06, 0x40, 0x00, 0x16, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x1A,
  0x00, 0x00, 0x98, 0x00, 0x0C, 0x40, 0x00, 0x43, 0x00, 0x06, 0x08, 0x00,
  0x20, 0x60, 0x03, 0x01, 0x00, 0x10, 0x08, 0x01, 0x80, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x04, 0x04, 0x00, 0x20, 0x20, 0x01, 0x83, 0x00, 0x04, 0x10,
  0x00, 0x31, 0x80, 0x00, 0x88, 0x00, 0x06, 0xC0, 0x00, 0x14, 0x00, 0x00,
  0xE0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0xFF, 0xFF, 0xC0, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x30, 0xFF, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00,
  0x02, 0x80, 0x00, 0x36, 0x00, 0x01, 0x10, 0x00, 0x18, 0xC0, 0x00, 0x82,
  0x00, 0x0C, 0x10, 0x00, 0x40, 0x40, 0x06, 0x02, 0x00, 0x20, 0x08, 0x03,
  0x00, 0x40, 0x10, 0x03, 0x01, 0x80, 0x08, 0x08, 0x00, 0x60, 0xC0, 0x01,
  0x04, 0x00, 0x0C, 0x40, 0x00, 0x22, 0x00, 0x01, 0xA0, 0x00, 0x06, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x03, 0xE0, 0x1F, 0xBC, 0x30, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x01, 0xFF, 0x0E, 0x01, 0x38, 0x01, 0x60, 0x01, 0x40, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0x40, 0x05, 0x60, 0x0D,
  0x30, 0x19, 0x1F, 0xE1, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x07, 0xC0, 0x43, 0xCE, 0x09, 0x80, 0x21, 0x60,
  0x02, 0x28, 0x00, 0x67, 0x00, 0x04, 0xC0, 0x00, 0xD8, 0x00, 0x0B, 0x00,
  0x01, 0x40, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x40, 0x00, 0x2C, 0x00,
  0x05, 0x80, 0x01, 0xB0, 0x00, 0x27, 0x00, 0x04, 0xA0, 0x01, 0x12, 0x00,
  0x62, 0x60, 0x18, 0x43, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xCF, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x01, 0x07, 0xFE, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x1F, 0x04, 0x3C,
  0x71, 0x18, 0x06, 0x4C, 0x00, 0xD2, 0x00, 0x15, 0x00, 0x03, 0x40, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x34, 0x00, 0x0D, 0x00, 0x03, 0x60, 0x01,
  0x4C, 0x00, 0xD1, 0x80, 0x64, 0x3F, 0xE1, 0x01, 0xE0, 0x07, 0x9E, 0x06,
  0x01, 0x86, 0x00, 0x42, 0x00, 0x13, 0x00, 0x09, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x01,
  0x83, 0xFF, 0x00, 0x00, 0xF0, 0x1F, 0xC1, 0x80, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x0F, 0xFC,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x00, 0x01, 0xF0, 0x03, 0xCF, 0x11, 0x80, 0x24, 0xC0,
  0x05, 0x20, 0x01, 0xD0, 0x00, 0x34, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0F, 0x00,
  0x03, 0x40, 0x00, 0xD0, 0x00, 0x72, 0x00, 0x14, 0xC0, 0x09, 0x18, 0x0E,
  0x41, 0xFE, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x68, 0x00, 0x31, 0x80,
  0x18, 0x3F, 0xFC, 0x00, 0xA0, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x7C, 0x11, 0xE7, 0x89, 0x80, 0x65, 0x80, 0x1A,
  0x80, 0x05, 0x80, 0x02, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x5D,
  0x80, 0x00, 0x01, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49,
  0x00, 0x02, 0x07, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0xFC, 0x20,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x02, 0x80, 0x04,
  0x80, 0x08, 0x80, 0x10, 0x80, 0x30, 0x80, 0x60, 0x80, 0x40, 0x80, 0x80,
  0x81, 0x00, 0x83, 0x00, 0x86, 0x00, 0x86, 0x00, 0x8A, 0x00, 0x93, 0x00,
  0xB1, 0x00, 0xE0, 0x80, 0xC0, 0xC0, 0x80, 0x40, 0x80, 0x60, 0x80, 0x30,
  0x80, 0x10, 0x80, 0x18, 0x80, 0x08, 0x80, 0x04, 0x80, 0x06, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x0F, 0x04, 0x73, 0x81, 0xCE,
  0x26, 0x02, 0x30, 0x19, 0x40, 0x09, 0x00, 0x6A, 0x00, 0x50, 0x01, 0x60,
  0x03, 0x80, 0x0F, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x40, 0x03, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x40, 0x01, 0xF0, 0x43, 0x9E, 0x26, 0x01, 0x96, 0x00,
  0x6A, 0x00, 0x16, 0x00, 0x0B, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x01, 0xF0, 0x01, 0xE7, 0x80, 0x60, 0x0C, 0x18, 0x00, 0x82, 0x00, 0x08,
  0x80, 0x01, 0x90, 0x00, 0x16, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x60, 0x00, 0x24,
  0x00, 0x0C, 0xC0, 0x01, 0x08, 0x00, 0x61, 0x80, 0x18, 0x1C, 0x06, 0x00,
  0xFF, 0x80, 0x01, 0xF0, 0x10, 0xF3, 0x82, 0x20, 0x0C, 0x48, 0x00, 0x8A,
  0x00, 0x19, 0x40, 0x01, 0x30, 0x00, 0x36, 0x00, 0x02, 0xC0, 0x00, 0x58,
  0x00, 0x0A, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x58, 0x00, 0x0B, 0x00, 0x01, 0x60,
  0x00, 0x6C, 0x00, 0x0D, 0x40, 0x01, 0x28, 0x00, 0x64, 0x80, 0x18, 0x8C,
  0x06, 0x10, 0xFF, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xF3, 0xC4, 0x30,
  0x0C, 0x8C, 0x00, 0xD3, 0x00, 0x0A, 0x40, 0x00, 0xC8, 0x00, 0x1B, 0x00,
  0x03, 0x40, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x14, 0x00,
  0x03, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00,
  0x05, 0x00, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0x40, 0x01, 0x4C, 0x00,
  0x28, 0xC0, 0x09, 0x0C, 0x06, 0x20, 0xFF, 0x84, 0x01, 0x80, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x03, 0xD1,
  0xFE, 0x60, 0x58, 0x0A, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x03, 0xE0,
  0x3C, 0xFC, 0xC0, 0x0B, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x01, 0xC0, 0x02, 0xC0, 0x1C, 0xFF, 0xE0, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x07, 0xFF, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x80, 0x30, 0x03, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x7C, 0x00, 0x3A, 0x00, 0x2D, 0x80, 0x32, 0x60, 0x31, 0x1F, 0xE0,
  0x80, 0xC0, 0x00, 0x50, 0x00, 0x34, 0x00, 0x09, 0x80, 0x02, 0x20, 0x01,
  0x88, 0x00, 0x43, 0x00, 0x10, 0x40, 0x0C, 0x10, 0x02, 0x06, 0x00, 0x80,
  0x80, 0x60, 0x20, 0x10, 0x0C, 0x04, 0x01, 0x03, 0x00, 0x40, 0x80, 0x18,
  0x20, 0x02, 0x18, 0x00, 0x84, 0x00, 0x31, 0x00, 0x04, 0xC0, 0x01, 0x20,
  0x00, 0x68, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x03, 0xC0, 0x07, 0x00, 0x24, 0x00, 0x50, 0x02,
  0x40, 0x0D, 0x00, 0x24, 0x00, 0x90, 0x06, 0x60, 0x08, 0x80, 0x42, 0x01,
  0x88, 0x04, 0x20, 0x10, 0x80, 0x43, 0x01, 0x0C, 0x0C, 0x10, 0x30, 0x40,
  0x81, 0x03, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x82, 0x06, 0x18, 0x08,
  0x60, 0x21, 0x00, 0x84, 0x02, 0x10, 0x08, 0x40, 0x31, 0x00, 0xCC, 0x01,
  0x30, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x1A, 0x00,
  0x78, 0x00, 0xA0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x04, 0x00, 0xE0, 0x01, 0x88, 0x00, 0x43, 0x00, 0x30, 0x40, 0x08, 0x08,
  0x04, 0x03, 0x03, 0x00, 0x40, 0x80, 0x18, 0x60, 0x02, 0x10, 0x00, 0x48,
  0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x12, 0x00,
  0x08, 0x40, 0x06, 0x18, 0x01, 0x02, 0x00, 0xC0, 0xC0, 0x60, 0x10, 0x10,
  0x02, 0x0C, 0x00, 0xC2, 0x00, 0x11, 0x00, 0x06, 0xC0, 0x00, 0xC0, 0xC0,
  0x00, 0x50, 0x00, 0x16, 0x00, 0x0C, 0x80, 0x02, 0x20, 0x00, 0x8C, 0x00,
  0x61, 0x00, 0x10, 0x40, 0x04, 0x18, 0x03, 0x02, 0x00, 0x80, 0x80, 0x20,
  0x30, 0x18, 0x04, 0x04, 0x01, 0x01, 0x00, 0x60, 0xC0, 0x08, 0x20, 0x02,
  0x08, 0x00, 0xC4, 0x00, 0x11, 0x00, 0x04, 0xC0, 0x01, 0xA0, 0x00, 0x28,
  0x00, 0x0A, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xFF, 0xFE, 0x00, 0xF0,
  0x38, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0xE0, 0x03, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x80, 0x07, 0x80, 0x70, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x01,
  0x80, 0xF8, 0x04, 0x00, 0x00, 0x1F, 0x80, 0x17, 0x0E, 0x01, 0xC0, 0x38,
  0x68, 0x00, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_Thin48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 2, 34, 10, 4, -34 },
  { 10, 9, 12, 15, 3, -34 },
  { 24, 25, 34, 27, 1, -34 },
  { 131, 19, 39, 24, 2, -36 },
  { 224, 29, 35, 34, 3, -35 },
  { 351, 25, 35, 28, 2, -35 },
  { 461, 2, 12, 8, 3, -34 },
  { 464, 9, 42, 12, 2, -34 },
  { 512, 8, 42, 12, 2, -34 },
  { 554, 17, 16, 23, 3, -36 },
  { 588, 20, 22, 24, 2, -28 },
  { 643, 4, 11, 9, 2, -5 },
  { 649, 11, 2, 14, 2, -14 },
  { 652, 2, 3, 10, 4, -3 },
  { 653, 14, 34, 16, 1, -34 },
  { 713, 19, 35, 24, 3, -35 },
  { 797, 10, 34, 24, 4, -34 },
  { 840, 19, 35, 24, 2, -35 },
  { 924, 19, 35, 24, 2, -35 },
  { 1008, 23, 34, 24, 1, -34 },
  { 1106, 19, 34, 24, 3, -34 },
  { 1187, 19, 36, 24, 3, -35 },
  { 1273, 19, 34, 24, 3, -34 },
  { 1354, 19, 35, 24, 3, -35 },
  { 1438, 19, 36, 24, 2, -35 },
  { 1524, 2, 26, 10, 4, -26 },
  { 1531, 4, 32, 10, 2, -26 },
  { 1547, 20, 21, 24, 2, -28 },
  { 1600, 20, 12, 24, 2, -23 },
  { 1630, 20, 21, 24, 2, -28 },
  { 1683, 15, 35, 17, 1, -35 },
  { 1749, 32, 39, 37, 3, -34 },
  { 1905, 24, 34, 24, 0, -34 },
  { 2007, 19, 34, 26, 5, -34 },
  { 2088, 22, 35, 26, 3, -35 },
  { 2185, 21, 34, 29, 5, -34 },
  { 2275, 16, 34, 23, 5, -34 },
  { 2343, 16, 34, 21, 5, -34 },
  { 2411, 25, 35, 31, 3, -35 },
  { 2521, 21, 34, 30, 5, -34 },
  { 2611, 7, 34, 12, 3, -34 },
  { 2641, 10, 42, 10, -4, -34 },
  { 2694, 19, 34, 24, 5, -34 },
  { 2775, 15, 34, 21, 5, -34 },
  { 2839, 27, 34, 37, 5, -34 },
  { 2954, 21, 34, 30, 5, -34 },
  { 3044, 26, 35, 32, 3, -35 },
  { 3158, 17, 34, 24, 5, -34 },
  { 3231, 26, 43, 32, 3, -35 },
  { 3371, 19, 34, 25, 5, -34 },
  { 3452, 19, 35, 23, 2, -35 },
  { 3536, 21, 34, 21, 0, -34 },
  { 3626, 22, 34, 30, 4, -34 },
  { 3720, 24, 34, 24, 0, -34 },
  { 3822, 36, 34, 38, 1, -34 },
  { 3975, 21, 34, 21, 0, -34 },
  { 4065, 21, 34, 21, 0, -34 },
  { 4155, 20, 34, 23, 2, -34 },
  { 4240, 9, 42, 15, 4, -34 },
  { 4288, 14, 34, 16, 1, -34 },
  { 4348, 10, 42, 15, 1, -34 },
  { 4401, 21, 19, 24, 2, -34 },
  { 4451, 19, 2, 19, 0, 4 },
  { 4456, 8, 8, 12, 2, -37 },
  { 4464, 16, 26, 22, 2, -26 },
  { 4516, 19, 36, 25, 4, -36 },
  { 4602, 16, 26, 20, 3, -26 },
  { 4654, 18, 36, 25, 3, -36 },
  { 4735, 17, 26, 23, 3, -26 },
  { 4791, 13, 37, 12, 1, -37 },
  { 4852, 18, 38, 25, 3, -26 },
  { 4938, 17, 36, 25, 4, -36 },
  { 5015, 3, 35, 9, 3, -35 },
  { 5029, 8, 47, 9, -2, -35 },
  { 5076, 16, 36, 19, 4, -36 },
  { 5148, 1, 36, 9, 4, -36 },
  { 5153, 29, 26, 37, 4, -26 },
  { 5248, 17, 26, 25, 4, -26 },
  { 5304, 19, 26, 25, 3, -26 },
  { 5366, 19, 37, 25, 4, -26 },
  { 5454, 19, 37, 25, 2, -26 },
  { 5542, 11, 26, 16, 4, -26 },
  { 5578, 15, 26, 19, 2, -26 },
  { 5627, 11, 32, 13, 1, -32 },
  { 5671, 17, 25, 25, 4, -25 },
  { 5725, 18, 25, 18, 0, -25 },
  { 5782, 28, 25, 30, 1, -25 },
  { 5870, 18, 25, 20, 1, -25 },
  { 5927, 18, 37, 19, 0, -25 },
  { 6011, 15, 25, 18, 2, -25 },
  { 6058, 12, 42, 16, 2, -34 },
  { 6121, 1, 49, 23, 11, -37 },
  { 6128, 13, 42, 16, 2, -34 },
  { 6197, 20, 4, 24, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_Thin48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin48pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_SEMICONDENSED_THIN48PT7B_H_
