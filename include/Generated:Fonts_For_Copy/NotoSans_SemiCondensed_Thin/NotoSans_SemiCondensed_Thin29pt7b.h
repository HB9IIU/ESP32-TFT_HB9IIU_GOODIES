#ifndef _NOTOSANS_SEMICONDENSED_THIN29PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin29pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x01, 0xC0, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x04, 0x10, 0x08, 0x20, 0x10, 0x40, 0x20, 0x80, 0x41, 0x00, 0x84, 0x02,
  0x08, 0x3F, 0xFF, 0x08, 0x20, 0x10, 0x40, 0x20, 0x80, 0x42, 0x01, 0x04,
  0x1F, 0xFF, 0x84, 0x10, 0x08, 0x20, 0x10, 0x40, 0x21, 0x00, 0x82, 0x01,
  0x04, 0x02, 0x08, 0x00, 0x08, 0x03, 0x03, 0xBF, 0x20, 0x88, 0x22, 0x08,
  0x82, 0x20, 0x88, 0x12, 0x03, 0x80, 0x30, 0x0B, 0x02, 0x20, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0xC9, 0x8B, 0x80, 0x80, 0x20, 0x78, 0x04,
  0x22, 0x04, 0x21, 0x02, 0x10, 0x42, 0x08, 0x21, 0x04, 0x11, 0x02, 0x08,
  0x81, 0x04, 0x80, 0x82, 0x4C, 0x42, 0x48, 0xA1, 0x24, 0x28, 0xA4, 0x17,
  0x92, 0x08, 0x11, 0x04, 0x08, 0x82, 0x04, 0x41, 0x04, 0x20, 0x82, 0x10,
  0x42, 0x08, 0x21, 0x02, 0x21, 0x00, 0xF0, 0x1F, 0x00, 0x82, 0x02, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x02, 0x08, 0x08, 0x40, 0x12, 0x00, 0x30,
  0x01, 0x40, 0x18, 0x80, 0x82, 0x06, 0x04, 0x18, 0x08, 0xA0, 0x12, 0x80,
  0x32, 0x00, 0x48, 0x03, 0x10, 0x32, 0x3F, 0x04, 0xFF, 0x08, 0x44, 0x42,
  0x21, 0x08, 0x44, 0x21, 0x08, 0x42, 0x10, 0x82, 0x10, 0x82, 0x10, 0x82,
  0x08, 0x40, 0x82, 0x08, 0x41, 0x08, 0x41, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x21, 0x08, 0x84, 0x44, 0x00, 0x08, 0x02, 0x00, 0x82, 0x21,
  0x7B, 0x83, 0x00, 0xC0, 0x48, 0x21, 0x10, 0x40, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0xFF, 0xF0, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x29, 0x25, 0x20, 0xFE, 0xF0, 0x00, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80,
  0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x0C, 0x00, 0x1F, 0x04, 0x11,
  0x01, 0x20, 0x28, 0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x48, 0x09, 0x01, 0x10,
  0x41, 0xF0, 0x08, 0xCA, 0x98, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x80, 0x3E, 0x18, 0x30, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x0F, 0xFE, 0x1F, 0x86, 0x04,
  0x80, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x18,
  0x1F, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x28, 0x04, 0x7F, 0x80, 0x00, 0x40, 0x06, 0x00, 0x30, 0x02, 0x80,
  0x24, 0x01, 0x20, 0x11, 0x01, 0x08, 0x08, 0x40, 0x82, 0x08, 0x10, 0x40,
  0x84, 0x04, 0x40, 0x22, 0x01, 0x1F, 0xFF, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x7F, 0xC8, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x1F, 0xF0, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x40, 0x4F, 0xF0, 0x07, 0xC3, 0x00,
  0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x8F, 0x16, 0x13, 0x01,
  0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x05, 0x01, 0x10,
  0x21, 0xF8, 0xFF, 0xE0, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x03, 0x00, 0x1F, 0x0C, 0x11, 0x01, 0x40,
  0x28, 0x03, 0x00, 0xA0, 0x12, 0x02, 0x21, 0x83, 0xC0, 0x68, 0x10, 0xC4,
  0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x20, 0x23, 0xF8,
  0x1F, 0x02, 0x0C, 0x40, 0x44, 0x02, 0x40, 0x28, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x14, 0x03, 0x40, 0x32, 0x05, 0x1F, 0x90, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x7F, 0x00, 0xC0, 0x00, 0x00, 0x2C,
  0x60, 0x00, 0x00, 0x00, 0x02, 0x92, 0x52, 0x00, 0x00, 0x10, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x06, 0x00, 0x10, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x00, 0x7C,
  0x82, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x04, 0x08, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x00, 0x00, 0x00, 0x20, 0x30, 0x00, 0xF0, 0x00, 0xE1,
  0xC0, 0x20, 0x04, 0x18, 0x00, 0x42, 0x00, 0x04, 0x80, 0x00, 0x90, 0x3C,
  0x14, 0x08, 0x41, 0x82, 0x08, 0x30, 0x81, 0x06, 0x10, 0x20, 0xC2, 0x04,
  0x18, 0x40, 0x83, 0x08, 0x10, 0x61, 0x02, 0x0C, 0x20, 0xC2, 0x82, 0x24,
  0x50, 0x38, 0x61, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x03, 0x00, 0x1F, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0A, 0x00, 0x14,
  0x00, 0x48, 0x00, 0x88, 0x01, 0x10, 0x04, 0x20, 0x08, 0x20, 0x10, 0x40,
  0x40, 0x80, 0x80, 0x81, 0xFF, 0x04, 0x02, 0x08, 0x02, 0x10, 0x04, 0x40,
  0x08, 0x80, 0x09, 0x00, 0x14, 0x00, 0x28, 0x00, 0x20, 0xFF, 0x10, 0x12,
  0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x50, 0x33, 0xFE,
  0x40, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x6F, 0xF0, 0x07, 0xF0, 0x40, 0x4C, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF,
  0x80, 0xFE, 0x04, 0x0C, 0x20, 0x11, 0x00, 0x48, 0x01, 0x40, 0x0A, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x02, 0x80, 0x14, 0x01, 0x20, 0x19, 0x01, 0x0F, 0xF0, 0x00,
  0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x0F, 0xFA, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x03, 0xFE, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x03, 0xF8, 0x18, 0x08, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x07, 0xF8, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x40, 0x02, 0x80, 0x04, 0x80, 0x08, 0xC0, 0x10, 0x7F, 0xC0, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0xFF, 0xF8, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0xF4, 0x44, 0x44, 0x44, 0x44, 0x44,
  0x44, 0x44, 0x44, 0x44, 0xF0, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x42, 0x0B,
  0xC0, 0x80, 0x30, 0x0A, 0x02, 0x40, 0x88, 0x31, 0x04, 0x21, 0x04, 0x40,
  0x90, 0x16, 0x03, 0x20, 0x44, 0x08, 0x41, 0x08, 0x20, 0x84, 0x08, 0x81,
  0x10, 0x12, 0x01, 0x40, 0x28, 0x02, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x0F, 0xF8, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x5A, 0x00, 0x2D, 0x00, 0x26, 0x80, 0x13, 0x20, 0x09, 0x90,
  0x08, 0xC8, 0x04, 0x62, 0x02, 0x31, 0x02, 0x18, 0x41, 0x0C, 0x21, 0x06,
  0x10, 0x83, 0x04, 0x41, 0x82, 0x40, 0xC1, 0x20, 0x60, 0x50, 0x30, 0x30,
  0x18, 0x08, 0x08, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0xA0, 0x19, 0x01,
  0x90, 0x18, 0x81, 0x88, 0x18, 0x41, 0x82, 0x18, 0x21, 0x81, 0x18, 0x11,
  0x80, 0x98, 0x09, 0x80, 0x58, 0x03, 0x80, 0x38, 0x01, 0x80, 0x10, 0x07,
  0xE0, 0x18, 0x10, 0x20, 0x08, 0x40, 0x04, 0x40, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x40, 0x02, 0x40, 0x04, 0x20,
  0x08, 0x10, 0x18, 0x0F, 0xE0, 0xFE, 0x20, 0x68, 0x0A, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x1B, 0xF8, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x18, 0x10,
  0x20, 0x08, 0x40, 0x04, 0x40, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x02, 0x40, 0x02, 0x40, 0x04, 0x20, 0x04, 0x10, 0x18,
  0x0F, 0xE0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0xFE, 0x10, 0x32, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80,
  0x50, 0x12, 0x04, 0x7F, 0x08, 0x21, 0x04, 0x20, 0x44, 0x08, 0x80, 0x90,
  0x12, 0x01, 0x40, 0x28, 0x02, 0x0F, 0xC3, 0x02, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x04, 0xFF,
  0x80, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xA0, 0x04, 0x80, 0x43, 0xFC, 0x00, 0x80,
  0x06, 0x00, 0x14, 0x00, 0x50, 0x02, 0x40, 0x08, 0x80, 0x22, 0x01, 0x08,
  0x04, 0x10, 0x10, 0x40, 0x81, 0x02, 0x02, 0x08, 0x08, 0x40, 0x21, 0x00,
  0x84, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00,
  0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x03, 0x00, 0xA0, 0x14, 0x05,
  0x01, 0x20, 0x28, 0x09, 0x02, 0x40, 0x48, 0x11, 0x04, 0x20, 0x88, 0x21,
  0x04, 0x41, 0x08, 0x42, 0x08, 0x42, 0x08, 0x81, 0x10, 0x44, 0x08, 0x82,
  0x20, 0x48, 0x11, 0x02, 0x40, 0x50, 0x0A, 0x02, 0x80, 0x50, 0x14, 0x03,
  0x00, 0xA0, 0x18, 0x02, 0x00, 0x40, 0x10, 0x00, 0x40, 0x1A, 0x00, 0x88,
  0x08, 0x40, 0x41, 0x04, 0x08, 0x20, 0x22, 0x00, 0x90, 0x05, 0x00, 0x10,
  0x00, 0x80, 0x0A, 0x00, 0x50, 0x04, 0x40, 0x22, 0x02, 0x08, 0x10, 0x41,
  0x01, 0x10, 0x04, 0x80, 0x28, 0x00, 0x80, 0x80, 0x0C, 0x00, 0x90, 0x04,
  0x80, 0x42, 0x02, 0x10, 0x20, 0x41, 0x02, 0x10, 0x08, 0x80, 0x48, 0x01,
  0x40, 0x0A, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x7F, 0xF0, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x00,
  0xFF, 0xF0, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xC0, 0x80, 0x20, 0x10, 0x04, 0x02,
  0x01, 0x00, 0x40, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08,
  0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0xFC, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x07, 0xF0, 0x02, 0x00, 0x28, 0x01, 0x40, 0x11, 0x00, 0x88, 0x08,
  0x20, 0x41, 0x04, 0x04, 0x20, 0x22, 0x00, 0x90, 0x05, 0x00, 0x30, 0xFF,
  0xE0, 0xC2, 0x08, 0x30, 0x0C, 0x0C, 0x60, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x1F, 0x38, 0x50, 0x14, 0x06, 0x01, 0x80, 0x60, 0x34, 0x0C, 0xFD,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x87, 0x09, 0x88,
  0xA0, 0x4C, 0x02, 0xC0, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x02, 0xC0, 0x2C, 0x02, 0xA0, 0x49, 0xF8, 0x0F, 0x08, 0x58,
  0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x02,
  0x01, 0x80, 0x3F, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x43,
  0x09, 0x8D, 0x40, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x34, 0x0A, 0x7E, 0x40, 0x06, 0x0C,
  0x44, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x07, 0xFF, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x10, 0x04, 0x00, 0xFF, 0x0F, 0x88, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x41, 0xFC, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x0C, 0x06, 0x35, 0x01, 0xC0,
  0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0xD0, 0x29, 0xF9, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x05,
  0x01, 0x1F, 0xC0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x23,
  0xC4, 0x84, 0xA0, 0x58, 0x0B, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0xF0, 0x0A,
  0xAA, 0xAA, 0xAA, 0x80, 0x18, 0xC0, 0x00, 0x00, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x85, 0xC0, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x02, 0x81, 0x20, 0x88, 0x42,
  0x20, 0x88, 0x26, 0x0A, 0x83, 0x10, 0x84, 0x20, 0x88, 0x12, 0x04, 0x80,
  0xA0, 0x10, 0xFF, 0xFF, 0xFC, 0x0E, 0x0C, 0x2C, 0x44, 0x6A, 0x0A, 0x0B,
  0x01, 0x01, 0x80, 0x40, 0x60, 0x10, 0x18, 0x04, 0x06, 0x01, 0x01, 0x80,
  0x40, 0x60, 0x10, 0x18, 0x04, 0x06, 0x01, 0x01, 0x80, 0x40, 0x60, 0x10,
  0x18, 0x04, 0x06, 0x01, 0x01, 0x0F, 0x12, 0x12, 0x81, 0x60, 0x2C, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x04, 0x06, 0x31, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x80, 0x90, 0x31,
  0xF8, 0x07, 0x09, 0x88, 0xA0, 0x4C, 0x02, 0xC0, 0x28, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0xC0, 0x2C, 0x02, 0xA0, 0x49,
  0xF8, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00,
  0x04, 0x06, 0x35, 0x02, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xD0, 0x29, 0xF9, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x0F, 0x22, 0x86, 0x0C,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x1C, 0x08,
  0x64, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0xE0, 0x06, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x40, 0x28, 0x09, 0xFC, 0x20, 0x40, 0x81, 0x0F, 0xE4, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x78, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x50, 0x33, 0xF4, 0x80, 0x28, 0x09, 0x01, 0x20, 0x22,
  0x08, 0x41, 0x08, 0x20, 0x88, 0x11, 0x02, 0x20, 0x28, 0x05, 0x00, 0xA0,
  0x14, 0x01, 0x00, 0xC0, 0x40, 0x50, 0x30, 0x24, 0x0C, 0x09, 0x02, 0x82,
  0x21, 0x20, 0x88, 0x48, 0x42, 0x11, 0x10, 0x88, 0x44, 0x12, 0x11, 0x04,
  0x84, 0x81, 0x20, 0xA0, 0x50, 0x28, 0x0C, 0x0A, 0x03, 0x01, 0x00, 0x80,
  0x40, 0x80, 0x50, 0x22, 0x10, 0x84, 0x12, 0x04, 0x80, 0xC0, 0x30, 0x0C,
  0x04, 0x82, 0x10, 0x84, 0x40, 0x90, 0x18, 0x04, 0x80, 0x28, 0x05, 0x01,
  0x20, 0x22, 0x04, 0x41, 0x08, 0x20, 0x84, 0x11, 0x02, 0x20, 0x24, 0x05,
  0x00, 0xA0, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x01, 0xC0, 0x00, 0x7F, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10,
  0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x03, 0xFE, 0x07, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xE0, 0x60, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x0C, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x80, 0x30, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x07, 0x06, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x10, 0x30, 0xC0, 0x7E, 0x18, 0x1E,
};

const GFXglyph NotoSans_SemiCondensed_Thin29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 21, 6, 2, -21 },
  { 7, 5, 8, 9, 2, -21 },
  { 12, 15, 21, 16, 1, -21 },
  { 52, 10, 24, 15, 2, -22 },
  { 82, 17, 21, 21, 2, -21 },
  { 127, 14, 21, 17, 2, -21 },
  { 164, 1, 8, 5, 2, -21 },
  { 165, 5, 26, 7, 1, -21 },
  { 182, 5, 26, 7, 1, -21 },
  { 199, 10, 10, 14, 2, -22 },
  { 212, 12, 13, 15, 1, -17 },
  { 232, 3, 7, 5, 1, -3 },
  { 235, 7, 1, 9, 1, -8 },
  { 236, 2, 2, 6, 2, -2 },
  { 237, 9, 21, 9, 0, -21 },
  { 261, 11, 21, 15, 2, -21 },
  { 290, 5, 21, 15, 3, -21 },
  { 304, 11, 21, 15, 2, -21 },
  { 333, 12, 21, 15, 1, -21 },
  { 365, 13, 21, 15, 1, -21 },
  { 400, 11, 21, 15, 2, -21 },
  { 429, 11, 21, 15, 2, -21 },
  { 458, 11, 21, 15, 2, -21 },
  { 487, 11, 21, 15, 2, -21 },
  { 516, 12, 21, 15, 1, -21 },
  { 548, 2, 15, 6, 2, -15 },
  { 552, 3, 19, 6, 1, -15 },
  { 560, 12, 13, 15, 1, -17 },
  { 580, 12, 7, 15, 1, -14 },
  { 591, 12, 13, 15, 1, -17 },
  { 611, 8, 21, 10, 1, -21 },
  { 632, 19, 24, 23, 2, -21 },
  { 689, 15, 21, 15, 0, -21 },
  { 729, 11, 21, 16, 3, -21 },
  { 758, 13, 21, 16, 2, -21 },
  { 793, 13, 21, 18, 3, -21 },
  { 828, 10, 21, 14, 3, -21 },
  { 855, 10, 21, 13, 3, -21 },
  { 882, 15, 21, 19, 2, -21 },
  { 922, 12, 21, 18, 3, -21 },
  { 954, 4, 21, 8, 2, -21 },
  { 965, 6, 26, 6, -2, -21 },
  { 985, 11, 21, 14, 3, -21 },
  { 1014, 9, 21, 13, 3, -21 },
  { 1038, 17, 21, 22, 3, -21 },
  { 1083, 12, 21, 18, 3, -21 },
  { 1115, 16, 21, 19, 2, -21 },
  { 1157, 10, 21, 15, 3, -21 },
  { 1184, 16, 26, 19, 2, -21 },
  { 1236, 11, 21, 15, 3, -21 },
  { 1265, 12, 21, 14, 1, -21 },
  { 1297, 13, 21, 13, 0, -21 },
  { 1332, 13, 21, 18, 3, -21 },
  { 1367, 14, 21, 14, 0, -21 },
  { 1404, 21, 21, 23, 1, -21 },
  { 1460, 13, 21, 13, 0, -21 },
  { 1495, 13, 21, 13, 0, -21 },
  { 1530, 12, 21, 14, 1, -21 },
  { 1562, 5, 26, 9, 3, -21 },
  { 1579, 9, 21, 9, 0, -21 },
  { 1603, 6, 26, 9, 1, -21 },
  { 1623, 13, 12, 15, 1, -21 },
  { 1643, 11, 1, 11, 0, 2 },
  { 1645, 5, 4, 7, 1, -22 },
  { 1648, 10, 16, 13, 1, -16 },
  { 1668, 12, 22, 15, 2, -22 },
  { 1701, 9, 16, 12, 2, -16 },
  { 1719, 11, 22, 15, 2, -22 },
  { 1750, 10, 16, 14, 2, -16 },
  { 1770, 9, 22, 7, 0, -22 },
  { 1795, 11, 23, 15, 2, -16 },
  { 1827, 11, 22, 15, 2, -22 },
  { 1858, 2, 21, 6, 2, -21 },
  { 1864, 5, 28, 6, -1, -21 },
  { 1882, 10, 22, 12, 2, -22 },
  { 1910, 1, 22, 6, 2, -22 },
  { 1913, 18, 16, 22, 2, -16 },
  { 1949, 11, 16, 15, 2, -16 },
  { 1971, 11, 16, 15, 2, -16 },
  { 1993, 12, 23, 15, 2, -16 },
  { 2028, 11, 23, 15, 2, -16 },
  { 2060, 7, 16, 10, 2, -16 },
  { 2074, 10, 16, 12, 1, -16 },
  { 2094, 7, 19, 8, 0, -19 },
  { 2111, 10, 15, 15, 2, -15 },
  { 2130, 11, 15, 11, 0, -15 },
  { 2151, 18, 15, 18, 0, -15 },
  { 2185, 10, 15, 12, 1, -15 },
  { 2204, 11, 22, 11, 0, -15 },
  { 2235, 9, 15, 11, 1, -15 },
  { 2252, 8, 26, 10, 1, -21 },
  { 2278, 1, 29, 14, 6, -22 },
  { 2282, 8, 26, 10, 1, -21 },
  { 2308, 12, 2, 15, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_Thin29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin29pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_SEMICONDENSED_THIN29PT7B_H_
