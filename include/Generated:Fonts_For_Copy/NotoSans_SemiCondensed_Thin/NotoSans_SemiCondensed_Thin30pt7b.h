#ifndef _NOTOSANS_SEMICONDENSED_THIN30PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin30pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x01, 0xC0, 0x8C, 0x63, 0x18, 0xC6, 0x20,
  0x02, 0x18, 0x08, 0x20, 0x10, 0x40, 0x20, 0x80, 0x41, 0x00, 0x82, 0x1F,
  0xFF, 0x84, 0x10, 0x08, 0x20, 0x10, 0x40, 0x20, 0x80, 0x41, 0x00, 0x82,
  0x1F, 0xFF, 0x84, 0x10, 0x08, 0x20, 0x10, 0x40, 0x20, 0x80, 0x41, 0x01,
  0x04, 0x02, 0x08, 0x00, 0x04, 0x00, 0x80, 0xFE, 0x22, 0x28, 0x41, 0x08,
  0x21, 0x04, 0x20, 0x84, 0x10, 0x81, 0x90, 0x0C, 0x00, 0x60, 0x0B, 0x01,
  0x10, 0x21, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10, 0x45, 0x8B, 0x0B, 0x80,
  0x20, 0x04, 0x00, 0x38, 0x00, 0x11, 0x01, 0x08, 0x40, 0x82, 0x08, 0x20,
  0x82, 0x10, 0x20, 0x84, 0x08, 0x22, 0x02, 0x08, 0x80, 0x82, 0x20, 0x20,
  0x93, 0xC8, 0x25, 0x0A, 0x12, 0x42, 0x44, 0x90, 0x4E, 0x48, 0x10, 0x12,
  0x04, 0x08, 0x81, 0x02, 0x20, 0x41, 0x08, 0x10, 0x41, 0x04, 0x20, 0x42,
  0x08, 0x10, 0x84, 0x03, 0xC0, 0x0E, 0x00, 0x23, 0x00, 0x82, 0x01, 0x02,
  0x04, 0x04, 0x04, 0x08, 0x08, 0x20, 0x10, 0x40, 0x11, 0x00, 0x1C, 0x00,
  0x20, 0x01, 0xA0, 0x04, 0x20, 0x50, 0x20, 0xA0, 0x21, 0x40, 0x22, 0x80,
  0x49, 0x00, 0x52, 0x00, 0x44, 0x01, 0x44, 0x04, 0x47, 0xF0, 0x40, 0xFE,
  0x0C, 0x41, 0x08, 0x21, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x41, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08, 0x30, 0xC2, 0x08, 0x21, 0x08,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x21, 0x08, 0x84, 0x44,
  0x00, 0x04, 0x01, 0x00, 0x40, 0x10, 0xC4, 0xCF, 0xC0, 0xC0, 0x48, 0x11,
  0x08, 0x44, 0x08, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x03, 0xFF, 0xE0, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x00, 0x29, 0x25, 0x20, 0xFE, 0x70, 0x01, 0x01, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x80, 0x80, 0x80, 0x0F, 0x06, 0x11, 0x01, 0x20, 0x28, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x05, 0x00, 0xA0, 0x22, 0x08, 0x3E, 0x00, 0x0C, 0x56,
  0x61, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x1E, 0x0C, 0x32, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0xFF, 0xC0, 0x0F, 0x03, 0x0C,
  0xC0, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04,
  0x1F, 0x80, 0x1C, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x02, 0x80, 0x67, 0xF8, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x50, 0x01, 0x40, 0x09, 0x00, 0x24, 0x01, 0x10, 0x08, 0x40, 0x21, 0x01,
  0x04, 0x08, 0x10, 0x20, 0x41, 0x01, 0x08, 0x04, 0x20, 0x10, 0x7F, 0xFC,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x7F, 0xC8, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0xBF, 0x08, 0x10, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x40,
  0x6F, 0xF0, 0x03, 0xC0, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x09, 0xF8, 0xA0, 0x4C, 0x02, 0x80, 0x28, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x02, 0x40, 0x24, 0x02, 0x20, 0x41, 0xF8, 0xFF,
  0xE0, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x0F, 0x06, 0x11, 0x01, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x0A, 0x02, 0x20, 0xC2, 0x20, 0x38, 0x09, 0x86, 0x0C, 0x80, 0xA0,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x14, 0x04, 0x7F, 0x00, 0x0F,
  0x01, 0x0C, 0x20, 0x24, 0x02, 0x40, 0x14, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x14, 0x01, 0x40, 0x12, 0x03, 0x30, 0xD0, 0xF1, 0x00, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x83, 0xF0, 0xF0, 0x00, 0x00, 0x07,
  0x6C, 0x00, 0x00, 0x00, 0x00, 0x52, 0x4A, 0x40, 0x00, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x08, 0x00, 0x00, 0x3C, 0x61, 0x00, 0x40, 0x10, 0x08, 0x04, 0x02,
  0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x00,
  0x00, 0x00, 0x01, 0x01, 0x80, 0x03, 0xFE, 0x00, 0xC0, 0x10, 0x10, 0x00,
  0x82, 0x00, 0x04, 0x40, 0x00, 0x24, 0x00, 0x02, 0x80, 0xFC, 0x28, 0x10,
  0x41, 0x82, 0x04, 0x18, 0x40, 0x41, 0x84, 0x04, 0x18, 0x40, 0x41, 0x84,
  0x08, 0x18, 0x40, 0x81, 0x84, 0x08, 0x28, 0x20, 0xC2, 0x82, 0x14, 0x48,
  0x1E, 0x38, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x04, 0x00, 0x3F, 0x80, 0x01, 0x00, 0x05, 0x00, 0x0A, 0x00, 0x12,
  0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x04, 0x10, 0x08, 0x20, 0x10, 0x40,
  0x40, 0x40, 0x80, 0x81, 0xFF, 0x04, 0x01, 0x08, 0x02, 0x10, 0x04, 0x40,
  0x04, 0x80, 0x09, 0x00, 0x14, 0x00, 0x18, 0x00, 0x20, 0xFF, 0x88, 0x04,
  0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x4F, 0xF8,
  0x80, 0xC8, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x28, 0x04, 0xFF, 0x80, 0x03, 0xE0, 0x60, 0xC4, 0x00, 0x40, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x80, 0x03, 0xFC, 0xFF, 0x82, 0x01, 0x88, 0x02, 0x20, 0x04,
  0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x00,
  0x48, 0x02, 0x20, 0x30, 0xFF, 0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xE8, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xFA, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00,
  0x00, 0xF0, 0x1C, 0x1C, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x07, 0xF8, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x80, 0x05, 0x00, 0x09,
  0x00, 0x11, 0x80, 0x20, 0xFF, 0x80, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0xE0, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0xF4, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44,
  0x44, 0x44, 0x44, 0xF0, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x0B, 0xC0,
  0x80, 0x38, 0x04, 0x80, 0x88, 0x10, 0x82, 0x08, 0x60, 0x84, 0x08, 0x80,
  0x90, 0x0B, 0x00, 0xC8, 0x08, 0x40, 0x84, 0x08, 0x20, 0x81, 0x08, 0x10,
  0x80, 0x88, 0x04, 0x80, 0x48, 0x02, 0x80, 0x30, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xC0, 0x80,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x74, 0x00, 0x3A, 0x00, 0x2D, 0x00, 0x16,
  0x40, 0x13, 0x20, 0x09, 0x90, 0x04, 0xC4, 0x04, 0x62, 0x02, 0x30, 0x81,
  0x18, 0x41, 0x0C, 0x20, 0x86, 0x08, 0x83, 0x04, 0x41, 0x82, 0x20, 0xC0,
  0xA0, 0x60, 0x50, 0x30, 0x28, 0x18, 0x08, 0x08, 0x80, 0x0E, 0x00, 0x70,
  0x03, 0x40, 0x1A, 0x00, 0xC8, 0x06, 0x20, 0x31, 0x01, 0x84, 0x0C, 0x20,
  0x60, 0x83, 0x02, 0x18, 0x10, 0xC0, 0x46, 0x02, 0x30, 0x09, 0x80, 0x2C,
  0x01, 0x60, 0x07, 0x00, 0x38, 0x00, 0x80, 0x03, 0xE0, 0x0C, 0x10, 0x10,
  0x0C, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x10,
  0x08, 0x0F, 0xF0, 0xFF, 0x10, 0x1A, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x50, 0x0A, 0x06, 0x7F, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x03, 0xE0, 0x0C, 0x10,
  0x10, 0x0C, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04,
  0x10, 0x08, 0x0F, 0xF0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x08, 0xFF, 0x88, 0x04, 0x80, 0x48, 0x02, 0x80, 0x28, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x48, 0x08, 0x87, 0x0F, 0xA0, 0x82, 0x08, 0x10, 0x81,
  0x08, 0x08, 0x80, 0x88, 0x04, 0x80, 0x48, 0x02, 0x80, 0x30, 0x0F, 0x86,
  0x0D, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x20, 0x0D, 0xFE, 0x00, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x50, 0x04, 0xC0,
  0x41, 0xFC, 0x00, 0x80, 0x02, 0x80, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00,
  0x84, 0x01, 0x08, 0x02, 0x10, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x80,
  0x41, 0x00, 0x82, 0x01, 0x08, 0x01, 0x10, 0x02, 0x20, 0x04, 0x80, 0x05,
  0x00, 0x0A, 0x00, 0x18, 0x00, 0x10, 0x00, 0x80, 0x20, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x90, 0x14, 0x02, 0x40, 0x50, 0x09, 0x01, 0x20, 0x24,
  0x04, 0x81, 0x08, 0x22, 0x04, 0x20, 0x88, 0x10, 0x82, 0x10, 0x42, 0x08,
  0x42, 0x04, 0x41, 0x08, 0x11, 0x04, 0x20, 0x44, 0x08, 0x81, 0x10, 0x24,
  0x02, 0x80, 0x90, 0x0A, 0x02, 0x40, 0x28, 0x06, 0x00, 0xA0, 0x18, 0x01,
  0x00, 0x60, 0x04, 0x00, 0x80, 0x40, 0x19, 0x00, 0x88, 0x08, 0x20, 0x41,
  0x04, 0x04, 0x20, 0x22, 0x00, 0x90, 0x05, 0x00, 0x18, 0x00, 0xC0, 0x0A,
  0x00, 0x48, 0x04, 0x40, 0x21, 0x02, 0x08, 0x10, 0x21, 0x01, 0x10, 0x04,
  0x80, 0x18, 0x00, 0x80, 0x80, 0x0A, 0x00, 0x90, 0x04, 0x40, 0x42, 0x02,
  0x08, 0x20, 0x41, 0x01, 0x10, 0x08, 0x80, 0x24, 0x01, 0x40, 0x0A, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x00, 0x7F, 0xF0, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x0F,
  0xFF, 0x80, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xC0, 0x80, 0x80, 0x40, 0x40, 0x40,
  0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x04, 0x02,
  0x02, 0x02, 0x01, 0x01, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x07, 0xF0,
  0x02, 0x00, 0x18, 0x01, 0x40, 0x09, 0x00, 0x88, 0x04, 0x20, 0x41, 0x02,
  0x04, 0x20, 0x21, 0x00, 0x90, 0x04, 0x80, 0x18, 0x00, 0x80, 0xFF, 0xF0,
  0x82, 0x08, 0x20, 0x80, 0x1F, 0x08, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x3F, 0x30, 0x50, 0x14, 0x06, 0x01, 0x80, 0x60, 0x14, 0x0C, 0xFD,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0xF8,
  0xB0, 0x4A, 0x02, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0xC0, 0x1C, 0x02, 0xC0, 0x2A, 0x04, 0x9F, 0x80, 0x1F,
  0xC8, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7F, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0xF9, 0x20, 0xA8, 0x0E, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x14, 0x06,
  0x80, 0xCF, 0xE8, 0x1F, 0x04, 0x11, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60,
  0x0F, 0xFF, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x08,
  0xFE, 0x07, 0x84, 0x04, 0x02, 0x01, 0x00, 0x80, 0x41, 0xFC, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x1F, 0xA4, 0x0D, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x80, 0xD0, 0x29,
  0xF9, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x9F, 0xE0, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x7C, 0xB0, 0x54,
  0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0xB0, 0x0A, 0xAA, 0xAA, 0xAA,
  0xA0, 0x10, 0xC0, 0x00, 0x00, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x2E, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x03, 0x80, 0xA0, 0x48, 0x22, 0x10, 0x88,
  0x22, 0x09, 0x82, 0x90, 0xC4, 0x20, 0x88, 0x22, 0x04, 0x80, 0xA0, 0x28,
  0x04, 0xFF, 0xFF, 0xFE, 0x9F, 0x0F, 0x94, 0x12, 0x0B, 0x01, 0x81, 0x60,
  0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80,
  0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00,
  0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x8F, 0x96, 0x0A, 0x80, 0xE0, 0x1C,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x1F, 0x82, 0x04, 0x40, 0x28, 0x02, 0x80, 0x28,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x24,
  0x02, 0x60, 0x41, 0xF8, 0x9F, 0x14, 0x13, 0x01, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xB0,
  0x25, 0xF8, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x00,
  0x1F, 0x24, 0x15, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x80, 0xD0, 0x29, 0xF9, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0xBF, 0x82, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x3F, 0xD0,
  0x04, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x07, 0x00, 0x20, 0x04,
  0x01, 0x00, 0x40, 0x18, 0x09, 0xFC, 0x20, 0x20, 0x20, 0x20, 0xFF, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x10, 0x1F, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x80, 0xD0, 0x29, 0xF9,
  0x80, 0x30, 0x05, 0x00, 0xA0, 0x24, 0x04, 0x40, 0x88, 0x21, 0x04, 0x10,
  0x82, 0x20, 0x44, 0x04, 0x80, 0xA0, 0x14, 0x01, 0x80, 0x20, 0x80, 0x40,
  0x50, 0x10, 0x14, 0x0A, 0x05, 0x02, 0x81, 0x40, 0xA0, 0x88, 0x24, 0x22,
  0x11, 0x08, 0x84, 0x42, 0x11, 0x11, 0x04, 0x82, 0x41, 0x20, 0x90, 0x48,
  0x24, 0x0C, 0x0A, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x80, 0x68,
  0x09, 0x02, 0x10, 0x81, 0x10, 0x24, 0x02, 0x80, 0x20, 0x0C, 0x01, 0x40,
  0x48, 0x10, 0x82, 0x08, 0x81, 0x10, 0x14, 0x01, 0x80, 0x14, 0x02, 0x40,
  0x24, 0x02, 0x20, 0x42, 0x04, 0x20, 0x41, 0x08, 0x10, 0x81, 0x08, 0x09,
  0x00, 0x90, 0x0A, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x00, 0xE0, 0x00, 0x7F, 0x80, 0x40, 0x40, 0x20,
  0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01,
  0xFF, 0x0F, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x30, 0xC0, 0x20, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x10, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x04, 0x03, 0x04, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0xE0, 0x3C, 0x0E, 0x18,
  0xC0, 0x38,
};

const GFXglyph NotoSans_SemiCondensed_Thin30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 21, 6, 2, -21 },
  { 7, 5, 7, 9, 2, -21 },
  { 12, 15, 21, 17, 1, -21 },
  { 52, 11, 25, 15, 2, -23 },
  { 87, 18, 22, 21, 2, -22 },
  { 137, 15, 22, 18, 2, -22 },
  { 179, 1, 7, 5, 2, -21 },
  { 180, 6, 26, 8, 1, -21 },
  { 200, 5, 26, 8, 1, -21 },
  { 217, 10, 11, 14, 2, -23 },
  { 231, 13, 13, 15, 1, -17 },
  { 253, 3, 7, 5, 1, -3 },
  { 256, 7, 1, 9, 1, -9 },
  { 257, 2, 2, 6, 2, -2 },
  { 258, 8, 21, 10, 1, -21 },
  { 279, 11, 22, 15, 2, -22 },
  { 310, 6, 21, 15, 3, -21 },
  { 326, 11, 22, 15, 2, -22 },
  { 357, 12, 22, 15, 1, -22 },
  { 390, 14, 22, 15, 1, -22 },
  { 429, 11, 21, 15, 2, -21 },
  { 458, 12, 22, 15, 2, -22 },
  { 491, 11, 21, 15, 2, -21 },
  { 520, 11, 22, 15, 2, -22 },
  { 551, 12, 22, 15, 1, -22 },
  { 584, 2, 16, 6, 2, -16 },
  { 588, 3, 20, 6, 1, -16 },
  { 596, 13, 13, 15, 1, -17 },
  { 618, 13, 7, 15, 1, -14 },
  { 630, 13, 13, 15, 1, -17 },
  { 652, 9, 22, 11, 1, -22 },
  { 677, 20, 24, 23, 2, -21 },
  { 737, 15, 21, 15, 0, -21 },
  { 777, 12, 21, 16, 3, -21 },
  { 809, 13, 22, 16, 2, -22 },
  { 845, 14, 21, 18, 3, -21 },
  { 882, 10, 21, 15, 3, -21 },
  { 909, 10, 21, 13, 3, -21 },
  { 936, 15, 22, 19, 2, -22 },
  { 978, 13, 21, 19, 3, -21 },
  { 1013, 4, 21, 8, 2, -21 },
  { 1024, 6, 26, 6, -2, -21 },
  { 1044, 12, 21, 15, 3, -21 },
  { 1076, 10, 21, 13, 3, -21 },
  { 1103, 17, 21, 23, 3, -21 },
  { 1148, 13, 21, 19, 3, -21 },
  { 1183, 16, 22, 20, 2, -22 },
  { 1227, 11, 21, 15, 3, -21 },
  { 1256, 16, 27, 20, 2, -22 },
  { 1310, 12, 21, 15, 3, -21 },
  { 1342, 11, 22, 15, 2, -22 },
  { 1373, 13, 21, 13, 0, -21 },
  { 1408, 13, 21, 19, 3, -21 },
  { 1443, 15, 21, 15, 0, -21 },
  { 1483, 22, 21, 24, 1, -21 },
  { 1541, 13, 21, 13, 0, -21 },
  { 1576, 13, 21, 13, 0, -21 },
  { 1611, 13, 21, 15, 1, -21 },
  { 1646, 5, 26, 9, 3, -21 },
  { 1663, 8, 21, 10, 1, -21 },
  { 1684, 6, 26, 9, 1, -21 },
  { 1704, 13, 13, 15, 1, -22 },
  { 1726, 12, 1, 12, 0, 3 },
  { 1728, 5, 5, 7, 1, -23 },
  { 1732, 10, 16, 14, 1, -16 },
  { 1752, 12, 23, 16, 2, -23 },
  { 1787, 10, 16, 12, 2, -16 },
  { 1807, 11, 23, 16, 2, -23 },
  { 1839, 11, 16, 14, 2, -16 },
  { 1861, 9, 23, 8, 0, -23 },
  { 1887, 11, 23, 16, 2, -16 },
  { 1919, 11, 23, 15, 2, -23 },
  { 1951, 2, 22, 6, 2, -22 },
  { 1957, 5, 29, 6, -1, -22 },
  { 1976, 10, 23, 12, 2, -23 },
  { 2005, 1, 23, 6, 2, -23 },
  { 2008, 19, 16, 23, 2, -16 },
  { 2046, 11, 16, 15, 2, -16 },
  { 2068, 12, 16, 15, 2, -16 },
  { 2092, 11, 23, 16, 3, -16 },
  { 2124, 11, 23, 16, 2, -16 },
  { 2156, 7, 16, 10, 3, -16 },
  { 2170, 10, 16, 12, 1, -16 },
  { 2190, 8, 20, 8, 0, -20 },
  { 2210, 11, 16, 15, 2, -16 },
  { 2232, 11, 16, 11, 0, -16 },
  { 2254, 18, 16, 19, 0, -16 },
  { 2290, 11, 16, 13, 1, -16 },
  { 2312, 12, 23, 12, 0, -16 },
  { 2347, 9, 16, 11, 1, -16 },
  { 2365, 8, 26, 10, 1, -21 },
  { 2391, 1, 30, 14, 7, -23 },
  { 2395, 8, 26, 10, 1, -21 },
  { 2421, 13, 3, 15, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_Thin30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin30pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_SEMICONDENSED_THIN30PT7B_H_
