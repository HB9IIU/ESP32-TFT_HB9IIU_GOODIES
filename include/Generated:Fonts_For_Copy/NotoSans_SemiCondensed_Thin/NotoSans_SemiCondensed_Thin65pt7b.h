#ifndef _NOTOSANS_SEMICONDENSED_THIN65PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin65pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x6E, 0xFE,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x02, 0x80,
  0x50, 0x0A, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x40, 0x02, 0x00, 0x00,
  0x20, 0x01, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x20, 0x00, 0x02, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x08, 0x00, 0x01, 0x80, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x01, 0x80, 0x00, 0x10, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x80, 0x04,
  0x00, 0x00, 0x40, 0x02, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x07, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x80, 0x00, 0x08, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x40, 0x02, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x38, 0x41, 0xF0, 0x70, 0x20, 0x18, 0x30, 0x10, 0x00, 0x30, 0x08, 0x00,
  0x30, 0x04, 0x00, 0x18, 0x02, 0x00, 0x08, 0x01, 0x00, 0x0C, 0x00, 0x80,
  0x06, 0x00, 0x40, 0x03, 0x00, 0x20, 0x01, 0x80, 0x10, 0x00, 0x40, 0x08,
  0x00, 0x30, 0x04, 0x00, 0x18, 0x02, 0x00, 0x06, 0x01, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x60, 0x40, 0x00, 0x1C, 0x20, 0x00, 0x07, 0x90, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0x3C, 0x00,
  0x00, 0x87, 0x00, 0x00, 0x40, 0xE0, 0x00, 0x20, 0x38, 0x00, 0x10, 0x0C,
  0x00, 0x08, 0x03, 0x00, 0x04, 0x00, 0x80, 0x02, 0x00, 0x60, 0x01, 0x00,
  0x30, 0x00, 0x80, 0x18, 0x00, 0x40, 0x0C, 0x00, 0x20, 0x06, 0x00, 0x10,
  0x03, 0x00, 0x08, 0x01, 0x00, 0x04, 0x01, 0x80, 0x02, 0x00, 0xC0, 0x01,
  0x00, 0xC8, 0x00, 0x81, 0xC3, 0xC0, 0x43, 0xC0, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0C, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x01, 0x80, 0xC0, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x06, 0x00, 0x08, 0x00, 0x20, 0x08, 0x00, 0x10, 0x00, 0x40,
  0x30, 0x00, 0x20, 0x00, 0x80, 0x40, 0x00, 0x40, 0x01, 0x01, 0x80, 0x00,
  0x80, 0x02, 0x03, 0x00, 0x01, 0x00, 0x04, 0x0C, 0x00, 0x02, 0x00, 0x18,
  0x18, 0x00, 0x06, 0x00, 0x30, 0x60, 0xFE, 0x0C, 0x00, 0x60, 0xC3, 0x87,
  0x18, 0x00, 0xC3, 0x0C, 0x06, 0x30, 0x01, 0x06, 0x18, 0x06, 0x30, 0x06,
  0x18, 0x60, 0x04, 0x60, 0x0C, 0x30, 0xC0, 0x0C, 0x60, 0x30, 0xC1, 0x00,
  0x18, 0xE0, 0xE1, 0x86, 0x00, 0x30, 0xFF, 0x82, 0x0C, 0x00, 0x20, 0x7C,
  0x0C, 0x18, 0x00, 0x60, 0x00, 0x10, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x60,
  0x01, 0x80, 0x00, 0x80, 0xC0, 0x03, 0x00, 0x03, 0x01, 0x80, 0x06, 0x00,
  0x04, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x18, 0x00, 0x30, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x18, 0x01, 0x80, 0x03, 0x00, 0x20,
  0x03, 0x00, 0x03, 0x00, 0xC0, 0x04, 0x00, 0x06, 0x03, 0x00, 0x18, 0x00,
  0x07, 0x0E, 0x00, 0x60, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1C, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x10, 0x60, 0x03, 0x00, 0x04, 0x30,
  0x00, 0xE0, 0x03, 0x0C, 0x00, 0x18, 0x00, 0xC6, 0x00, 0x03, 0x00, 0x21,
  0x80, 0x00, 0x60, 0x18, 0x40, 0x00, 0x0C, 0x06, 0x30, 0x00, 0x01, 0x81,
  0x0C, 0x00, 0x00, 0x60, 0xC3, 0x00, 0x00, 0x0C, 0x20, 0xC0, 0x00, 0x01,
  0x98, 0x30, 0x00, 0x00, 0x3C, 0x04, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x00, 0xF0, 0x0C, 0x00, 0x00, 0x66, 0x03, 0x00,
  0x00, 0x30, 0xC0, 0x60, 0x00, 0x18, 0x18, 0x0E, 0x00, 0x1C, 0x03, 0x01,
  0xE0, 0x1E, 0x00, 0xC0, 0x1F, 0xFE, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00,
  0xEA, 0xAA, 0xAA, 0xAA, 0x00, 0x60, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C,
  0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0xE0, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x40, 0x08, 0x01, 0xF0, 0x10, 0x1E, 0x78,
  0x21, 0xF0, 0x1E, 0x4E, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x11, 0x00, 0x00, 0x43, 0x00, 0x01, 0x83, 0x00, 0x06, 0x02,
  0x00, 0x18, 0x06, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x30, 0xC6, 0x18, 0x61,
  0x84, 0x30, 0xC3, 0x08, 0x61, 0x8C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xF0, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xE0, 0x01, 0xC0, 0x1C,
  0x00, 0xC0, 0x07, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x40, 0x00,
  0x10, 0x60, 0x00, 0x0C, 0x20, 0x00, 0x06, 0x30, 0x00, 0x01, 0x98, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x64, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x90, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x08, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x0C,
  0x00, 0x06, 0x07, 0x00, 0x02, 0x01, 0x80, 0x03, 0x00, 0x70, 0x03, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x38, 0x03,
  0xC0, 0x36, 0x07, 0x30, 0x71, 0x87, 0x0C, 0x60, 0x6E, 0x03, 0xE0, 0x1A,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0x80, 0x1C, 0x07, 0x00, 0x03,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x07, 0x80, 0x1E,
  0x0E, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE2, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x90, 0x00, 0x01, 0x8E, 0x00, 0x03, 0x87,
  0xE0, 0x07, 0x80, 0x7F, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x58,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x03, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x1F, 0xFF, 0xFC, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x3E, 0x00, 0x0F,
  0xFF, 0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x20,
  0x00, 0x06, 0x1C, 0x00, 0x0E, 0x07, 0xC0, 0x1E, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x1F, 0xFC, 0x0C, 0x3C, 0x0F, 0x06, 0x38, 0x00, 0xE3,
  0x30, 0x00, 0x31, 0xB0, 0x00, 0x0C, 0xF0, 0x00, 0x03, 0x70, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x28, 0x00, 0x00, 0x16, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x0C, 0x80, 0x00, 0x06, 0x60, 0x00, 0x02, 0x30, 0x00, 0x03, 0x0C,
  0x00, 0x01, 0x86, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80, 0x60, 0x01, 0x80,
  0x1C, 0x03, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xC0, 0x1C,
  0x03, 0x80, 0x03, 0x01, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x80, 0x00,
  0x18, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x10, 0x80,
  0x00, 0x18, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x0E, 0x00, 0x0C, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xCF, 0x00, 0x03, 0x81, 0xC0, 0x03, 0x80, 0x38,
  0x07, 0x00, 0x06, 0x07, 0x00, 0x01, 0x83, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x30,
  0x00, 0x01, 0x9C, 0x00, 0x01, 0x87, 0x00, 0x01, 0x81, 0xC0, 0x01, 0x80,
  0x78, 0x07, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x70, 0x07, 0x00, 0x30, 0x00, 0x60, 0x18, 0x00,
  0x0C, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x60,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x44, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1D, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x72, 0x00, 0x00, 0x3C,
  0xC0, 0x00, 0x1B, 0x18, 0x00, 0x0C, 0xC7, 0x00, 0x06, 0x30, 0xE0, 0x07,
  0x08, 0x0F, 0xFF, 0x82, 0x00, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x04,
  0x01, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x5F, 0xF4, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x08,
  0x38, 0x78, 0xE0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC1, 0x83, 0x0C, 0x18, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x10, 0x60, 0xC3,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0xC3, 0x80, 0x1C, 0x40, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x41, 0x80, 0x00, 0x7F, 0x80, 0x06, 0x30,
  0x00, 0x3F, 0xFE, 0x00, 0x63, 0x00, 0x07, 0x00, 0x60, 0x02, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x32, 0x00, 0x18, 0x00, 0x60, 0x03, 0x60, 0x03, 0x00,
  0x06, 0x00, 0x36, 0x00, 0x30, 0x00, 0x60, 0x03, 0x60, 0x02, 0x00, 0x06,
  0x00, 0x36, 0x00, 0x60, 0x00, 0x60, 0x03, 0x40, 0x06, 0x00, 0x06, 0x00,
  0x34, 0x00, 0x40, 0x00, 0x60, 0x03, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x3C,
  0x00, 0xC0, 0x00, 0x40, 0x03, 0xC0, 0x0C, 0x00, 0x04, 0x00, 0x3C, 0x00,
  0xC0, 0x00, 0x40, 0x03, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0xC0,
  0x00, 0xC0, 0x03, 0x40, 0x04, 0x00, 0x0C, 0x00, 0x24, 0x00, 0x40, 0x00,
  0xC0, 0x06, 0x60, 0x06, 0x00, 0x1C, 0x00, 0x66, 0x00, 0x60, 0x01, 0x60,
  0x06, 0x60, 0x03, 0x00, 0x36, 0x00, 0xC6, 0x00, 0x30, 0x06, 0x30, 0x18,
  0x60, 0x01, 0xC0, 0xE3, 0x03, 0x83, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x30,
  0x00, 0x3E, 0x00, 0x7C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x58, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x10, 0x01, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x10, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x10, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0x0C, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x7E, 0x0C, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xE0, 0xC0, 0x01, 0xF0, 0x3F, 0xFF,
  0xE0, 0x0C, 0x00, 0x7F, 0x03, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x06, 0x30,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x03, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x10, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x1F, 0x80, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x1F, 0xC0, 0x0C, 0x00, 0x03,
  0xC0, 0x30, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x3C, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xEC, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x0E, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x04, 0x60, 0x00,
  0x00, 0x02, 0x18, 0x00, 0x00, 0x01, 0x0E, 0x00, 0x00, 0x00, 0x83, 0x80,
  0x00, 0x00, 0x40, 0xE0, 0x00, 0x00, 0x20, 0x38, 0x00, 0x00, 0x10, 0x07,
  0x00, 0x00, 0x38, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0C, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x41, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x01, 0x9C,
  0x78, 0xFF, 0x80, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0E, 0x0C, 0x00,
  0x07, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x0C,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x30, 0x07, 0x00,
  0x0C, 0x03, 0x80, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC7, 0xC0, 0x00, 0x31,
  0xB0, 0x00, 0x0C, 0xC6, 0x00, 0x03, 0x61, 0xC0, 0x00, 0xF0, 0x30, 0x00,
  0x38, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0xC0,
  0x01, 0x80, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xD8,
  0x00, 0x00, 0x00, 0x6F, 0x60, 0x00, 0x00, 0x01, 0xBD, 0x80, 0x00, 0x00,
  0x06, 0xF3, 0x00, 0x00, 0x00, 0x33, 0xCC, 0x00, 0x00, 0x00, 0xCF, 0x10,
  0x00, 0x00, 0x02, 0x3C, 0x60, 0x00, 0x00, 0x18, 0xF1, 0x80, 0x00, 0x00,
  0x63, 0xC2, 0x00, 0x00, 0x03, 0x0F, 0x0C, 0x00, 0x00, 0x0C, 0x3C, 0x30,
  0x00, 0x00, 0x30, 0xF0, 0x60, 0x00, 0x01, 0x83, 0xC1, 0x80, 0x00, 0x06,
  0x0F, 0x02, 0x00, 0x00, 0x10, 0x3C, 0x0C, 0x00, 0x00, 0xC0, 0xF0, 0x30,
  0x00, 0x03, 0x03, 0xC0, 0x40, 0x00, 0x08, 0x0F, 0x01, 0x80, 0x00, 0x60,
  0x3C, 0x06, 0x00, 0x01, 0x80, 0xF0, 0x0C, 0x00, 0x0C, 0x03, 0xC0, 0x30,
  0x00, 0x30, 0x0F, 0x00, 0xC0, 0x00, 0xC0, 0x3C, 0x01, 0x80, 0x06, 0x00,
  0xF0, 0x06, 0x00, 0x18, 0x03, 0xC0, 0x08, 0x00, 0x40, 0x0F, 0x00, 0x30,
  0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0C, 0x00, 0xF0, 0x01, 0x80, 0x60, 0x03,
  0xC0, 0x06, 0x01, 0x80, 0x0F, 0x00, 0x18, 0x06, 0x00, 0x3C, 0x00, 0x30,
  0x30, 0x00, 0xF0, 0x00, 0xC0, 0xC0, 0x03, 0xC0, 0x01, 0x02, 0x00, 0x0F,
  0x00, 0x06, 0x18, 0x00, 0x3C, 0x00, 0x18, 0x60, 0x00, 0xF0, 0x00, 0x23,
  0x00, 0x03, 0xC0, 0x00, 0xCC, 0x00, 0x0F, 0x00, 0x03, 0x30, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x30,
  0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3D, 0x80, 0x00,
  0x01, 0xEC, 0x00, 0x00, 0x0F, 0x30, 0x00, 0x00, 0x79, 0x80, 0x00, 0x03,
  0xC6, 0x00, 0x00, 0x1E, 0x18, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x07, 0x83,
  0x00, 0x00, 0x3C, 0x18, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x0F, 0x01, 0x00,
  0x00, 0x78, 0x0C, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x1E, 0x01, 0x80, 0x00,
  0xF0, 0x06, 0x00, 0x07, 0x80, 0x30, 0x00, 0x3C, 0x00, 0xC0, 0x01, 0xE0,
  0x03, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x78, 0x00, 0x60, 0x03, 0xC0, 0x03,
  0x00, 0x1E, 0x00, 0x0C, 0x00, 0xF0, 0x00, 0x30, 0x07, 0x80, 0x01, 0x80,
  0x3C, 0x00, 0x06, 0x01, 0xE0, 0x00, 0x30, 0x0F, 0x00, 0x00, 0xC0, 0x78,
  0x00, 0x03, 0x03, 0xC0, 0x00, 0x18, 0x1E, 0x00, 0x00, 0x60, 0xF0, 0x00,
  0x03, 0x07, 0x80, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0x31, 0xE0, 0x00, 0x01,
  0x8F, 0x00, 0x00, 0x06, 0x78, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x00, 0xDE,
  0x00, 0x00, 0x06, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x30, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0xC0, 0x07, 0xE0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0xE0,
  0xC0, 0x7F, 0x80, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x30, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0x00, 0x30,
  0x01, 0xF8, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C,
  0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x03, 0x00,
  0x7F, 0x00, 0xFF, 0xFE, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x18,
  0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x0C, 0x00,
  0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x70, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0x01, 0xE0, 0x01, 0xC1,
  0xC0, 0x00, 0x21, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xCC, 0x00, 0x03, 0xC7, 0xE0,
  0x07, 0x80, 0x7F, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0x09, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60, 0x1E, 0x00, 0x0E, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x0C, 0x10, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x18, 0x08, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x30, 0x04, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x98, 0x00, 0x00, 0x70, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x36, 0x00, 0x00, 0x31, 0x80, 0x00, 0x1B,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x18, 0x60, 0x00, 0x04,
  0x40, 0x00, 0x0C, 0x10, 0x00, 0x06, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x82, 0x00, 0x01, 0x80, 0x80, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0x60, 0x00,
  0x60, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0x18, 0x00,
  0x18, 0x10, 0x00, 0x30, 0x04, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x03, 0x00,
  0x0C, 0x06, 0x00, 0x18, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x00, 0xC0,
  0x03, 0x00, 0x80, 0x06, 0x00, 0x20, 0x03, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x06,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x01, 0x00, 0x20, 0x03, 0x00, 0x40, 0x00,
  0xC0, 0x30, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x00,
  0x30, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x08, 0x04, 0x00, 0x10, 0x08, 0x00,
  0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x00, 0x40, 0x80, 0x00, 0xC1, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20,
  0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x12, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x60, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x20, 0x03, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x0C,
  0x00, 0x03, 0x00, 0x40, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x20, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0xC0, 0x01, 0x80, 0x08, 0x00,
  0x18, 0x01, 0x80, 0x00, 0xC0, 0x10, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFF,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0xFF, 0xF8, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x06,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x60, 0x40, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x23, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0x7E, 0x00, 0x1F,
  0xFF, 0x01, 0xE0, 0x0E, 0x06, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x3F, 0xFC, 0x0F, 0xE0, 0x30, 0xF0, 0x00,
  0xC7, 0x00, 0x03, 0x30, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF4, 0x00, 0x06, 0xD8, 0x00, 0x13,
  0x30, 0x01, 0xCC, 0x70, 0x1C, 0x30, 0xFF, 0xE0, 0xC0, 0x3C, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x03, 0xF8, 0x03,
  0x07, 0xFF, 0x80, 0xC3, 0x80, 0x38, 0x31, 0x80, 0x07, 0x0C, 0xC0, 0x00,
  0xC3, 0x60, 0x00, 0x18, 0xD0, 0x00, 0x03, 0x3C, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x13, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01,
  0x38, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x33, 0x40, 0x00, 0x18, 0xD8, 0x00,
  0x0E, 0x33, 0x00, 0x03, 0x0C, 0x60, 0x03, 0x83, 0x0E, 0x03, 0xC0, 0xC1,
  0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xC0,
  0xF0, 0x06, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x01, 0xC0,
  0x7F, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x01, 0xFC, 0x06, 0x03, 0xFF, 0x83, 0x07, 0x00, 0x71, 0x87, 0x00,
  0x0C, 0xC6, 0x00, 0x03, 0x66, 0x00, 0x01, 0xB3, 0x00, 0x00, 0x7B, 0x00,
  0x00, 0x3D, 0x80, 0x00, 0x0E, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x01, 0xE6, 0x00, 0x00, 0xB3, 0x00,
  0x00, 0xD8, 0xC0, 0x00, 0xCC, 0x30, 0x00, 0xC6, 0x0F, 0x01, 0xC3, 0x03,
  0xFF, 0xC1, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06,
  0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x04, 0x03, 0xC0, 0x3C,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFC, 0x03,
  0x81, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0xFF, 0xFC, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0xC1,
  0xC0, 0x1C, 0x61, 0x80, 0x03, 0x31, 0x80, 0x00, 0xD9, 0x80, 0x00, 0x2C,
  0xC0, 0x00, 0x1E, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x03, 0xA0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x79,
  0x80, 0x00, 0x2C, 0xC0, 0x00, 0x36, 0x30, 0x00, 0x33, 0x0C, 0x00, 0x31,
  0x83, 0xC0, 0x70, 0xC0, 0x7F, 0xE0, 0x60, 0x07, 0x80, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x31, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x70, 0x7C,
  0x00, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x1F, 0xE0, 0x60, 0xFF, 0xF0, 0xC3, 0x80, 0x71, 0x8C, 0x00,
  0x33, 0x30, 0x00, 0x36, 0xC0, 0x00, 0x6D, 0x00, 0x00, 0x5E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x02, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x92,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x90,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x0C, 0x87, 0x3F, 0x87, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x06, 0xC0, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00, 0x61, 0x80, 0x06, 0x0C,
  0x00, 0x30, 0x60, 0x03, 0x03, 0x00, 0x30, 0x18, 0x03, 0x00, 0xC0, 0x30,
  0x06, 0x01, 0x80, 0x30, 0x18, 0x01, 0x81, 0x80, 0x0C, 0x18, 0x00, 0x61,
  0xC0, 0x03, 0x0F, 0x00, 0x18, 0xCC, 0x00, 0xCC, 0x60, 0x06, 0xC1, 0x80,
  0x3C, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00,
  0x18, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x21,
  0x80, 0x01, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x00, 0xD8, 0x00,
  0x03, 0xC0, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0xC3, 0xFF,
  0x80, 0x7F, 0xF0, 0xC7, 0x01, 0xC1, 0xC0, 0x38, 0xCC, 0x00, 0x63, 0x80,
  0x1C, 0xD8, 0x00, 0x63, 0x00, 0x0C, 0xD0, 0x00, 0x36, 0x00, 0x06, 0xF0,
  0x00, 0x34, 0x00, 0x06, 0xE0, 0x00, 0x1C, 0x00, 0x06, 0xE0, 0x00, 0x18,
  0x00, 0x02, 0xE0, 0x00, 0x18, 0x00, 0x02, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x7F, 0x81, 0x83, 0xFF, 0xC3, 0x0E, 0x01, 0xC6, 0x30, 0x00, 0xCC,
  0xC0, 0x00, 0xDB, 0x00, 0x01, 0xB4, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x08, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x70, 0x07, 0x80, 0x38, 0x00, 0x70, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x10, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C,
  0x60, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x70, 0x00,
  0x30, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x3C, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3F, 0x80, 0x30, 0x7F, 0xF8, 0x0C, 0x38, 0x03, 0x83,
  0x18, 0x00, 0x70, 0xCC, 0x00, 0x0E, 0x36, 0x00, 0x01, 0x8D, 0x80, 0x00,
  0x33, 0xC0, 0x00, 0x0C, 0xF0, 0x00, 0x01, 0x38, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x1B, 0xC0, 0x00, 0x0C, 0xF0, 0x00, 0x03,
  0x36, 0x00, 0x01, 0x8D, 0x80, 0x00, 0x63, 0x30, 0x00, 0x30, 0xC7, 0x00,
  0x38, 0x30, 0xF0, 0x3C, 0x0C, 0x0F, 0xFC, 0x03, 0x00, 0x78, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0xF8, 0x30, 0x38, 0x03, 0x8C, 0x1C, 0x00, 0x73, 0x0C, 0x00,
  0x04, 0xC6, 0x00, 0x01, 0xB1, 0x80, 0x00, 0x3C, 0xC0, 0x00, 0x0F, 0x30,
  0x00, 0x01, 0xC8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03,
  0x60, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x03, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x0F, 0x30, 0x00, 0x03, 0xC6, 0x00, 0x01, 0xB1, 0x80,
  0x00, 0x6C, 0x30, 0x00, 0x33, 0x06, 0x00, 0x18, 0xC0, 0xE0, 0x1C, 0x30,
  0x1F, 0xFC, 0x0C, 0x00, 0x78, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x7C, 0xC1, 0xFF, 0xC7, 0x00, 0xCE, 0x00,
  0xCC, 0x00, 0xD8, 0x00, 0xD0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0xE0, 0x03, 0x86, 0x00,
  0x02, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0xF0, 0x07, 0x01,
  0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0xFF,
  0xFF, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x81, 0x01, 0xFF, 0x00, 0x38, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3A, 0x00, 0x00, 0x76, 0x00, 0x01, 0x6C, 0x00, 0x06, 0xCC,
  0x00, 0x19, 0x9C, 0x00, 0x63, 0x1E, 0x03, 0x86, 0x0F, 0xFE, 0x0C, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x01, 0xA0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x10,
  0x20, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x04, 0x02, 0x00, 0x06,
  0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x00, 0x20, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0,
  0x10, 0x00, 0x20, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x04, 0x00, 0x02,
  0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x18, 0xC0, 0x00, 0x0C, 0x40, 0x00, 0x02, 0x60, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x19, 0x00,
  0x00, 0xE0, 0x00, 0x33, 0x00, 0x01, 0x40, 0x00, 0x66, 0x00, 0x06, 0xC0,
  0x00, 0x8C, 0x00, 0x0D, 0x80, 0x03, 0x08, 0x00, 0x19, 0x00, 0x06, 0x18,
  0x00, 0x23, 0x00, 0x0C, 0x30, 0x00, 0xC6, 0x00, 0x10, 0x60, 0x01, 0x84,
  0x00, 0x60, 0x40, 0x02, 0x08, 0x00, 0xC0, 0xC0, 0x0C, 0x18, 0x01, 0x81,
  0x80, 0x18, 0x30, 0x02, 0x01, 0x00, 0x30, 0x20, 0x0C, 0x03, 0x00, 0x40,
  0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x40,
  0x08, 0x04, 0x01, 0x01, 0x80, 0x18, 0x18, 0x03, 0x03, 0x00, 0x30, 0x30,
  0x06, 0x06, 0x00, 0x60, 0x60, 0x04, 0x08, 0x00, 0x41, 0x80, 0x0C, 0x30,
  0x00, 0xC3, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x03, 0x08,
  0x00, 0x21, 0x00, 0x02, 0x30, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0xCC,
  0x00, 0x0C, 0xC0, 0x00, 0x98, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x16,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x70,
  0x00, 0x07, 0x18, 0x00, 0x03, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80,
  0xC0, 0x01, 0x80, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0xC0,
  0x01, 0x80, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30,
  0x00, 0x06, 0x30, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x0C,
  0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x01, 0x80, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x70, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x98, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x21, 0x80, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x08, 0x18,
  0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x02, 0x01, 0x80, 0x03, 0x00,
  0x60, 0x01, 0x80, 0x30, 0x00, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x20, 0x01, 0x80, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x08,
  0x00, 0x18, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x02, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x06,
  0x60, 0x00, 0x03, 0x20, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x58, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x01, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x03, 0x80, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0xF0, 0x01, 0xF8, 0x01, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x38, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x05, 0xC0, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0xE8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFC, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Thin65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 4, 46, 14, 5, -46 },
  { 24, 11, 16, 20, 5, -46 },
  { 46, 33, 46, 37, 2, -46 },
  { 236, 25, 53, 33, 3, -49 },
  { 402, 39, 48, 46, 4, -47 },
  { 636, 34, 48, 38, 3, -47 },
  { 840, 2, 16, 11, 5, -46 },
  { 844, 11, 56, 17, 3, -46 },
  { 921, 12, 56, 17, 2, -46 },
  { 1005, 23, 22, 31, 4, -49 },
  { 1069, 27, 30, 33, 3, -38 },
  { 1171, 6, 15, 12, 2, -7 },
  { 1183, 15, 2, 20, 2, -19 },
  { 1187, 3, 4, 13, 5, -4 },
  { 1189, 19, 46, 21, 1, -46 },
  { 1299, 25, 48, 33, 4, -47 },
  { 1449, 13, 46, 33, 6, -46 },
  { 1524, 25, 47, 33, 3, -47 },
  { 1671, 25, 48, 33, 3, -47 },
  { 1821, 31, 47, 33, 1, -47 },
  { 2004, 25, 47, 33, 4, -46 },
  { 2151, 25, 48, 33, 4, -47 },
  { 2301, 26, 46, 33, 3, -46 },
  { 2451, 25, 48, 33, 4, -47 },
  { 2601, 26, 48, 33, 3, -47 },
  { 2757, 3, 35, 13, 5, -35 },
  { 2771, 7, 43, 13, 2, -35 },
  { 2809, 27, 28, 33, 3, -37 },
  { 2904, 27, 15, 33, 3, -30 },
  { 2955, 27, 28, 33, 3, -37 },
  { 3050, 19, 47, 23, 2, -47 },
  { 3162, 44, 52, 51, 3, -46 },
  { 3448, 33, 46, 33, 0, -46 },
  { 3638, 26, 46, 35, 6, -46 },
  { 3788, 29, 48, 35, 4, -47 },
  { 3962, 30, 46, 40, 6, -46 },
  { 4135, 22, 46, 32, 6, -46 },
  { 4262, 22, 46, 29, 6, -46 },
  { 4389, 33, 48, 42, 4, -47 },
  { 4587, 29, 46, 41, 6, -46 },
  { 4754, 11, 46, 17, 3, -46 },
  { 4818, 13, 57, 14, -5, -46 },
  { 4911, 26, 46, 32, 6, -46 },
  { 5061, 22, 46, 29, 6, -46 },
  { 5188, 38, 46, 50, 6, -46 },
  { 5407, 29, 46, 41, 6, -46 },
  { 5574, 35, 48, 43, 4, -47 },
  { 5784, 24, 46, 33, 6, -46 },
  { 5922, 35, 58, 43, 4, -47 },
  { 6176, 26, 46, 33, 6, -46 },
  { 6326, 25, 48, 32, 3, -47 },
  { 6476, 29, 46, 29, 0, -46 },
  { 6643, 29, 47, 41, 6, -46 },
  { 6814, 32, 46, 32, 0, -46 },
  { 6998, 49, 46, 51, 1, -46 },
  { 7280, 29, 46, 29, 0, -46 },
  { 7447, 28, 46, 28, 0, -46 },
  { 7608, 27, 46, 32, 2, -46 },
  { 7764, 12, 56, 20, 6, -46 },
  { 7848, 19, 46, 21, 1, -46 },
  { 7958, 13, 56, 20, 2, -46 },
  { 8049, 29, 27, 33, 2, -47 },
  { 8147, 26, 2, 25, 0, 6 },
  { 8154, 10, 11, 16, 3, -50 },
  { 8168, 22, 36, 30, 3, -35 },
  { 8267, 26, 50, 34, 5, -49 },
  { 8430, 21, 36, 27, 4, -35 },
  { 8525, 25, 50, 34, 4, -49 },
  { 8682, 24, 36, 31, 4, -35 },
  { 8790, 19, 50, 16, 1, -50 },
  { 8909, 25, 51, 34, 4, -35 },
  { 9069, 23, 49, 33, 5, -49 },
  { 9210, 3, 47, 13, 5, -47 },
  { 9228, 10, 63, 13, -2, -47 },
  { 9307, 21, 49, 26, 5, -49 },
  { 9436, 2, 49, 12, 5, -49 },
  { 9449, 40, 35, 50, 5, -35 },
  { 9624, 23, 35, 33, 5, -35 },
  { 9725, 26, 36, 33, 4, -35 },
  { 9842, 26, 50, 34, 5, -35 },
  { 10005, 26, 50, 34, 3, -35 },
  { 10168, 16, 35, 22, 5, -35 },
  { 10238, 22, 36, 26, 2, -35 },
  { 10337, 16, 44, 18, 1, -43 },
  { 10425, 23, 35, 33, 5, -34 },
  { 10526, 25, 34, 25, 0, -34 },
  { 10633, 39, 34, 40, 1, -34 },
  { 10799, 25, 34, 27, 1, -34 },
  { 10906, 25, 50, 25, 0, -34 },
  { 11063, 21, 34, 25, 2, -34 },
  { 11153, 17, 56, 22, 2, -46 },
  { 11272, 1, 66, 31, 15, -50 },
  { 11281, 17, 56, 22, 3, -46 },
  { 11400, 27, 6, 33, 3, -26 },
};

const GFXfont NotoSans_SemiCondensed_Thin65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin65pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_SEMICONDENSED_THIN65PT7B_H_
