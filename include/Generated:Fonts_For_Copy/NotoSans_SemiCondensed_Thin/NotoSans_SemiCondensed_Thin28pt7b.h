#ifndef _NOTOSANS_SEMICONDENSED_THIN28PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin28pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x68, 0x0B, 0x8C, 0x63, 0x18, 0xC6, 0x20, 0x04,
  0x10, 0x10, 0x40, 0x42, 0x01, 0x08, 0x08, 0x20, 0x20, 0x87, 0xFF, 0xC2,
  0x08, 0x08, 0x40, 0x21, 0x01, 0x04, 0x04, 0x10, 0x10, 0x43, 0xFF, 0xE1,
  0x08, 0x04, 0x20, 0x10, 0x80, 0x82, 0x02, 0x08, 0x08, 0x20, 0x04, 0x01,
  0xE0, 0xD3, 0x22, 0x04, 0x41, 0x08, 0x21, 0x02, 0x20, 0x44, 0x06, 0x80,
  0x30, 0x03, 0x80, 0x4C, 0x08, 0x81, 0x08, 0x21, 0x04, 0x20, 0x84, 0x11,
  0x32, 0xC1, 0xC0, 0x08, 0x01, 0x00, 0x78, 0x08, 0x84, 0x10, 0x84, 0x10,
  0x84, 0x10, 0x84, 0x20, 0x84, 0x20, 0x84, 0x40, 0x84, 0x40, 0x84, 0x9E,
  0x84, 0xA1, 0x85, 0x21, 0x79, 0x21, 0x02, 0x41, 0x02, 0x41, 0x04, 0x41,
  0x04, 0x41, 0x08, 0x21, 0x08, 0x21, 0x10, 0x21, 0x10, 0x1E, 0x0F, 0x80,
  0x21, 0x00, 0x81, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x04, 0x20, 0x04,
  0x80, 0x0A, 0x00, 0x18, 0x00, 0x48, 0x01, 0x08, 0x24, 0x08, 0x50, 0x08,
  0xA0, 0x12, 0x40, 0x14, 0x80, 0x10, 0x80, 0x50, 0x81, 0x10, 0xFC, 0x30,
  0xFE, 0x08, 0x84, 0x42, 0x21, 0x08, 0x84, 0x21, 0x08, 0x42, 0x10, 0x42,
  0x10, 0x82, 0x10, 0x41, 0x82, 0x08, 0x41, 0x08, 0x41, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x84, 0x22, 0x11, 0x18, 0x08, 0x02, 0x00, 0x83, 0x23,
  0x3F, 0x02, 0x01, 0x40, 0x88, 0x61, 0x00, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0xFF, 0xF0, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x55, 0x68, 0xFC, 0xB0, 0x00, 0x80, 0x80, 0x40, 0x40,
  0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x18, 0x00, 0x3F, 0x08, 0x11, 0x02, 0x40, 0x28,
  0x05, 0x00, 0xA0, 0x14, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xA0, 0x14, 0x02, 0x80, 0x48, 0x10, 0x82, 0x0F, 0x80, 0x08, 0xDB,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x3F,
  0x08, 0x18, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x7F, 0xF0, 0x3F, 0x98, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x83, 0xE0, 0x06, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x06, 0x01, 0x3F, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x50,
  0x04, 0x80, 0x24, 0x02, 0x20, 0x21, 0x01, 0x08, 0x10, 0x40, 0x82, 0x08,
  0x10, 0x80, 0x84, 0x04, 0x40, 0x23, 0xFF, 0xE0, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x7F, 0x88, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00,
  0x20, 0x04, 0x00, 0xFF, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x0A, 0x02, 0x7F, 0x80, 0x0F, 0xC2, 0x00, 0x80,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0xBF, 0x18, 0x12, 0x01, 0x40,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x48, 0x09, 0x02, 0x1F, 0x80,
  0xFF, 0xF0, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x3F, 0x08, 0x12, 0x01, 0x40, 0x28,
  0x05, 0x00, 0x90, 0x13, 0x04, 0x13, 0x01, 0x80, 0xCC, 0x20, 0x48, 0x05,
  0x00, 0xA0, 0x0C, 0x01, 0x80, 0x30, 0x09, 0x02, 0x1F, 0x80, 0x1F, 0x84,
  0x09, 0x01, 0x20, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x40, 0x28, 0x04,
  0x81, 0x8F, 0xD0, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x06,
  0x3F, 0x00, 0xF0, 0x00, 0x00, 0x2C, 0x6C, 0x00, 0x00, 0x00, 0x04, 0x92,
  0x52, 0x00, 0x00, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0xFC,
  0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x20, 0x20, 0x00, 0x00, 0x00, 0x20, 0x30, 0x01, 0xFC, 0x00, 0xC0, 0x60,
  0x20, 0x02, 0x08, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x50, 0x3F, 0x0A,
  0x08, 0x21, 0x42, 0x04, 0x28, 0x40, 0x86, 0x08, 0x10, 0xC2, 0x02, 0x18,
  0x40, 0x83, 0x04, 0x10, 0x50, 0x82, 0x0A, 0x10, 0xA2, 0x41, 0xE3, 0x88,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x18, 0x00,
  0x3C, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x28, 0x01, 0x20, 0x04, 0x80, 0x11,
  0x00, 0x84, 0x02, 0x10, 0x08, 0x40, 0x40, 0x81, 0x02, 0x07, 0xF8, 0x20,
  0x10, 0x80, 0x42, 0x01, 0x10, 0x02, 0x40, 0x09, 0x00, 0x28, 0x00, 0x60,
  0x01, 0xFF, 0x10, 0x12, 0x01, 0x40, 0x28, 0x03, 0x00, 0xA0, 0x14, 0x02,
  0x80, 0x9F, 0xE2, 0x02, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x0A, 0x02, 0x7F, 0x80, 0x0F, 0xF1, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xFF, 0xFF,
  0x08, 0x08, 0x80, 0x48, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x28, 0x04, 0x81, 0x8F, 0xE0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x7F, 0xE0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x1F, 0xF0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x3F, 0xF0, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x00, 0x07, 0xF8, 0x60, 0x12, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x0F, 0xE0, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x50, 0x01, 0x40, 0x04, 0x80, 0x11, 0x00,
  0x43, 0xFE, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xF9, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x09, 0xF0, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0xF0, 0x80, 0x70, 0x12, 0x04, 0x40, 0x88, 0x21, 0x08, 0x22, 0x04, 0x80,
  0xA0, 0x1A, 0x03, 0x20, 0x44, 0x08, 0x41, 0x04, 0x20, 0x84, 0x08, 0x80,
  0x90, 0x12, 0x01, 0x40, 0x10, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x1F, 0xF0, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x05,
  0xA0, 0x05, 0xA0, 0x05, 0xA0, 0x09, 0x90, 0x09, 0x90, 0x09, 0x90, 0x11,
  0x88, 0x11, 0x88, 0x21, 0x88, 0x21, 0x84, 0x21, 0x84, 0x41, 0x82, 0x41,
  0x82, 0x41, 0x82, 0x81, 0x81, 0x81, 0x81, 0x01, 0x80, 0x18, 0x01, 0xC0,
  0x1C, 0x01, 0xA0, 0x19, 0x01, 0x90, 0x18, 0x81, 0x88, 0x18, 0x41, 0x82,
  0x18, 0x21, 0x81, 0x18, 0x11, 0x80, 0x98, 0x05, 0x80, 0x58, 0x03, 0x80,
  0x38, 0x01, 0x0F, 0xE0, 0x20, 0x20, 0x80, 0x22, 0x00, 0x28, 0x00, 0x50,
  0x00, 0xA0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x40, 0x02, 0x40, 0x04, 0x40, 0x10,
  0xC0, 0x40, 0x7F, 0x00, 0xFE, 0x20, 0x68, 0x0A, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0xA0, 0x28, 0x73, 0xE0, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x0F, 0xE0, 0x20, 0x20, 0x80, 0x22, 0x00,
  0x28, 0x00, 0x50, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x40, 0x02, 0x40,
  0x04, 0x40, 0x10, 0xC0, 0x40, 0x7F, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x10, 0xFE, 0x10, 0x32, 0x02, 0x40, 0x28, 0x05, 0x00,
  0xA0, 0x14, 0x02, 0x80, 0x90, 0x23, 0xF8, 0x42, 0x08, 0x21, 0x04, 0x20,
  0x44, 0x08, 0x80, 0x90, 0x12, 0x01, 0x40, 0x30, 0x1F, 0xE4, 0x01, 0x00,
  0x20, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x7F, 0xC0,
  0xFF, 0xF0, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x40, 0x0A, 0x00, 0x88,
  0x0C, 0x3F, 0x80, 0x80, 0x06, 0x00, 0x24, 0x00, 0x90, 0x02, 0x40, 0x10,
  0x80, 0x42, 0x01, 0x08, 0x08, 0x10, 0x20, 0x40, 0x81, 0x04, 0x02, 0x10,
  0x08, 0x40, 0x22, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x80, 0x40, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x40, 0x90, 0x24, 0x09, 0x02, 0x40, 0x90, 0x24, 0x09, 0x02, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x12, 0x04, 0x81, 0x20,
  0x48, 0x12, 0x04, 0x81, 0x20, 0x48, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0x40, 0x30, 0x40, 0x14, 0x02, 0x20, 0x21, 0x04, 0x10, 0x40,
  0x88, 0x08, 0x80, 0x50, 0x05, 0x00, 0x20, 0x06, 0x00, 0x50, 0x09, 0x00,
  0x88, 0x10, 0x42, 0x04, 0x20, 0x24, 0x02, 0x40, 0x18, 0x01, 0x80, 0x14,
  0x01, 0x40, 0x22, 0x02, 0x20, 0x42, 0x04, 0x10, 0x81, 0x08, 0x09, 0x00,
  0x90, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x7F, 0xE0, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x0F, 0xFF, 0xFE, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x3F, 0xC0, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x02, 0x00,
  0x80, 0x40, 0x10, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x3F, 0x02, 0x00, 0x60, 0x05, 0x00, 0x90,
  0x10, 0x81, 0x08, 0x20, 0x42, 0x04, 0x40, 0x24, 0x02, 0x80, 0x10, 0xFF,
  0xE0, 0xC2, 0x08, 0x30, 0x3F, 0x10, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10,
  0x0C, 0x7D, 0x60, 0x50, 0x18, 0x06, 0x01, 0x80, 0xD0, 0x53, 0xE4, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x27, 0xC5, 0x06, 0xC0, 0x58,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07,
  0x01, 0x50, 0x29, 0xF8, 0x1F, 0x90, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x02, 0x00, 0xFE, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x11, 0xF5, 0x83, 0x40, 0xE0, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x03, 0x3F, 0x40,
  0x1E, 0x18, 0x44, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x07, 0xFE, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x10, 0x03, 0xF8, 0x0F, 0x10, 0x10, 0x10, 0x10,
  0x10, 0xFC, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x1F, 0x58, 0x34, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x33, 0xF4, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0xC1, 0x8F, 0x80, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x09, 0xF2, 0x82, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0xE0,
  0x2A, 0xAA, 0xAA, 0xAA, 0x18, 0x80, 0x00, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0xB0, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x03, 0x02, 0x82, 0x42, 0x21, 0x11, 0x09, 0x05,
  0x43, 0x21, 0x08, 0x82, 0x41, 0x20, 0x50, 0x18, 0x08, 0xFF, 0xFF, 0xF8,
  0x9E, 0x1E, 0x50, 0x90, 0xB0, 0x30, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04,
  0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30,
  0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x02, 0x9F, 0x28, 0x2C, 0x07,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x04, 0x1F, 0x0C, 0x11, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x28, 0x04, 0x81, 0x0F, 0xC0,
  0x9F, 0x14, 0x1B, 0x01, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xE0, 0x1C, 0x05, 0x40, 0xA7, 0xE4, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x00, 0x0F, 0xA6, 0x0C, 0x81, 0xA0,
  0x14, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x05, 0x00, 0xA0, 0x14,
  0x06, 0x40, 0xC7, 0xE8, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x9F, 0x43, 0x06, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x00, 0x3F, 0x20, 0x60, 0x10, 0x08, 0x02, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x40, 0x20, 0x10, 0x08, 0x07, 0xFC, 0x20, 0x40, 0x87,
  0xF2, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x10,
  0x3C, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0xD0, 0x33, 0xF4, 0x80, 0x30, 0x09, 0x01,
  0x20, 0x24, 0x08, 0x41, 0x08, 0x21, 0x08, 0x11, 0x02, 0x20, 0x48, 0x05,
  0x00, 0xA0, 0x18, 0x01, 0x00, 0x80, 0x80, 0xA0, 0x60, 0x50, 0x30, 0x28,
  0x28, 0x24, 0x12, 0x11, 0x09, 0x08, 0x84, 0x84, 0x44, 0x44, 0x22, 0x12,
  0x09, 0x09, 0x05, 0x04, 0x82, 0x81, 0x81, 0x40, 0xC0, 0x40, 0x60, 0x20,
  0x20, 0x80, 0x50, 0x24, 0x10, 0x84, 0x22, 0x04, 0x80, 0xC0, 0x20, 0x0C,
  0x04, 0x82, 0x20, 0x84, 0x40, 0xA0, 0x28, 0x04, 0x80, 0x28, 0x09, 0x01,
  0x20, 0x22, 0x08, 0x41, 0x08, 0x20, 0x88, 0x11, 0x02, 0x20, 0x28, 0x05,
  0x00, 0xA0, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x01, 0x80, 0x00, 0x7F, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10,
  0x10, 0x08, 0x08, 0x04, 0x04, 0x04, 0x03, 0xFE, 0x06, 0x10, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x41, 0x0C, 0x04, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x10, 0x10,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x04, 0x07, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0xE0, 0x7C, 0x18, 0x3E,
};

const GFXglyph NotoSans_SemiCondensed_Thin28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 20, 6, 2, -20 },
  { 6, 5, 7, 9, 2, -20 },
  { 11, 14, 20, 16, 1, -20 },
  { 46, 11, 23, 14, 1, -21 },
  { 78, 16, 20, 20, 2, -20 },
  { 118, 15, 20, 16, 1, -20 },
  { 156, 1, 7, 5, 2, -20 },
  { 157, 5, 24, 7, 1, -20 },
  { 172, 5, 24, 7, 1, -20 },
  { 187, 10, 9, 13, 2, -21 },
  { 199, 12, 13, 14, 1, -16 },
  { 219, 2, 7, 5, 1, -3 },
  { 221, 6, 1, 8, 1, -8 },
  { 222, 2, 2, 6, 2, -2 },
  { 223, 9, 20, 9, 0, -20 },
  { 246, 11, 20, 14, 2, -20 },
  { 274, 5, 20, 14, 3, -20 },
  { 287, 11, 20, 14, 1, -20 },
  { 315, 11, 20, 14, 1, -20 },
  { 343, 13, 20, 14, 1, -20 },
  { 376, 11, 20, 14, 2, -20 },
  { 404, 11, 20, 14, 2, -20 },
  { 432, 12, 20, 14, 1, -20 },
  { 462, 11, 20, 14, 2, -20 },
  { 490, 11, 20, 14, 1, -20 },
  { 518, 2, 15, 6, 2, -15 },
  { 522, 3, 19, 6, 1, -15 },
  { 530, 12, 12, 14, 1, -16 },
  { 548, 12, 6, 14, 1, -13 },
  { 557, 12, 12, 14, 1, -16 },
  { 575, 8, 20, 10, 1, -20 },
  { 595, 19, 23, 22, 1, -20 },
  { 650, 14, 20, 14, 0, -20 },
  { 685, 11, 20, 15, 3, -20 },
  { 713, 12, 20, 15, 2, -20 },
  { 743, 12, 20, 17, 3, -20 },
  { 773, 9, 20, 14, 3, -20 },
  { 796, 9, 20, 12, 3, -20 },
  { 819, 14, 20, 18, 2, -20 },
  { 854, 12, 20, 18, 3, -20 },
  { 884, 5, 20, 7, 1, -20 },
  { 897, 5, 25, 6, -2, -20 },
  { 913, 11, 20, 14, 3, -20 },
  { 941, 9, 20, 12, 3, -20 },
  { 964, 16, 20, 22, 3, -20 },
  { 1004, 12, 20, 18, 3, -20 },
  { 1034, 15, 20, 19, 2, -20 },
  { 1072, 10, 20, 14, 3, -20 },
  { 1097, 15, 25, 19, 2, -20 },
  { 1144, 11, 20, 14, 3, -20 },
  { 1172, 11, 20, 14, 1, -20 },
  { 1200, 12, 20, 12, 0, -20 },
  { 1230, 13, 20, 18, 2, -20 },
  { 1263, 14, 20, 14, 0, -20 },
  { 1298, 20, 20, 22, 1, -20 },
  { 1348, 12, 20, 12, 0, -20 },
  { 1378, 12, 20, 12, 0, -20 },
  { 1408, 12, 20, 14, 1, -20 },
  { 1438, 6, 24, 9, 2, -20 },
  { 1456, 9, 20, 9, 0, -20 },
  { 1479, 5, 24, 9, 1, -20 },
  { 1494, 12, 11, 14, 1, -20 },
  { 1511, 11, 1, 11, 0, 2 },
  { 1513, 5, 4, 7, 1, -21 },
  { 1516, 10, 15, 13, 1, -15 },
  { 1535, 11, 21, 15, 2, -21 },
  { 1564, 9, 15, 12, 2, -15 },
  { 1581, 10, 21, 15, 2, -21 },
  { 1608, 10, 15, 13, 2, -15 },
  { 1627, 8, 21, 7, 0, -21 },
  { 1648, 10, 22, 15, 2, -15 },
  { 1676, 10, 21, 14, 2, -21 },
  { 1703, 2, 20, 5, 2, -20 },
  { 1708, 5, 27, 5, -1, -20 },
  { 1725, 9, 21, 11, 2, -21 },
  { 1749, 1, 21, 5, 2, -21 },
  { 1752, 17, 15, 21, 2, -15 },
  { 1784, 10, 15, 14, 2, -15 },
  { 1803, 11, 15, 14, 2, -15 },
  { 1824, 11, 22, 15, 2, -15 },
  { 1855, 11, 22, 15, 1, -15 },
  { 1886, 7, 15, 9, 2, -15 },
  { 1900, 9, 15, 11, 1, -15 },
  { 1917, 7, 18, 8, 0, -18 },
  { 1933, 10, 15, 14, 2, -15 },
  { 1952, 11, 15, 11, 0, -15 },
  { 1973, 17, 15, 17, 0, -15 },
  { 2005, 10, 15, 12, 1, -15 },
  { 2024, 11, 22, 11, 0, -15 },
  { 2055, 9, 15, 11, 1, -15 },
  { 2072, 7, 24, 10, 1, -20 },
  { 2093, 1, 28, 13, 6, -21 },
  { 2097, 8, 24, 10, 1, -20 },
  { 2121, 12, 2, 14, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_Thin28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin28pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_SEMICONDENSED_THIN28PT7B_H_
