#ifndef _NOTOSANS_SEMICONDENSED_THIN41PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin41pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x55, 0x50, 0x03, 0xC0, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00,
  0x20, 0x20, 0x01, 0x01, 0x00, 0x08, 0x08, 0x00, 0x80, 0x40, 0x04, 0x04,
  0x00, 0x20, 0x20, 0x01, 0x01, 0x03, 0xFF, 0xFF, 0xC0, 0x40, 0x40, 0x04,
  0x02, 0x00, 0x20, 0x20, 0x01, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0x40,
  0x02, 0x02, 0x00, 0x20, 0x10, 0x01, 0x01, 0x01, 0xFF, 0xFF, 0xE0, 0x40,
  0x40, 0x02, 0x02, 0x00, 0x10, 0x10, 0x01, 0x80, 0x80, 0x08, 0x08, 0x00,
  0x40, 0x40, 0x02, 0x02, 0x00, 0x10, 0x10, 0x00, 0x80, 0x80, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x07, 0xE0, 0x19, 0x1C, 0x21, 0x04, 0x41, 0x00, 0x41,
  0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x41, 0x00, 0x41,
  0x00, 0x31, 0x00, 0x19, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x01, 0x70, 0x01,
  0x18, 0x01, 0x04, 0x01, 0x02, 0x01, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x03, 0x01, 0x02, 0x01, 0x02, 0x01, 0x04, 0xC1, 0x08, 0x7F, 0xF0, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x0E, 0x00, 0x00, 0x19, 0x80, 0x08, 0x08,
  0x20, 0x08, 0x08, 0x10, 0x04, 0x04, 0x04, 0x04, 0x02, 0x02, 0x02, 0x02,
  0x01, 0x02, 0x01, 0x00, 0x81, 0x00, 0x80, 0x41, 0x00, 0x40, 0x20, 0x80,
  0x20, 0x10, 0x80, 0x10, 0x08, 0x40, 0x08, 0x04, 0x63, 0xC2, 0x02, 0x22,
  0x11, 0x01, 0x32, 0x04, 0x81, 0x11, 0x02, 0x20, 0x89, 0x81, 0x99, 0x88,
  0x80, 0x43, 0x84, 0x40, 0x20, 0x04, 0x20, 0x10, 0x02, 0x10, 0x08, 0x02,
  0x08, 0x04, 0x01, 0x04, 0x02, 0x01, 0x02, 0x01, 0x00, 0x81, 0x00, 0x80,
  0x80, 0x80, 0xC0, 0x40, 0x20, 0x40, 0x40, 0x10, 0x20, 0x20, 0x0C, 0x20,
  0x30, 0x03, 0xE0, 0x01, 0xC0, 0x00, 0x31, 0x80, 0x02, 0x02, 0x00, 0x30,
  0x10, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x0C, 0x00, 0x40, 0x40, 0x02, 0x06, 0x00, 0x08, 0x60, 0x00, 0x66,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x90, 0x00, 0x10, 0x40, 0x01,
  0x01, 0x00, 0x90, 0x0C, 0x04, 0x80, 0x30, 0x28, 0x00, 0x82, 0x40, 0x02,
  0x12, 0x00, 0x09, 0x90, 0x00, 0x28, 0x80, 0x01, 0xC6, 0x00, 0x0C, 0x10,
  0x00, 0xD0, 0xC0, 0x0C, 0x43, 0x00, 0xC1, 0x07, 0xF8, 0x0C, 0xFF, 0xC0,
  0x06, 0x18, 0x20, 0x81, 0x04, 0x08, 0x30, 0x40, 0x81, 0x06, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x40, 0x81, 0x03,
  0x02, 0x04, 0x04, 0x08, 0x08, 0x18, 0x18, 0x80, 0x81, 0x81, 0x01, 0x02,
  0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40, 0x81, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x60, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x18, 0x20,
  0x83, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x1C,
  0x21, 0xC7, 0x5C, 0x01, 0xC0, 0x02, 0x80, 0x04, 0x80, 0x11, 0x00, 0x41,
  0x01, 0x81, 0x02, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x7F, 0xFF, 0xC0, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x25, 0xB4,
  0x94, 0x90, 0xFF, 0xC0, 0xF0, 0x00, 0x30, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x00, 0x01, 0xC0, 0x0E, 0x30, 0x18, 0x08, 0x10, 0x04, 0x20, 0x06, 0x20,
  0x02, 0x40, 0x02, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40,
  0x03, 0x20, 0x02, 0x20, 0x02, 0x30, 0x04, 0x10, 0x04, 0x08, 0x18, 0x07,
  0xF0, 0x03, 0x05, 0x19, 0x31, 0x61, 0x81, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0xC0, 0x1C, 0x70, 0x60, 0x08,
  0x40, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0x03, 0x80, 0x1C, 0x70, 0x60, 0x0C,
  0x80, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x0F, 0xC0,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x04, 0xC0, 0x18, 0x7F, 0xF0, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0B, 0x00, 0x02, 0x60, 0x00, 0xCC, 0x00, 0x11, 0x80, 0x04,
  0x30, 0x00, 0x86, 0x00, 0x20, 0xC0, 0x0C, 0x18, 0x01, 0x03, 0x00, 0x40,
  0x60, 0x18, 0x0C, 0x02, 0x01, 0x80, 0x80, 0x30, 0x30, 0x06, 0x04, 0x00,
  0xC1, 0x00, 0x18, 0x60, 0x03, 0x0F, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x7F, 0xFC, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x0F, 0xFE, 0x08, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x24, 0x01, 0x87, 0xFE, 0x00, 0x00, 0x78,
  0x01, 0xE3, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x3F, 0x02, 0x60, 0x61, 0x40, 0x18, 0xC0, 0x04, 0xE0, 0x01, 0x60, 0x00,
  0xB0, 0x00, 0x48, 0x00, 0x34, 0x00, 0x1A, 0x00, 0x0D, 0x00, 0x04, 0x80,
  0x02, 0x60, 0x01, 0x10, 0x00, 0x88, 0x00, 0x82, 0x00, 0xC0, 0x80, 0xC0,
  0x3F, 0xC0, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x03, 0xC0, 0x0E, 0x78, 0x10, 0x0C, 0x20, 0x06, 0x60, 0x02, 0x40, 0x02,
  0x40, 0x03, 0x40, 0x03, 0x40, 0x02, 0x60, 0x02, 0x20, 0x06, 0x10, 0x0C,
  0x0C, 0x18, 0x07, 0x60, 0x01, 0xC0, 0x06, 0x70, 0x18, 0x18, 0x30, 0x04,
  0x60, 0x02, 0x40, 0x03, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x40, 0x01, 0x40, 0x03, 0x20, 0x06, 0x10, 0x0C, 0x0F, 0xF0,
  0x03, 0x80, 0x0C, 0x70, 0x30, 0x08, 0x20, 0x04, 0x40, 0x04, 0x40, 0x02,
  0xC0, 0x02, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x40, 0x03, 0x40, 0x03, 0x60, 0x05, 0x30, 0x09, 0x1C, 0x71,
  0x03, 0xC1, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x7F, 0xC0,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x2D, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x04, 0xB6, 0x92, 0x92, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x00, 0x0E, 0x07, 0x1C, 0x80, 0x60,
  0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0E, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x08, 0x10, 0x00, 0x00, 0x42, 0x00, 0x00, 0x04, 0x20, 0x07, 0xC0, 0x26,
  0x01, 0x82, 0x02, 0x40, 0x20, 0x20, 0x24, 0x04, 0x02, 0x03, 0x40, 0x40,
  0x20, 0x1C, 0x08, 0x02, 0x01, 0x80, 0x80, 0x20, 0x18, 0x08, 0x02, 0x01,
  0x80, 0x80, 0x20, 0x18, 0x08, 0x02, 0x03, 0x80, 0x80, 0x20, 0x28, 0x08,
  0x02, 0x02, 0x80, 0x80, 0x60, 0x24, 0x0C, 0x06, 0x06, 0x40, 0x40, 0x90,
  0x44, 0x03, 0xF1, 0xF8, 0x40, 0x08, 0x06, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x10, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x08,
  0x80, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00,
  0x08, 0x20, 0x00, 0x81, 0x80, 0x04, 0x04, 0x00, 0x20, 0x20, 0x02, 0x01,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x01, 0x80, 0x7F, 0xFC, 0x02,
  0x00, 0x20, 0x20, 0x01, 0x81, 0x00, 0x04, 0x08, 0x00, 0x20, 0x80, 0x01,
  0x84, 0x00, 0x04, 0x20, 0x00, 0x22, 0x00, 0x01, 0x90, 0x00, 0x05, 0x80,
  0x00, 0x28, 0x00, 0x01, 0x80, 0xFF, 0xF0, 0x80, 0x1C, 0x80, 0x04, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x18, 0xFF, 0xE0, 0x80, 0x38, 0x80,
  0x06, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x02, 0x80, 0x04, 0x80,
  0x18, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x3C, 0x7C, 0x0C, 0x00, 0x82, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x02,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x10, 0x03, 0x02, 0x00, 0x18, 0x40, 0x01,
  0x88, 0x00, 0x11, 0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x02, 0x80, 0x00,
  0x50, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0A, 0x00, 0x01,
  0x40, 0x00, 0x28, 0x00, 0x05, 0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x0C,
  0x80, 0x01, 0x10, 0x00, 0x42, 0x00, 0x30, 0x40, 0x1C, 0x0F, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0xFF,
  0xE8, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xC3, 0xC0,
  0x30, 0x00, 0x81, 0x80, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x0F, 0xFD, 0x00, 0x00, 0x14, 0x00, 0x00, 0x50, 0x00,
  0x01, 0x40, 0x00, 0x05, 0x00, 0x00, 0x12, 0x00, 0x00, 0x48, 0x00, 0x01,
  0x30, 0x00, 0x04, 0x40, 0x00, 0x10, 0x80, 0x00, 0x41, 0x80, 0x01, 0x03,
  0x00, 0x1C, 0x03, 0xFF, 0xC0, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0xFE,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x8F,
  0xE0, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x06,
  0xFC, 0x80, 0x03, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x18, 0x80, 0x30, 0x80,
  0x60, 0x80, 0x40, 0x80, 0x80, 0x81, 0x00, 0x83, 0x00, 0x86, 0x00, 0x8C,
  0x00, 0x9C, 0x00, 0x94, 0x00, 0xA2, 0x00, 0xC2, 0x00, 0xC1, 0x00, 0x81,
  0x80, 0x80, 0x80, 0x80, 0x40, 0x80, 0x60, 0x80, 0x20, 0x80, 0x10, 0x80,
  0x18, 0x80, 0x08, 0x80, 0x04, 0x80, 0x06, 0x80, 0x02, 0x80, 0x01, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xFF, 0x80, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x05, 0xA0, 0x00, 0x05, 0xA0,
  0x00, 0x09, 0xB0, 0x00, 0x09, 0x90, 0x00, 0x09, 0x90, 0x00, 0x11, 0x88,
  0x00, 0x11, 0x88, 0x00, 0x31, 0x88, 0x00, 0x21, 0x84, 0x00, 0x21, 0x84,
  0x00, 0x41, 0x86, 0x00, 0x41, 0x82, 0x00, 0x41, 0x82, 0x00, 0x81, 0x81,
  0x00, 0x81, 0x81, 0x01, 0x81, 0x81, 0x01, 0x01, 0x80, 0x81, 0x01, 0x80,
  0x82, 0x01, 0x80, 0xC2, 0x01, 0x80, 0x42, 0x01, 0x80, 0x44, 0x01, 0x80,
  0x24, 0x01, 0x80, 0x2C, 0x01, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x80, 0x01, 0xB0,
  0x00, 0x64, 0x00, 0x18, 0x80, 0x06, 0x20, 0x01, 0x84, 0x00, 0x61, 0x80,
  0x18, 0x20, 0x06, 0x04, 0x01, 0x81, 0x00, 0x60, 0x20, 0x18, 0x0C, 0x06,
  0x01, 0x01, 0x80, 0x20, 0x60, 0x08, 0x18, 0x01, 0x06, 0x00, 0x61, 0x80,
  0x08, 0x60, 0x03, 0x18, 0x00, 0x46, 0x00, 0x09, 0x80, 0x03, 0x60, 0x00,
  0x58, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x40, 0x00, 0x38, 0x00, 0x03,
  0x87, 0x00, 0x18, 0x01, 0x00, 0x40, 0x01, 0x01, 0x80, 0x01, 0x02, 0x00,
  0x03, 0x08, 0x00, 0x02, 0x10, 0x00, 0x06, 0x40, 0x00, 0x04, 0x80, 0x00,
  0x09, 0x00, 0x00, 0x12, 0x00, 0x00, 0x34, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x05,
  0x00, 0x00, 0x0A, 0x00, 0x00, 0x24, 0x00, 0x00, 0x48, 0x00, 0x00, 0x98,
  0x00, 0x01, 0x10, 0x00, 0x04, 0x20, 0x00, 0x08, 0x20, 0x00, 0x30, 0x60,
  0x00, 0x40, 0x60, 0x01, 0x00, 0x60, 0x0C, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xE1, 0x00, 0x62, 0x00, 0x24, 0x00, 0x28, 0x00, 0x50, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x28, 0x00, 0x50,
  0x01, 0x20, 0x0C, 0x7F, 0xF0, 0xFC, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0x87, 0x00,
  0x18, 0x01, 0x00, 0x60, 0x01, 0x01, 0x80, 0x01, 0x02, 0x00, 0x03, 0x08,
  0x00, 0x02, 0x10, 0x00, 0x06, 0x40, 0x00, 0x04, 0x80, 0x00, 0x09, 0x00,
  0x00, 0x12, 0x00, 0x00, 0x34, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0x34, 0x00, 0x00, 0x48, 0x00, 0x00, 0x98, 0x00, 0x01,
  0x10, 0x00, 0x06, 0x20, 0x00, 0x08, 0x20, 0x00, 0x30, 0x60, 0x00, 0x40,
  0x60, 0x01, 0x00, 0x60, 0x0C, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0xFF, 0xE0, 0x80, 0x38, 0x80, 0x0C, 0x80,
  0x04, 0x80, 0x04, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x18, 0x80, 0xE0, 0xFF,
  0x80, 0x80, 0x80, 0x80, 0x40, 0x80, 0x40, 0x80, 0x20, 0x80, 0x20, 0x80,
  0x10, 0x80, 0x18, 0x80, 0x08, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x06, 0x80,
  0x02, 0x80, 0x01, 0x01, 0xE0, 0x0E, 0x3E, 0x30, 0x02, 0x20, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x80,
  0x18, 0x7F, 0xF0, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x90, 0x00, 0x22, 0x00, 0x10, 0x60, 0x18,
  0x0F, 0xF8, 0x00, 0x80, 0x00, 0x14, 0x00, 0x03, 0x40, 0x00, 0x24, 0x00,
  0x02, 0x20, 0x00, 0x62, 0x00, 0x04, 0x20, 0x00, 0x41, 0x00, 0x0C, 0x10,
  0x00, 0x81, 0x00, 0x08, 0x18, 0x00, 0x80, 0x80, 0x10, 0x08, 0x01, 0x00,
  0xC0, 0x10, 0x04, 0x02, 0x00, 0x40, 0x20, 0x06, 0x02, 0x00, 0x20, 0x40,
  0x02, 0x04, 0x00, 0x30, 0x40, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08,
  0x00, 0x09, 0x00, 0x00, 0x90, 0x00, 0x09, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x14,
  0x00, 0x30, 0x00, 0x50, 0x00, 0xE0, 0x02, 0x40, 0x04, 0x80, 0x09, 0x80,
  0x12, 0x00, 0x22, 0x00, 0x48, 0x00, 0x88, 0x01, 0x30, 0x04, 0x20, 0x08,
  0x40, 0x10, 0xC0, 0x21, 0x00, 0x41, 0x00, 0x84, 0x01, 0x04, 0x02, 0x18,
  0x08, 0x10, 0x18, 0x20, 0x20, 0x60, 0x40, 0x80, 0x80, 0x81, 0x02, 0x06,
  0x02, 0x04, 0x0C, 0x10, 0x08, 0x30, 0x10, 0x40, 0x30, 0x80, 0x41, 0x00,
  0x42, 0x01, 0x0C, 0x01, 0x08, 0x06, 0x20, 0x04, 0x60, 0x08, 0x80, 0x19,
  0x00, 0x22, 0x00, 0x24, 0x00, 0x98, 0x00, 0x90, 0x02, 0x40, 0x02, 0xC0,
  0x05, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x18, 0x00, 0x50, 0x00, 0x60, 0x01,
  0x80, 0x01, 0x80, 0x02, 0x00, 0x60, 0x00, 0xC8, 0x00, 0x61, 0x00, 0x10,
  0x40, 0x0C, 0x08, 0x02, 0x02, 0x01, 0x80, 0x40, 0x40, 0x10, 0x20, 0x02,
  0x08, 0x00, 0xC4, 0x00, 0x11, 0x00, 0x06, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x80, 0x01, 0x20, 0x00, 0x44, 0x00, 0x21, 0x80,
  0x18, 0x20, 0x04, 0x0C, 0x03, 0x01, 0x00, 0x80, 0x60, 0x40, 0x08, 0x10,
  0x03, 0x08, 0x00, 0x46, 0x00, 0x09, 0x00, 0x02, 0xC0, 0x00, 0x40, 0xC0,
  0x00, 0xD0, 0x00, 0x24, 0x00, 0x18, 0x80, 0x04, 0x20, 0x03, 0x04, 0x00,
  0x81, 0x00, 0x20, 0x20, 0x10, 0x08, 0x04, 0x01, 0x02, 0x00, 0x40, 0x80,
  0x08, 0x40, 0x02, 0x10, 0x00, 0xC8, 0x00, 0x12, 0x00, 0x07, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xFF,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x0C,
  0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x30, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0xFF, 0x00, 0x60, 0x00, 0x28, 0x00, 0x0B, 0x00,
  0x04, 0x40, 0x01, 0x18, 0x00, 0x82, 0x00, 0x20, 0xC0, 0x10, 0x10, 0x04,
  0x06, 0x02, 0x00, 0x81, 0x80, 0x20, 0x40, 0x04, 0x30, 0x01, 0x08, 0x00,
  0x26, 0x00, 0x0B, 0x00, 0x01, 0xFF, 0xFF, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x0F, 0xC0, 0xC0, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x7F, 0xC6, 0x01, 0x60, 0x05, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0x70, 0x05, 0x60,
  0x64, 0xFF, 0x10, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x87, 0xF0, 0x8C,
  0x18, 0x90, 0x04, 0xA0, 0x02, 0xA0, 0x02, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x02, 0xA0, 0x02, 0xB0,
  0x04, 0x98, 0x18, 0x8F, 0xF0, 0x03, 0xF8, 0x38, 0x11, 0x80, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x04, 0x1F, 0xF0, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x07, 0xE1, 0x0C, 0x19, 0x10, 0x05, 0x20, 0x07, 0x60, 0x03,
  0x40, 0x03, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x01, 0x40, 0x03,
  0x40, 0x03, 0x20, 0x03, 0x20, 0x05, 0x18, 0x09, 0x0F, 0xF1, 0x07, 0xE0,
  0x18, 0x30, 0x40, 0x31, 0x00, 0x22, 0x00, 0x68, 0x00, 0x50, 0x00, 0xA0,
  0x01, 0xC0, 0x03, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x60, 0xFF, 0x80, 0x03, 0xF0, 0x60, 0x04, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x0F, 0xF8, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x07, 0xF1, 0x0C, 0x19, 0x10, 0x05, 0x20, 0x03, 0x60,
  0x03, 0x40, 0x03, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x01, 0x40,
  0x03, 0x40, 0x03, 0x20, 0x03, 0x30, 0x05, 0x18, 0x09, 0x0F, 0xF1, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00,
  0x02, 0x40, 0x04, 0x78, 0x38, 0x0F, 0xE0, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x0F, 0xC2, 0x30, 0x64, 0x80, 0x6A, 0x00, 0x54, 0x00, 0xB0, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0C, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x08, 0x29, 0xB8, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x28, 0x01, 0x20, 0x08, 0x80, 0x42, 0x03, 0x08, 0x08, 0x20, 0x40,
  0x82, 0x02, 0x10, 0x08, 0xC0, 0x23, 0x80, 0x92, 0x02, 0x84, 0x0C, 0x10,
  0x30, 0x20, 0x80, 0xC2, 0x01, 0x08, 0x02, 0x20, 0x0C, 0x80, 0x12, 0x00,
  0x28, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x87,
  0xC0, 0xFC, 0x4C, 0x10, 0xC3, 0x2C, 0x04, 0x80, 0x54, 0x01, 0x80, 0x3C,
  0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x20, 0x03, 0x80, 0x10, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x87, 0xE1, 0x18, 0x32,
  0x40, 0x35, 0x00, 0x2A, 0x00, 0x58, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x03, 0xF0, 0x06, 0x0C, 0x04, 0x01, 0x04, 0x00, 0x46, 0x00,
  0x32, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x80, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x04, 0x80, 0x02,
  0x40, 0x01, 0x20, 0x01, 0x88, 0x00, 0x86, 0x00, 0xC1, 0x80, 0xC0, 0x3F,
  0x80, 0x83, 0xF0, 0x8C, 0x18, 0x90, 0x04, 0xA0, 0x02, 0xA0, 0x02, 0xC0,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xA0,
  0x02, 0xA0, 0x02, 0x90, 0x04, 0x98, 0x08, 0xC7, 0xF0, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x07, 0xE1, 0x0C, 0x19, 0x10, 0x05, 0x20,
  0x07, 0x60, 0x03, 0x40, 0x03, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x01, 0x40, 0x03, 0x40, 0x03, 0x60, 0x05, 0x20, 0x05, 0x18, 0x09, 0x0F,
  0xF1, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x87, 0xE2, 0x09,
  0x02, 0x80, 0xA0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x00, 0x1F, 0xE1, 0x81, 0x90, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x28, 0x02, 0x3F,
  0xE0, 0x10, 0x08, 0x04, 0x06, 0x03, 0x07, 0xFC, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x20, 0x10, 0x08, 0x03, 0xE0, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x0D, 0x00, 0x2A, 0x00, 0x92, 0x03, 0x23,
  0xF8, 0x40, 0x80, 0x03, 0xC0, 0x02, 0x40, 0x02, 0x40, 0x04, 0x60, 0x04,
  0x20, 0x04, 0x20, 0x08, 0x30, 0x08, 0x10, 0x08, 0x10, 0x10, 0x18, 0x10,
  0x08, 0x10, 0x08, 0x20, 0x0C, 0x20, 0x04, 0x20, 0x04, 0x40, 0x06, 0x40,
  0x02, 0x40, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0xC0, 0x18, 0x02, 0x40, 0x24,
  0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x04, 0x60, 0x66, 0x04, 0x20, 0x42,
  0x04, 0x20, 0x42, 0x04, 0x20, 0x42, 0x08, 0x10, 0x81, 0x08, 0x10, 0x81,
  0x08, 0x10, 0x81, 0x08, 0x11, 0x81, 0x90, 0x09, 0x00, 0x90, 0x09, 0x00,
  0x90, 0x09, 0x00, 0x90, 0x0A, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0xC0, 0x06, 0x80, 0x08, 0x80, 0x21, 0x80, 0x41,
  0x01, 0x03, 0x06, 0x02, 0x08, 0x02, 0x20, 0x06, 0xC0, 0x05, 0x00, 0x04,
  0x00, 0x1C, 0x00, 0x28, 0x00, 0x88, 0x01, 0x10, 0x04, 0x10, 0x18, 0x30,
  0x20, 0x20, 0x80, 0x23, 0x00, 0x64, 0x00, 0x58, 0x00, 0x40, 0x80, 0x01,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04,
  0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x08, 0x10, 0x08, 0x10, 0x08, 0x10,
  0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x98, 0x00,
  0xF0, 0x00, 0xFF, 0xF0, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x0F, 0xFF, 0x01,
  0xE0, 0x60, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x18, 0x1C, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x06, 0x00, 0xC0, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x30, 0x30, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02,
  0x0F, 0x00, 0x7F, 0x00, 0xE0, 0xE0, 0xE0, 0x1F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Thin41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 29, 9, 3, -29 },
  { 9, 7, 10, 13, 3, -29 },
  { 18, 21, 29, 23, 1, -29 },
  { 95, 16, 33, 21, 2, -31 },
  { 161, 25, 30, 29, 2, -30 },
  { 255, 21, 30, 24, 2, -30 },
  { 334, 1, 10, 7, 3, -29 },
  { 336, 7, 35, 11, 2, -29 },
  { 367, 7, 35, 11, 2, -29 },
  { 398, 15, 14, 19, 2, -31 },
  { 425, 17, 19, 21, 2, -24 },
  { 466, 3, 10, 7, 2, -5 },
  { 470, 10, 1, 12, 1, -12 },
  { 472, 2, 2, 8, 3, -2 },
  { 473, 12, 29, 13, 1, -29 },
  { 517, 16, 30, 21, 2, -30 },
  { 577, 8, 29, 21, 4, -29 },
  { 606, 16, 30, 21, 2, -30 },
  { 666, 16, 30, 21, 2, -30 },
  { 726, 19, 29, 21, 1, -29 },
  { 795, 15, 29, 21, 3, -29 },
  { 850, 17, 30, 21, 2, -30 },
  { 914, 16, 29, 21, 2, -29 },
  { 972, 16, 30, 21, 2, -30 },
  { 1032, 16, 30, 21, 2, -30 },
  { 1092, 2, 22, 8, 3, -22 },
  { 1098, 3, 27, 8, 2, -22 },
  { 1109, 17, 18, 21, 2, -24 },
  { 1148, 17, 9, 21, 2, -19 },
  { 1168, 17, 18, 21, 2, -24 },
  { 1207, 12, 30, 15, 1, -30 },
  { 1252, 28, 33, 32, 2, -29 },
  { 1368, 21, 29, 21, 0, -29 },
  { 1445, 16, 29, 22, 4, -29 },
  { 1503, 19, 30, 22, 2, -30 },
  { 1575, 19, 29, 25, 4, -29 },
  { 1644, 14, 29, 20, 4, -29 },
  { 1695, 14, 29, 18, 4, -29 },
  { 1746, 22, 30, 27, 2, -30 },
  { 1829, 18, 29, 26, 4, -29 },
  { 1895, 7, 29, 11, 2, -29 },
  { 1921, 8, 36, 9, -3, -29 },
  { 1957, 16, 29, 20, 4, -29 },
  { 2015, 13, 29, 18, 4, -29 },
  { 2063, 24, 29, 32, 4, -29 },
  { 2150, 18, 29, 26, 4, -29 },
  { 2216, 23, 30, 27, 2, -30 },
  { 2303, 15, 29, 21, 4, -29 },
  { 2358, 23, 37, 27, 2, -30 },
  { 2465, 16, 29, 21, 4, -29 },
  { 2523, 16, 30, 20, 2, -30 },
  { 2583, 18, 29, 18, 0, -29 },
  { 2649, 18, 29, 26, 4, -29 },
  { 2715, 20, 29, 20, 0, -29 },
  { 2788, 30, 29, 32, 1, -29 },
  { 2897, 18, 29, 18, 0, -29 },
  { 2963, 18, 29, 18, 0, -29 },
  { 3029, 18, 29, 20, 1, -29 },
  { 3095, 8, 35, 13, 4, -29 },
  { 3130, 12, 29, 13, 1, -29 },
  { 3174, 8, 35, 13, 1, -29 },
  { 3209, 18, 16, 21, 1, -29 },
  { 3245, 16, 1, 16, 0, 4 },
  { 3247, 6, 6, 10, 2, -31 },
  { 3252, 14, 22, 19, 2, -22 },
  { 3291, 16, 31, 22, 3, -31 },
  { 3353, 14, 22, 17, 2, -22 },
  { 3392, 16, 31, 22, 2, -31 },
  { 3454, 15, 22, 20, 2, -22 },
  { 3496, 12, 31, 10, 0, -31 },
  { 3543, 16, 32, 21, 2, -22 },
  { 3607, 15, 31, 21, 3, -31 },
  { 3666, 2, 30, 8, 3, -30 },
  { 3674, 6, 40, 8, -1, -30 },
  { 3704, 14, 31, 17, 3, -31 },
  { 3759, 2, 31, 8, 3, -31 },
  { 3767, 25, 22, 31, 3, -22 },
  { 3836, 15, 22, 21, 3, -22 },
  { 3878, 17, 22, 21, 2, -22 },
  { 3925, 16, 32, 21, 3, -22 },
  { 3989, 16, 32, 21, 2, -22 },
  { 4053, 10, 22, 14, 3, -22 },
  { 4081, 13, 22, 17, 2, -22 },
  { 4117, 9, 27, 11, 1, -27 },
  { 4148, 15, 22, 21, 3, -22 },
  { 4190, 16, 22, 16, 0, -22 },
  { 4234, 24, 22, 26, 1, -22 },
  { 4300, 15, 22, 17, 1, -22 },
  { 4342, 16, 32, 16, 0, -22 },
  { 4406, 12, 22, 16, 2, -22 },
  { 4439, 11, 35, 14, 1, -29 },
  { 4488, 1, 41, 20, 9, -31 },
  { 4494, 10, 35, 14, 2, -29 },
  { 4538, 17, 3, 21, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_Thin41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin41pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_SEMICONDENSED_THIN41PT7B_H_
