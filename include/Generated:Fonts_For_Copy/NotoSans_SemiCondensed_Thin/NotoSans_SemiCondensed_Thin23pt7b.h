#ifndef _NOTOSANS_SEMICONDENSED_THIN23PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF1, 0x99, 0x99, 0x99, 0x08, 0x81, 0x10, 0x22, 0x08, 0x4F,
  0xFE, 0x21, 0x04, 0x40, 0x88, 0x11, 0x04, 0x23, 0xFF, 0x90, 0x82, 0x20,
  0x44, 0x08, 0x82, 0x10, 0x08, 0x1F, 0x92, 0x11, 0x08, 0x84, 0x41, 0x20,
  0x50, 0x18, 0x07, 0x02, 0x41, 0x10, 0x88, 0x44, 0x23, 0x16, 0x7C, 0x04,
  0x00, 0x30, 0x01, 0x20, 0x88, 0x42, 0x21, 0x10, 0x84, 0x42, 0x12, 0x08,
  0x48, 0x21, 0x4E, 0x85, 0x45, 0x29, 0x13, 0x28, 0x41, 0x21, 0x04, 0x84,
  0x22, 0x10, 0x84, 0x42, 0x11, 0x10, 0x38, 0x1C, 0x02, 0x20, 0x21, 0x02,
  0x10, 0x21, 0x02, 0x10, 0x12, 0x01, 0x40, 0x18, 0x02, 0x40, 0x42, 0x18,
  0x12, 0x81, 0x28, 0x0C, 0x80, 0x44, 0x0A, 0x3F, 0x10, 0xFC, 0x12, 0x44,
  0x48, 0x88, 0x88, 0x88, 0x88, 0x44, 0x42, 0x21, 0x84, 0x22, 0x21, 0x11,
  0x11, 0x11, 0x11, 0x22, 0x24, 0x48, 0x08, 0x04, 0x32, 0x67, 0xC1, 0x80,
  0xA0, 0x88, 0x44, 0x08, 0x02, 0x00, 0x80, 0x20, 0xFF, 0xC2, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x56, 0xA0, 0xF8, 0x80, 0x02, 0x04, 0x10, 0x20,
  0x81, 0x02, 0x08, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x40, 0x1E, 0x10,
  0x90, 0x48, 0x14, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0A, 0x05, 0x02, 0x42, 0x1E, 0x00, 0x19, 0x72, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x3C, 0x21, 0x00, 0x40, 0x10, 0x08, 0x04, 0x04,
  0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x00, 0x80, 0x80, 0x80, 0xFF, 0x80,
  0x3C, 0x61, 0x80, 0x40, 0x10, 0x08, 0x04, 0x04, 0x04, 0x3E, 0x00, 0x80,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0xFE, 0x00, 0x00, 0x80, 0x30, 0x06,
  0x01, 0x40, 0x48, 0x09, 0x02, 0x20, 0x84, 0x10, 0x84, 0x11, 0x02, 0x20,
  0x4F, 0xFE, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x7F, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0xF8, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x05, 0xFC, 0x0F, 0x08, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x3E, 0xE0,
  0xE0, 0x60, 0x30, 0x18, 0x0A, 0x05, 0x02, 0x41, 0x1F, 0x00, 0xFF, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x00,
  0x80, 0x80, 0x40, 0x20, 0x1E, 0x10, 0x90, 0x28, 0x14, 0x0A, 0x05, 0x84,
  0x24, 0x1C, 0x11, 0x90, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x81, 0x3F, 0x00,
  0x1C, 0x31, 0x10, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x40, 0xB1, 0xC7,
  0x20, 0x10, 0x08, 0x08, 0x04, 0x04, 0x7C, 0x00, 0x80, 0x10, 0x40, 0x00,
  0x15, 0xA8, 0x00, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x10, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x20, 0x00,
  0x72, 0x30, 0x41, 0x04, 0x10, 0x42, 0x10, 0x82, 0x08, 0x20, 0x00, 0x00,
  0x20, 0x0F, 0xF0, 0x10, 0x08, 0x20, 0x04, 0x40, 0x02, 0x41, 0xC2, 0x42,
  0x21, 0x84, 0x21, 0x88, 0x21, 0x88, 0x21, 0x88, 0x21, 0x88, 0x21, 0x84,
  0x22, 0x84, 0xD2, 0x43, 0x0C, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0F,
  0xE0, 0x06, 0x00, 0x60, 0x0A, 0x00, 0x90, 0x09, 0x01, 0x10, 0x10, 0x81,
  0x08, 0x20, 0x83, 0xF8, 0x20, 0x44, 0x04, 0x40, 0x24, 0x02, 0x80, 0x28,
  0x01, 0xFF, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x05, 0xFC, 0x81, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x05, 0xFC, 0x07, 0xC3, 0x04, 0x80, 0x10,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xE0, 0xFF, 0x10, 0x12, 0x01, 0x40,
  0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x28,
  0x05, 0x01, 0x20, 0x47, 0xF0, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x07, 0xC0, 0x83, 0x30, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x1F, 0x80, 0x18, 0x01, 0x40, 0x14, 0x01, 0x20, 0x11,
  0x01, 0x0F, 0xF0, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07,
  0xFF, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xF4,
  0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x4F, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x43, 0xE0, 0x81, 0xC0, 0xA0, 0x90,
  0x88, 0x84, 0x82, 0x81, 0xA0, 0xC8, 0x44, 0x21, 0x10, 0x48, 0x24, 0x0A,
  0x03, 0x01, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x0F, 0x00, 0x3C, 0x01, 0x68,
  0x05, 0xA0, 0x16, 0x80, 0x99, 0x02, 0x64, 0x11, 0x88, 0x46, 0x21, 0x18,
  0x88, 0x61, 0x21, 0x84, 0x86, 0x14, 0x18, 0x30, 0x60, 0x81, 0x80, 0x70,
  0x1A, 0x06, 0x81, 0x90, 0x64, 0x18, 0x86, 0x11, 0x84, 0x60, 0x98, 0x26,
  0x05, 0x80, 0xE0, 0x38, 0x06, 0x01, 0x07, 0x80, 0xC2, 0x08, 0x08, 0x80,
  0x24, 0x01, 0x20, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x14, 0x00, 0xA0, 0x08, 0x80, 0x44, 0x04, 0x1F, 0xC0, 0xFE, 0x40,
  0xA0, 0x30, 0x18, 0x0C, 0x06, 0x05, 0x06, 0xFC, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x07, 0x80, 0xC2, 0x08, 0x08, 0x80, 0x24, 0x01,
  0x20, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x14,
  0x00, 0xA0, 0x08, 0x80, 0x44, 0x04, 0x1F, 0xC0, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0xFE, 0x40, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x05, 0x04,
  0xFC, 0x42, 0x21, 0x10, 0x48, 0x24, 0x0A, 0x03, 0x01, 0x1F, 0x10, 0x50,
  0x10, 0x08, 0x04, 0x01, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x10, 0x08,
  0x04, 0x02, 0x02, 0xFE, 0x00, 0xFF, 0xC1, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x08, 0xFC, 0x80, 0x30, 0x05,
  0x00, 0xA0, 0x24, 0x04, 0x40, 0x88, 0x21, 0x04, 0x10, 0x82, 0x20, 0x44,
  0x04, 0x80, 0xA0, 0x14, 0x01, 0x00, 0x20, 0x81, 0x80, 0xC0, 0xC0, 0xA0,
  0x60, 0x50, 0x30, 0x24, 0x24, 0x12, 0x12, 0x11, 0x09, 0x08, 0x84, 0x84,
  0x24, 0x22, 0x12, 0x12, 0x09, 0x09, 0x04, 0x84, 0x81, 0x81, 0x80, 0xC0,
  0xC0, 0x60, 0x60, 0x20, 0x10, 0x40, 0x50, 0x22, 0x10, 0x44, 0x12, 0x02,
  0x80, 0xC0, 0x10, 0x0C, 0x02, 0x81, 0x20, 0x84, 0x21, 0x10, 0x24, 0x06,
  0x01, 0x80, 0x50, 0x24, 0x08, 0x84, 0x21, 0x04, 0x81, 0x20, 0x28, 0x0C,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0xFF, 0x80, 0x80,
  0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x02,
  0x02, 0x01, 0xFF, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x8F, 0xC0, 0x81, 0x01, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20,
  0x40, 0x80, 0x81, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x1F, 0x0C, 0x03, 0x01, 0x20, 0x88, 0x21, 0x10, 0x44, 0x0A, 0x02, 0x80,
  0x40, 0xFF, 0x80, 0x84, 0x43, 0x7E, 0x01, 0x01, 0x01, 0x01, 0x1F, 0x61,
  0x81, 0x81, 0x81, 0x83, 0x7D, 0x80, 0x40, 0x20, 0x10, 0x08, 0x85, 0xB3,
  0x05, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x05, 0x82, 0xBE,
  0x00, 0x3F, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40,
  0x3F, 0x00, 0x80, 0x40, 0x20, 0x10, 0xC9, 0x95, 0x06, 0x81, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x05, 0x02, 0x83, 0x3E, 0x80, 0x3E, 0x20, 0x90,
  0x30, 0x18, 0x0F, 0xFE, 0x01, 0x00, 0x80, 0x20, 0x10, 0x07, 0xE0, 0x0E,
  0x20, 0x81, 0x02, 0x04, 0x3E, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x3F, 0xA0, 0xD0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xA0, 0x50, 0x67, 0xD0, 0x08, 0x04, 0x02, 0x01, 0x43, 0x16, 0x00,
  0x80, 0x80, 0x80, 0x80, 0x88, 0xB6, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0xC7, 0xFF, 0x80, 0x11, 0x00, 0x01, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x12, 0xC0, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x61, 0x44, 0x91, 0x42, 0x86, 0x88, 0x91, 0x21, 0x41, 0x82, 0xFF,
  0xFF, 0x80, 0xFC, 0xFA, 0x0C, 0x18, 0x20, 0x60, 0x81, 0x82, 0x06, 0x08,
  0x18, 0x20, 0x60, 0x81, 0x82, 0x06, 0x08, 0x18, 0x20, 0x60, 0x81, 0xBE,
  0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x3F,
  0x10, 0x24, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x90, 0x24,
  0x08, 0xFC, 0xBE, 0x60, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0xB0, 0x57, 0xC8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x00, 0x3E, 0xA0,
  0xD0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0, 0x50, 0x67, 0xD0,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xBE, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x00, 0x7F, 0x02, 0x04, 0x04, 0x06, 0x03, 0x01, 0x02, 0x04, 0x0F,
  0xE0, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83,
  0xC0, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83,
  0x7D, 0x80, 0xC0, 0x90, 0x48, 0x24, 0x21, 0x10, 0x88, 0x48, 0x14, 0x0A,
  0x06, 0x01, 0x00, 0x81, 0x05, 0x04, 0x14, 0x28, 0x50, 0xA2, 0x44, 0x88,
  0x92, 0x22, 0x44, 0x89, 0x14, 0x28, 0x50, 0x61, 0x41, 0x82, 0x04, 0x08,
  0x81, 0x42, 0x44, 0x24, 0x28, 0x10, 0x18, 0x28, 0x24, 0x42, 0x82, 0x81,
  0x80, 0xA0, 0x90, 0x48, 0x22, 0x21, 0x10, 0x88, 0x28, 0x14, 0x0A, 0x02,
  0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x20, 0x60, 0x00, 0xFE, 0x08, 0x10,
  0x40, 0x82, 0x04, 0x10, 0x40, 0x82, 0x07, 0xF0, 0x1C, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x23, 0x06, 0x08, 0x20, 0x82, 0x08, 0x20, 0x81, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x31, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x42, 0x30, 0x78, 0x61, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Thin23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 16, 5, 2, -16 },
  { 3, 4, 6, 7, 2, -16 },
  { 6, 11, 16, 13, 1, -16 },
  { 28, 9, 18, 12, 1, -17 },
  { 49, 14, 17, 16, 1, -17 },
  { 79, 12, 17, 13, 1, -17 },
  { 105, 1, 6, 4, 1, -16 },
  { 106, 4, 20, 6, 1, -16 },
  { 116, 4, 20, 6, 1, -16 },
  { 126, 9, 8, 11, 1, -17 },
  { 135, 10, 10, 12, 1, -13 },
  { 148, 2, 6, 4, 1, -3 },
  { 150, 5, 1, 7, 1, -7 },
  { 151, 1, 1, 5, 2, -1 },
  { 152, 7, 16, 7, 0, -16 },
  { 166, 9, 17, 12, 1, -17 },
  { 186, 5, 16, 12, 2, -16 },
  { 196, 9, 17, 12, 1, -17 },
  { 216, 9, 17, 12, 1, -17 },
  { 236, 11, 17, 12, 0, -17 },
  { 260, 9, 16, 12, 1, -16 },
  { 278, 9, 17, 12, 1, -17 },
  { 298, 9, 16, 12, 1, -16 },
  { 316, 9, 17, 12, 1, -17 },
  { 336, 9, 17, 12, 1, -17 },
  { 356, 1, 12, 5, 2, -12 },
  { 358, 2, 15, 5, 1, -12 },
  { 362, 10, 10, 12, 1, -13 },
  { 375, 10, 6, 12, 1, -11 },
  { 383, 10, 10, 12, 1, -13 },
  { 396, 6, 17, 8, 1, -17 },
  { 409, 16, 18, 18, 1, -16 },
  { 445, 12, 16, 12, 0, -16 },
  { 469, 9, 16, 13, 2, -16 },
  { 487, 11, 17, 12, 1, -17 },
  { 511, 11, 16, 14, 2, -16 },
  { 533, 8, 16, 11, 2, -16 },
  { 549, 8, 16, 10, 2, -16 },
  { 565, 12, 17, 15, 1, -17 },
  { 591, 10, 16, 14, 2, -16 },
  { 611, 4, 16, 6, 1, -16 },
  { 619, 5, 20, 5, -2, -16 },
  { 632, 9, 16, 11, 2, -16 },
  { 650, 8, 16, 10, 2, -16 },
  { 666, 14, 16, 18, 2, -16 },
  { 694, 10, 16, 14, 2, -16 },
  { 714, 13, 17, 15, 1, -17 },
  { 742, 9, 16, 12, 2, -16 },
  { 760, 13, 21, 15, 1, -17 },
  { 795, 9, 16, 12, 2, -16 },
  { 813, 9, 17, 11, 1, -17 },
  { 833, 10, 16, 10, 0, -16 },
  { 853, 10, 16, 14, 2, -16 },
  { 873, 11, 16, 11, 0, -16 },
  { 895, 17, 16, 18, 1, -16 },
  { 929, 10, 16, 10, 0, -16 },
  { 949, 10, 16, 10, 0, -16 },
  { 969, 9, 16, 11, 1, -16 },
  { 987, 4, 20, 7, 2, -16 },
  { 997, 7, 16, 7, 0, -16 },
  { 1011, 4, 20, 7, 1, -16 },
  { 1021, 10, 9, 12, 1, -16 },
  { 1033, 9, 1, 9, 0, 2 },
  { 1035, 4, 4, 6, 1, -18 },
  { 1037, 8, 12, 11, 1, -12 },
  { 1049, 9, 17, 12, 2, -17 },
  { 1069, 8, 12, 10, 1, -12 },
  { 1081, 9, 17, 12, 1, -17 },
  { 1101, 9, 12, 11, 1, -12 },
  { 1115, 7, 18, 6, 0, -18 },
  { 1131, 9, 18, 12, 1, -12 },
  { 1152, 8, 17, 12, 2, -17 },
  { 1169, 1, 17, 5, 2, -17 },
  { 1172, 4, 23, 5, -1, -17 },
  { 1184, 7, 17, 9, 2, -17 },
  { 1199, 1, 17, 4, 2, -17 },
  { 1202, 14, 12, 18, 2, -12 },
  { 1223, 8, 12, 12, 2, -12 },
  { 1235, 10, 12, 12, 1, -12 },
  { 1250, 9, 17, 12, 2, -12 },
  { 1270, 9, 17, 12, 1, -12 },
  { 1290, 5, 12, 8, 2, -12 },
  { 1298, 7, 12, 9, 1, -12 },
  { 1309, 6, 15, 6, 0, -15 },
  { 1321, 8, 12, 12, 2, -12 },
  { 1333, 9, 12, 9, 0, -12 },
  { 1347, 14, 12, 14, 0, -12 },
  { 1368, 8, 12, 10, 1, -12 },
  { 1380, 9, 18, 9, 0, -12 },
  { 1401, 7, 12, 9, 1, -12 },
  { 1412, 6, 20, 8, 1, -16 },
  { 1427, 1, 24, 11, 5, -18 },
  { 1430, 6, 20, 8, 1, -16 },
  { 1445, 10, 2, 12, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_Thin23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin23pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_SEMICONDENSED_THIN23PT7B_H_
