#ifndef _NOTOSANS_SEMICONDENSED_THIN25PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0x40, 0x99, 0x99, 0x99, 0x90, 0x08, 0x40, 0x42, 0x02,
  0x10, 0x10, 0x80, 0x84, 0x04, 0x23, 0xDE, 0xE2, 0x10, 0x10, 0x80, 0x84,
  0x04, 0x21, 0xBD, 0xE2, 0x10, 0x10, 0x80, 0x84, 0x04, 0x20, 0x21, 0x01,
  0x08, 0x00, 0x08, 0x07, 0x82, 0x99, 0x20, 0x88, 0x22, 0x08, 0x81, 0x20,
  0x28, 0x06, 0x00, 0x60, 0x26, 0x08, 0x82, 0x10, 0x84, 0x21, 0x08, 0xB2,
  0x43, 0xE0, 0x20, 0x38, 0x10, 0x88, 0x22, 0x10, 0x44, 0x21, 0x08, 0x22,
  0x10, 0x48, 0x20, 0x90, 0x42, 0x4E, 0x44, 0xA2, 0x8A, 0x44, 0xE5, 0x08,
  0x12, 0x10, 0x24, 0x20, 0x88, 0x41, 0x10, 0x84, 0x21, 0x08, 0x22, 0x20,
  0x38, 0x1E, 0x01, 0x08, 0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x80, 0x44,
  0x01, 0xC0, 0x18, 0x01, 0x20, 0x10, 0x82, 0x82, 0x28, 0x09, 0x40, 0x2A,
  0x01, 0x90, 0x0C, 0x40, 0x91, 0xF8, 0x40, 0xFE, 0x18, 0x88, 0x44, 0x22,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x42, 0x10, 0x41, 0x0C, 0x84, 0x42,
  0x21, 0x11, 0x11, 0x11, 0x11, 0x11, 0x12, 0x24, 0x48, 0x08, 0x04, 0x02,
  0x1D, 0x31, 0xE0, 0x60, 0x48, 0x44, 0x21, 0x00, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x55, 0xA0, 0xFC, 0x80, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0x80, 0x1F,
  0x08, 0x24, 0x09, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x50, 0x14, 0x05, 0x02, 0x20, 0x87, 0xC0, 0x08, 0xCB,
  0x90, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x40, 0x3E, 0x10,
  0x40, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20,
  0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x40, 0x3F, 0xF0, 0x3F, 0x30, 0x20,
  0x08, 0x01, 0x00, 0x40, 0x10, 0x08, 0x04, 0x3C, 0x00, 0xC0, 0x08, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xBF, 0xC0, 0x01, 0x00, 0x20, 0x0A,
  0x02, 0x40, 0x48, 0x11, 0x04, 0x20, 0x84, 0x20, 0x84, 0x11, 0x02, 0x40,
  0x48, 0x08, 0xFF, 0xC0, 0x20, 0x04, 0x00, 0x80, 0x10, 0x7F, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0xF8, 0x83, 0x00, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x01, 0x7F, 0x00, 0x1F, 0x10, 0x10, 0x08, 0x08, 0x04,
  0x02, 0x01, 0x7C, 0xC1, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x41, 0x1F, 0x00, 0xFF, 0xC0, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x00, 0x1F, 0x08, 0x24, 0x05, 0x01, 0x40, 0x50, 0x12, 0x08, 0x4C,
  0x0C, 0x04, 0xC6, 0x09, 0x01, 0x80, 0x60, 0x18, 0x05, 0x01, 0x40, 0x8F,
  0xC0, 0x3E, 0x10, 0x44, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x40,
  0x50, 0x33, 0xF4, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x1F, 0x80,
  0x80, 0x08, 0x40, 0x00, 0x05, 0x5A, 0x00, 0xE0, 0x60, 0x30, 0x18, 0x0C,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x00, 0xFC, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x82, 0x08, 0x20, 0x81, 0x02, 0x04, 0x00, 0x00, 0x00, 0x40, 0x03,
  0xF0, 0x06, 0x06, 0x04, 0x00, 0x84, 0x00, 0x22, 0x00, 0x12, 0x07, 0x05,
  0x0C, 0x43, 0x04, 0x21, 0x84, 0x10, 0xC2, 0x08, 0x61, 0x04, 0x30, 0x82,
  0x18, 0x41, 0x0C, 0x21, 0x89, 0x0F, 0x3C, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0xFE, 0x00, 0x02, 0x00, 0x30, 0x01, 0x40, 0x0A,
  0x00, 0x90, 0x04, 0x40, 0x22, 0x02, 0x10, 0x10, 0x40, 0x82, 0x0F, 0xF0,
  0x40, 0x42, 0x02, 0x20, 0x11, 0x00, 0x48, 0x02, 0x80, 0x14, 0x00, 0x40,
  0xFF, 0x20, 0x28, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02, 0xFF, 0x20,
  0x68, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xBF, 0xC0, 0x07,
  0xF1, 0x80, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0xFF, 0xFE, 0x08, 0x18, 0x80, 0x48, 0x02, 0x80, 0x28, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80,
  0x28, 0x04, 0x80, 0x8F, 0xF0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0xFF, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x7F, 0xC0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x7F, 0xA0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x00, 0x07,
  0xF0, 0x40, 0x44, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x07, 0xE0, 0x03, 0x00, 0x14, 0x00, 0xA0, 0x05, 0x00, 0x24,
  0x01, 0x10, 0x08, 0x7F, 0xC0, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0xFF, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0xF2, 0x22, 0x22, 0x22, 0x22, 0x22,
  0x22, 0x22, 0x2F, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0xF8, 0x80, 0x60, 0x28, 0x12, 0x08, 0x84, 0x21,
  0x08, 0x82, 0x40, 0xB0, 0x32, 0x08, 0x42, 0x10, 0x82, 0x20, 0x48, 0x12,
  0x02, 0x80, 0xA0, 0x10, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7F,
  0xC0, 0x80, 0x03, 0x80, 0x0F, 0x00, 0x1D, 0x00, 0x5A, 0x00, 0xB4, 0x01,
  0x64, 0x04, 0xC8, 0x09, 0x88, 0x13, 0x10, 0x46, 0x20, 0x8C, 0x21, 0x18,
  0x44, 0x30, 0x88, 0x60, 0xA0, 0xC1, 0x41, 0x81, 0x83, 0x02, 0x04, 0x80,
  0x38, 0x07, 0x00, 0xD0, 0x19, 0x03, 0x20, 0x62, 0x0C, 0x41, 0x84, 0x30,
  0x46, 0x08, 0xC0, 0x98, 0x13, 0x01, 0x60, 0x1C, 0x03, 0x80, 0x30, 0x04,
  0x0F, 0xE0, 0x40, 0x42, 0x00, 0x90, 0x02, 0x40, 0x05, 0x00, 0x14, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x40, 0x05, 0x00,
  0x14, 0x00, 0x88, 0x02, 0x10, 0x10, 0x3F, 0x80, 0xFE, 0x20, 0x48, 0x0A,
  0x02, 0x80, 0x60, 0x18, 0x06, 0x02, 0x80, 0xA1, 0xCF, 0x82, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x0F, 0xE0, 0x40, 0x42, 0x00,
  0x90, 0x02, 0x40, 0x05, 0x00, 0x14, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x40, 0x05, 0x00, 0x14, 0x00, 0x88, 0x02, 0x10,
  0x10, 0x3F, 0x80, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0xFC, 0x20,
  0x48, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x81, 0x3F, 0x88, 0x42,
  0x08, 0x82, 0x20, 0x48, 0x12, 0x02, 0x80, 0x60, 0x10, 0x1F, 0xD8, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xBF, 0xC0, 0xFF, 0xE0, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x24, 0x02, 0x60, 0x41, 0xF8,
  0x80, 0x18, 0x01, 0x40, 0x14, 0x02, 0x40, 0x22, 0x02, 0x20, 0x42, 0x04,
  0x10, 0x41, 0x08, 0x10, 0x80, 0x88, 0x09, 0x00, 0x90, 0x09, 0x00, 0x60,
  0x06, 0x00, 0x20, 0x80, 0x80, 0x60, 0x20, 0x18, 0x0C, 0x06, 0x05, 0x02,
  0x41, 0x40, 0x90, 0x48, 0x24, 0x12, 0x09, 0x04, 0x84, 0x22, 0x21, 0x08,
  0x84, 0x42, 0x21, 0x10, 0x88, 0x48, 0x14, 0x12, 0x05, 0x02, 0x81, 0x40,
  0xA0, 0x50, 0x30, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x28, 0x08, 0x81,
  0x10, 0x41, 0x08, 0x22, 0x02, 0x80, 0x50, 0x04, 0x00, 0xC0, 0x28, 0x04,
  0x81, 0x10, 0x41, 0x08, 0x22, 0x02, 0x40, 0x50, 0x04, 0x80, 0x30, 0x09,
  0x01, 0x20, 0x42, 0x08, 0x41, 0x04, 0x40, 0x88, 0x0A, 0x01, 0x40, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0xFF, 0xC0,
  0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x3F, 0xF0, 0xFC, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x7C, 0x80,
  0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04,
  0x04, 0x02, 0x02, 0x02, 0x01, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0xFC, 0x04, 0x01, 0x40, 0x28, 0x08,
  0x81, 0x10, 0x41, 0x08, 0x22, 0x02, 0x40, 0x50, 0x04, 0xFF, 0xC0, 0x84,
  0x21, 0x7E, 0x00, 0x80, 0x20, 0x10, 0x08, 0x3C, 0xE2, 0x81, 0x80, 0xC0,
  0x60, 0x70, 0x57, 0xC8, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x23, 0x0B,
  0x33, 0x02, 0x80, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0xB0, 0x4B, 0xE0, 0x1F, 0x90, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0xF8, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x43, 0x93, 0x15, 0x03, 0x40, 0x50, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x40, 0x50, 0x33, 0xF4, 0x1F, 0x08, 0x24, 0x09, 0x01,
  0x80, 0x7F, 0xF8, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x1F, 0x80,
  0x0F, 0x10, 0x20, 0x20, 0x20, 0x20, 0xFC, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x3F, 0x50, 0x34, 0x05, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x14, 0x05, 0x03, 0x3F, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x50, 0x23, 0xF0, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x62, 0xCD, 0x82, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x20, 0xC7, 0xFF, 0xC0, 0x11, 0x00, 0x01, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1E, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x81, 0x82, 0x84, 0x84, 0x88, 0x90, 0xB0, 0xD0, 0xC8, 0x84, 0x84,
  0x82, 0x82, 0x81, 0xFF, 0xFF, 0xE0, 0xBE, 0x7D, 0x83, 0x06, 0x04, 0x0C,
  0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0xC0, 0x81, 0x81, 0x03, 0x02,
  0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x20, 0xBF, 0x60, 0xA0, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x3F, 0x10,
  0x24, 0x05, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x14, 0x04,
  0x82, 0x1F, 0x00, 0xBF, 0x30, 0x28, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x0B, 0x02, 0xBF, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x00, 0x3F, 0x50, 0x34, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x14, 0x05, 0x03, 0x3F, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0xBF, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x80, 0x7F, 0x80, 0x80, 0x80, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x01, 0x01,
  0x01, 0xFE, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x07, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x70, 0x37, 0xE8, 0x80, 0xC0, 0x50, 0x28, 0x24, 0x11, 0x08,
  0x88, 0x44, 0x12, 0x0A, 0x05, 0x01, 0x80, 0x80, 0x81, 0x02, 0x83, 0x05,
  0x06, 0x0A, 0x14, 0x24, 0x24, 0x44, 0x48, 0x88, 0x91, 0x12, 0x14, 0x24,
  0x28, 0x28, 0x50, 0x60, 0xA0, 0xC0, 0x80, 0x81, 0x00, 0x81, 0xA0, 0x90,
  0x84, 0x81, 0x40, 0xC0, 0x20, 0x28, 0x24, 0x11, 0x10, 0x90, 0x28, 0x08,
  0x80, 0x50, 0x24, 0x09, 0x02, 0x21, 0x08, 0x42, 0x10, 0x48, 0x12, 0x04,
  0x80, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x0E, 0x00,
  0xFF, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x80,
  0xFF, 0x0C, 0x42, 0x08, 0x20, 0x82, 0x08, 0x20, 0x84, 0x30, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x10, 0x30, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x40,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x71, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x1C, 0x00, 0x78, 0x30, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Thin25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 1, 18, 5, 2, -18 },
  { 4, 4, 7, 8, 2, -18 },
  { 8, 13, 18, 14, 1, -18 },
  { 38, 10, 20, 13, 1, -19 },
  { 63, 15, 18, 18, 1, -18 },
  { 97, 13, 18, 15, 1, -18 },
  { 127, 1, 7, 4, 2, -18 },
  { 128, 5, 22, 6, 1, -18 },
  { 142, 4, 22, 6, 1, -18 },
  { 153, 9, 9, 12, 1, -19 },
  { 164, 11, 12, 13, 1, -15 },
  { 181, 2, 6, 5, 1, -3 },
  { 183, 6, 1, 8, 1, -7 },
  { 184, 1, 1, 5, 2, -1 },
  { 185, 8, 18, 8, 0, -18 },
  { 203, 10, 18, 13, 1, -18 },
  { 226, 5, 18, 13, 2, -18 },
  { 238, 10, 18, 13, 1, -18 },
  { 261, 10, 18, 13, 1, -18 },
  { 284, 11, 18, 13, 1, -18 },
  { 309, 9, 18, 13, 2, -18 },
  { 330, 9, 18, 13, 2, -18 },
  { 351, 10, 18, 13, 1, -18 },
  { 374, 10, 18, 13, 1, -18 },
  { 397, 10, 18, 13, 1, -18 },
  { 420, 1, 13, 5, 2, -13 },
  { 422, 2, 16, 5, 1, -13 },
  { 426, 11, 10, 13, 1, -14 },
  { 440, 11, 6, 13, 1, -12 },
  { 449, 11, 10, 13, 1, -14 },
  { 463, 7, 18, 9, 1, -18 },
  { 479, 17, 20, 19, 1, -18 },
  { 522, 13, 18, 13, 0, -18 },
  { 552, 10, 18, 14, 2, -18 },
  { 575, 12, 18, 14, 1, -18 },
  { 602, 12, 18, 15, 2, -18 },
  { 629, 9, 18, 12, 2, -18 },
  { 650, 9, 18, 11, 2, -18 },
  { 671, 13, 18, 16, 1, -18 },
  { 701, 11, 18, 16, 2, -18 },
  { 726, 4, 18, 7, 1, -18 },
  { 735, 5, 22, 5, -2, -18 },
  { 749, 10, 18, 12, 2, -18 },
  { 772, 9, 18, 11, 2, -18 },
  { 793, 15, 18, 19, 2, -18 },
  { 827, 11, 18, 16, 2, -18 },
  { 852, 14, 18, 17, 1, -18 },
  { 884, 10, 18, 13, 2, -18 },
  { 907, 14, 22, 17, 1, -18 },
  { 946, 10, 18, 13, 2, -18 },
  { 969, 10, 18, 12, 1, -18 },
  { 992, 11, 18, 11, 0, -18 },
  { 1017, 12, 18, 16, 2, -18 },
  { 1044, 12, 18, 12, 0, -18 },
  { 1071, 18, 18, 20, 1, -18 },
  { 1112, 11, 18, 11, 0, -18 },
  { 1137, 11, 18, 11, 0, -18 },
  { 1162, 10, 18, 12, 1, -18 },
  { 1185, 5, 22, 8, 2, -18 },
  { 1199, 8, 18, 8, 0, -18 },
  { 1217, 5, 22, 8, 1, -18 },
  { 1231, 11, 10, 13, 1, -18 },
  { 1245, 10, 1, 10, 0, 2 },
  { 1247, 4, 4, 6, 1, -19 },
  { 1249, 9, 13, 11, 1, -13 },
  { 1264, 10, 19, 13, 2, -19 },
  { 1288, 9, 13, 10, 1, -13 },
  { 1303, 10, 19, 13, 1, -19 },
  { 1327, 10, 13, 12, 1, -13 },
  { 1344, 8, 19, 6, 0, -19 },
  { 1363, 10, 19, 13, 1, -13 },
  { 1387, 9, 19, 13, 2, -19 },
  { 1409, 1, 18, 5, 2, -18 },
  { 1412, 4, 24, 5, -1, -18 },
  { 1424, 8, 19, 10, 2, -19 },
  { 1443, 1, 19, 5, 2, -19 },
  { 1446, 15, 13, 19, 2, -13 },
  { 1471, 9, 13, 13, 2, -13 },
  { 1486, 10, 13, 13, 1, -13 },
  { 1503, 10, 19, 13, 2, -13 },
  { 1527, 10, 19, 13, 1, -13 },
  { 1551, 6, 13, 8, 2, -13 },
  { 1561, 8, 13, 10, 1, -13 },
  { 1574, 6, 16, 7, 0, -16 },
  { 1586, 9, 13, 13, 2, -13 },
  { 1601, 9, 13, 10, 0, -13 },
  { 1616, 15, 13, 16, 0, -13 },
  { 1641, 9, 13, 10, 1, -13 },
  { 1656, 10, 19, 10, 0, -13 },
  { 1680, 8, 13, 10, 1, -13 },
  { 1693, 6, 22, 9, 1, -18 },
  { 1710, 1, 25, 12, 5, -19 },
  { 1714, 7, 22, 9, 1, -18 },
  { 1734, 11, 2, 13, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_Thin25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin25pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_SEMICONDENSED_THIN25PT7B_H_
