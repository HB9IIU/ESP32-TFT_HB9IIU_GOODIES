#ifndef _NOTOSANS_SEMICONDENSED_THIN40PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin40pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x55, 0x50, 0x03, 0xC0, 0x87, 0x0E, 0x1C,
  0x38, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x00, 0x80, 0x80, 0x04, 0x04,
  0x00, 0x20, 0x20, 0x01, 0x01, 0x00, 0x10, 0x10, 0x00, 0x80, 0x80, 0x04,
  0x04, 0x00, 0x20, 0x20, 0x01, 0x01, 0x03, 0xFF, 0xFF, 0xC0, 0x80, 0x80,
  0x04, 0x04, 0x00, 0x20, 0x20, 0x01, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40,
  0x40, 0x04, 0x04, 0x00, 0x20, 0x20, 0x01, 0x01, 0x01, 0xFF, 0xFF, 0xC0,
  0x40, 0x40, 0x02, 0x02, 0x00, 0x30, 0x20, 0x01, 0x01, 0x00, 0x08, 0x08,
  0x00, 0x40, 0x40, 0x02, 0x02, 0x00, 0x10, 0x10, 0x01, 0x81, 0x80, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x3F, 0xC1, 0x88, 0x66, 0x10, 0x08, 0x20, 0x20,
  0x40, 0x40, 0x80, 0x81, 0x01, 0x02, 0x02, 0x04, 0x02, 0x08, 0x06, 0x10,
  0x06, 0x20, 0x03, 0x40, 0x01, 0xC0, 0x01, 0xE0, 0x02, 0x30, 0x04, 0x30,
  0x08, 0x20, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x81, 0x01, 0x02, 0x02,
  0x0C, 0x04, 0x14, 0x08, 0xC7, 0xFF, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x1E, 0x00, 0x30, 0x21, 0x00, 0x20, 0x40, 0x80, 0x60, 0x40, 0x80, 0x40,
  0x40, 0xC0, 0x40, 0x80, 0x40, 0x80, 0x80, 0x40, 0x80, 0x80, 0x41, 0x00,
  0x80, 0x41, 0x00, 0x80, 0x42, 0x00, 0x80, 0x42, 0x00, 0x80, 0x44, 0x10,
  0x80, 0x44, 0x6C, 0x40, 0x88, 0x82, 0x40, 0x89, 0x82, 0x60, 0x91, 0x01,
  0x31, 0x11, 0x01, 0x1E, 0x31, 0x01, 0x00, 0x21, 0x01, 0x00, 0x61, 0x01,
  0x00, 0x41, 0x01, 0x00, 0x41, 0x01, 0x00, 0x81, 0x01, 0x00, 0x81, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x01, 0x82, 0x02, 0x00, 0x82,
  0x04, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x61, 0x80, 0x02, 0x02, 0x00, 0x20,
  0x10, 0x01, 0x00, 0x80, 0x08, 0x06, 0x00, 0x40, 0x30, 0x02, 0x01, 0x00,
  0x10, 0x08, 0x00, 0x40, 0xC0, 0x02, 0x04, 0x00, 0x08, 0xC0, 0x00, 0x2C,
  0x00, 0x01, 0x80, 0x00, 0x36, 0x00, 0x03, 0x10, 0x00, 0x20, 0x40, 0x13,
  0x01, 0x00, 0x90, 0x04, 0x09, 0x00, 0x10, 0x48, 0x00, 0xC2, 0x40, 0x02,
  0x22, 0x00, 0x09, 0x10, 0x00, 0x30, 0xC0, 0x01, 0x82, 0x00, 0x1E, 0x18,
  0x01, 0x98, 0x60, 0x10, 0x40, 0xFF, 0x01, 0x80, 0xFF, 0xE0, 0x02, 0x08,
  0x20, 0xC1, 0x06, 0x08, 0x10, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xC0, 0x81, 0x02, 0x02, 0x04,
  0x04, 0x08, 0x08, 0x10, 0x18, 0xC0, 0x60, 0x20, 0x10, 0x10, 0x08, 0x08,
  0x04, 0x04, 0x04, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x03, 0x03,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x08,
  0x10, 0x10, 0x20, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x08,
  0x10, 0x4E, 0x23, 0xC3, 0xF8, 0x00, 0x80, 0x02, 0x80, 0x08, 0x80, 0x21,
  0x00, 0x41, 0x03, 0x01, 0x02, 0x02, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF,
  0xFF, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x2D, 0x24, 0xA4, 0x80, 0xFF,
  0xC0, 0xF0, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x80, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x00, 0x03, 0xE0, 0x0C, 0x10, 0x10, 0x08,
  0x30, 0x04, 0x20, 0x04, 0x60, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x03,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x20, 0x06, 0x20, 0x04, 0x10, 0x08,
  0x08, 0x18, 0x07, 0xE0, 0x01, 0x07, 0x0D, 0x11, 0x61, 0xC1, 0x81, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x07, 0xC0, 0x38,
  0x30, 0x60, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0x0F, 0xC0, 0x30, 0x30, 0xC0,
  0x08, 0x80, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0xE0, 0x0F,
  0xE0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x0C, 0xC0, 0x18, 0x7F, 0xE0, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0A, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x11, 0x00, 0x06, 0x20,
  0x00, 0x84, 0x00, 0x20, 0x80, 0x0C, 0x10, 0x01, 0x02, 0x00, 0x40, 0x40,
  0x18, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x04, 0x00, 0x81,
  0x00, 0x10, 0x20, 0x02, 0x08, 0x00, 0x41, 0xFF, 0xFF, 0xC0, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x7F, 0xF8, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x0B, 0xFC, 0x08, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x64, 0x01, 0x87, 0xFC, 0x00, 0x00, 0xFC, 0x03,
  0x02, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x80, 0x47, 0xF8, 0x58,
  0x0C, 0xB0, 0x06, 0xA0, 0x02, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40,
  0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x20, 0x02, 0x20,
  0x02, 0x10, 0x04, 0x08, 0x0C, 0x07, 0xF0, 0xFF, 0xFF, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x07, 0xE0, 0x18, 0x18, 0x30, 0x04, 0x20,
  0x06, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x20,
  0x04, 0x30, 0x0C, 0x18, 0x18, 0x06, 0x30, 0x03, 0xC0, 0x07, 0xE0, 0x0C,
  0x30, 0x30, 0x0C, 0x20, 0x06, 0x40, 0x02, 0xC0, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x03, 0x40, 0x02, 0x20, 0x06, 0x30,
  0x0C, 0x0F, 0xF0, 0x07, 0xC0, 0x18, 0x30, 0x20, 0x08, 0x60, 0x0C, 0x40,
  0x04, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x40, 0x03, 0x40, 0x05, 0x20, 0x09, 0x18,
  0x33, 0x0F, 0xC2, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x60, 0x7F,
  0x80, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x6C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x05, 0xA4, 0x94, 0x90, 0x00, 0x01, 0x00, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x00, 0x3F, 0x0E, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x30, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x02, 0x00, 0x01, 0x80, 0x80, 0x00, 0x10, 0x20, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x31, 0x00, 0x00, 0x02, 0x60, 0x1F, 0xE0, 0x48,
  0x06, 0x04, 0x0D, 0x01, 0x00, 0x80, 0xA0, 0x20, 0x10, 0x1C, 0x08, 0x02,
  0x03, 0x01, 0x00, 0x40, 0x60, 0x20, 0x08, 0x0C, 0x0C, 0x01, 0x01, 0x81,
  0x00, 0x60, 0x30, 0x30, 0x0C, 0x06, 0x02, 0x01, 0x81, 0xC0, 0x40, 0x30,
  0x2C, 0x08, 0x0A, 0x04, 0x80, 0x81, 0x41, 0x10, 0x1D, 0xC6, 0xC2, 0x00,
  0x40, 0x30, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x70,
  0x38, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x05, 0x00, 0x00, 0x90, 0x00, 0x09, 0x80, 0x00, 0x88, 0x00, 0x10,
  0x80, 0x01, 0x08, 0x00, 0x10, 0x40, 0x02, 0x04, 0x00, 0x20, 0x40, 0x02,
  0x02, 0x00, 0x40, 0x20, 0x04, 0x02, 0x00, 0x40, 0x10, 0x08, 0x01, 0x00,
  0xFF, 0xF0, 0x08, 0x00, 0x81, 0x00, 0x08, 0x10, 0x00, 0x81, 0x00, 0x04,
  0x20, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00,
  0x2C, 0x00, 0x01, 0x80, 0x00, 0x10, 0xFE, 0x00, 0x81, 0xF0, 0x80, 0x0C,
  0x80, 0x04, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x18, 0xFF, 0xE0, 0x81, 0xF0,
  0x80, 0x0C, 0x80, 0x06, 0x80, 0x02, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x02, 0x80, 0x06, 0x80, 0x0C,
  0x80, 0x38, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x30, 0x1C, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x20, 0x1F,
  0xFC, 0xFC, 0x00, 0x20, 0xFC, 0x08, 0x01, 0x82, 0x00, 0x18, 0x80, 0x02,
  0x20, 0x00, 0x48, 0x00, 0x1A, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xA0, 0x00, 0x28, 0x00, 0x1A, 0x00, 0x04, 0x80, 0x03, 0x20, 0x01, 0x88,
  0x00, 0xC2, 0x01, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x7F, 0xFE, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x1F, 0xFF, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0E, 0x03,
  0x80, 0x80, 0x02, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x01,
  0xFF, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80, 0x00, 0x14,
  0x00, 0x00, 0xA0, 0x00, 0x04, 0x80, 0x00, 0x24, 0x00, 0x01, 0x10, 0x00,
  0x08, 0x40, 0x00, 0x41, 0x00, 0x02, 0x06, 0x00, 0x30, 0x0F, 0xFE, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0xFC,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x02, 0x86, 0xF8,
  0x80, 0x02, 0x80, 0x06, 0x80, 0x0C, 0x80, 0x18, 0x80, 0x10, 0x80, 0x20,
  0x80, 0x40, 0x80, 0x80, 0x81, 0x80, 0x83, 0x00, 0x86, 0x00, 0x8C, 0x00,
  0x88, 0x00, 0x9C, 0x00, 0xA4, 0x00, 0xE2, 0x00, 0xC3, 0x00, 0x81, 0x00,
  0x80, 0x80, 0x80, 0xC0, 0x80, 0x40, 0x80, 0x20, 0x80, 0x30, 0x80, 0x10,
  0x80, 0x08, 0x80, 0x08, 0x80, 0x04, 0x80, 0x06, 0x80, 0x03, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xFF, 0x80, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x5A, 0x00, 0x00,
  0xB4, 0x00, 0x01, 0x6C, 0x00, 0x04, 0xC8, 0x00, 0x09, 0x90, 0x00, 0x33,
  0x10, 0x00, 0x46, 0x20, 0x00, 0x8C, 0x40, 0x02, 0x18, 0x40, 0x04, 0x30,
  0x80, 0x08, 0x61, 0x80, 0x20, 0xC1, 0x00, 0x41, 0x82, 0x01, 0x83, 0x02,
  0x02, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x10, 0x18, 0x08, 0x20, 0x30, 0x10,
  0x40, 0x60, 0x31, 0x00, 0xC0, 0x22, 0x01, 0x80, 0x4C, 0x03, 0x00, 0x50,
  0x06, 0x00, 0xA0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x00, 0x20, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1A, 0x00, 0x0D, 0x80, 0x06, 0x40,
  0x03, 0x10, 0x01, 0x88, 0x00, 0xC2, 0x00, 0x61, 0x80, 0x30, 0x40, 0x18,
  0x10, 0x0C, 0x08, 0x06, 0x02, 0x03, 0x01, 0x81, 0x80, 0x40, 0xC0, 0x10,
  0x60, 0x08, 0x30, 0x02, 0x18, 0x01, 0x8C, 0x00, 0x46, 0x00, 0x13, 0x00,
  0x09, 0x80, 0x02, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x08,
  0x00, 0xFE, 0x00, 0x0C, 0x06, 0x00, 0x40, 0x04, 0x02, 0x00, 0x08, 0x10,
  0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x00, 0x98, 0x00, 0x02, 0x40, 0x00,
  0x09, 0x00, 0x00, 0x14, 0x00, 0x00, 0x50, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x05, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x50, 0x00, 0x01, 0x40, 0x00, 0x0D, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x88, 0x00, 0x06, 0x10, 0x00, 0x10, 0x60, 0x00, 0x80,
  0xC0, 0x06, 0x01, 0x80, 0x20, 0x01, 0xFF, 0x00, 0xFC, 0x02, 0x0F, 0x88,
  0x01, 0x20, 0x02, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x28, 0x01, 0x20, 0x38,
  0xFF, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x0C, 0x06, 0x00, 0x40, 0x04, 0x02, 0x00, 0x08, 0x10, 0x00,
  0x10, 0x80, 0x00, 0x42, 0x00, 0x00, 0x98, 0x00, 0x02, 0x40, 0x00, 0x0D,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x50, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x05, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x50, 0x00, 0x01, 0x40, 0x00, 0x0D, 0x00, 0x00, 0x22,
  0x00, 0x00, 0x88, 0x00, 0x06, 0x10, 0x00, 0x10, 0x60, 0x00, 0x80, 0xC0,
  0x06, 0x01, 0x80, 0x20, 0x01, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0xFC, 0x00, 0x83, 0xE0, 0x80, 0x18, 0x80, 0x08, 0x80, 0x04,
  0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x04, 0x80, 0x08, 0x80, 0x18, 0x80, 0x20, 0xFF, 0xC0, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x40, 0x80, 0x40, 0x80, 0x20, 0x80, 0x30, 0x80, 0x10,
  0x80, 0x18, 0x80, 0x08, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x02, 0x80, 0x03,
  0x07, 0xF0, 0x38, 0x1C, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x34, 0x00, 0xC7, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x14, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x12, 0x00, 0x02, 0x60, 0x00,
  0x44, 0x00, 0x10, 0xC0, 0x06, 0x0C, 0x01, 0x80, 0x7F, 0xC0, 0x80, 0x00,
  0x18, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x42, 0x00,
  0x04, 0x20, 0x00, 0x42, 0x00, 0x08, 0x10, 0x00, 0x81, 0x00, 0x08, 0x10,
  0x01, 0x00, 0x80, 0x10, 0x08, 0x01, 0x00, 0x80, 0x20, 0x04, 0x02, 0x00,
  0x40, 0x20, 0x04, 0x04, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x20, 0x80,
  0x03, 0x08, 0x00, 0x10, 0x80, 0x01, 0x10, 0x00, 0x19, 0x00, 0x00, 0x90,
  0x00, 0x0B, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x80,
  0x02, 0x00, 0x06, 0x00, 0x08, 0x00, 0x2C, 0x00, 0x30, 0x00, 0x90, 0x01,
  0x40, 0x02, 0x40, 0x05, 0x00, 0x19, 0x00, 0x14, 0x00, 0x46, 0x00, 0x48,
  0x01, 0x08, 0x03, 0x20, 0x04, 0x20, 0x08, 0x80, 0x30, 0x80, 0x22, 0x00,
  0x83, 0x00, 0x84, 0x02, 0x04, 0x06, 0x10, 0x08, 0x10, 0x10, 0x40, 0x60,
  0x40, 0x41, 0x01, 0x01, 0x81, 0x02, 0x04, 0x02, 0x0C, 0x08, 0x10, 0x08,
  0x20, 0x20, 0xC0, 0x20, 0x80, 0x82, 0x00, 0xC2, 0x01, 0x08, 0x01, 0x18,
  0x04, 0x20, 0x04, 0x40, 0x11, 0x80, 0x11, 0x00, 0x44, 0x00, 0x64, 0x00,
  0x90, 0x00, 0xB0, 0x02, 0x40, 0x02, 0x80, 0x0B, 0x00, 0x0A, 0x00, 0x28,
  0x00, 0x28, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x40, 0x00, 0x88, 0x00, 0x62, 0x00, 0x10, 0x40, 0x0C, 0x10, 0x02, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x10, 0x20, 0x06, 0x08, 0x00, 0x84, 0x00, 0x31,
  0x00, 0x04, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x20, 0x00, 0x4C, 0x00, 0x21, 0x00, 0x18, 0x60, 0x04, 0x08, 0x02,
  0x03, 0x00, 0x80, 0x40, 0x40, 0x08, 0x10, 0x02, 0x08, 0x00, 0x46, 0x00,
  0x11, 0x00, 0x02, 0xC0, 0x00, 0xC0, 0x80, 0x00, 0xE0, 0x00, 0x50, 0x00,
  0x4C, 0x00, 0x22, 0x00, 0x31, 0x80, 0x10, 0x40, 0x18, 0x20, 0x08, 0x08,
  0x04, 0x04, 0x04, 0x01, 0x02, 0x00, 0x82, 0x00, 0x21, 0x00, 0x11, 0x00,
  0x04, 0x80, 0x02, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x10, 0x03,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x60,
  0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10,
  0x02, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF,
  0x00, 0x40, 0x00, 0x38, 0x00, 0x0A, 0x00, 0x04, 0x80, 0x01, 0x10, 0x00,
  0x84, 0x00, 0x20, 0x80, 0x10, 0x20, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x20, 0x40, 0x08, 0x10, 0x01, 0x08, 0x00, 0x46, 0x00, 0x09, 0x00, 0x02,
  0xC0, 0x00, 0x40, 0xFF, 0xFF, 0x83, 0x04, 0x08, 0x10, 0x20, 0x40, 0x1F,
  0xE1, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x1F, 0xC7, 0x02, 0x40, 0x14, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xF0, 0x0A, 0x80, 0xD3, 0xF8, 0x80, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x80, 0x8F, 0xF0, 0x98, 0x08, 0xA0, 0x04, 0xA0, 0x06,
  0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x02, 0xC0, 0x02,
  0xC0, 0x02, 0xA0, 0x04, 0xA0, 0x0C, 0x90, 0x18, 0x8F, 0xF0, 0x00, 0x40,
  0x3F, 0xC2, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x83, 0xFC, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x81, 0x0F, 0xF1, 0x18, 0x09, 0x30, 0x05, 0x20, 0x05,
  0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x40, 0x03,
  0x40, 0x03, 0x60, 0x05, 0x20, 0x05, 0x10, 0x09, 0x0F, 0xF1, 0x00, 0x80,
  0x1F, 0xE0, 0x60, 0x61, 0x80, 0x62, 0x00, 0x48, 0x00, 0x90, 0x00, 0xA0,
  0x01, 0xC0, 0x03, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x40, 0xFF, 0x00, 0x00, 0xC0, 0x3B, 0x04, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0xFF, 0x80, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x00, 0x80, 0x0F, 0xF1, 0x18, 0x09, 0x20, 0x05, 0x20,
  0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x03, 0x40,
  0x03, 0x40, 0x03, 0x60, 0x05, 0x20, 0x0D, 0x18, 0x19, 0x0F, 0xF1, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x04, 0x40, 0x0C, 0x3C, 0xF0, 0x03, 0xC0, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x82, 0x3F,
  0xC9, 0x01, 0xA8, 0x03, 0xA0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10,
  0xF8, 0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x80, 0x0C, 0x30, 0x80, 0x00,
  0x00, 0x00, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0A,
  0xC4, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0xA0, 0x09, 0x00, 0xC8, 0x0C, 0x40,
  0x42, 0x04, 0x10, 0x40, 0x86, 0x04, 0x60, 0x23, 0x01, 0x24, 0x0A, 0x20,
  0x60, 0x83, 0x06, 0x10, 0x10, 0x80, 0x44, 0x03, 0x20, 0x09, 0x00, 0x28,
  0x01, 0x40, 0x04, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x20, 0x8F, 0xE1,
  0xFC, 0x90, 0x32, 0x02, 0xA0, 0x14, 0x03, 0xC0, 0x14, 0x01, 0xC0, 0x08,
  0x01, 0xC0, 0x08, 0x01, 0x80, 0x08, 0x01, 0x80, 0x08, 0x01, 0x80, 0x08,
  0x01, 0x80, 0x08, 0x01, 0x80, 0x08, 0x01, 0x80, 0x08, 0x01, 0x80, 0x08,
  0x01, 0x80, 0x08, 0x01, 0x80, 0x08, 0x01, 0x80, 0x08, 0x01, 0x80, 0x08,
  0x01, 0x80, 0x08, 0x01, 0x80, 0x08, 0x01, 0x80, 0x08, 0x01, 0x80, 0x08,
  0x01, 0x00, 0x82, 0x3F, 0xC9, 0x81, 0xA8, 0x03, 0xA0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x0F, 0xF0, 0x18, 0x0C, 0x30, 0x04,
  0x20, 0x02, 0x40, 0x02, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x01,
  0x40, 0x01, 0x40, 0x02, 0x20, 0x02, 0x30, 0x04, 0x18, 0x08, 0x0F, 0xF0,
  0x00, 0x80, 0x8F, 0xF0, 0x98, 0x08, 0xB0, 0x04, 0xA0, 0x06, 0xC0, 0x02,
  0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02,
  0xA0, 0x04, 0xB0, 0x0C, 0x98, 0x18, 0x8F, 0xF0, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x0F, 0xF1, 0x18, 0x09, 0x20, 0x05, 0x60, 0x05,
  0x40, 0x03, 0x40, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x40, 0x03,
  0x40, 0x03, 0x60, 0x05, 0x20, 0x0D, 0x10, 0x19, 0x0F, 0xE1, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x8F, 0xE4, 0x0A, 0x02, 0x80, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x02, 0x03, 0xDF, 0x60, 0x1C,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x03, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x80, 0x2F, 0xFC, 0x20, 0x10, 0x08, 0x04, 0x02, 0x07, 0xFC, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x07, 0xC0, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0D, 0x00, 0x34, 0x01, 0x48, 0x09, 0x1F, 0xC4, 0x80,
  0x02, 0x80, 0x0D, 0x00, 0x12, 0x00, 0x22, 0x00, 0xC4, 0x01, 0x08, 0x02,
  0x08, 0x04, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x41, 0x00, 0x82, 0x00,
  0x84, 0x01, 0x10, 0x02, 0x20, 0x02, 0x40, 0x05, 0x00, 0x0A, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x80, 0x10, 0x03, 0x00, 0x30, 0x06, 0x00, 0xA0, 0x0A,
  0x01, 0x40, 0x24, 0x02, 0x80, 0x48, 0x04, 0x80, 0x90, 0x11, 0x01, 0x10,
  0x22, 0x04, 0x20, 0x42, 0x08, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x84,
  0x10, 0x81, 0x08, 0x11, 0x02, 0x20, 0x22, 0x04, 0x40, 0x44, 0x04, 0x80,
  0x50, 0x0A, 0x00, 0xA0, 0x14, 0x01, 0x40, 0x28, 0x02, 0x80, 0x30, 0x02,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x04, 0xC0, 0x10, 0x80, 0x21, 0x80, 0x81,
  0x03, 0x01, 0x04, 0x03, 0x10, 0x02, 0x60, 0x02, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x14, 0x00, 0x48, 0x00, 0x88, 0x02, 0x18, 0x0C, 0x10, 0x10, 0x10,
  0x40, 0x31, 0x80, 0x22, 0x00, 0x28, 0x00, 0x60, 0xC0, 0x02, 0x80, 0x05,
  0x00, 0x19, 0x00, 0x22, 0x00, 0x44, 0x01, 0x84, 0x02, 0x08, 0x04, 0x10,
  0x18, 0x10, 0x20, 0x20, 0x40, 0x41, 0x80, 0x42, 0x00, 0x84, 0x01, 0x18,
  0x01, 0x20, 0x02, 0x40, 0x05, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x80, 0x13, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x20, 0x3C, 0x08, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x40, 0x08, 0x1E, 0x01, 0xC0, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3C, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x70, 0x38,
  0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x08, 0x06, 0x0F, 0x00, 0x3C, 0x00, 0xC3, 0x81,
  0x80, 0xF7, 0x00, 0x08,
};

const GFXglyph NotoSans_SemiCondensed_Thin40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 29, 8, 3, -29 },
  { 9, 7, 11, 12, 3, -29 },
  { 19, 21, 29, 23, 1, -29 },
  { 96, 15, 32, 20, 2, -30 },
  { 156, 24, 29, 28, 2, -29 },
  { 243, 21, 29, 23, 2, -29 },
  { 320, 1, 11, 7, 3, -29 },
  { 322, 7, 35, 10, 2, -29 },
  { 353, 8, 35, 10, 1, -29 },
  { 388, 15, 14, 19, 2, -30 },
  { 415, 16, 18, 20, 2, -23 },
  { 451, 3, 9, 7, 2, -4 },
  { 455, 10, 1, 12, 1, -11 },
  { 457, 2, 2, 8, 3, -2 },
  { 458, 11, 29, 13, 1, -29 },
  { 498, 16, 29, 20, 2, -29 },
  { 556, 8, 29, 20, 4, -29 },
  { 585, 16, 29, 20, 2, -29 },
  { 643, 16, 29, 20, 2, -29 },
  { 701, 19, 29, 20, 1, -29 },
  { 770, 15, 29, 20, 3, -29 },
  { 825, 16, 29, 20, 2, -29 },
  { 883, 16, 29, 20, 2, -29 },
  { 941, 16, 29, 20, 2, -29 },
  { 999, 16, 29, 20, 2, -29 },
  { 1057, 2, 21, 8, 3, -21 },
  { 1063, 3, 26, 8, 2, -21 },
  { 1073, 16, 17, 20, 2, -23 },
  { 1107, 16, 10, 20, 2, -19 },
  { 1127, 16, 17, 20, 2, -23 },
  { 1161, 12, 29, 14, 1, -29 },
  { 1205, 27, 32, 31, 2, -28 },
  { 1313, 20, 29, 20, 0, -29 },
  { 1386, 16, 29, 22, 4, -29 },
  { 1444, 19, 29, 22, 2, -29 },
  { 1513, 18, 29, 24, 4, -29 },
  { 1579, 13, 29, 20, 4, -29 },
  { 1627, 13, 29, 18, 4, -29 },
  { 1675, 21, 29, 26, 2, -29 },
  { 1752, 17, 29, 25, 4, -29 },
  { 1814, 6, 29, 10, 2, -29 },
  { 1836, 8, 36, 9, -3, -29 },
  { 1872, 16, 29, 20, 4, -29 },
  { 1930, 13, 29, 18, 4, -29 },
  { 1978, 23, 29, 31, 4, -29 },
  { 2062, 17, 29, 25, 4, -29 },
  { 2124, 22, 29, 27, 2, -29 },
  { 2204, 14, 29, 20, 4, -29 },
  { 2255, 22, 36, 27, 2, -29 },
  { 2354, 16, 29, 21, 4, -29 },
  { 2412, 15, 29, 19, 2, -29 },
  { 2467, 18, 29, 18, 0, -29 },
  { 2533, 19, 29, 25, 3, -29 },
  { 2602, 20, 29, 20, 0, -29 },
  { 2675, 30, 29, 32, 1, -29 },
  { 2784, 18, 29, 18, 0, -29 },
  { 2850, 17, 29, 17, 0, -29 },
  { 2912, 17, 29, 19, 1, -29 },
  { 2974, 8, 35, 12, 3, -29 },
  { 3009, 11, 29, 13, 1, -29 },
  { 3049, 8, 35, 12, 1, -29 },
  { 3084, 18, 17, 20, 1, -29 },
  { 3123, 16, 1, 16, 0, 4 },
  { 3125, 6, 7, 10, 2, -31 },
  { 3131, 13, 21, 18, 2, -21 },
  { 3166, 16, 30, 21, 3, -30 },
  { 3226, 13, 22, 17, 2, -22 },
  { 3262, 16, 30, 21, 2, -30 },
  { 3322, 15, 22, 19, 2, -22 },
  { 3364, 12, 31, 10, 0, -31 },
  { 3411, 16, 32, 21, 2, -22 },
  { 3475, 14, 30, 21, 3, -30 },
  { 3528, 2, 29, 8, 3, -29 },
  { 3536, 6, 39, 8, -1, -29 },
  { 3566, 13, 30, 16, 3, -30 },
  { 3615, 1, 30, 8, 3, -30 },
  { 3619, 24, 22, 31, 3, -22 },
  { 3685, 14, 22, 21, 3, -22 },
  { 3724, 16, 22, 20, 2, -22 },
  { 3768, 16, 31, 21, 3, -22 },
  { 3830, 16, 31, 21, 2, -22 },
  { 3892, 10, 21, 13, 3, -21 },
  { 3919, 12, 22, 16, 2, -22 },
  { 3952, 9, 26, 11, 1, -26 },
  { 3982, 14, 21, 21, 3, -21 },
  { 4019, 15, 21, 15, 0, -21 },
  { 4059, 23, 21, 25, 1, -21 },
  { 4120, 15, 21, 17, 1, -21 },
  { 4160, 15, 31, 15, 0, -21 },
  { 4219, 13, 21, 15, 1, -21 },
  { 4254, 11, 35, 14, 1, -29 },
  { 4303, 1, 40, 19, 9, -30 },
  { 4308, 10, 35, 14, 2, -29 },
  { 4352, 16, 4, 20, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_Thin40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin40pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_SEMICONDENSED_THIN40PT7B_H_
