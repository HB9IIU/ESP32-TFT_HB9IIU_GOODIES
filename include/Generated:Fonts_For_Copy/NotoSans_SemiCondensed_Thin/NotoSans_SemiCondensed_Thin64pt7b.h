#ifndef _NOTOSANS_SEMICONDENSED_THIN64PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin64pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xDB, 0x6D, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0xC0, 0x68, 0x05, 0x00, 0xA0,
  0x14, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x14,
  0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x20, 0x00, 0x04, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x10, 0x00, 0x01, 0x80, 0x08, 0x00,
  0x00, 0x80, 0x04, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x20, 0x03, 0x00,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x20, 0x00, 0x02, 0x00, 0x30, 0x00, 0x01, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x20, 0x01, 0x00, 0x00, 0x10, 0x01, 0x80, 0x00, 0x08, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x08, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x40,
  0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x04, 0x00, 0x20, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x20, 0x01, 0x00, 0x00,
  0x10, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x10, 0x00, 0x01, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x0C, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x38, 0x60, 0x78, 0x30, 0x30, 0x08, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00,
  0x18, 0x06, 0x00, 0x08, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x0C,
  0x00, 0x18, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0,
  0xC0, 0x00, 0x38, 0x60, 0x00, 0x07, 0x30, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x78, 0x00, 0x01, 0x8F, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x03,
  0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x20, 0x01, 0x80,
  0x10, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x04, 0x00, 0x30, 0x02, 0x00, 0x18,
  0x03, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x01, 0x80, 0x03, 0x01, 0xC8, 0x01,
  0x81, 0xC3, 0x80, 0xC3, 0xC1, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x02, 0x00, 0x1C, 0x70, 0x00, 0x0C,
  0x00, 0x60, 0x30, 0x00, 0x10, 0x01, 0x80, 0x60, 0x00, 0x60, 0x03, 0x00,
  0x60, 0x00, 0x80, 0x04, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x80, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x60, 0x03, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0xC0, 0x01, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x18, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x30, 0x00, 0x30,
  0x00, 0xC0, 0x60, 0x00, 0x60, 0x01, 0x80, 0x80, 0x00, 0xC0, 0x03, 0x03,
  0x00, 0x00, 0x80, 0x06, 0x04, 0x00, 0x01, 0x00, 0x0C, 0x18, 0x1F, 0x03,
  0x00, 0x18, 0x20, 0xF7, 0x86, 0x00, 0x30, 0xC3, 0x03, 0x0C, 0x00, 0x41,
  0x04, 0x03, 0x08, 0x01, 0x86, 0x18, 0x03, 0x18, 0x03, 0x0C, 0x20, 0x06,
  0x30, 0x0C, 0x30, 0xC0, 0x04, 0x30, 0x38, 0x61, 0x80, 0x08, 0x38, 0xE1,
  0x83, 0x00, 0x18, 0x3F, 0x03, 0x04, 0x00, 0x30, 0x00, 0x0C, 0x08, 0x00,
  0x60, 0x00, 0x18, 0x10, 0x00, 0xC0, 0x00, 0x60, 0x20, 0x01, 0x80, 0x00,
  0xC0, 0xC0, 0x03, 0x00, 0x01, 0x01, 0x80, 0x06, 0x00, 0x06, 0x01, 0x00,
  0x0C, 0x00, 0x08, 0x02, 0x00, 0x18, 0x00, 0x30, 0x04, 0x00, 0x30, 0x00,
  0x40, 0x08, 0x00, 0x60, 0x01, 0x80, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x20, 0x03, 0x00, 0x01,
  0x80, 0xC0, 0x06, 0x00, 0x01, 0x83, 0x00, 0x18, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x20, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x40, 0x00, 0x18, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x60, 0x00, 0x80, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x10, 0xE0, 0x00, 0x00,
  0x0C, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xB0, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC6, 0x00, 0x18, 0x00,
  0x63, 0x00, 0x06, 0x00, 0x23, 0x00, 0x01, 0x80, 0x31, 0x80, 0x00, 0xC0,
  0x18, 0x80, 0x00, 0x30, 0x08, 0xC0, 0x00, 0x0C, 0x0C, 0x60, 0x00, 0x03,
  0x06, 0x30, 0x00, 0x00, 0xC6, 0x18, 0x00, 0x00, 0x33, 0x0C, 0x00, 0x00,
  0x1B, 0x02, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x01, 0xE0, 0x60, 0x00, 0x01, 0x98, 0x18, 0x00, 0x01, 0x8C, 0x06, 0x00,
  0x03, 0x83, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x78, 0x07, 0x00, 0x30, 0x0F,
  0xFE, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0xD5, 0x55, 0x55, 0x55, 0x40,
  0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18,
  0x01, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x30, 0x03, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x10, 0x0F, 0xC0, 0x40, 0xF1, 0xE1, 0x1E, 0x00,
  0xF7, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x80, 0x00, 0x31,
  0x00, 0x01, 0x86, 0x00, 0x0C, 0x0C, 0x00, 0x20, 0x10, 0x01, 0x80, 0x60,
  0x0C, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x80, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x30, 0xC6, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x08, 0x61, 0x8C, 0x00, 0xFF,
  0xFE, 0x7F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xE0, 0xF0, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x06, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x20, 0x00, 0x06, 0x30, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x88, 0x00, 0x00, 0x64, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x01, 0x60, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x05, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03,
  0x60, 0x00, 0x01, 0x90, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x46, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x18, 0x18, 0x00,
  0x0C, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x3C,
  0x1C, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x01, 0xC0,
  0x3E, 0x03, 0xB0, 0x31, 0x87, 0x0C, 0x70, 0x67, 0x03, 0x60, 0x1E, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x01,
  0xFF, 0x80, 0x03, 0xE1, 0xF0, 0x07, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0x80, 0x07, 0xE0, 0xF0, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x20, 0x00,
  0x03, 0x18, 0x00, 0x07, 0x0F, 0xC0, 0x0F, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x06,
  0x40, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x0C, 0x01, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x60, 0x04, 0x00,
  0x01, 0x80, 0x08, 0x00, 0x03, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x60, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x30, 0x00, 0x08, 0x00, 0x60,
  0x00, 0x10, 0x01, 0x80, 0x00, 0x20, 0x06, 0x00, 0x00, 0x40, 0x0C, 0x00,
  0x00, 0x80, 0x30, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0xFF, 0xF0, 0x07, 0xFC, 0x7E, 0x01, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x20, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x0F, 0x80, 0x3C, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x0E, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x1F, 0xE0, 0x18, 0x3F, 0xFC, 0x0C, 0x70, 0x03, 0x86, 0x60, 0x00,
  0x63, 0x60, 0x00, 0x19, 0xE0, 0x00, 0x0C, 0xF0, 0x00, 0x03, 0x70, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x58, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x08, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x18, 0x00, 0x06,
  0x0C, 0x00, 0x03, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x38, 0x07,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x70, 0x01, 0x80, 0x30,
  0x00, 0x30, 0x18, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x30, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x07, 0x00, 0x07, 0x03, 0x80, 0x00, 0x7B, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0x87, 0x80, 0x03, 0x80, 0x70, 0x01, 0x80,
  0x06, 0x00, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x18, 0x30, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x02, 0x40, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x26, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x30,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x38, 0x00, 0x70,
  0x07, 0x80, 0x78, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xE1, 0xF0, 0x03, 0x80, 0x1C, 0x01, 0x80, 0x03, 0x01, 0x80,
  0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60,
  0x00, 0x03, 0x20, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x14, 0xC0, 0x00, 0x1A, 0x60, 0x00,
  0x19, 0x18, 0x00, 0x19, 0x87, 0x00, 0x18, 0xC1, 0xE0, 0x78, 0x60, 0x3F,
  0xF0, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x02, 0x00, 0x78, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x0C, 0x71, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x0C,
  0x71, 0x86, 0x18, 0x63, 0x0C, 0x30, 0xC6, 0x18, 0x63, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x1F, 0x83, 0xC3, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x41, 0x80, 0x00, 0x3C, 0x00, 0x0C, 0x30,
  0x00, 0x3F, 0xFC, 0x01, 0x8C, 0x00, 0x1E, 0x03, 0x00, 0x11, 0x80, 0x07,
  0x00, 0x20, 0x03, 0x20, 0x01, 0x80, 0x04, 0x00, 0x6C, 0x00, 0x60, 0x00,
  0x80, 0x0D, 0x80, 0x0C, 0x00, 0x10, 0x01, 0xB0, 0x03, 0x00, 0x02, 0x00,
  0x16, 0x00, 0x60, 0x00, 0xC0, 0x02, 0x80, 0x08, 0x00, 0x18, 0x00, 0x50,
  0x03, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x60, 0x01, 0xC0, 0x0C,
  0x00, 0x0C, 0x00, 0x38, 0x01, 0x80, 0x01, 0x80, 0x07, 0x00, 0x30, 0x00,
  0x30, 0x00, 0xE0, 0x06, 0x00, 0x06, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0xC0,
  0x07, 0x80, 0x18, 0x00, 0x18, 0x00, 0xD0, 0x03, 0x00, 0x07, 0x00, 0x1A,
  0x00, 0x20, 0x00, 0xA0, 0x06, 0x60, 0x06, 0x00, 0x14, 0x00, 0xCC, 0x00,
  0xC0, 0x06, 0x80, 0x11, 0x80, 0x0C, 0x01, 0x98, 0x06, 0x30, 0x00, 0xC0,
  0x61, 0x81, 0x82, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x60, 0x00, 0xFC, 0x01,
  0xF0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x08, 0x00, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x02, 0x60, 0x00,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x04, 0x30, 0x00,
  0x00, 0x0C, 0x10, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x08, 0x18, 0x00,
  0x00, 0x18, 0x08, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x10, 0x0C, 0x00,
  0x00, 0x30, 0x04, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x20, 0x06, 0x00,
  0x00, 0x60, 0x02, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x40, 0x03, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x00, 0x00, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x0C, 0x00,
  0x0F, 0x83, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x30, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x13, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0xC0, 0x00, 0xF0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0x00, 0x01, 0xE0, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x04, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3,
  0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x20, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x30, 0x00, 0x7C, 0x01,
  0x80, 0x00, 0x78, 0x0C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x70, 0x30, 0x00, 0x0F,
  0x01, 0x80, 0x01, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xB0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x20, 0x1C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0xC8, 0x00,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x60,
  0x1E, 0x00, 0x00, 0x70, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x3F, 0xF0, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x03,
  0x9F, 0xF8, 0xFF, 0x00, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0E, 0x0C,
  0x00, 0x07, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x60,
  0x0C, 0x00, 0x30, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x30, 0x07,
  0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30,
  0x30, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC7, 0x80, 0x00,
  0x31, 0xB0, 0x00, 0x0C, 0xCC, 0x00, 0x03, 0x61, 0x80, 0x00, 0xF0, 0x30,
  0x00, 0x38, 0x0C, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0xC0,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x0C, 0x00,
  0xC0, 0x01, 0x80, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xDF, 0x00, 0x00, 0x00, 0x06, 0xEC, 0x00,
  0x00, 0x00, 0x37, 0x60, 0x00, 0x00, 0x03, 0x3B, 0x00, 0x00, 0x00, 0x19,
  0xCC, 0x00, 0x00, 0x00, 0x8E, 0x60, 0x00, 0x00, 0x0C, 0x71, 0x00, 0x00,
  0x00, 0x63, 0x8C, 0x00, 0x00, 0x06, 0x1C, 0x60, 0x00, 0x00, 0x30, 0xE1,
  0x00, 0x00, 0x01, 0x87, 0x0C, 0x00, 0x00, 0x18, 0x38, 0x60, 0x00, 0x00,
  0xC1, 0xC1, 0x80, 0x00, 0x04, 0x0E, 0x0C, 0x00, 0x00, 0x60, 0x70, 0x20,
  0x00, 0x03, 0x03, 0x81, 0x80, 0x00, 0x10, 0x1C, 0x0C, 0x00, 0x01, 0x80,
  0xE0, 0x20, 0x00, 0x0C, 0x07, 0x01, 0x80, 0x00, 0xC0, 0x38, 0x0C, 0x00,
  0x06, 0x01, 0xC0, 0x30, 0x00, 0x20, 0x0E, 0x01, 0x80, 0x03, 0x00, 0x70,
  0x0C, 0x00, 0x18, 0x03, 0x80, 0x30, 0x00, 0x80, 0x1C, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x04, 0x00, 0x60, 0x07, 0x00, 0x30, 0x06, 0x00, 0x38, 0x01,
  0x80, 0x30, 0x01, 0xC0, 0x06, 0x01, 0x00, 0x0E, 0x00, 0x30, 0x18, 0x00,
  0x70, 0x01, 0x80, 0xC0, 0x03, 0x80, 0x06, 0x04, 0x00, 0x1C, 0x00, 0x30,
  0x60, 0x00, 0xE0, 0x00, 0x83, 0x00, 0x07, 0x00, 0x06, 0x30, 0x00, 0x38,
  0x00, 0x31, 0x80, 0x01, 0xC0, 0x00, 0x8C, 0x00, 0x0E, 0x00, 0x06, 0xC0,
  0x00, 0x70, 0x00, 0x36, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3D, 0x80, 0x00, 0x03, 0xD8, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x03,
  0xCC, 0x00, 0x00, 0x3C, 0x60, 0x00, 0x03, 0xC3, 0x00, 0x00, 0x3C, 0x30,
  0x00, 0x03, 0xC1, 0x80, 0x00, 0x3C, 0x18, 0x00, 0x03, 0xC0, 0xC0, 0x00,
  0x3C, 0x06, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x3C, 0x03, 0x00, 0x03, 0xC0,
  0x30, 0x00, 0x3C, 0x01, 0x80, 0x03, 0xC0, 0x0C, 0x00, 0x3C, 0x00, 0xC0,
  0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x03, 0x00, 0x3C,
  0x00, 0x10, 0x03, 0xC0, 0x01, 0x80, 0x3C, 0x00, 0x0C, 0x03, 0xC0, 0x00,
  0xC0, 0x3C, 0x00, 0x06, 0x03, 0xC0, 0x00, 0x60, 0x3C, 0x00, 0x03, 0x03,
  0xC0, 0x00, 0x18, 0x3C, 0x00, 0x01, 0x83, 0xC0, 0x00, 0x0C, 0x3C, 0x00,
  0x00, 0xC3, 0xC0, 0x00, 0x06, 0x3C, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x03,
  0x3C, 0x00, 0x00, 0x1B, 0xC0, 0x00, 0x01, 0xBC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x06, 0x10, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x00, 0x01, 0x90, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0x00, 0x0F, 0x86,
  0x00, 0x03, 0x8C, 0x00, 0x01, 0x98, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x70,
  0xC0, 0x07, 0xC1, 0xFF, 0xFE, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00,
  0x08, 0xC0, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x05, 0x80,
  0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x10, 0x20, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x30, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x18, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x30, 0x00, 0xF8, 0x18,
  0x00, 0x0E, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x98, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x26, 0x00, 0x00, 0x13, 0x00, 0x00,
  0x09, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00,
  0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x86, 0x00, 0x01, 0x83, 0x00,
  0x03, 0x81, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x18, 0x03,
  0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30,
  0x30, 0x00, 0x18, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00,
  0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0C, 0x00, 0xFF, 0xF0, 0x01, 0xF0, 0x7F, 0x01, 0xC0, 0x01, 0xC3,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x18, 0x00, 0x07, 0x0F, 0x80, 0x0F, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60, 0x1C, 0x00,
  0x0E, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x02, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x40, 0x01, 0x80, 0x00, 0xC0,
  0x03, 0x00, 0x01, 0x80, 0x04, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x40, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x20, 0x30,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x02, 0x30, 0x00,
  0x00, 0x06, 0x40, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x06,
  0x20, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x40, 0x00, 0x06,
  0x30, 0x00, 0x02, 0x40, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0x10, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0x18, 0x00, 0x04, 0x20, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18,
  0x08, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x18,
  0x0C, 0x00, 0x0C, 0x10, 0x00, 0x10, 0x0C, 0x00, 0x08, 0x18, 0x00, 0x30,
  0x04, 0x00, 0x18, 0x18, 0x00, 0x30, 0x06, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x06, 0x00, 0x18, 0x08, 0x00, 0x20, 0x06, 0x00, 0x10, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x04, 0x00, 0x40, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0,
  0x01, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x06, 0x00, 0xC0,
  0x01, 0x80, 0x60, 0x02, 0x00, 0x80, 0x01, 0x80, 0x40, 0x03, 0x01, 0x80,
  0x00, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x00, 0xC0, 0xC0, 0x03, 0x01, 0x80,
  0x00, 0xC0, 0xC0, 0x01, 0x01, 0x00, 0x00, 0xC0, 0x80, 0x01, 0x83, 0x00,
  0x00, 0x41, 0x80, 0x01, 0x83, 0x00, 0x00, 0x61, 0x80, 0x01, 0x83, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x86, 0x00, 0x00, 0x61, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x23, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x23, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x32, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x16, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x28, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x03,
  0x00, 0x20, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x10, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x0C, 0x00, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x02, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x08, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x18, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x80, 0x10, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x40, 0x20, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x60, 0x40, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFF, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x10, 0x60,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x20, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x04, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x02, 0x00,
  0x60, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x18, 0x18, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xC0,
  0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x03, 0xFF, 0x00, 0x7C, 0x1E, 0x06, 0x00, 0x18, 0x20, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x03, 0xFF, 0x01, 0xFF, 0x08, 0x3C, 0x00, 0x47,
  0x00, 0x02, 0x60, 0x00, 0x16, 0x00, 0x00, 0xB0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x02, 0xE0, 0x00, 0x35, 0x80, 0x03, 0x26, 0x00, 0x31,
  0x3C, 0x07, 0x08, 0x7F, 0xF0, 0x40, 0x38, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x81, 0xFF, 0x80, 0xC3, 0xE0,
  0xF0, 0x63, 0x80, 0x1C, 0x33, 0x00, 0x07, 0x1B, 0x00, 0x01, 0x8D, 0x00,
  0x00, 0x67, 0x80, 0x00, 0x13, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x06, 0xE0,
  0x00, 0x01, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x05, 0xC0, 0x00,
  0x02, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x01, 0xBC, 0x00, 0x01, 0x9E, 0x00,
  0x00, 0xCD, 0x80, 0x00, 0xC6, 0x60, 0x00, 0xC3, 0x38, 0x00, 0xE1, 0x8F,
  0x01, 0xC0, 0xC1, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x0F, 0x83, 0xC1, 0xC0, 0x02, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x38,
  0x0F, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x01, 0xFF, 0x81, 0x01, 0xE0, 0xF0, 0x83, 0x80,
  0x1C, 0x43, 0x80, 0x03, 0x21, 0x80, 0x00, 0xD1, 0x80, 0x00, 0x69, 0x80,
  0x00, 0x14, 0xC0, 0x00, 0x0E, 0x40, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x28, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x1A, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00,
  0x01, 0x98, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xA6, 0x00, 0x00, 0xD1, 0x80,
  0x00, 0x68, 0x60, 0x00, 0x64, 0x18, 0x00, 0x62, 0x07, 0x00, 0xE1, 0x01,
  0xFF, 0xC0, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0x87, 0x80,
  0x38, 0x01, 0x80, 0x60, 0x01, 0x81, 0x80, 0x01, 0x86, 0x00, 0x01, 0x0C,
  0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x05, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x02, 0x07, 0x80, 0x3C, 0x03, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x80, 0x1F, 0xF0, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x03, 0xFF, 0xF0, 0xFF,
  0xFC, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x81, 0xF0, 0x78, 0x41, 0xC0, 0x06, 0x21,
  0xC0, 0x01, 0x90, 0xC0, 0x00, 0x68, 0xC0, 0x00, 0x14, 0xC0, 0x00, 0x0E,
  0x60, 0x00, 0x03, 0x20, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x05, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x14, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x51, 0x00, 0x00, 0x68, 0xC0, 0x00, 0x24,
  0x30, 0x00, 0x32, 0x0C, 0x00, 0x71, 0x03, 0x80, 0xF0, 0x80, 0xFF, 0xE0,
  0x40, 0x07, 0x80, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x60, 0x3E, 0x01, 0xE0, 0x07, 0xFF, 0xC0, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x7F, 0xE0, 0xC3, 0xC1,
  0xE1, 0x8C, 0x00, 0x63, 0x30, 0x00, 0x66, 0xC0, 0x00, 0x6D, 0x00, 0x00,
  0xDE, 0x00, 0x01, 0xB8, 0x00, 0x01, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xFF, 0xE0, 0x00,
  0x00, 0x0D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xDB, 0x6D, 0x80, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x32, 0x38, 0xFC, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x06, 0xC0, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00, 0x61, 0x80, 0x07,
  0x0C, 0x00, 0x30, 0x60, 0x03, 0x03, 0x00, 0x30, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x01, 0x80, 0x30, 0x18, 0x01, 0x81, 0x80, 0x0C, 0x18, 0x00,
  0x60, 0xC0, 0x03, 0x0F, 0x00, 0x18, 0xD8, 0x00, 0xCC, 0x60, 0x06, 0xC1,
  0x80, 0x34, 0x0C, 0x01, 0xE0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x06, 0x03,
  0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x08, 0x30, 0x00,
  0x61, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x00, 0x00, 0xD8,
  0x00, 0x06, 0xC0, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC1, 0xFF, 0x00, 0x7F, 0xC1, 0x8F,
  0x07, 0x01, 0xC1, 0xE3, 0x38, 0x03, 0x0E, 0x00, 0xE6, 0x40, 0x03, 0x18,
  0x00, 0xCD, 0x80, 0x06, 0x60, 0x00, 0xDE, 0x00, 0x07, 0x80, 0x01, 0xB8,
  0x00, 0x0F, 0x00, 0x01, 0x70, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x1E,
  0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0x00, 0x00, 0x78, 0x00, 0x02,
  0x00, 0x00, 0xF0, 0x00, 0x04, 0x00, 0x01, 0xE0, 0x00, 0x08, 0x00, 0x03,
  0xC0, 0x00, 0x10, 0x00, 0x07, 0x80, 0x00, 0x20, 0x00, 0x0F, 0x00, 0x00,
  0x40, 0x00, 0x1E, 0x00, 0x00, 0x80, 0x00, 0x3C, 0x00, 0x01, 0x00, 0x00,
  0x78, 0x00, 0x02, 0x00, 0x00, 0xF0, 0x00, 0x04, 0x00, 0x01, 0xE0, 0x00,
  0x08, 0x00, 0x03, 0xC0, 0x00, 0x10, 0x00, 0x07, 0x80, 0x00, 0x20, 0x00,
  0x0F, 0x00, 0x00, 0x40, 0x00, 0x1E, 0x00, 0x00, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0x00, 0x00, 0x78, 0x00, 0x02, 0x00, 0x00, 0xF0, 0x00, 0x04, 0x00,
  0x01, 0xE0, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x10, 0x00, 0x07, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0xC0, 0xFF, 0xC1, 0x87, 0x83, 0xC3, 0x18, 0x00,
  0xC6, 0x60, 0x00, 0xCD, 0x80, 0x00, 0xDA, 0x00, 0x01, 0xBC, 0x00, 0x03,
  0x70, 0x00, 0x02, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x7F, 0xE0, 0x00, 0x78, 0x3E,
  0x00, 0x70, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x0C, 0x00, 0x06, 0x06, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x20, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x26, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x40, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x88, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x04, 0x18, 0x00, 0x03, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x78, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0xC0, 0xFF, 0xC0, 0x61, 0xF0, 0x78, 0x31, 0xC0, 0x0E, 0x19, 0xC0, 0x01,
  0x8C, 0xC0, 0x00, 0xC6, 0xC0, 0x00, 0x33, 0x40, 0x00, 0x0D, 0xE0, 0x00,
  0x06, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x00, 0xB8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0x70, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0xDE, 0x00, 0x00, 0xCD, 0x00, 0x00, 0x66, 0xC0, 0x00, 0x63, 0x30, 0x00,
  0x71, 0x8C, 0x00, 0x70, 0xC3, 0x80, 0xE0, 0x60, 0xFF, 0xE0, 0x30, 0x07,
  0x80, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x81, 0xF0, 0x78, 0x41, 0xC0, 0x0E, 0x21, 0xC0, 0x01, 0x90, 0xC0,
  0x00, 0x48, 0xC0, 0x00, 0x34, 0xC0, 0x00, 0x0A, 0x60, 0x00, 0x07, 0x20,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xC8, 0x00, 0x00, 0xA6, 0x00,
  0x00, 0x53, 0x00, 0x00, 0x68, 0xC0, 0x00, 0x64, 0x30, 0x00, 0x32, 0x1C,
  0x00, 0x73, 0x03, 0x80, 0xF1, 0x80, 0xFF, 0xE0, 0xC0, 0x0F, 0x80, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC1, 0xFF, 0x87, 0x8F,
  0x18, 0x06, 0x60, 0x0D, 0x80, 0x1A, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x7C, 0x0F, 0xC7, 0x00, 0x04, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xD8, 0x00, 0x0C,
  0xFC, 0x01, 0xC0, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x02, 0x03, 0xFC, 0x00, 0xE0, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x60, 0x00,
  0x15, 0x80, 0x00, 0xD3, 0x00, 0x06, 0x4E, 0x00, 0x31, 0x1E, 0x03, 0x84,
  0x1F, 0xF8, 0x10, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03,
  0x60, 0x00, 0x02, 0x60, 0x00, 0x06, 0x20, 0x00, 0x06, 0x30, 0x00, 0x04,
  0x30, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x18, 0x00, 0x18,
  0x08, 0x00, 0x18, 0x0C, 0x00, 0x10, 0x0C, 0x00, 0x30, 0x04, 0x00, 0x30,
  0x06, 0x00, 0x20, 0x06, 0x00, 0x60, 0x02, 0x00, 0x60, 0x03, 0x00, 0x40,
  0x03, 0x00, 0xC0, 0x01, 0x00, 0xC0, 0x01, 0x80, 0x80, 0x01, 0x81, 0x80,
  0x00, 0x81, 0x80, 0x00, 0xC1, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x90, 0x00, 0x0E, 0x00, 0x06, 0x60, 0x00, 0x68, 0x00, 0x19,
  0x80, 0x01, 0xB0, 0x00, 0x62, 0x00, 0x04, 0xC0, 0x01, 0x0C, 0x00, 0x33,
  0x00, 0x0C, 0x30, 0x00, 0xC4, 0x00, 0x30, 0xC0, 0x03, 0x18, 0x00, 0xC1,
  0x00, 0x08, 0x60, 0x02, 0x06, 0x00, 0x60, 0x80, 0x18, 0x18, 0x01, 0x83,
  0x00, 0x60, 0x60, 0x04, 0x0C, 0x01, 0x80, 0x80, 0x30, 0x30, 0x04, 0x03,
  0x00, 0xC0, 0x40, 0x30, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x08, 0x06,
  0x03, 0x00, 0x40, 0x60, 0x08, 0x08, 0x01, 0x81, 0x80, 0x30, 0x60, 0x06,
  0x04, 0x00, 0xC1, 0x80, 0x08, 0x30, 0x03, 0x06, 0x00, 0x20, 0xC0, 0x04,
  0x10, 0x00, 0xC3, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x04,
  0x60, 0x00, 0x8C, 0x00, 0x19, 0x80, 0x02, 0x20, 0x00, 0x64, 0x00, 0x0D,
  0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x02, 0xC0, 0x00, 0x58, 0x00, 0x0A,
  0x00, 0x01, 0x40, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x60, 0x00, 0x07, 0x30, 0x00, 0x06,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x30,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0,
  0x01, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x63, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x66, 0x00, 0x00, 0x63, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0xC1, 0x80, 0x01, 0x80, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x03,
  0x40, 0x00, 0x01, 0xB0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x40, 0x00, 0x18, 0x30, 0x00,
  0x18, 0x18, 0x00, 0x0C, 0x04, 0x00, 0x06, 0x03, 0x00, 0x06, 0x01, 0x80,
  0x03, 0x00, 0x40, 0x01, 0x80, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0x40, 0x10, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x04, 0x04, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x41, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0,
  0x00, 0x04, 0x40, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x50,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x01, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0x80, 0x0F, 0xC0, 0x1E, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x1F,
  0x80, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0xFC, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x2F, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x03, 0x40, 0x01, 0xF7, 0xC8,
  0x00, 0x0F, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Thin64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 3, 46, 14, 5, -46 },
  { 19, 11, 17, 20, 4, -46 },
  { 43, 33, 46, 36, 2, -46 },
  { 233, 25, 53, 32, 3, -49 },
  { 399, 39, 47, 46, 3, -46 },
  { 629, 33, 47, 38, 3, -46 },
  { 823, 2, 17, 11, 4, -46 },
  { 828, 11, 56, 17, 3, -46 },
  { 905, 12, 56, 17, 2, -46 },
  { 989, 22, 23, 30, 4, -49 },
  { 1053, 27, 29, 32, 3, -37 },
  { 1151, 6, 15, 12, 2, -7 },
  { 1163, 15, 1, 19, 2, -18 },
  { 1165, 3, 4, 13, 5, -4 },
  { 1167, 19, 46, 21, 1, -46 },
  { 1277, 25, 47, 32, 4, -46 },
  { 1424, 13, 46, 32, 6, -46 },
  { 1499, 25, 46, 32, 3, -46 },
  { 1643, 25, 47, 32, 3, -46 },
  { 1790, 31, 46, 32, 1, -46 },
  { 1969, 25, 47, 32, 4, -46 },
  { 2116, 25, 47, 32, 4, -46 },
  { 2263, 26, 46, 32, 3, -46 },
  { 2413, 26, 47, 32, 3, -46 },
  { 2566, 25, 47, 32, 3, -46 },
  { 2713, 3, 34, 13, 5, -34 },
  { 2726, 6, 42, 13, 2, -34 },
  { 2758, 27, 28, 32, 3, -37 },
  { 2853, 27, 15, 32, 3, -30 },
  { 2904, 27, 28, 32, 3, -37 },
  { 2999, 19, 46, 23, 2, -46 },
  { 3109, 43, 51, 50, 3, -45 },
  { 3384, 32, 46, 32, 0, -46 },
  { 3568, 26, 46, 35, 6, -46 },
  { 3718, 29, 47, 35, 4, -46 },
  { 3889, 29, 46, 39, 6, -46 },
  { 4056, 22, 46, 31, 6, -46 },
  { 4183, 22, 46, 28, 6, -46 },
  { 4310, 33, 47, 41, 4, -46 },
  { 4504, 28, 46, 40, 6, -46 },
  { 4665, 10, 46, 17, 3, -46 },
  { 4723, 13, 57, 14, -5, -46 },
  { 4816, 26, 46, 31, 6, -46 },
  { 4966, 21, 46, 29, 6, -46 },
  { 5087, 37, 46, 49, 6, -46 },
  { 5300, 28, 46, 40, 6, -46 },
  { 5461, 35, 47, 43, 4, -46 },
  { 5667, 23, 46, 33, 6, -46 },
  { 5800, 35, 57, 43, 4, -46 },
  { 6050, 25, 46, 33, 6, -46 },
  { 6194, 25, 47, 31, 3, -46 },
  { 6341, 28, 46, 28, 0, -46 },
  { 6502, 29, 47, 40, 6, -46 },
  { 6673, 31, 46, 31, 0, -46 },
  { 6852, 48, 46, 50, 1, -46 },
  { 7128, 28, 46, 28, 0, -46 },
  { 7289, 28, 46, 28, 0, -46 },
  { 7450, 27, 46, 31, 2, -46 },
  { 7606, 12, 56, 20, 6, -46 },
  { 7690, 19, 46, 21, 1, -46 },
  { 7800, 12, 56, 20, 2, -46 },
  { 7884, 28, 26, 32, 2, -46 },
  { 7975, 25, 1, 25, 0, 6 },
  { 7979, 10, 10, 15, 3, -49 },
  { 7992, 21, 35, 29, 3, -34 },
  { 8084, 25, 50, 34, 5, -49 },
  { 8241, 21, 35, 27, 4, -34 },
  { 8333, 25, 50, 34, 3, -49 },
  { 8490, 23, 35, 31, 4, -34 },
  { 8591, 18, 49, 16, 1, -49 },
  { 8702, 25, 49, 34, 3, -34 },
  { 8856, 23, 49, 33, 5, -49 },
  { 8997, 3, 46, 13, 5, -46 },
  { 9015, 10, 61, 13, -2, -46 },
  { 9092, 21, 49, 26, 5, -49 },
  { 9221, 2, 49, 12, 5, -49 },
  { 9234, 39, 34, 49, 5, -34 },
  { 9400, 23, 34, 33, 5, -34 },
  { 9498, 26, 35, 33, 3, -34 },
  { 9612, 25, 49, 34, 5, -34 },
  { 9766, 25, 49, 34, 3, -34 },
  { 9920, 15, 34, 21, 5, -34 },
  { 9984, 21, 35, 26, 2, -34 },
  { 10076, 15, 43, 18, 1, -42 },
  { 10157, 22, 35, 33, 5, -34 },
  { 10254, 24, 34, 24, 0, -34 },
  { 10356, 38, 34, 40, 1, -34 },
  { 10518, 24, 34, 27, 1, -34 },
  { 10620, 25, 50, 25, 0, -34 },
  { 10777, 20, 34, 25, 2, -34 },
  { 10862, 17, 56, 22, 2, -46 },
  { 10981, 2, 65, 31, 14, -49 },
  { 10998, 16, 56, 22, 3, -46 },
  { 11110, 27, 5, 32, 3, -25 },
};

const GFXfont NotoSans_SemiCondensed_Thin64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin64pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_SEMICONDENSED_THIN64PT7B_H_
