#ifndef _NOTOSANS_SEMICONDENSED_THIN11PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFC, 0x28, 0xA7, 0xCA, 0x4B, 0xD5, 0x14, 0x6C, 0xCC, 0x65,
  0x5E, 0x40, 0xCA, 0xAB, 0x2B, 0xF4, 0xD5, 0x53, 0xE4, 0xA8, 0x8A, 0xD6,
  0x5F, 0xE0, 0x5A, 0xA9, 0x50, 0x95, 0x55, 0x60, 0x4B, 0xE0, 0x21, 0x3E,
  0x42, 0x00, 0xC0, 0xE0, 0x80, 0x24, 0x94, 0xA4, 0xE9, 0x99, 0x99, 0x9E,
  0x75, 0x55, 0xE1, 0x11, 0x24, 0x8F, 0x70, 0x42, 0x60, 0x84, 0x3E, 0x10,
  0x8A, 0x94, 0xFC, 0x21, 0xE8, 0x8E, 0x11, 0x1E, 0x78, 0x8E, 0x99, 0x9F,
  0xF1, 0x22, 0x24, 0x44, 0xE9, 0x96, 0x99, 0x9F, 0xE9, 0x99, 0xF1, 0x1E,
  0x84, 0x86, 0x1B, 0x38, 0x30, 0xFF, 0xC0, 0xE0, 0x87, 0xC0, 0xE1, 0x12,
  0x44, 0x04, 0x7D, 0x06, 0x4D, 0x5C, 0xB9, 0x6F, 0x40, 0x78, 0x20, 0x85,
  0x14, 0x7A, 0x28, 0xA1, 0xF9, 0x9F, 0x99, 0x9F, 0x7C, 0x21, 0x08, 0x42,
  0x0F, 0xF4, 0x63, 0x18, 0xC6, 0x3E, 0xF8, 0x8F, 0x88, 0x8F, 0xF8, 0x88,
  0xF8, 0x88, 0x7C, 0x21, 0x09, 0xC6, 0x2F, 0x8C, 0x63, 0xF8, 0xC6, 0x31,
  0xFF, 0x55, 0x55, 0x70, 0x9A, 0xAC, 0xCA, 0x99, 0x88, 0x88, 0x88, 0x8F,
  0x86, 0x18, 0x73, 0xCE, 0xBB, 0x65, 0x8C, 0x73, 0x5A, 0xCE, 0x71, 0x7A,
  0x28, 0x61, 0x86, 0x18, 0x5E, 0xE9, 0x99, 0xE8, 0x88, 0x7A, 0x28, 0x61,
  0x86, 0x18, 0x5A, 0x10, 0x20, 0xE9, 0x99, 0xEA, 0x99, 0xF8, 0x8C, 0x21,
  0x1E, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x8C, 0x63, 0x18, 0xC6, 0x3E, 0x8C,
  0x62, 0x95, 0x28, 0x84, 0x89, 0x89, 0x99, 0x55, 0x55, 0x56, 0x62, 0x22,
  0x8A, 0x94, 0x42, 0x29, 0x51, 0x8C, 0x94, 0xA2, 0x10, 0x84, 0x78, 0x44,
  0x42, 0x21, 0x1F, 0xEA, 0xAA, 0xB0, 0x91, 0x24, 0x49, 0xD5, 0x55, 0x70,
  0x21, 0x94, 0x98, 0x80, 0xF0, 0xC0, 0x71, 0x35, 0x9F, 0x88, 0xF9, 0x99,
  0x9F, 0x72, 0x49, 0xC0, 0x11, 0xF9, 0x99, 0x9F, 0xE9, 0xF8, 0x8F, 0x6B,
  0xA4, 0x92, 0xF9, 0x99, 0x9F, 0x11, 0xE0, 0x88, 0xE9, 0x99, 0x99, 0xBF,
  0xBF, 0xE0, 0x92, 0xDD, 0xAD, 0xFF, 0xED, 0x26, 0x4C, 0x99, 0x32, 0x40,
  0xE9, 0x99, 0x99, 0xE9, 0x99, 0x9F, 0xF9, 0x99, 0x9F, 0x88, 0x80, 0xF9,
  0x99, 0x9F, 0x11, 0x10, 0xF2, 0x49, 0x00, 0x78, 0x43, 0x1F, 0x5D, 0x24,
  0x98, 0x99, 0x99, 0x9F, 0x99, 0x96, 0x64, 0x93, 0x26, 0xB3, 0x64, 0x49,
  0x00, 0x95, 0x22, 0x59, 0x99, 0x56, 0x24, 0x44, 0x80, 0x71, 0x24, 0x4F,
  0x29, 0x2C, 0x92, 0x44, 0xFF, 0xE0, 0xC4, 0x92, 0x49, 0x58, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Thin11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 8, 2, 1, -8 },
  { 2, 2, 3, 3, 1, -8 },
  { 3, 6, 8, 6, 0, -8 },
  { 9, 4, 9, 6, 1, -8 },
  { 14, 6, 8, 8, 1, -8 },
  { 20, 5, 8, 6, 1, -8 },
  { 25, 1, 3, 2, 0, -8 },
  { 26, 2, 10, 3, 0, -8 },
  { 29, 2, 10, 3, 0, -8 },
  { 32, 4, 3, 5, 1, -8 },
  { 34, 5, 5, 6, 0, -6 },
  { 38, 1, 2, 2, 0, -1 },
  { 39, 3, 1, 3, 0, -3 },
  { 40, 1, 1, 2, 1, -1 },
  { 41, 3, 8, 4, 0, -8 },
  { 44, 4, 8, 6, 1, -8 },
  { 48, 2, 8, 6, 1, -8 },
  { 50, 4, 8, 6, 1, -8 },
  { 54, 5, 8, 6, 0, -8 },
  { 59, 5, 8, 6, 0, -8 },
  { 64, 4, 8, 6, 1, -8 },
  { 68, 4, 8, 6, 1, -8 },
  { 72, 4, 8, 6, 1, -8 },
  { 76, 4, 8, 6, 1, -8 },
  { 80, 4, 8, 6, 1, -8 },
  { 84, 1, 6, 2, 1, -6 },
  { 85, 1, 7, 2, 0, -6 },
  { 86, 5, 4, 6, 0, -6 },
  { 89, 5, 2, 6, 0, -5 },
  { 91, 5, 4, 6, 0, -6 },
  { 94, 4, 8, 4, 0, -8 },
  { 98, 7, 9, 9, 1, -8 },
  { 106, 6, 8, 6, 0, -8 },
  { 112, 4, 8, 6, 1, -8 },
  { 116, 5, 8, 6, 1, -8 },
  { 121, 5, 8, 7, 1, -8 },
  { 126, 4, 8, 5, 1, -8 },
  { 130, 4, 8, 5, 1, -8 },
  { 134, 5, 8, 7, 1, -8 },
  { 139, 5, 8, 7, 1, -8 },
  { 144, 1, 8, 3, 1, -8 },
  { 145, 2, 10, 2, -1, -8 },
  { 148, 4, 8, 5, 1, -8 },
  { 152, 4, 8, 5, 1, -8 },
  { 156, 6, 8, 8, 1, -8 },
  { 162, 5, 8, 7, 1, -8 },
  { 167, 6, 8, 7, 1, -8 },
  { 173, 4, 8, 6, 1, -8 },
  { 177, 6, 10, 7, 1, -8 },
  { 185, 4, 8, 6, 1, -8 },
  { 189, 4, 8, 5, 1, -8 },
  { 193, 5, 8, 5, 0, -8 },
  { 198, 5, 8, 7, 1, -8 },
  { 203, 5, 8, 5, 0, -8 },
  { 208, 8, 8, 9, 0, -8 },
  { 216, 5, 8, 5, 0, -8 },
  { 221, 5, 8, 5, 0, -8 },
  { 226, 5, 8, 5, 0, -8 },
  { 231, 2, 10, 3, 1, -8 },
  { 234, 3, 8, 4, 0, -8 },
  { 237, 2, 10, 3, 0, -8 },
  { 240, 5, 5, 6, 0, -8 },
  { 244, 4, 1, 4, 0, 1 },
  { 245, 2, 1, 3, 0, -8 },
  { 246, 4, 6, 5, 0, -6 },
  { 249, 4, 8, 6, 1, -8 },
  { 253, 3, 6, 5, 1, -6 },
  { 256, 4, 8, 6, 1, -8 },
  { 260, 4, 6, 5, 1, -6 },
  { 263, 3, 8, 3, 0, -8 },
  { 266, 4, 9, 6, 1, -6 },
  { 271, 4, 8, 6, 1, -8 },
  { 275, 1, 8, 2, 1, -8 },
  { 276, 1, 11, 2, 0, -8 },
  { 278, 3, 8, 4, 1, -8 },
  { 281, 1, 8, 2, 1, -8 },
  { 282, 7, 6, 8, 1, -6 },
  { 288, 4, 6, 6, 1, -6 },
  { 291, 4, 6, 6, 1, -6 },
  { 294, 4, 9, 6, 1, -6 },
  { 299, 4, 9, 6, 1, -6 },
  { 304, 3, 6, 4, 1, -6 },
  { 307, 4, 6, 4, 0, -6 },
  { 310, 3, 7, 3, 0, -7 },
  { 313, 4, 6, 6, 1, -6 },
  { 316, 4, 6, 4, 0, -6 },
  { 319, 7, 6, 7, 0, -6 },
  { 325, 4, 6, 5, 0, -6 },
  { 328, 4, 9, 4, 0, -6 },
  { 333, 4, 6, 4, 0, -6 },
  { 336, 3, 10, 4, 0, -8 },
  { 340, 1, 11, 5, 2, -8 },
  { 342, 3, 10, 4, 0, -8 },
  { 346, 5, 1, 6, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_Thin11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin11pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_SEMICONDENSED_THIN11PT7B_H_
