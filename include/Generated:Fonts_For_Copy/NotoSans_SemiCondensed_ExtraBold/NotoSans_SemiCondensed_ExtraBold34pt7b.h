#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD34PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0x00, 0x03, 0x3E, 0xFF, 0xFF, 0xFE, 0xF9, 0xFF, 0xCF, 0xFE, 0x3D,
  0xF1, 0xEF, 0x8F, 0x7C, 0x7B, 0xE3, 0xDF, 0x1E, 0x78, 0xF0, 0x03, 0xC7,
  0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E,
  0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x3C, 0x78,
  0x07, 0x8F, 0x00, 0xF1, 0xC0, 0x1E, 0x78, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xC3, 0xC7, 0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xC7, 0x80,
  0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x0F, 0xFC, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFD, 0x86, 0xF9,
  0x80, 0xF9, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0x9F, 0x01, 0x9F, 0xC1, 0x9F, 0xFD,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF8, 0x0F, 0xE0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xC0, 0x7F, 0xC0,
  0x78, 0x07, 0xFC, 0x0F, 0x80, 0xFB, 0xE0, 0xF0, 0x0F, 0x1E, 0x1F, 0x00,
  0xF1, 0xE1, 0xE0, 0x0F, 0x1E, 0x3E, 0x00, 0xF1, 0xE3, 0xC0, 0x0F, 0x1E,
  0x7C, 0x00, 0xF1, 0xE7, 0x8F, 0x8F, 0xBE, 0xF9, 0xFC, 0x7F, 0xCF, 0x3F,
  0xE7, 0xFD, 0xF7, 0xFE, 0x3F, 0x9E, 0x79, 0xF0, 0xC3, 0xE7, 0x8F, 0x00,
  0x3C, 0x78, 0xF0, 0x07, 0xC7, 0x8F, 0x00, 0x78, 0x78, 0xF0, 0x0F, 0x87,
  0x8F, 0x00, 0xF0, 0x79, 0xF0, 0x1F, 0x07, 0xDE, 0x01, 0xE0, 0x3F, 0xE0,
  0x3E, 0x03, 0xFC, 0x03, 0xC0, 0x1F, 0x80, 0x00, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xC3, 0xE0,
  0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xC7, 0xFE, 0x1F, 0x9F,
  0xFE, 0x3E, 0x3F, 0x7E, 0xFC, 0xFC, 0x7F, 0xF9, 0xF8, 0x7F, 0xE3, 0xF0,
  0x7F, 0xC7, 0xE0, 0xFF, 0x0F, 0xE3, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xF8, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x78, 0x07, 0xC3, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x07,
  0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0xF0, 0x7C, 0x1F, 0x07, 0x83, 0xE1, 0xF0, 0x7C, 0x3E,
  0x1F, 0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xC3, 0x86, 0xFB,
  0xBE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0x1E,
  0xF8, 0x3E, 0xF8, 0x7C, 0x7C, 0x1C, 0x70, 0x04, 0x20, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x7E, 0xF9, 0xF3, 0xE7, 0xCF, 0x3E, 0x7C,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x33, 0xEF, 0xFF, 0xFF, 0xE0, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x0F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7E, 0x7E, 0x7C, 0x3E, 0x7C, 0x3F, 0xFC,
  0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7E, 0x3E, 0x7E,
  0x7E, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x7F,
  0x0F, 0xF1, 0xFF, 0x3F, 0xF7, 0xFF, 0xFD, 0xF7, 0x9F, 0x73, 0xF2, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0x80, 0x1F,
  0xF0, 0x3F, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0x7C, 0x7E, 0x30, 0x3F, 0x20,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x3F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x30, 0x7E, 0x20,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x3F, 0xF0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xF8, 0x7F,
  0xF0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0x7C, 0x0F, 0x3E, 0x0F, 0x9F,
  0x07, 0x8F, 0x87, 0xC7, 0xC3, 0xC3, 0xE3, 0xC1, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xFB, 0xC1, 0xFF, 0xE3, 0xFF,
  0xE7, 0xFF, 0xEF, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFE, 0x01, 0xFF, 0x0F, 0xEF, 0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x3F,
  0xF0, 0x00, 0x18, 0x03, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0xF8, 0xFB, 0xFC, 0xFB,
  0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0x7C, 0x3F, 0x7E, 0x7F, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F,
  0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x01, 0x80, 0x0F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F,
  0xFE, 0x7C, 0x3F, 0x7C, 0x3F, 0x7C, 0x3E, 0x7E, 0x3E, 0x3F, 0x7E, 0x3F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFE, 0x7E, 0x7E, 0xFC,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7F, 0xFF, 0x7F,
  0xFE, 0x3F, 0xFC, 0x0F, 0xF8, 0x01, 0x80, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xFC, 0x7F, 0xFE, 0xFC, 0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F,
  0xDF, 0x0F, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xFC, 0x3F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xC0, 0x7B, 0xEF, 0xFF, 0xFD, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x8F, 0xBF, 0xFF, 0xFF, 0x80, 0x3C, 0xFD,
  0xFB, 0xF7, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x7C, 0xF9, 0xF3, 0xE7, 0x9F, 0x3E, 0x78, 0x00, 0x01, 0x00, 0x07, 0x00,
  0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x00,
  0x7F, 0x01, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF8,
  0x00, 0xE0, 0x00, 0x80, 0x00, 0x03, 0x00, 0x7F, 0xE3, 0xFF, 0xE3, 0xFF,
  0xE7, 0xFF, 0xCE, 0x0F, 0xC8, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x03, 0xC1,
  0xE0, 0x00, 0x78, 0xF0, 0x7F, 0x9E, 0x3C, 0x7F, 0xF3, 0xDE, 0x3F, 0xFC,
  0xF7, 0x8F, 0x1E, 0x3D, 0xE7, 0x87, 0x8F, 0x71, 0xE1, 0xE3, 0xFC, 0x78,
  0x78, 0xFF, 0x1E, 0x1E, 0x3F, 0xC7, 0x87, 0x8F, 0xF1, 0xE1, 0xE3, 0xDE,
  0x7C, 0xF9, 0xE7, 0x8F, 0xFF, 0xF9, 0xE3, 0xFD, 0xFC, 0x7C, 0x7E, 0x3E,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x60, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80,
  0x3F, 0x3F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xE0, 0x7E,
  0x1F, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x1F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xEF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F,
  0xFF, 0xEF, 0x87, 0xF7, 0xC1, 0xFB, 0xE0, 0xFD, 0xF0, 0x7E, 0xF8, 0x3F,
  0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0xE7, 0xFF, 0xFB, 0xE0,
  0xFD, 0xF0, 0x3E, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xDF, 0x1F, 0xEF,
  0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x60, 0x03, 0xFF,
  0x83, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xF3, 0xFC, 0x39, 0xF8, 0x05, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x27, 0xFC, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x07,
  0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8,
  0xFF, 0xBE, 0x0F, 0xEF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xEF, 0x83, 0xFB, 0xFF, 0xFC, 0xFF,
  0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xFF,
  0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3F, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x14, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3,
  0xFF, 0xF8, 0xFF, 0x03, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFF,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xBF,
  0x03, 0xF7, 0xFC, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x03,
  0xFF, 0x80, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xE1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x87,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F,
  0xC3, 0xF9, 0xFF, 0xFE, 0xFF, 0xBF, 0xCF, 0xE0, 0xF8, 0x0F, 0xFE, 0x07,
  0xEF, 0x83, 0xF3, 0xE0, 0xFC, 0xF8, 0x7E, 0x3E, 0x3F, 0x0F, 0x8F, 0xC3,
  0xE7, 0xE0, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xE3, 0xF0, 0xF8, 0xFC, 0x3E, 0x1F,
  0x8F, 0x87, 0xE3, 0xE0, 0xFC, 0xF8, 0x3F, 0x3E, 0x07, 0xEF, 0x81, 0xFB,
  0xE0, 0x3F, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xDE, 0x07, 0xFF, 0xEF, 0x03, 0xDF, 0xF7, 0xC1, 0xEF,
  0xFF, 0xE1, 0xF7, 0xFE, 0xF0, 0xF3, 0xFF, 0x7C, 0x79, 0xFF, 0xBE, 0x7C,
  0xFF, 0xCF, 0x3C, 0x7F, 0xE7, 0x9E, 0x3F, 0xF3, 0xEF, 0x1F, 0xF9, 0xFF,
  0x8F, 0xFC, 0x7F, 0x87, 0xFE, 0x3F, 0xC3, 0xFF, 0x1F, 0xE1, 0xFF, 0x87,
  0xE0, 0xFF, 0xC3, 0xF0, 0x7F, 0xE1, 0xF8, 0x3F, 0xF0, 0xFC, 0x1F, 0xFE,
  0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0x7E, 0x1F, 0xF7, 0xE1, 0xFF, 0x3F, 0x1F,
  0xFB, 0xF1, 0xFF, 0x9F, 0x9F, 0xF9, 0xF9, 0xFF, 0x8F, 0xDF, 0xF8, 0xFD,
  0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x81,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0x00,
  0x70, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE,
  0x3F, 0x87, 0xF9, 0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xBF, 0x80,
  0xFC, 0xFC, 0x0F, 0xE7, 0xFD, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFE, 0xF8, 0xFE, 0xF8, 0x7E, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x7E, 0xF8, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0x80, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x87, 0xF9, 0xF8, 0x0F, 0xDF,
  0x80, 0x7E, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x1F, 0xBF, 0x80, 0xFC, 0xFC, 0x0F, 0xE7, 0xFD, 0xFE,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8,
  0xF8, 0x7E, 0x3E, 0x0F, 0xCF, 0x83, 0xF3, 0xE0, 0xFC, 0xF8, 0x3F, 0x3E,
  0x1F, 0x8F, 0x9F, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xE7, 0xE0, 0xF8, 0xFC, 0x3E, 0x3F, 0x0F, 0x87, 0xE3, 0xE1, 0xF8,
  0xF8, 0x3F, 0x3E, 0x0F, 0xEF, 0x81, 0xFB, 0xE0, 0x7F, 0x01, 0x80, 0x1F,
  0xF8, 0xFF, 0xF9, 0xFF, 0xF7, 0xFF, 0xEF, 0xC3, 0x9F, 0x01, 0x3E, 0x00,
  0x7E, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFE, 0x01, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0x7C, 0x07,
  0xEF, 0x80, 0xFD, 0xF8, 0x1F, 0xBF, 0xDF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF,
  0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0xDF, 0x80,
  0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xFC, 0x1F, 0x87,
  0xE0, 0xFC, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xE3, 0xF0, 0x1F, 0x1F,
  0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3F, 0x7E, 0x00, 0xFB, 0xE0, 0x07,
  0xDF, 0x00, 0x3E, 0xF8, 0x00, 0xF7, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x07, 0xC0, 0x7F,
  0xF8, 0x0F, 0xC0, 0xFD, 0xF0, 0x3F, 0x81, 0xFB, 0xE0, 0x7F, 0x03, 0xE7,
  0xC0, 0xFE, 0x07, 0xCF, 0xC1, 0xFC, 0x1F, 0x8F, 0x83, 0xFC, 0x3F, 0x1F,
  0x0F, 0xF8, 0x7C, 0x3E, 0x1E, 0xF0, 0xF8, 0x7E, 0x3D, 0xE1, 0xF0, 0x7C,
  0x7B, 0xE7, 0xE0, 0xF9, 0xF7, 0xCF, 0x81, 0xF3, 0xE7, 0x9F, 0x03, 0xE7,
  0x8F, 0x3E, 0x07, 0xCF, 0x1E, 0x7C, 0x07, 0xDE, 0x3F, 0xF8, 0x0F, 0xFC,
  0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xC1,
  0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFC, 0x07,
  0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x7E, 0x03, 0xF1, 0xF0, 0x3F, 0x0F, 0xC1,
  0xF8, 0x3E, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0xCF, 0xC0, 0x3F, 0x7E, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F,
  0xDF, 0x80, 0x7E, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x83, 0xF0, 0x7E,
  0x3F, 0x83, 0xF9, 0xF8, 0x0F, 0xDF, 0x80, 0x7F, 0xFC, 0x03, 0xF7, 0xE0,
  0x7E, 0x7E, 0x07, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F,
  0x9F, 0x80, 0xF9, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0xC0, 0x3C, 0xF0, 0x0F, 0x3E, 0x07, 0x87, 0x81, 0xE1, 0xF0, 0xF0, 0x3C,
  0x3C, 0x0F, 0x9F, 0x01, 0xEF, 0x80, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFE, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x07, 0xF0, 0x3F, 0xFC,
  0x3F, 0xFE, 0x1F, 0xFE, 0x1C, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x01, 0xFF,
  0x1F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xCF, 0x3F, 0x8F, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF9, 0xF0, 0xFD, 0xFC, 0x7D, 0xFF, 0x3F, 0xFF, 0xDF, 0xEF, 0xEF,
  0xC3, 0xF7, 0xE0, 0xFB, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xF7, 0xF1, 0xFB, 0xFF, 0xFD, 0xFF,
  0xFC, 0xFB, 0xFC, 0x7C, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xFC, 0x7F, 0xF1,
  0xFF, 0xE7, 0xFB, 0x8F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x5F, 0xC3, 0x1F, 0xFE,
  0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x1F, 0x3F, 0x1F,
  0xEF, 0x9F, 0xF7, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xE1, 0xFB, 0xE0, 0xFF,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xEF, 0x83,
  0xF7, 0xE1, 0xFB, 0xF1, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xEF, 0x87,
  0xE7, 0xC0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xE3,
  0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x0C, 0x7F, 0xFE,
  0x3F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x87, 0xFC,
  0x7F, 0xE3, 0xF2, 0x1F, 0x80, 0xF8, 0x07, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F,
  0xF9, 0xFF, 0xC3, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x00, 0x0F, 0x8F, 0x8F, 0xF7, 0xCF, 0xFF, 0xE7, 0xFF, 0xF7, 0xF3,
  0xFB, 0xF0, 0xFD, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xF7, 0xC0, 0xFB, 0xF0, 0xFD, 0xF8, 0xFE, 0xFF, 0xFF,
  0x3F, 0xFF, 0x8F, 0xF7, 0xC3, 0xF7, 0xE0, 0x03, 0xF0, 0x01, 0xFA, 0x00,
  0xFD, 0xE1, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x07, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF9, 0xF0, 0xFB, 0xFE, 0x7D, 0xFF, 0x3F, 0xFF, 0xDF,
  0xFF, 0xEF, 0xE3, 0xF7, 0xE0, 0xFB, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xC0, 0x7B, 0xFF, 0xFF, 0x78,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x07, 0x80, 0x00,
  0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xE7, 0xFF, 0xFB, 0xFE, 0xFF, 0x3F, 0x80, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0xFC, 0x1F, 0xBF, 0x0F, 0xCF, 0xC7, 0xE3,
  0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x7E, 0x0F, 0xFF, 0x03, 0xEF, 0x80, 0xFF,
  0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFB, 0xF0, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x1F, 0xBF, 0x03, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF8, 0x3F, 0x1F, 0x7F, 0xCF,
  0xF3, 0xFF, 0xFB, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xF7, 0xFF, 0xFF, 0xF8,
  0x7F, 0x0F, 0xFF, 0x07, 0xE1, 0xFF, 0xE0, 0xF8, 0x3F, 0xFC, 0x1F, 0x07,
  0xFF, 0x83, 0xE0, 0xFF, 0xF0, 0x7C, 0x1F, 0xFE, 0x0F, 0x83, 0xFF, 0xC1,
  0xF0, 0x7F, 0xF8, 0x3E, 0x0F, 0xFF, 0x07, 0xC1, 0xFF, 0xE0, 0xF8, 0x3F,
  0xFC, 0x1F, 0x07, 0xFF, 0x83, 0xE0, 0xFF, 0xF0, 0x7C, 0x1F, 0x80, 0xF0,
  0xF8, 0x7D, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xE0, 0xFB,
  0xF0, 0x7D, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF,
  0xE7, 0xF3, 0xF3, 0xF0, 0xFD, 0xF0, 0x3E, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xF7, 0xC0, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E,
  0x7F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0xF8, 0xF8, 0x7C,
  0xFE, 0x3E, 0xFF, 0x9F, 0xFF, 0xEF, 0xF7, 0xF7, 0xE1, 0xFB, 0xF0, 0x7D,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE1, 0xFB, 0xF8, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x7D, 0xFE, 0x3F,
  0x7E, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x8F, 0x8F, 0xF7, 0xCF,
  0xFB, 0xE7, 0xFF, 0xF7, 0xF7, 0xFB, 0xF0, 0xFD, 0xF0, 0x7F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xF7, 0xC0, 0xFB, 0xF0,
  0xFD, 0xF8, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xF7, 0xC3, 0xF7, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0xF0, 0xFF, 0x9F, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0,
  0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0xFC, 0x33, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x80, 0xFE, 0x01, 0xF8, 0x03, 0xFE, 0x0F,
  0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xC7, 0xFE, 0x00, 0x0E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x3F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F,
  0x13, 0xFF, 0x3F, 0xF1, 0xFF, 0x0F, 0xF0, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFE,
  0x7F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xEF, 0x1F, 0x8F, 0xFC, 0x07, 0xFF,
  0x03, 0xF7, 0xC0, 0xFD, 0xF8, 0x3E, 0x7E, 0x0F, 0x8F, 0x87, 0xE3, 0xE1,
  0xF0, 0xFC, 0x7C, 0x1F, 0x3F, 0x07, 0xCF, 0x80, 0xF3, 0xE0, 0x3E, 0xF8,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0xFC, 0x1F, 0x83, 0xEF, 0x83, 0xF0, 0x7D, 0xF0,
  0xFE, 0x0F, 0xBE, 0x1F, 0xE3, 0xF7, 0xE3, 0xFC, 0x7C, 0x7C, 0x7F, 0x8F,
  0x8F, 0x9E, 0xF1, 0xF1, 0xF3, 0xDE, 0x3E, 0x3E, 0x79, 0xEF, 0x83, 0xEF,
  0x3D, 0xF0, 0x7D, 0xE7, 0xBE, 0x0F, 0xB8, 0xF7, 0xC1, 0xFF, 0x1E, 0xF0,
  0x1F, 0xE1, 0xDE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xE0,
  0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x81, 0xF8, 0x00, 0xFE, 0x0F, 0xDF,
  0x87, 0xE3, 0xF1, 0xF8, 0xFC, 0xFC, 0x1F, 0xBF, 0x07, 0xFF, 0x80, 0xFF,
  0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF0,
  0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFB, 0xF0, 0xFC, 0xFC, 0x3E, 0x1F, 0x9F,
  0x83, 0xFF, 0xC0, 0xFC, 0xFC, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0xFD, 0xF8,
  0x3E, 0x3E, 0x0F, 0x8F, 0x87, 0xE3, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F,
  0x07, 0xCF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x04, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x07, 0xE0, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0xFF, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8,
  0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xF8, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x8F, 0xF1, 0xFC, 0x3E, 0x07,
  0xF0, 0xFF, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x81, 0xFC, 0x3F, 0x87, 0xF0, 0x7E, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0xF0, 0xFF, 0x01,
  0xF0, 0xFF, 0x1F, 0xF1, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFC, 0x08, 0x00, 0x3E,
  0x01, 0x7F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0x7C,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 24, 9, 2, -24 },
  { 19, 13, 9, 17, 2, -24 },
  { 34, 19, 24, 21, 1, -24 },
  { 91, 16, 28, 18, 1, -26 },
  { 147, 28, 25, 30, 1, -25 },
  { 235, 23, 25, 24, 1, -25 },
  { 307, 5, 9, 9, 2, -24 },
  { 313, 10, 30, 11, 1, -25 },
  { 351, 9, 30, 11, 1, -25 },
  { 385, 16, 16, 17, 1, -26 },
  { 417, 16, 16, 18, 1, -20 },
  { 449, 7, 9, 10, 1, -4 },
  { 457, 9, 4, 11, 1, -11 },
  { 462, 6, 6, 9, 2, -6 },
  { 467, 14, 25, 14, 0, -25 },
  { 511, 16, 25, 18, 1, -25 },
  { 561, 12, 24, 18, 2, -24 },
  { 597, 16, 25, 18, 1, -25 },
  { 647, 16, 25, 18, 1, -25 },
  { 697, 17, 24, 18, 1, -24 },
  { 748, 15, 24, 18, 2, -24 },
  { 793, 16, 25, 18, 1, -25 },
  { 843, 16, 24, 18, 1, -24 },
  { 891, 16, 25, 18, 1, -25 },
  { 941, 16, 25, 18, 1, -25 },
  { 991, 6, 19, 9, 2, -19 },
  { 1006, 7, 24, 10, 1, -19 },
  { 1027, 16, 18, 18, 1, -21 },
  { 1063, 16, 11, 18, 1, -17 },
  { 1085, 16, 18, 18, 1, -21 },
  { 1121, 15, 25, 15, 0, -25 },
  { 1168, 26, 28, 29, 1, -25 },
  { 1259, 22, 24, 22, 0, -24 },
  { 1325, 17, 24, 21, 3, -24 },
  { 1376, 17, 25, 20, 2, -25 },
  { 1430, 18, 24, 23, 3, -24 },
  { 1484, 13, 24, 17, 3, -24 },
  { 1523, 13, 24, 17, 3, -24 },
  { 1562, 19, 25, 23, 2, -25 },
  { 1622, 18, 24, 24, 3, -24 },
  { 1676, 11, 24, 13, 1, -24 },
  { 1709, 10, 31, 11, -2, -24 },
  { 1748, 18, 24, 21, 3, -24 },
  { 1802, 14, 24, 17, 3, -24 },
  { 1844, 25, 24, 30, 3, -24 },
  { 1919, 20, 24, 26, 3, -24 },
  { 1979, 21, 25, 25, 2, -25 },
  { 2045, 16, 24, 20, 3, -24 },
  { 2093, 21, 31, 25, 2, -25 },
  { 2175, 18, 24, 21, 3, -24 },
  { 2229, 15, 25, 18, 1, -25 },
  { 2276, 16, 24, 18, 1, -24 },
  { 2324, 19, 24, 24, 2, -24 },
  { 2381, 21, 24, 21, 0, -24 },
  { 2444, 31, 24, 31, 0, -24 },
  { 2537, 21, 24, 21, 0, -24 },
  { 2600, 20, 24, 20, 0, -24 },
  { 2660, 17, 24, 18, 1, -24 },
  { 2711, 8, 31, 11, 2, -25 },
  { 2742, 14, 25, 14, 0, -25 },
  { 2786, 8, 31, 11, 1, -25 },
  { 2817, 18, 15, 19, 0, -24 },
  { 2851, 15, 3, 15, 0, 3 },
  { 2857, 10, 5, 12, 1, -26 },
  { 2864, 16, 19, 19, 1, -19 },
  { 2902, 17, 26, 20, 2, -26 },
  { 2958, 15, 19, 17, 1, -19 },
  { 2994, 17, 26, 20, 1, -26 },
  { 3050, 17, 19, 19, 1, -19 },
  { 3091, 13, 26, 12, 1, -26 },
  { 3134, 17, 27, 20, 1, -19 },
  { 3192, 17, 26, 21, 2, -26 },
  { 3248, 6, 26, 10, 2, -26 },
  { 3268, 10, 34, 10, -2, -26 },
  { 3311, 18, 26, 20, 2, -26 },
  { 3370, 6, 26, 10, 2, -26 },
  { 3390, 27, 19, 31, 2, -19 },
  { 3455, 17, 19, 21, 2, -19 },
  { 3496, 17, 19, 20, 1, -19 },
  { 3537, 17, 27, 20, 2, -19 },
  { 3595, 17, 27, 20, 1, -19 },
  { 3653, 12, 19, 14, 2, -19 },
  { 3682, 14, 19, 16, 1, -19 },
  { 3716, 12, 23, 14, 1, -23 },
  { 3751, 16, 19, 21, 2, -19 },
  { 3789, 18, 19, 19, 0, -19 },
  { 3832, 27, 19, 28, 0, -19 },
  { 3897, 18, 19, 19, 0, -19 },
  { 3940, 18, 27, 19, 0, -19 },
  { 4001, 14, 19, 15, 1, -19 },
  { 4035, 11, 30, 13, 1, -24 },
  { 4077, 4, 34, 17, 6, -26 },
  { 4094, 12, 30, 13, 1, -24 },
  { 4139, 16, 6, 18, 1, -15 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold34pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD34PT7B_H_
