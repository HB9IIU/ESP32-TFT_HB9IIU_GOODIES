#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD13PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0xC0, 0xDE, 0xB4, 0x16, 0x34, 0x7F, 0x7F, 0x2C, 0xFE,
  0x2C, 0x68, 0x68, 0x10, 0x79, 0xF6, 0x87, 0x07, 0x87, 0x4B, 0x7C, 0x60,
  0x40, 0x71, 0x9B, 0x63, 0x68, 0x6F, 0x67, 0x5E, 0x1A, 0xC2, 0x58, 0xCF,
  0x11, 0xC0, 0x3C, 0x36, 0x1B, 0x07, 0x87, 0x9B, 0x7B, 0xBC, 0xFE, 0x7F,
  0x80, 0xFC, 0x7B, 0x69, 0x26, 0xD9, 0x80, 0xE6, 0x23, 0x33, 0x33, 0x26,
  0xC0, 0x30, 0x4F, 0xCC, 0x78, 0xB0, 0x10, 0x20, 0x47, 0xF1, 0x02, 0x04,
  0x00, 0x6D, 0x60, 0xF0, 0xF0, 0x18, 0xC4, 0x63, 0x31, 0x8C, 0xC0, 0x7C,
  0xD9, 0xB7, 0x7E, 0xED, 0xDB, 0x3E, 0x38, 0x37, 0xFB, 0x33, 0x33, 0x30,
  0xFC, 0xD8, 0x30, 0x61, 0x87, 0x1C, 0x7F, 0xFE, 0xFC, 0x98, 0x31, 0xE3,
  0x81, 0x83, 0xFE, 0xF8, 0x1C, 0x38, 0xF1, 0x66, 0xDF, 0xFF, 0x86, 0x0C,
  0xFF, 0xF1, 0xEF, 0x8C, 0x7F, 0xF0, 0x3C, 0xE1, 0x82, 0xEF, 0xDC, 0xD9,
  0xBE, 0x3C, 0xFF, 0xF8, 0x30, 0x61, 0x83, 0x0C, 0x18, 0x70, 0x7C, 0xD9,
  0xB3, 0xE7, 0x8D, 0xB1, 0xB6, 0x7C, 0x7C, 0xDB, 0x37, 0x77, 0xE6, 0x83,
  0x3E, 0x78, 0xF0, 0x3C, 0x6C, 0x00, 0xDA, 0xC0, 0x06, 0x3D, 0xE7, 0x03,
  0x81, 0xC0, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0xC1, 0xE0, 0xF0, 0x73,
  0x9C, 0x20, 0x00, 0xF9, 0x70, 0xC6, 0x30, 0x80, 0x1C, 0x70, 0x3F, 0x30,
  0xF7, 0xB6, 0xDB, 0x6D, 0xB6, 0xFF, 0x92, 0x62, 0x1F, 0x00, 0x1C, 0x3C,
  0x34, 0x36, 0x66, 0x7E, 0x7F, 0xE3, 0xC3, 0xFF, 0x3C, 0xFF, 0xFF, 0x3C,
  0xFF, 0xF8, 0x7F, 0x9C, 0x30, 0xC3, 0x0C, 0x3F, 0x7C, 0xFD, 0xFB, 0x1E,
  0x3C, 0x78, 0xF3, 0xFE, 0xF8, 0xFE, 0x31, 0xFF, 0xE3, 0x1F, 0xF8, 0xFE,
  0x31, 0x8F, 0xE3, 0x18, 0xC0, 0x7F, 0xCB, 0x06, 0x0D, 0xF8, 0xF1, 0xFF,
  0x7E, 0xC7, 0x8F, 0x1F, 0xFF, 0xF8, 0xF1, 0xE3, 0xC6, 0xFB, 0x9C, 0xE7,
  0x39, 0xCE, 0xF8, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFE, 0xCF, 0x9B, 0x67,
  0xCF, 0x9F, 0x37, 0x66, 0xCE, 0xC6, 0x31, 0x8C, 0x63, 0x1F, 0xF8, 0xE1,
  0xF8, 0xFF, 0x3F, 0xCB, 0xD6, 0xF7, 0xBD, 0xCF, 0x73, 0xCC, 0xC0, 0xE3,
  0xF3, 0xF3, 0xFB, 0xDB, 0xDF, 0xCF, 0xCF, 0xC7, 0x7C, 0xEE, 0xC7, 0xC7,
  0xC3, 0xC7, 0xC6, 0xFE, 0x7C, 0xFB, 0x7C, 0xF3, 0xFF, 0xCC, 0x30, 0xC0,
  0x7C, 0xEE, 0xC7, 0xC7, 0xC3, 0xC7, 0xC6, 0xFE, 0x7C, 0x0C, 0x07, 0xF9,
  0xBB, 0x36, 0x6F, 0x9B, 0x37, 0x66, 0xCE, 0x7D, 0xB6, 0x1C, 0x3C, 0x70,
  0xFF, 0xF8, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xFF, 0x7C, 0xC3, 0x67, 0x66, 0x66, 0x66, 0x3C,
  0x3C, 0x3C, 0x18, 0xC6, 0x3C, 0x66, 0x6F, 0x66, 0xF6, 0x6F, 0x66, 0x96,
  0x29, 0xC3, 0x9C, 0x39, 0xC0, 0xE7, 0x66, 0x3C, 0x3C, 0x18, 0x3C, 0x7E,
  0x66, 0xE7, 0xE7, 0x66, 0x6C, 0x3C, 0x38, 0x18, 0x18, 0x18, 0x18, 0xFE,
  0x18, 0x30, 0xC3, 0x06, 0x18, 0x7F, 0xFE, 0xFB, 0x6D, 0xB6, 0xDB, 0x80,
  0xC3, 0x18, 0xC3, 0x18, 0x43, 0x18, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x10,
  0x70, 0xA3, 0x64, 0x58, 0xC0, 0xFC, 0xCC, 0x7C, 0x98, 0x3B, 0xFE, 0xFD,
  0xDD, 0x80, 0xC3, 0x0C, 0x3E, 0xFF, 0x3C, 0xF3, 0xFF, 0xE0, 0x7F, 0x71,
  0x8C, 0x7D, 0xE0, 0x0C, 0x30, 0xFF, 0xDF, 0x3C, 0xF3, 0xFF, 0xB0, 0x7B,
  0x6C, 0xFF, 0xC3, 0xA7, 0x80, 0x3B, 0xD9, 0xF6, 0x31, 0x8C, 0x63, 0x00,
  0xFF, 0x7C, 0xF3, 0xCF, 0xFE, 0xC3, 0xFF, 0xE0, 0xC3, 0x0C, 0x3F, 0xFF,
  0x3C, 0xF3, 0xCF, 0x30, 0xF3, 0xFF, 0xF0, 0x33, 0x03, 0x33, 0x33, 0x33,
  0x3F, 0xE0, 0xC1, 0x83, 0x0E, 0x6D, 0x9E, 0x3C, 0x6C, 0xDD, 0x9C, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCC, 0xFF,
  0xFC, 0xF3, 0xCF, 0x3C, 0xC0, 0x7B, 0x7C, 0xF3, 0xCF, 0xF7, 0x80, 0xFB,
  0xFC, 0xF3, 0xCF, 0xFF, 0xB0, 0xC3, 0x00, 0xFF, 0x7C, 0xF3, 0xCF, 0xFE,
  0xC3, 0x0C, 0x30, 0xFF, 0xCC, 0xCC, 0xC0, 0x7B, 0xA7, 0x1E, 0x1F, 0xEF,
  0x80, 0x23, 0x3E, 0xC6, 0x31, 0x8F, 0x38, 0xCF, 0x3C, 0xF3, 0xCF, 0xFF,
  0xC0, 0xC6, 0xD9, 0xB3, 0x62, 0x87, 0x0E, 0x00, 0xCE, 0xED, 0xD9, 0xBB,
  0x3D, 0x67, 0xA8, 0x67, 0x0C, 0xE0, 0xEE, 0xD8, 0xE1, 0xC3, 0xCD, 0xBB,
  0x80, 0xC6, 0xDD, 0xB3, 0x62, 0x87, 0x0E, 0x18, 0x70, 0xC0, 0xFB, 0xE3,
  0x8C, 0x63, 0xFF, 0xC0, 0x39, 0x8C, 0x66, 0x71, 0xC6, 0x31, 0x8E, 0xFF,
  0xFF, 0xFF, 0xC0, 0xE3, 0x08, 0x43, 0x0C, 0xC4, 0x23, 0x38, 0x63, 0xFE,
  0x30,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 4, 1, -9 },
  { 4, 5, 3, 6, 1, -9 },
  { 6, 8, 9, 8, 0, -9 },
  { 15, 7, 11, 7, 0, -10 },
  { 25, 11, 9, 11, 0, -9 },
  { 38, 9, 9, 9, 0, -9 },
  { 49, 2, 3, 3, 1, -9 },
  { 50, 3, 11, 4, 1, -9 },
  { 55, 4, 11, 4, 0, -9 },
  { 61, 6, 6, 7, 0, -10 },
  { 66, 7, 7, 7, 0, -8 },
  { 73, 3, 4, 4, 0, -2 },
  { 75, 4, 1, 4, 0, -4 },
  { 76, 2, 2, 4, 1, -2 },
  { 77, 5, 9, 5, 0, -9 },
  { 83, 7, 9, 7, 0, -9 },
  { 91, 4, 9, 7, 1, -9 },
  { 96, 7, 9, 7, 0, -9 },
  { 104, 7, 9, 7, 0, -9 },
  { 112, 7, 9, 7, 0, -9 },
  { 120, 5, 9, 7, 1, -9 },
  { 126, 7, 9, 7, 0, -9 },
  { 134, 7, 9, 7, 0, -9 },
  { 142, 7, 9, 7, 0, -9 },
  { 150, 7, 9, 7, 0, -9 },
  { 158, 2, 7, 4, 1, -7 },
  { 160, 3, 9, 4, 0, -7 },
  { 164, 7, 7, 7, 0, -8 },
  { 171, 7, 5, 7, 0, -7 },
  { 176, 7, 7, 7, 0, -8 },
  { 183, 6, 9, 6, 0, -9 },
  { 190, 9, 10, 11, 1, -9 },
  { 202, 8, 9, 8, 0, -9 },
  { 211, 6, 9, 8, 1, -9 },
  { 218, 6, 9, 8, 1, -9 },
  { 225, 7, 9, 9, 1, -9 },
  { 233, 5, 9, 7, 1, -9 },
  { 239, 5, 9, 7, 1, -9 },
  { 245, 7, 9, 9, 1, -9 },
  { 253, 7, 9, 9, 1, -9 },
  { 261, 5, 9, 5, 0, -9 },
  { 267, 4, 12, 4, -1, -9 },
  { 273, 7, 9, 8, 1, -9 },
  { 281, 5, 9, 7, 1, -9 },
  { 287, 10, 9, 12, 1, -9 },
  { 299, 8, 9, 10, 1, -9 },
  { 308, 8, 9, 9, 1, -9 },
  { 317, 6, 9, 8, 1, -9 },
  { 324, 8, 11, 9, 1, -9 },
  { 335, 7, 9, 8, 1, -9 },
  { 343, 6, 9, 7, 0, -9 },
  { 350, 7, 9, 7, 0, -9 },
  { 358, 7, 9, 9, 1, -9 },
  { 366, 8, 9, 8, 0, -9 },
  { 375, 12, 9, 12, 0, -9 },
  { 389, 8, 9, 8, 0, -9 },
  { 398, 8, 9, 8, 0, -9 },
  { 407, 7, 9, 7, 0, -9 },
  { 415, 3, 11, 4, 1, -9 },
  { 420, 5, 9, 5, 0, -9 },
  { 426, 3, 11, 4, 0, -9 },
  { 431, 7, 6, 7, 0, -9 },
  { 437, 6, 1, 6, 0, 1 },
  { 438, 3, 2, 5, 1, -10 },
  { 439, 7, 7, 7, 0, -7 },
  { 446, 6, 10, 8, 1, -10 },
  { 454, 5, 7, 6, 1, -7 },
  { 459, 6, 10, 8, 1, -10 },
  { 467, 6, 7, 7, 1, -7 },
  { 473, 5, 10, 5, 0, -10 },
  { 480, 6, 10, 8, 1, -7 },
  { 488, 6, 10, 8, 1, -10 },
  { 496, 2, 10, 4, 1, -10 },
  { 499, 4, 13, 4, -1, -10 },
  { 506, 7, 10, 8, 1, -10 },
  { 515, 2, 10, 4, 1, -10 },
  { 518, 10, 7, 12, 1, -7 },
  { 527, 6, 7, 8, 1, -7 },
  { 533, 6, 7, 8, 1, -7 },
  { 539, 6, 10, 8, 1, -7 },
  { 547, 6, 10, 8, 1, -7 },
  { 555, 4, 7, 5, 1, -7 },
  { 559, 6, 7, 6, 0, -7 },
  { 565, 5, 9, 5, 0, -9 },
  { 571, 6, 7, 8, 1, -7 },
  { 577, 7, 7, 7, 0, -7 },
  { 584, 11, 7, 11, 0, -7 },
  { 594, 7, 7, 7, 0, -7 },
  { 601, 7, 10, 7, 0, -7 },
  { 610, 6, 7, 6, 0, -7 },
  { 616, 5, 11, 5, 0, -9 },
  { 623, 2, 13, 6, 2, -10 },
  { 627, 5, 11, 5, 0, -9 },
  { 634, 7, 3, 7, 0, -6 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold13pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD13PT7B_H_
