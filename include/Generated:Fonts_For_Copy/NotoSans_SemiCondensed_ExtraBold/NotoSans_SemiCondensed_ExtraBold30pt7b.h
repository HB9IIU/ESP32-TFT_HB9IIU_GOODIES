#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD30PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x79, 0xE7, 0x9E, 0x79, 0xE0,
  0x00, 0x39, 0xFF, 0xDF, 0x78, 0xF3, 0xFE, 0x7F, 0xCF, 0xF8, 0xFF, 0x1F,
  0xE3, 0xFC, 0x70, 0x07, 0x9E, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE7, 0x80,
  0xF3, 0xC3, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0x3C,
  0x07, 0x9E, 0x03, 0xCE, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0x39,
  0xE0, 0x3C, 0xF0, 0x1E, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x9E, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x78, 0x0F, 0xFF, 0x7F, 0xF9, 0xFF, 0xEF, 0xB3,
  0xBE, 0xC0, 0xFB, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0xDF, 0x03, 0x3F, 0x0D, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xF0, 0x7F, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x3F,
  0x80, 0xF0, 0x1F, 0xE0, 0x70, 0x1F, 0xF0, 0x78, 0x0F, 0x38, 0x38, 0x07,
  0x9E, 0x3C, 0x03, 0xCF, 0x1C, 0x01, 0xE7, 0x9E, 0x00, 0xF3, 0xCE, 0x00,
  0x79, 0xEF, 0x3E, 0x3D, 0xE7, 0x3F, 0x8F, 0xF7, 0xBF, 0xE3, 0xF3, 0x9E,
  0xF0, 0x63, 0xCE, 0x38, 0x01, 0xC7, 0x1E, 0x01, 0xE3, 0x8F, 0x00, 0xE1,
  0xC7, 0x80, 0xF0, 0xE3, 0x80, 0x70, 0x7B, 0xC0, 0x78, 0x3F, 0xE0, 0x38,
  0x0F, 0xE0, 0x3C, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x3E, 0x7C, 0x03, 0xC7, 0xC0, 0x3C, 0x7C, 0x03, 0xEF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xC3, 0xE3, 0xFE, 0x3E, 0x7F,
  0xE3, 0xEF, 0xDF, 0x7C, 0xF8, 0xFF, 0xCF, 0x8F, 0xFC, 0xF8, 0x7F, 0x8F,
  0xC3, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x87, 0x87, 0x87, 0xC3, 0xC1, 0xE1, 0xF0,
  0xF0, 0x78, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C,
  0x1E, 0x0F, 0x07, 0xC3, 0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xC0, 0xF0,
  0xF8, 0x78, 0x7C, 0x3C, 0x3E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x7C, 0x78,
  0xF8, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0xE7, 0x3B, 0xFF,
  0xEF, 0xFF, 0xBF, 0xFF, 0x0F, 0xC0, 0x7F, 0x03, 0xDE, 0x1F, 0x3C, 0x38,
  0xE0, 0x22, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x7D, 0xF7, 0x9E, 0x7B, 0xCF, 0x3C,
  0xFF, 0xFF, 0xFF, 0xFF, 0x39, 0xFF, 0xDF, 0x78, 0x00, 0xF8, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C,
  0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x00, 0x03, 0x80, 0x7F, 0x83,
  0xFF, 0x1F, 0xFE, 0x7C, 0xF9, 0xF1, 0xEF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0x78, 0x7D, 0xF3, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F, 0xF0, 0x3F, 0x00, 0x03,
  0xE0, 0xFC, 0x3F, 0x8F, 0xF3, 0xFF, 0xFB, 0xDE, 0x79, 0x9F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xFF, 0x87, 0xFF, 0x3F, 0xFE, 0x7D,
  0xF8, 0xC3, 0xF2, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x81, 0xFF, 0x8F, 0xFF,
  0x9F, 0xFE, 0x79, 0xF8, 0x81, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x7F,
  0xC1, 0xFC, 0x07, 0xF8, 0x1F, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7E, 0x03, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF1, 0xFF, 0x00, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0x78,
  0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x78, 0x78, 0x78, 0x78, 0x78,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE7, 0xFF, 0x88,
  0x7F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xC0, 0xFF, 0xFF, 0xEF,
  0xFF, 0xBF, 0xFC, 0x7F, 0xC0, 0x00, 0xF8, 0x1F, 0xE1, 0xFF, 0x8F, 0xFE,
  0x3F, 0x09, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xFB, 0xE3, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x7D, 0xF1,
  0xF7, 0xFF, 0xCF, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0x7F,
  0xC3, 0xFF, 0x9F, 0xFE, 0x7C, 0x7D, 0xE1, 0xF7, 0x87, 0xDF, 0x3E, 0x7F,
  0xF8, 0xFF, 0xC1, 0xFE, 0x07, 0xF8, 0x7F, 0xF9, 0xF3, 0xEF, 0x87, 0xFE,
  0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0xDF, 0xFE, 0x7F, 0xF8, 0x7F, 0x80,
  0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1F, 0xFE, 0xFC, 0xFB, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0xCF, 0xDF, 0xFF, 0x7F, 0xBC, 0xFE,
  0xF0, 0xE7, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE7, 0xFF, 0x1F, 0xF8, 0x7F,
  0xC1, 0xFE, 0x00, 0x31, 0xFF, 0xDF, 0x78, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x39, 0xFF, 0xDF, 0x78, 0x31, 0xF7, 0xDF, 0x7C, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF7, 0xDE, 0x79, 0xEF, 0x3C, 0xF0, 0x00, 0x04, 0x00, 0x30,
  0x03, 0xC0, 0x3F, 0x03, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x80, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFC, 0x01, 0xF0, 0x01, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7C, 0x0F, 0xF0, 0xFF, 0x1F,
  0xF0, 0xFF, 0x03, 0xF0, 0x0E, 0x00, 0x20, 0x00, 0x0F, 0x03, 0xFF, 0x3F,
  0xFC, 0xFF, 0xF7, 0x9F, 0xA0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F,
  0x81, 0xF8, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7E, 0x0F, 0x81, 0xF0, 0x07, 0x87, 0x80,
  0x07, 0x8F, 0x1F, 0xE7, 0x3C, 0x7F, 0xCF, 0x71, 0xFF, 0x9E, 0xE7, 0x87,
  0x1F, 0xCF, 0x1E, 0x3F, 0x9E, 0x3C, 0x7F, 0x38, 0x79, 0xFE, 0x70, 0xF3,
  0xFC, 0xF1, 0xE7, 0x79, 0xE7, 0xDE, 0x71, 0xFF, 0xF8, 0xF1, 0xFB, 0xF1,
  0xE1, 0xC1, 0x81, 0xE0, 0x00, 0x03, 0xE0, 0x04, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0x7C, 0x03, 0xEF, 0x80, 0x7C, 0xF0,
  0x0F, 0x9F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x87, 0xC1, 0xFF, 0xF8,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x7E, 0x07, 0xCF, 0x80, 0xF9,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3E, 0xFF, 0xF1, 0xFF, 0xFB, 0xFF,
  0xF7, 0xCF, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x3E, 0xFF, 0xFD,
  0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xCF, 0xFE, 0x00, 0x00,
  0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3E, 0x02, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x02, 0x3F,
  0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F,
  0xFF, 0x1F, 0xFF, 0xCF, 0x83, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0,
  0xFB, 0xE0, 0x7D, 0xF0, 0x7E, 0xF8, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F,
  0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0xFF,
  0xC3, 0xFF, 0xE3, 0xFF, 0xE3, 0xFC, 0xF1, 0xF8, 0x09, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x1F, 0xFF, 0x8F, 0xF7, 0xC7, 0xFB,
  0xE3, 0xFD, 0xF0, 0x3E, 0xF8, 0x1F, 0x7E, 0x0F, 0x9F, 0x87, 0xCF, 0xFF,
  0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xF8, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0xCF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0xFF, 0xFF, 0x7F,
  0xBF, 0x04, 0x00, 0xF8, 0x1F, 0xFC, 0x1F, 0x3E, 0x1F, 0x9F, 0x0F, 0x8F,
  0x8F, 0x87, 0xCF, 0xC3, 0xE7, 0xC1, 0xF7, 0xC0, 0xFB, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xCF, 0xC3, 0xE3, 0xE1, 0xF1,
  0xF8, 0xF8, 0x7C, 0x7C, 0x3F, 0x3E, 0x0F, 0x9F, 0x07, 0xEF, 0x81, 0xF8,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03,
  0xFF, 0xDE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xEF, 0xFB, 0xC7, 0xBF,
  0xEF, 0x1E, 0xFF, 0xBC, 0x73, 0xFE, 0xF3, 0xCF, 0xF9, 0xEF, 0x3F, 0xE7,
  0xBC, 0xFF, 0x9F, 0xE3, 0xFE, 0x7F, 0x8F, 0xF8, 0xFE, 0x3F, 0xE3, 0xF0,
  0xFF, 0x8F, 0xC3, 0xFE, 0x1F, 0x0F, 0xF8, 0x78, 0x3C, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x0F, 0xFB, 0xE3, 0xFE, 0xF8, 0xFF, 0x9F, 0x3F, 0xE7, 0xEF,
  0xF8, 0xFB, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFB, 0xFC, 0xFC, 0x0F, 0x9F,
  0x01, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x3F, 0x7E,
  0x07, 0xE7, 0xE1, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07,
  0xF8, 0x00, 0xFF, 0xE3, 0xFF, 0xEF, 0xFF, 0xBF, 0xFF, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xEF, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF,
  0xE3, 0xFE, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF,
  0xC3, 0xFB, 0xFC, 0xFC, 0x0F, 0x9F, 0x01, 0xFB, 0xE0, 0x1F, 0x7C, 0x03,
  0xEF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07,
  0xDF, 0x00, 0xFB, 0xE0, 0x3F, 0x7E, 0x07, 0xE7, 0xE1, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xE0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x1F, 0x7F, 0x8F, 0x87, 0xC7, 0xC3, 0xF3, 0xE1, 0xF9, 0xF0,
  0xF8, 0xF8, 0x7C, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0x07,
  0xCF, 0x83, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x0F,
  0x9F, 0x07, 0xEF, 0x81, 0xF8, 0x07, 0x80, 0xFF, 0xCF, 0xFE, 0xFF, 0xF7,
  0xEF, 0x7C, 0x0B, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x81, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7F, 0x07, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF8, 0x3E, 0x7C, 0x1F, 0x3F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF,
  0x80, 0xFF, 0x00, 0xF8, 0x07, 0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x07,
  0xC7, 0xC0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0xF8, 0x1F, 0x1F,
  0x03, 0xE3, 0xE0, 0x7C, 0x78, 0x07, 0x9F, 0x00, 0xFB, 0xE0, 0x1F, 0x78,
  0x01, 0xEF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x1F, 0x03, 0xEF, 0x03, 0xE0, 0x7D,
  0xE0, 0x7E, 0x0F, 0xBE, 0x0F, 0xC1, 0xF7, 0xC3, 0xF8, 0x3C, 0xF8, 0x7F,
  0x0F, 0x8F, 0x0F, 0xF1, 0xF1, 0xE1, 0xFE, 0x3E, 0x3E, 0x7B, 0xC7, 0x87,
  0xCF, 0x78, 0xF0, 0x79, 0xE7, 0x3E, 0x0F, 0x3C, 0xF7, 0xC1, 0xE7, 0x9E,
  0xF8, 0x3F, 0xE3, 0xDE, 0x03, 0xFC, 0x7B, 0xC0, 0x7F, 0x87, 0xF8, 0x0F,
  0xF0, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x03, 0xF0, 0x3F,
  0x00, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8, 0x7C, 0x0F,
  0x8F, 0x81, 0xF3, 0xE0, 0x1F, 0x7C, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F,
  0xF8, 0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x1F, 0x07, 0xC3, 0xE1, 0xF8,
  0x3E, 0x3E, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xDF, 0x03, 0xE7, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x3E, 0x07, 0xCF, 0x81, 0xF7, 0xC0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x7F, 0xFF, 0xFF, 0xF8, 0xF8, 0x03, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x1C,
  0x3C, 0x3C, 0x3C, 0x38, 0x1E, 0x78, 0x1E, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x3F, 0x07, 0x81, 0xE0, 0x78, 0x07, 0xC0, 0xFF,
  0xC3, 0xFF, 0x8F, 0xFF, 0x10, 0x7C, 0x01, 0xF0, 0x07, 0xC7, 0xFF, 0x7F,
  0xFD, 0xFF, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xF3, 0xFF, 0xFF, 0xDF,
  0xEF, 0x3F, 0x3C, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x78, 0x7D, 0xF8, 0xFF, 0xF9, 0xFF, 0xFB, 0xF3, 0xF7,
  0xC3, 0xEF, 0x87, 0xDF, 0x07, 0xBE, 0x0F, 0xFC, 0x1E, 0xF8, 0x7D, 0xF0,
  0xFB, 0xE1, 0xF7, 0xFF, 0xEF, 0xFF, 0x9E, 0xFF, 0x3C, 0xFC, 0x00, 0x03,
  0xC0, 0xFF, 0xCF, 0xFC, 0xFF, 0xE7, 0xE3, 0x3E, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC1, 0x3F, 0xF8, 0xFF, 0xC7,
  0xFE, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC3, 0xCF, 0x8F, 0xDF, 0x3F, 0xFE, 0xFF, 0xFD, 0xF9, 0xFB,
  0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7D, 0xF0, 0xFB, 0xFF, 0xF7, 0xFF, 0xE7, 0xFF, 0xC7, 0xE7, 0x80, 0x07,
  0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xCF, 0x07, 0xBE, 0x0F,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x4F,
  0xE7, 0x8F, 0xFF, 0x0F, 0xFE, 0x0F, 0xF8, 0x07, 0xE0, 0xFF, 0x1F, 0xE1,
  0xFE, 0x1F, 0x01, 0xE0, 0x1E, 0x07, 0xFE, 0xFF, 0xEF, 0xFE, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x1E, 0x3F, 0x7C, 0xFF, 0xFB,
  0xFF, 0xF7, 0xC7, 0xEF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xF7, 0xC3, 0xEF, 0xFF, 0xDF, 0xFF, 0x9F, 0xFF,
  0x1F, 0xBE, 0x00, 0x7C, 0x00, 0xFA, 0x03, 0xE7, 0xFF, 0xCF, 0xFF, 0x9F,
  0xFE, 0x1F, 0xF0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x9E, 0x3E, 0xFE, 0xF7, 0xFB, 0xFF, 0xFF, 0xCF, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xC0, 0xF7, 0xFF, 0xF7, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E,
  0x1F, 0x1F, 0x1F, 0x0C, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0xFF, 0xFE, 0xFE, 0xF8, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8,
  0xF8, 0xF9, 0xF0, 0xFB, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFF, 0xF0, 0xF9, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8,
  0x7E, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF1, 0xE0, 0xF1, 0xEF, 0xF3, 0xFB,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xE3, 0xFF, 0x0F, 0xC7, 0xFE,
  0x1F, 0x0F, 0xFC, 0x3E, 0x0F, 0xF8, 0x7C, 0x1F, 0xF0, 0xF8, 0x3F, 0xE1,
  0xF0, 0x7F, 0xC3, 0xE0, 0xFF, 0x87, 0xC1, 0xFF, 0x0F, 0x83, 0xFE, 0x1F,
  0x07, 0xFC, 0x3E, 0x0F, 0xF8, 0x7C, 0x1E, 0xF1, 0xE3, 0xDF, 0xEF, 0x7F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3C, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xCF, 0x87,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFB, 0xC1, 0xF7,
  0xC3, 0xEF, 0xDF, 0x8F, 0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0xF1, 0xE1, 0xE7,
  0xE3, 0xDF, 0xE7, 0xFF, 0xEF, 0xCF, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x1E,
  0xF8, 0x3F, 0xF0, 0x7B, 0xE1, 0xF7, 0xC3, 0xEF, 0xC7, 0xDF, 0xFF, 0xBF,
  0xFE, 0x7F, 0xFC, 0xFB, 0xE1, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0x1E, 0x3F, 0x7C, 0xFF, 0xFB,
  0xFF, 0xF7, 0xC7, 0xEF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xF7, 0xC3, 0xEF, 0xFF, 0xDF, 0xFF, 0x9F, 0xFF,
  0x1F, 0xBE, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0xF1, 0xFC, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x00, 0x0F, 0x83, 0xFF, 0x7F, 0xEF, 0xFE, 0xF8, 0x6F, 0x80, 0xFE, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x1F, 0x81, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFE, 0x7F, 0x80, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFD,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x3F,
  0xCF, 0xF3, 0xFC, 0x7F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xEF, 0x3F, 0x3C, 0xF8, 0x1F,
  0xF8, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0x7C, 0x3E, 0x3C, 0x3E, 0x3E, 0x3C,
  0x3E, 0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x7E, 0x1F, 0x78,
  0x7E, 0x1F, 0x7C, 0x7F, 0x1E, 0x7C, 0x7F, 0x1E, 0x3C, 0xFF, 0x3E, 0x3C,
  0xF7, 0x3E, 0x3E, 0xF7, 0x3C, 0x3E, 0xE7, 0xBC, 0x1E, 0xE7, 0xBC, 0x1E,
  0xE7, 0xFC, 0x1F, 0xE3, 0xF8, 0x1F, 0xE3, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F,
  0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF0, 0xFC, 0x3F, 0x7E, 0x3E,
  0x3E, 0x7C, 0x1F, 0x7C, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x3E, 0x7C, 0x3E, 0x3E,
  0x7C, 0x3E, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E,
  0x7C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x1F, 0x78,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x43, 0xF1, 0xFC, 0x7F, 0x1F,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0xFC, 0x3C, 0x0F,
  0xC3, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7F,
  0x1F, 0xC3, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x3E, 0x0F, 0xC3, 0xF8, 0x3E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0xC1, 0xF0, 0xFC, 0x7F,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE3, 0xF8, 0xFC, 0x3F,
  0x0F, 0x00, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x80, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 21, 8, 1, -21 },
  { 17, 11, 7, 15, 2, -21 },
  { 27, 17, 21, 18, 1, -21 },
  { 72, 14, 25, 16, 1, -23 },
  { 116, 25, 22, 26, 1, -22 },
  { 185, 20, 22, 21, 1, -22 },
  { 240, 4, 7, 8, 2, -21 },
  { 244, 9, 27, 10, 1, -22 },
  { 275, 8, 27, 10, 1, -22 },
  { 302, 14, 14, 15, 1, -23 },
  { 327, 14, 15, 16, 1, -18 },
  { 354, 6, 8, 8, 1, -4 },
  { 360, 8, 4, 10, 1, -10 },
  { 364, 6, 5, 8, 1, -5 },
  { 368, 13, 22, 13, 0, -22 },
  { 404, 14, 22, 16, 1, -22 },
  { 443, 11, 21, 16, 1, -21 },
  { 472, 14, 22, 16, 1, -22 },
  { 511, 14, 22, 16, 1, -22 },
  { 550, 16, 21, 16, 0, -21 },
  { 592, 14, 21, 16, 1, -21 },
  { 629, 14, 22, 16, 1, -22 },
  { 668, 14, 21, 16, 1, -21 },
  { 705, 14, 22, 16, 1, -22 },
  { 744, 14, 22, 16, 1, -22 },
  { 783, 6, 17, 8, 1, -17 },
  { 796, 6, 21, 8, 1, -17 },
  { 812, 14, 16, 16, 1, -19 },
  { 840, 14, 9, 16, 1, -15 },
  { 856, 14, 16, 16, 1, -19 },
  { 884, 13, 22, 14, 0, -22 },
  { 920, 23, 24, 25, 1, -22 },
  { 989, 19, 21, 19, 0, -21 },
  { 1039, 15, 21, 19, 2, -21 },
  { 1079, 16, 22, 18, 1, -22 },
  { 1123, 17, 21, 20, 2, -21 },
  { 1168, 12, 21, 15, 2, -21 },
  { 1200, 12, 21, 15, 2, -21 },
  { 1232, 17, 22, 20, 1, -22 },
  { 1279, 17, 21, 21, 2, -21 },
  { 1324, 10, 21, 11, 1, -21 },
  { 1351, 9, 28, 10, -2, -21 },
  { 1383, 17, 21, 19, 2, -21 },
  { 1428, 13, 21, 15, 2, -21 },
  { 1463, 22, 21, 27, 2, -21 },
  { 1521, 18, 21, 23, 2, -21 },
  { 1569, 19, 22, 22, 1, -22 },
  { 1622, 14, 21, 17, 2, -21 },
  { 1659, 19, 27, 22, 1, -22 },
  { 1724, 17, 21, 18, 2, -21 },
  { 1769, 13, 22, 16, 1, -22 },
  { 1805, 14, 21, 16, 1, -21 },
  { 1842, 17, 21, 21, 2, -21 },
  { 1887, 19, 21, 19, 0, -21 },
  { 1937, 27, 21, 28, 0, -21 },
  { 2008, 19, 21, 19, 0, -21 },
  { 2058, 18, 21, 18, 0, -21 },
  { 2106, 14, 21, 16, 1, -21 },
  { 2143, 7, 27, 10, 2, -22 },
  { 2167, 13, 22, 13, 0, -22 },
  { 2203, 7, 27, 10, 1, -22 },
  { 2227, 16, 13, 16, 0, -21 },
  { 2253, 14, 3, 14, 0, 2 },
  { 2259, 9, 5, 11, 1, -23 },
  { 2265, 14, 17, 17, 1, -17 },
  { 2295, 15, 23, 18, 2, -23 },
  { 2339, 13, 17, 15, 1, -17 },
  { 2367, 15, 23, 18, 1, -23 },
  { 2411, 15, 17, 17, 1, -17 },
  { 2443, 12, 23, 11, 0, -23 },
  { 2478, 15, 24, 18, 1, -17 },
  { 2523, 14, 23, 18, 2, -23 },
  { 2564, 5, 23, 9, 2, -23 },
  { 2579, 8, 30, 9, -1, -23 },
  { 2609, 16, 23, 18, 2, -23 },
  { 2655, 5, 23, 9, 2, -23 },
  { 2670, 23, 17, 27, 2, -17 },
  { 2719, 14, 17, 18, 2, -17 },
  { 2749, 15, 17, 17, 1, -17 },
  { 2781, 15, 24, 18, 2, -17 },
  { 2826, 15, 24, 18, 1, -17 },
  { 2871, 10, 17, 13, 2, -17 },
  { 2893, 12, 17, 14, 1, -17 },
  { 2919, 10, 20, 12, 1, -20 },
  { 2944, 14, 17, 18, 2, -17 },
  { 2974, 16, 17, 16, 0, -17 },
  { 3008, 24, 16, 25, 0, -16 },
  { 3056, 16, 16, 16, 0, -16 },
  { 3088, 16, 24, 16, 0, -17 },
  { 3136, 12, 17, 14, 1, -17 },
  { 3162, 10, 27, 12, 1, -22 },
  { 3196, 3, 30, 15, 6, -23 },
  { 3208, 10, 27, 12, 1, -22 },
  { 3242, 14, 5, 16, 1, -13 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold30pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD30PT7B_H_
