#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD24PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBD, 0xEF, 0x7B, 0xCE, 0x73, 0x9C, 0x00, 0x3B, 0xDE, 0x70,
  0xF3, 0xF9, 0xDC, 0xEE, 0x77, 0x3B, 0x9C, 0x07, 0x30, 0x1D, 0xC0, 0x67,
  0x03, 0x9C, 0x0E, 0x71, 0xFF, 0xF7, 0xFF, 0xC3, 0x38, 0x0C, 0xE0, 0x73,
  0x8F, 0xFF, 0xBF, 0xFE, 0x1C, 0xC0, 0x67, 0x01, 0x9C, 0x0E, 0x70, 0x39,
  0xC0, 0x04, 0x00, 0xC0, 0xFF, 0xBF, 0xEF, 0xFD, 0xC8, 0x3D, 0x07, 0xE0,
  0x7F, 0x07, 0xF8, 0x3F, 0x82, 0xF0, 0x4F, 0x0B, 0xFF, 0xFF, 0xFE, 0x7F,
  0x80, 0x80, 0x10, 0x00, 0x7C, 0x0E, 0x1F, 0xC3, 0x83, 0xB8, 0x70, 0x73,
  0x1C, 0x0E, 0x73, 0x81, 0xCE, 0xE0, 0x3B, 0x9C, 0x47, 0x77, 0x3E, 0xFE,
  0xEF, 0xEF, 0xB9, 0xDC, 0x07, 0x3B, 0x81, 0xCE, 0x70, 0x38, 0xCE, 0x06,
  0x1D, 0xC1, 0xC3, 0xB8, 0x38, 0x7F, 0x0E, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0xC0, 0x7F, 0xE0, 0x79, 0xE0, 0x79, 0xE0, 0x3B, 0xC0, 0x3F, 0xC0, 0x1F,
  0x80, 0x7F, 0x1E, 0x7F, 0x9E, 0xF7, 0xFC, 0xF3, 0xFC, 0xF1, 0xF8, 0xF0,
  0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0x9F, 0xFF, 0x77, 0x77, 0x1E, 0x70,
  0xE3, 0xC7, 0x0E, 0x3C, 0x78, 0xE1, 0xC3, 0x87, 0x0F, 0x1E, 0x3C, 0x38,
  0x70, 0xF0, 0xE1, 0xE1, 0xE0, 0xF0, 0x70, 0xF1, 0xE1, 0xC3, 0xC7, 0x8F,
  0x0E, 0x1C, 0x38, 0x70, 0xE3, 0xC7, 0x8E, 0x1C, 0x78, 0xE3, 0xC7, 0x00,
  0x1E, 0x01, 0xC2, 0x30, 0xF6, 0xEF, 0xFF, 0xFF, 0xC7, 0xC1, 0xF8, 0x7B,
  0x8E, 0x78, 0x48, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x7B, 0xBD, 0xEE, 0x70,
  0xFF, 0xFF, 0xC0, 0x7F, 0xF7, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x03,
  0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81,
  0xC0, 0xF0, 0x00, 0x3F, 0x0F, 0xF1, 0xFF, 0x78, 0xEF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1E, 0xF7, 0x9F, 0xF1,
  0xFC, 0x1F, 0x00, 0x07, 0x87, 0xC7, 0xEF, 0xFF, 0xFB, 0xBC, 0x9E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x80, 0x3F,
  0x9F, 0xFB, 0xFF, 0x31, 0xF4, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x81,
  0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0x9F, 0xF9, 0xFF, 0x21, 0xF0, 0x1E, 0x07, 0x81, 0xF1, 0xF8, 0x3F, 0x87,
  0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x07, 0xFF, 0xF7, 0xFE, 0xFF, 0x00, 0x01,
  0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x77, 0x87, 0xBC,
  0x39, 0xE3, 0x8F, 0x1C, 0x79, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x7F, 0xCF, 0xF9, 0xFF, 0x38, 0x07, 0x00, 0xE0, 0x1F,
  0xC7, 0xFE, 0xFF, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x1F, 0x07, 0xFF, 0xF7,
  0xFC, 0xFF, 0x00, 0x0F, 0xC7, 0xF8, 0xFF, 0x3C, 0x07, 0x01, 0xE0, 0x3B,
  0xE7, 0x7E, 0xFF, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xDF, 0xF9,
  0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1C, 0x07, 0x80,
  0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01,
  0xE0, 0x7C, 0x00, 0x3F, 0x8F, 0xFB, 0xFF, 0xF8, 0xFF, 0x1E, 0xF7, 0x9F,
  0xF1, 0xFC, 0x3F, 0x8F, 0xFB, 0xCF, 0xF8, 0xFE, 0x0F, 0xE3, 0xFF, 0xFB,
  0xFE, 0x3F, 0x80, 0x3F, 0x0F, 0xF3, 0xFF, 0x78, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xFF, 0xEF, 0xDC, 0xF7, 0x80, 0xF0, 0x1C, 0x07, 0x9F, 0xE3,
  0xF8, 0x7E, 0x00, 0xF7, 0xFC, 0xE0, 0x00, 0x00, 0x03, 0xBD, 0xF7, 0x00,
  0x77, 0xFC, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0xEF, 0x7B, 0x9C, 0x00, 0x20,
  0x1C, 0x0F, 0x87, 0xF3, 0xF1, 0xF8, 0x3C, 0x07, 0xE0, 0x3F, 0x81, 0xFC,
  0x07, 0x80, 0x30, 0x02, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x80, 0x1C, 0x03, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x78,
  0x3F, 0x3F, 0x9F, 0xC3, 0xC0, 0x60, 0x08, 0x00, 0x7F, 0xBF, 0xF7, 0xFD,
  0x07, 0x01, 0xC0, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0x81, 0xC0, 0x00, 0x00,
  0x07, 0x01, 0xE0, 0x78, 0x1E, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x81, 0xE0,
  0xF0, 0xE0, 0x0E, 0x71, 0xFD, 0x9C, 0xFE, 0x7E, 0x79, 0x9F, 0x9C, 0x67,
  0xE7, 0x19, 0xFB, 0x8E, 0x7E, 0x63, 0x9F, 0x9C, 0xE7, 0xE7, 0xFF, 0x98,
  0xFB, 0xC7, 0x00, 0x00, 0xE0, 0x08, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xF0, 0x1E,
  0xF0, 0x1E, 0x70, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x3F, 0xFC, 0x3F,
  0xFC, 0x7F, 0xFC, 0x78, 0x3E, 0x78, 0x1E, 0xF8, 0x1E, 0xF0, 0x1F, 0xFF,
  0x8F, 0xFE, 0xFF, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF3, 0xEF, 0xFC, 0xFF,
  0xCF, 0xFE, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xFF, 0xEF, 0xFC, 0xFF,
  0x80, 0x0F, 0xF1, 0xFF, 0x3F, 0xF7, 0xC2, 0x78, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC3, 0x3F, 0xF1,
  0xFF, 0x0F, 0xE0, 0xFF, 0x87, 0xFE, 0x3F, 0xF9, 0xE3, 0xEF, 0x0F, 0x78,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F,
  0x79, 0xFB, 0xFF, 0x9F, 0xF8, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x0F, 0x07, 0x83, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x0F,
  0xF8, 0x7F, 0xE3, 0xFF, 0x9F, 0x04, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x03, 0xFE, 0x0F, 0x78, 0x3D, 0xF0, 0xF3,
  0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x78, 0xFF, 0xFD, 0xF9,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xBF, 0xFF, 0xFE,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0xFE, 0xFE, 0xF8, 0xF0, 0xFF,
  0x87, 0xBC, 0x79, 0xE7, 0xCF, 0x3C, 0x7B, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF,
  0x07, 0xFC, 0x3F, 0xE1, 0xE7, 0x8F, 0x3E, 0x78, 0xF3, 0xC7, 0xDE, 0x1E,
  0xF0, 0xF8, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFB,
  0x87, 0xFE, 0xE3, 0xBF, 0xB8, 0xEF, 0xEF, 0x3B, 0xF9, 0xDC, 0xFE, 0x77,
  0x3F, 0x9D, 0xCF, 0xE3, 0xF3, 0xF8, 0xF8, 0xFE, 0x3E, 0x3F, 0x8F, 0x8F,
  0xE1, 0xC3, 0xC0, 0xF8, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x87, 0xFE, 0x1F,
  0xBC, 0x7E, 0xF1, 0xF9, 0xE7, 0xE7, 0x9F, 0x8F, 0x7E, 0x3D, 0xF8, 0x7F,
  0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7C, 0x0F, 0xF0, 0x7F,
  0xF0, 0xFF, 0xF3, 0xE1, 0xE7, 0x83, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xF7, 0x83, 0xEF, 0x8F, 0x8F,
  0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0xFF, 0x1F, 0xFB, 0xFF, 0xF9, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x9F, 0xFF, 0xDF, 0xFB, 0xFC, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF3, 0xE1,
  0xE7, 0x83, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0xC0, 0xF7, 0x83, 0xEF, 0x8F, 0x8F, 0xFF, 0x0F, 0xFC, 0x0F,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0x87, 0xFE,
  0x3F, 0xF9, 0xE3, 0xCF, 0x1E, 0x78, 0xF3, 0xC7, 0x9F, 0xFC, 0xFF, 0xC7,
  0xF8, 0x3F, 0xE1, 0xE7, 0x8F, 0x3C, 0x78, 0xF3, 0xC7, 0x9E, 0x1E, 0xF0,
  0xF8, 0x3F, 0xEF, 0xFB, 0xFF, 0x78, 0x6F, 0x01, 0xE0, 0x3F, 0x03, 0xF8,
  0x3F, 0x83, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0xC7, 0xBF, 0xF7, 0xFC, 0x7F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xFC, 0x79, 0xFF, 0xCF, 0xFC, 0x1F, 0xC0, 0xF0, 0x1F, 0xF0, 0x79, 0xE0,
  0xF3, 0xC1, 0xE7, 0x83, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C, 0x1C, 0xF0,
  0x3D, 0xE0, 0x7B, 0xC0, 0x77, 0x00, 0xEE, 0x01, 0xFC, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xF7, 0x07, 0x83, 0x9E,
  0x3F, 0x1E, 0x78, 0xFC, 0x79, 0xE3, 0xF1, 0xE3, 0x8F, 0xC7, 0x0E, 0x7F,
  0x9C, 0x3D, 0xCE, 0xF0, 0xF7, 0x3B, 0xC1, 0xDC, 0xEF, 0x07, 0x73, 0xB8,
  0x1D, 0xC6, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F,
  0x87, 0xC0, 0xF8, 0x3C, 0xF0, 0xF8, 0xF1, 0xE1, 0xE7, 0x81, 0xEF, 0x03,
  0xFC, 0x03, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0xFF,
  0x81, 0xEF, 0x07, 0x8F, 0x1F, 0x1E, 0x3C, 0x1E, 0xF8, 0x3E, 0xF0, 0x3D,
  0xE1, 0xE7, 0x87, 0x8F, 0x3C, 0x3C, 0xF0, 0x7B, 0x81, 0xFE, 0x03, 0xF0,
  0x0F, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3C, 0x0F,
  0x01, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xFC, 0xF0, 0x1C, 0x07, 0x80,
  0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x07,
  0x01, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x38, 0x03,
  0xE0, 0x1F, 0x01, 0xDC, 0x0E, 0xE0, 0xE3, 0x87, 0x1C, 0x70, 0x73, 0x83,
  0xBC, 0x0E, 0xFF, 0xFF, 0xFC, 0xF8, 0x78, 0x78, 0x3F, 0x8F, 0xF8, 0xEF,
  0x80, 0xF0, 0x1E, 0x7F, 0xDF, 0xFF, 0x8F, 0xF1, 0xFE, 0x3F, 0xFF, 0xFF,
  0x77, 0xCE, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xDF, 0x3F, 0xF7,
  0xFF, 0xF1, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xE3, 0xFC, 0x7F, 0xFE,
  0xFF, 0xDD, 0xF0, 0x1F, 0xCF, 0xF7, 0xFB, 0xE0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3E, 0x17, 0xFD, 0xFF, 0x1F, 0x80, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF3, 0xEF, 0x7F, 0xF7, 0xFF, 0xF9, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF9, 0xF7, 0xFF, 0x7F, 0xF3, 0xEF, 0x1F,
  0x8F, 0xF9, 0xEF, 0xF8, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1F,
  0x05, 0xFF, 0x9F, 0xF1, 0xFC, 0x1F, 0xC7, 0xE3, 0xF8, 0xF0, 0x3C, 0x1F,
  0xEF, 0xFB, 0xFE, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x00, 0x3E, 0xF7, 0xFF, 0x7F, 0xFF, 0x9F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F, 0x7F, 0xF7, 0xFF, 0x3E, 0xF0,
  0x0F, 0x00, 0xE7, 0x3E, 0x7F, 0xE7, 0xFC, 0x3F, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xDF, 0xBF, 0xF7, 0xFF, 0xF1, 0xFE, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3C, 0x77, 0xDC,
  0x00, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x80, 0x1C, 0x7C,
  0x70, 0x00, 0x03, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x71, 0xEF, 0xDF, 0xBE, 0x78, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x1F, 0xE3, 0xEE, 0x3C, 0xE7, 0x8E, 0xF0, 0xFE, 0x0F,
  0xF0, 0xFF, 0x8F, 0x78, 0xE3, 0xCE, 0x3E, 0xE1, 0xEE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xEF, 0xDF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC7, 0x8F, 0xF1, 0xE3, 0xF8, 0x78, 0xFE, 0x1E, 0x3F, 0x87, 0x8F, 0xE1,
  0xE3, 0xF8, 0x78, 0xFE, 0x1E, 0x3F, 0x87, 0x8F, 0xE1, 0xE3, 0xC0, 0xEF,
  0xDF, 0xFB, 0xFF, 0xF8, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1E, 0x1F, 0x87, 0xFC, 0x7F, 0xEF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9E, 0x7F, 0xE3, 0xFC, 0x1F,
  0x80, 0xEF, 0x9F, 0xFB, 0xFF, 0xF8, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xF1, 0xFE, 0x3F, 0xFF, 0x7F, 0xEE, 0xF9, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x00, 0x3E, 0xF7, 0xFF, 0x7F, 0xFF, 0x1F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F, 0x7F, 0xF7, 0xFF, 0x3E, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xEF, 0xFF, 0xFF,
  0xF9, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x7F, 0xFF,
  0xFC, 0xDE, 0x0F, 0x87, 0xF1, 0xFC, 0x3F, 0x07, 0xC1, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1C, 0x0E, 0x0F, 0x0F, 0xFF, 0xFF, 0xFC, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xFC, 0xFE, 0x3F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x9F, 0x7F, 0xF7,
  0xF7, 0x3E, 0x70, 0xF0, 0x7B, 0x83, 0x9E, 0x3C, 0xF1, 0xE3, 0x8E, 0x1E,
  0xF0, 0xF7, 0x83, 0xB8, 0x1D, 0xC0, 0xFE, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x00, 0xF0, 0xF1, 0xEE, 0x3E, 0x3D, 0xE7, 0xE7, 0xBC, 0xFC, 0xE7, 0x9B,
  0x9C, 0x77, 0x77, 0x8E, 0xEE, 0xF1, 0xFC, 0xDC, 0x3F, 0x9F, 0x83, 0xE3,
  0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0x81, 0xF0, 0xF0, 0xF8, 0xFB, 0xC7, 0x8F,
  0x78, 0x7B, 0xC1, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF8, 0x1F, 0xC1, 0xEF,
  0x0F, 0x7C, 0xF1, 0xEF, 0x8F, 0x80, 0xF0, 0x7B, 0xC3, 0x9E, 0x3C, 0xF1,
  0xE3, 0x8E, 0x1E, 0xF0, 0xF7, 0x83, 0xB8, 0x1D, 0xC0, 0x7E, 0x03, 0xE0,
  0x1F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x0B, 0xE0, 0x7E, 0x03, 0xE0, 0x1C,
  0x00, 0xFF, 0xFF, 0xFF, 0xE1, 0xE0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x78,
  0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0x87, 0xC7, 0xE3, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x3C, 0x7E, 0x3C, 0x1F, 0x81, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0xE1, 0xF0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF0, 0xF8, 0xF8, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x1F, 0x0F,
  0x3F, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0xF8, 0xF8, 0xE0, 0x20, 0x3F,
  0xC7, 0xFF, 0xE7, 0xF8, 0x18,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 17, 7, 1, -17 },
  { 12, 9, 6, 12, 1, -17 },
  { 19, 14, 17, 15, 0, -17 },
  { 49, 11, 19, 13, 1, -18 },
  { 76, 19, 17, 21, 1, -17 },
  { 117, 16, 17, 17, 1, -17 },
  { 151, 4, 6, 6, 1, -17 },
  { 154, 7, 21, 8, 1, -17 },
  { 173, 7, 21, 8, 0, -17 },
  { 192, 11, 11, 12, 1, -18 },
  { 208, 11, 11, 13, 1, -14 },
  { 224, 5, 6, 7, 1, -3 },
  { 228, 6, 3, 8, 1, -8 },
  { 231, 4, 4, 7, 1, -4 },
  { 233, 10, 17, 10, 0, -17 },
  { 255, 11, 17, 13, 1, -17 },
  { 279, 9, 17, 13, 1, -17 },
  { 299, 11, 17, 13, 1, -17 },
  { 323, 11, 17, 13, 1, -17 },
  { 347, 13, 17, 13, 0, -17 },
  { 375, 11, 17, 13, 1, -17 },
  { 399, 11, 17, 13, 1, -17 },
  { 423, 11, 17, 13, 1, -17 },
  { 447, 11, 17, 13, 1, -17 },
  { 471, 11, 17, 13, 1, -17 },
  { 495, 5, 13, 7, 1, -13 },
  { 504, 5, 16, 7, 1, -13 },
  { 514, 11, 13, 13, 1, -15 },
  { 532, 11, 7, 13, 1, -12 },
  { 542, 11, 13, 13, 1, -15 },
  { 560, 10, 17, 11, 0, -17 },
  { 582, 18, 19, 20, 1, -17 },
  { 625, 16, 17, 16, 0, -17 },
  { 659, 12, 17, 15, 2, -17 },
  { 685, 12, 17, 14, 1, -17 },
  { 711, 13, 17, 16, 2, -17 },
  { 739, 9, 17, 12, 2, -17 },
  { 759, 9, 17, 12, 2, -17 },
  { 779, 14, 17, 16, 1, -17 },
  { 809, 13, 17, 17, 2, -17 },
  { 837, 7, 17, 9, 1, -17 },
  { 852, 8, 22, 8, -2, -17 },
  { 874, 13, 17, 15, 2, -17 },
  { 902, 10, 17, 12, 2, -17 },
  { 924, 18, 17, 21, 2, -17 },
  { 963, 14, 17, 18, 2, -17 },
  { 993, 15, 17, 17, 1, -17 },
  { 1025, 11, 17, 14, 2, -17 },
  { 1049, 15, 21, 17, 1, -17 },
  { 1089, 13, 17, 15, 2, -17 },
  { 1117, 11, 17, 12, 1, -17 },
  { 1141, 12, 17, 13, 0, -17 },
  { 1167, 13, 17, 17, 2, -17 },
  { 1195, 15, 17, 15, 0, -17 },
  { 1227, 22, 17, 22, 0, -17 },
  { 1274, 15, 17, 15, 0, -17 },
  { 1306, 14, 17, 14, 0, -17 },
  { 1336, 11, 17, 13, 1, -17 },
  { 1360, 6, 21, 8, 1, -17 },
  { 1376, 10, 17, 10, 0, -17 },
  { 1398, 5, 21, 8, 1, -17 },
  { 1412, 13, 11, 13, 0, -17 },
  { 1430, 11, 2, 11, 0, 2 },
  { 1433, 7, 3, 9, 1, -18 },
  { 1436, 11, 13, 13, 1, -13 },
  { 1454, 11, 18, 14, 2, -18 },
  { 1479, 10, 13, 12, 1, -13 },
  { 1496, 12, 18, 14, 1, -18 },
  { 1523, 11, 13, 13, 1, -13 },
  { 1541, 10, 18, 9, 0, -18 },
  { 1564, 12, 19, 14, 1, -13 },
  { 1593, 11, 18, 15, 2, -18 },
  { 1618, 5, 18, 7, 1, -18 },
  { 1630, 7, 24, 7, -1, -18 },
  { 1651, 12, 18, 14, 2, -18 },
  { 1678, 3, 18, 7, 2, -18 },
  { 1685, 18, 13, 22, 2, -13 },
  { 1715, 11, 13, 15, 2, -13 },
  { 1733, 12, 13, 14, 1, -13 },
  { 1753, 11, 19, 14, 2, -13 },
  { 1780, 12, 19, 14, 1, -13 },
  { 1809, 8, 13, 10, 2, -13 },
  { 1822, 9, 13, 11, 1, -13 },
  { 1837, 9, 16, 10, 0, -16 },
  { 1855, 12, 13, 15, 1, -13 },
  { 1875, 13, 13, 13, 0, -13 },
  { 1897, 19, 13, 20, 0, -13 },
  { 1928, 13, 13, 13, 0, -13 },
  { 1950, 13, 19, 13, 0, -13 },
  { 1981, 9, 13, 11, 1, -13 },
  { 1996, 9, 21, 9, 0, -17 },
  { 2020, 3, 23, 12, 4, -18 },
  { 2029, 8, 21, 9, 1, -17 },
  { 2050, 11, 5, 13, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold24pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD24PT7B_H_
