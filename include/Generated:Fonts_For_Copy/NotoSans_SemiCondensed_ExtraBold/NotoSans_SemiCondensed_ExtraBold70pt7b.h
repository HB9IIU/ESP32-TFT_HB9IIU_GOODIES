#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD70PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold70pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF,
  0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0x3F, 0xF9,
  0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0xF3, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xEF, 0xFE, 0x7F, 0xF1, 0xFF, 0x03, 0xE0,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xDF, 0xF0, 0x3F, 0xF7, 0xFC, 0x0F, 0xF9,
  0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F,
  0xF9, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xE0, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xE3, 0xC0, 0xF8, 0xFF, 0xC3, 0xC0,
  0x18, 0xFF, 0xC3, 0xC0, 0x00, 0xFF, 0xC3, 0xC0, 0x00, 0xFF, 0xC3, 0xC0,
  0x00, 0xFF, 0xE3, 0xC0, 0x00, 0xFF, 0xF3, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x03, 0xCF, 0xFF, 0x00, 0x03, 0xC7, 0xFF, 0x00, 0x03, 0xC3,
  0xFF, 0x00, 0x03, 0xC3, 0xFF, 0x80, 0x03, 0xC3, 0xFF, 0xE0, 0x03, 0xC3,
  0xFF, 0xFC, 0x03, 0xC7, 0xFF, 0xFF, 0xC3, 0xDF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x83,
  0xFE, 0x1F, 0xF0, 0x1F, 0x80, 0x3F, 0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xF8,
  0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0xFF,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x7F, 0xC7, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x1F, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xF8, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC3, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF,
  0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0x87, 0xFC, 0x3F, 0xE0, 0x3F,
  0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x01, 0xE0, 0x0F, 0xF0, 0x7F, 0x81,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x01, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x9F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xFC, 0xFF, 0xFD,
  0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xFD, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x01, 0xE8, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xBF, 0xF7,
  0xFE, 0xFF, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7F, 0xCF, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x70, 0x0F, 0xF0, 0x0E, 0x7E, 0x0F, 0xE0, 0x7E, 0x7F, 0xCF,
  0xE3, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFE,
  0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xF8,
  0x1F, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x10,
  0x08, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7,
  0xFE, 0x1F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x83,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xE1, 0xFF, 0x9F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0x8F, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0x87, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xF1,
  0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFE,
  0x7F, 0xF0, 0x07, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0xFF,
  0xEF, 0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x1F,
  0xFD, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0xC0,
  0x0F, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0xBF, 0xF8,
  0x01, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xF7, 0xFF,
  0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F,
  0xF0, 0x1F, 0xFE, 0x3F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xF7, 0xFF, 0x9F, 0xFC, 0xFF, 0xC7, 0xFF, 0x1F, 0xE1, 0xFF,
  0xC7, 0xF0, 0x7F, 0xF0, 0xF8, 0x3F, 0xFC, 0x1C, 0x0F, 0xFF, 0x02, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFC, 0x01,
  0xFF, 0xE0, 0xF8, 0x00, 0xFF, 0xF0, 0x38, 0x00, 0x3F, 0xF8, 0x18, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x03, 0xF0, 0x0F, 0xFF, 0xC1, 0xE0, 0x01, 0xFF, 0xE0, 0x40, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xEF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xDF, 0xFC, 0x00, 0x07,
  0xFD, 0xFF, 0xC0, 0x00, 0xFF, 0x9F, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0xC0,
  0x01, 0xFF, 0x1F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x03, 0xFE, 0x1F,
  0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xFC, 0x00, 0xFF,
  0x81, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC0,
  0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x80,
  0x00, 0x1F, 0xFE, 0xE0, 0x00, 0x3F, 0xFE, 0xFC, 0x00, 0x7F, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xF0, 0x01,
  0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0xF0, 0x1F, 0xF9, 0xFF, 0xFE,
  0x07, 0xFE, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xF8,
  0x7F, 0xFE, 0xFF, 0xFC, 0x07, 0xFF, 0xBF, 0xFE, 0x00, 0xFF, 0xEF, 0xFF,
  0x00, 0x3F, 0xFB, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x07, 0xFF,
  0x7F, 0xF0, 0x03, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x3F,
  0xF8, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xFC, 0x07, 0xFF, 0x8F, 0xFF, 0x83,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0xC3,
  0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xF0, 0x07, 0xFF,
  0x0F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F,
  0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE3,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xF3, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFC, 0x7F, 0xF8, 0x0F,
  0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xFB, 0xFF, 0x80,
  0x0F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x9F,
  0xFC, 0x00, 0xFF, 0xE7, 0xFF, 0xC0, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xA0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0xE7,
  0xFF, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x3F, 0xFB, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xF0, 0x1F,
  0xFF, 0x7F, 0xFC, 0x1F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xEF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0x01, 0xFF,
  0xE1, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x07, 0x87, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC1, 0xFF,
  0x1F, 0xFC, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB,
  0xFF, 0x8F, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0xF9, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xF8, 0xFF,
  0x80, 0xF0, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0xFF, 0x3F, 0xFC, 0xFF,
  0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xFF, 0xE1, 0xFF, 0x83, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC,
  0x7F, 0xE1, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC,
  0x3F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xF8,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFC, 0x03, 0xFF, 0xC7, 0x80, 0x07, 0xFF, 0x08, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0,
  0x0F, 0xFF, 0xE0, 0x7F, 0x83, 0xFE, 0x01, 0xFF, 0xFF, 0xC3, 0xFC, 0x1F,
  0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF1, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F,
  0x8F, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFC, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x0F, 0xE7, 0xF8, 0x1F, 0xF8, 0x1F, 0xE0, 0x7F, 0xBF, 0xC0, 0xFF, 0x80,
  0xFF, 0x03, 0xFD, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F,
  0x80, 0x3F, 0xC0, 0xFF, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xFF, 0xF8,
  0x3F, 0xE0, 0x0F, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0x81, 0xFF,
  0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x80, 0x3F, 0xE0,
  0x7F, 0xFF, 0x83, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0x00, 0x7F, 0xC0, 0xFE, 0xFF, 0x07, 0xFC,
  0x03, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xBF, 0xC0,
  0xFF, 0x01, 0xFF, 0x83, 0xF9, 0xFE, 0x07, 0xFC, 0x1F, 0xFC, 0x3F, 0xCF,
  0xF8, 0x3F, 0xFB, 0xFF, 0xF7, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xF0, 0x1F, 0xFF, 0xE7,
  0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0x01, 0xFE, 0x01, 0xFF,
  0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xCF, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xCF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0x03,
  0xFF, 0xFB, 0xFF, 0xC0, 0x1F, 0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0xEF, 0xFF,
  0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x7F, 0xF7,
  0xFF, 0x80, 0x1F, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x7F,
  0xF3, 0xFF, 0xC0, 0x1F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0x07, 0xFF,
  0xFD, 0xFF, 0xE0, 0x0F, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xC1, 0xFF,
  0xFC, 0x00, 0x38, 0x1F, 0xFF, 0x00, 0x00, 0x81, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x04, 0x1F, 0xFF, 0xC0,
  0x01, 0xC0, 0xFF, 0xFF, 0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xFF, 0xC7, 0xFF, 0x80, 0x1F,
  0xFF, 0x8F, 0xFF, 0x00, 0x1F, 0xFF, 0x9F, 0xFE, 0x00, 0x1F, 0xFF, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00,
  0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0xFF, 0xF7,
  0xFF, 0x80, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x0F, 0xFF, 0x7F, 0xF8,
  0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0xFF,
  0xFB, 0xFF, 0xC0, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x03, 0xFF, 0xCF, 0xFF,
  0x00, 0x0F, 0xFF, 0x9F, 0xFE, 0x00, 0x3F, 0xFE, 0x3F, 0xFC, 0x00, 0xFF,
  0xFC, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xC0, 0x7F, 0xFF, 0x00, 0x03, 0x81, 0xFF, 0xF8, 0x00, 0x01,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x03, 0xFF,
  0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFB, 0xFF, 0x80, 0x7F,
  0xFF, 0xF7, 0xFF, 0x00, 0xFF, 0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0xFF, 0xDF,
  0xFE, 0x03, 0xFF, 0xFF, 0xBF, 0xFC, 0x07, 0xFF, 0xFF, 0x7F, 0xF8, 0x00,
  0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFD, 0xFF, 0xE0, 0x00, 0x3F, 0xF9,
  0xFF, 0xE0, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x00, 0xFF, 0xE7, 0xFF, 0xC0,
  0x01, 0xFF, 0xCF, 0xFF, 0x80, 0x03, 0xFF, 0x8F, 0xFF, 0x80, 0x07, 0xFF,
  0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xB8, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFB,
  0xFF, 0xC0, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x07, 0xFF, 0x8F, 0xFF, 0x00,
  0x1F, 0xFF, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x3F, 0xFC,
  0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0xFF, 0xF1, 0xFF, 0xF0,
  0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x07, 0xFF,
  0xBF, 0xFE, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xBF, 0xFC, 0x00, 0x7F, 0xFE, 0x7F,
  0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0xC1, 0xFF, 0xE0,
  0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFF, 0x87, 0xFF, 0x80, 0x0F, 0xFF,
  0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x3F, 0xFC,
  0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x7F,
  0xFD, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xDF, 0xF0, 0x00, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF,
  0x00, 0x0F, 0xFB, 0xFF, 0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xBF, 0xFF, 0xFC,
  0xFF, 0x80, 0x1F, 0xF3, 0xFF, 0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0xFF,
  0xFE, 0xFF, 0x80, 0x1F, 0xF3, 0xFF, 0xFF, 0xEF, 0xFC, 0x01, 0xFE, 0x3F,
  0xFF, 0xFE, 0x7F, 0xC0, 0x3F, 0xE3, 0xFF, 0xFF, 0xE7, 0xFC, 0x03, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xE0, 0x3F, 0xE7, 0xFF, 0xFF, 0xE3, 0xFE, 0x07,
  0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xE0, 0x7F, 0xC7, 0xFF, 0xFF, 0xE3, 0xFE,
  0x07, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xF0, 0x7F, 0x87, 0xFF, 0xFF, 0xE1,
  0xFF, 0x0F, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFF, 0xFF,
  0xE1, 0xFF, 0x8F, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xF9, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0x9F, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xF9, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xDF, 0xFE, 0x00, 0xFF, 0xFF, 0xF9, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x3F,
  0xFC, 0x03, 0xFF, 0xFF, 0xE3, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x7F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFC, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0x8F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xF9, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xF3,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xEF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFD, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xE3, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE7,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF7, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x02, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFB, 0xFF, 0xC0, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xE7, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF7,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF7, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF,
  0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0x83, 0xFF,
  0xC0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xF0,
  0xFF, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00,
  0x7F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x01, 0xFF, 0xE3,
  0xFF, 0xC0, 0x07, 0xFF, 0xCF, 0xFF, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00,
  0x3F, 0xFE, 0xFF, 0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xF0, 0x3F, 0xC7, 0xFF, 0xC0, 0x07, 0x8F, 0xFF,
  0x00, 0x03, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFD, 0xFF, 0x81, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00,
  0xFF, 0xF7, 0xFF, 0x80, 0x07, 0xFF, 0xDF, 0xFF, 0x00, 0x3F, 0xFE, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x01,
  0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x8F, 0xFF, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x7F, 0xF8,
  0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x3F, 0xF1, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00,
  0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x00,
  0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x7F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFE, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x7F, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0x7F, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x7F,
  0xF0, 0x07, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0x03,
  0xFE, 0x7F, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF,
  0xE0, 0x03, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x07,
  0xFE, 0x3F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF,
  0xC0, 0x03, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0xC0, 0x03, 0xFF, 0x87,
  0xFC, 0x3F, 0xE1, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x1F, 0xF1, 0xFF,
  0xC0, 0x01, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0xCF,
  0xF8, 0x1F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xF8, 0x1F, 0xF3, 0xFF,
  0x80, 0x00, 0xFF, 0xCF, 0xF8, 0x1F, 0xF3, 0xFF, 0x80, 0x00, 0xFF, 0xCF,
  0xF8, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x0F, 0xFB, 0xFF,
  0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xDF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE1, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xDF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xBF,
  0xFC, 0x00, 0x07, 0xFF, 0xDF, 0xFE, 0x00, 0x03, 0xFF, 0xC7, 0xFF, 0x80,
  0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFE,
  0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xC7, 0xFF, 0x80, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0x7F, 0xF9,
  0xFF, 0xC0, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFB, 0xFE, 0x00,
  0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03, 0xFE,
  0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x1F, 0xFF, 0x00, 0xF0, 0x07, 0xFF,
  0xC0, 0x40, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xF0, 0x07, 0xFF, 0x7F, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFD, 0xFF,
  0xE0, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xE3, 0xFF, 0xFF, 0x1F, 0xF1,
  0xFF, 0xFF, 0x0F, 0xF8, 0x7F, 0xFF, 0x07, 0xFC, 0x0F, 0xFE, 0x01, 0xFE,
  0x00, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x1F, 0xE0, 0x07, 0xFF, 0x8F,
  0xFF, 0x00, 0xFF, 0xF3, 0xFF, 0xF8, 0x1F, 0xFC, 0xFF, 0xFF, 0x83, 0xFF,
  0xBF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xF0, 0x7F,
  0xFC, 0xFF, 0xFC, 0x07, 0xFF, 0x9F, 0xFF, 0x00, 0x7F, 0xFB, 0xFF, 0xC0,
  0x0F, 0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFD, 0xFF,
  0xE0, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x0F, 0xFE,
  0xFF, 0xF0, 0x01, 0xFF, 0xDF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0xE0,
  0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x1F, 0xFE, 0xFF,
  0xF0, 0x03, 0xFF, 0xDF, 0xFF, 0x00, 0x7F, 0xFB, 0xFF, 0xE0, 0x1F, 0xFE,
  0x7F, 0xFE, 0x07, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFD, 0xFF, 0xFF, 0x83, 0xFF, 0x1F, 0xFF, 0xE0, 0x7F,
  0xE1, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xF8,
  0x1F, 0x1F, 0xFF, 0x00, 0x10, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x17, 0xFF, 0xC0, 0x03, 0x3F, 0xFF,
  0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x07, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x03, 0xFF,
  0xF1, 0xFF, 0xC1, 0xFF, 0xFE, 0x7F, 0xF0, 0xFF, 0xFF, 0xDF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xF8, 0x7F, 0xFF, 0x7F, 0xFC, 0x07, 0xFF,
  0xDF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0xFF,
  0xF7, 0xFF, 0x80, 0x3F, 0xFD, 0xFF, 0xF0, 0x1F, 0xFF, 0x7F, 0xFF, 0x3F,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0xF0, 0x7F,
  0xFF, 0x8F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0x9F, 0xFE, 0x00,
  0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x23, 0xFF, 0xE0, 0x00, 0x30, 0xFF, 0xF8, 0x00, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0xF0, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0xF0, 0x3F, 0xFF, 0x8F, 0xFC, 0x1F, 0xFF, 0xF3, 0xFF, 0x0F, 0xFF, 0xFD,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0x83, 0xFF, 0xF7, 0xFF,
  0xC0, 0x7F, 0xFD, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFD, 0xFF,
  0xC0, 0x0F, 0xFF, 0x7F, 0xF8, 0x03, 0xFF, 0xDF, 0xFF, 0x01, 0xFF, 0xF7,
  0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xDF, 0xFC, 0x3F, 0xFF, 0xF7,
  0xFF, 0x07, 0xFF, 0xF9, 0xFF, 0xC0, 0xFF, 0xFC, 0x7F, 0xF0, 0x0F, 0xFC,
  0x1F, 0xFC, 0x00, 0x78, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x20,
  0x00, 0x07, 0xFF, 0x8F, 0x00, 0x03, 0xFF, 0xE3, 0xFE, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE3,
  0xFF, 0xFC, 0x3F, 0xF9, 0xFF, 0xFF, 0x8F, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x0F, 0x03, 0xFE, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xF7, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF,
  0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF,
  0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF,
  0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF,
  0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x00, 0x1E, 0x00,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFF, 0xDF, 0xFF,
  0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC,
  0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0xFF, 0xE0,
  0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F,
  0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xE1,
  0xFF, 0xF0, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F,
  0xFE, 0x7F, 0xF8, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xF0,
  0x00, 0xFF, 0xDF, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFD, 0xFF, 0xE0, 0x0F, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xF0,
  0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF,
  0xF0, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0xFF, 0xE0,
  0x07, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0xEF,
  0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x01,
  0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x87, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFC, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xFE, 0x0F, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF,
  0x1F, 0xFF, 0xF8, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0x81, 0xFF, 0xF1, 0xFF, 0xE0, 0x1F, 0xFE, 0x3F, 0xFC, 0x01, 0xFF,
  0xE7, 0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0xE0, 0x03, 0xFF, 0xBF, 0xFC, 0x00,
  0x7F, 0xF7, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xF9, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0xE7, 0xFF,
  0x80, 0x3F, 0xFC, 0x7F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xFE, 0x03,
  0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0xFE, 0x0F, 0xFE, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xC1, 0xFF, 0xF3, 0xFF,
  0xF0, 0x1F, 0xFE, 0x7F, 0xFC, 0x01, 0xFF, 0xEF, 0xFF, 0x80, 0x3F, 0xFD,
  0xFF, 0xE0, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x0F,
  0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xDF, 0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0xC0,
  0x07, 0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFD, 0xFF,
  0xE0, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x0F, 0xFE,
  0xFF, 0xF0, 0x01, 0xFF, 0xDF, 0xFE, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x0F,
  0xFF, 0x7F, 0xFC, 0x01, 0xFF, 0xEF, 0xFF, 0x80, 0x7F, 0xF9, 0xFF, 0xF8,
  0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xF7, 0xFF, 0xFE, 0x0F, 0xFE, 0x7F, 0xFF, 0x81, 0xFF, 0xE7, 0xFF,
  0xE0, 0x3F, 0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3F, 0xF0, 0x3F, 0xFF, 0x8F, 0xFC, 0x1F, 0xFF, 0xF3,
  0xFF, 0x0F, 0xFF, 0xFD, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0x83, 0xFF, 0xF7, 0xFF, 0xC0, 0x7F, 0xFD, 0xFF, 0xE0, 0x0F, 0xFF, 0x7F,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x0F, 0xFF, 0x7F, 0xF8, 0x03, 0xFF, 0xDF,
  0xFF, 0x01, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xDF,
  0xFC, 0x3F, 0xFF, 0xF7, 0xFF, 0x07, 0xFF, 0xF9, 0xFF, 0xC0, 0xFF, 0xFC,
  0x7F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x78, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0xEF, 0xFC, 0x7F, 0xF7, 0xFE, 0x7F,
  0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF,
  0xF0, 0x3F, 0x1F, 0xFC, 0x00, 0xE3, 0xFF, 0x00, 0x04, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x0B, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x41,
  0xFF, 0xFB, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xDF,
  0xFF, 0x03, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF,
  0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xC1, 0xFF, 0xFC,
  0x1F, 0xF0, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x03, 0xFF,
  0x9F, 0xFE, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0xFF, 0xE0,
  0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x01, 0xFF, 0x87,
  0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x01, 0xFF, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFC,
  0x3F, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xEF, 0xF0,
  0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xEF, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xEF, 0xF0, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xEF, 0xF8, 0x3F, 0xF0, 0x1F,
  0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F,
  0xF0, 0x0F, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xC7,
  0xF8, 0x7F, 0xE0, 0x0F, 0xFE, 0x7F, 0xC7, 0xFC, 0x7F, 0xE0, 0x0F, 0xFE,
  0x7F, 0x83, 0xFC, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0xC0,
  0x07, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0x83, 0xFC,
  0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0xC0, 0x03, 0xFE, 0x7F,
  0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0xFF,
  0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x7F,
  0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x7F, 0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x03, 0xFF, 0xCF, 0xFF,
  0x00, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x03, 0xFF, 0xCF, 0xFF, 0x00,
  0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x83,
  0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x7F, 0xFC, 0x00,
  0x7F, 0xFB, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x03, 0xFF, 0x9F, 0xFE, 0x00,
  0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x01, 0xFF, 0xC3,
  0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x03,
  0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x7F,
  0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x03,
  0xFF, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0xF3, 0xFF,
  0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0x1F, 0xFE, 0x00, 0x01, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x80, 0x00,
  0x3F, 0xF8, 0x80, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 13, 51, 19, 3, -50 },
  { 84, 26, 18, 34, 4, -50 },
  { 143, 40, 50, 42, 1, -50 },
  { 393, 32, 57, 38, 3, -53 },
  { 621, 58, 52, 62, 2, -51 },
  { 998, 48, 52, 50, 2, -51 },
  { 1310, 11, 18, 19, 4, -50 },
  { 1335, 19, 62, 24, 3, -51 },
  { 1483, 20, 62, 24, 1, -51 },
  { 1638, 32, 32, 36, 2, -53 },
  { 1766, 32, 34, 38, 3, -42 },
  { 1902, 14, 18, 20, 2, -9 },
  { 1934, 18, 10, 22, 2, -24 },
  { 1957, 13, 12, 19, 3, -11 },
  { 1977, 29, 52, 30, 0, -51 },
  { 2166, 33, 52, 38, 2, -51 },
  { 2381, 26, 50, 38, 3, -50 },
  { 2544, 33, 51, 38, 2, -51 },
  { 2755, 33, 52, 38, 2, -51 },
  { 2970, 36, 50, 38, 1, -50 },
  { 3195, 32, 51, 38, 3, -50 },
  { 3399, 34, 52, 38, 2, -51 },
  { 3620, 34, 50, 38, 2, -50 },
  { 3833, 34, 52, 38, 2, -51 },
  { 4054, 33, 52, 38, 2, -51 },
  { 4269, 13, 40, 20, 3, -39 },
  { 4334, 14, 48, 20, 2, -39 },
  { 4418, 32, 36, 38, 3, -43 },
  { 4562, 32, 23, 38, 3, -36 },
  { 4654, 32, 36, 38, 3, -43 },
  { 4798, 30, 52, 32, 0, -51 },
  { 4993, 53, 56, 59, 3, -51 },
  { 5364, 45, 50, 45, 0, -50 },
  { 5646, 35, 50, 44, 5, -50 },
  { 5865, 36, 52, 41, 3, -51 },
  { 6099, 39, 50, 47, 5, -50 },
  { 6343, 27, 50, 36, 5, -50 },
  { 6512, 27, 50, 35, 5, -50 },
  { 6681, 39, 52, 47, 3, -51 },
  { 6935, 39, 50, 49, 5, -50 },
  { 7179, 23, 50, 27, 2, -50 },
  { 7323, 22, 65, 22, -5, -50 },
  { 7502, 39, 50, 44, 5, -50 },
  { 7746, 29, 50, 36, 5, -50 },
  { 7928, 52, 50, 63, 5, -50 },
  { 8253, 43, 50, 53, 5, -50 },
  { 8522, 44, 52, 51, 3, -51 },
  { 8808, 33, 50, 41, 5, -50 },
  { 9015, 44, 63, 51, 3, -51 },
  { 9362, 38, 50, 43, 5, -50 },
  { 9600, 31, 52, 36, 3, -51 },
  { 9802, 35, 50, 37, 1, -50 },
  { 10021, 38, 51, 48, 5, -50 },
  { 10264, 43, 50, 43, 0, -50 },
  { 10533, 64, 50, 64, 0, -50 },
  { 10933, 43, 50, 43, 0, -50 },
  { 11202, 41, 50, 41, 0, -50 },
  { 11459, 34, 50, 38, 2, -50 },
  { 11672, 17, 62, 22, 4, -51 },
  { 11804, 29, 52, 30, 0, -51 },
  { 11993, 16, 62, 22, 2, -51 },
  { 12117, 36, 32, 38, 1, -50 },
  { 12261, 32, 7, 32, 0, 5 },
  { 12289, 20, 12, 26, 3, -54 },
  { 12319, 33, 40, 39, 2, -39 },
  { 12484, 35, 54, 41, 4, -53 },
  { 12721, 29, 40, 34, 3, -39 },
  { 12866, 34, 54, 41, 3, -53 },
  { 13096, 33, 40, 39, 3, -39 },
  { 13261, 27, 54, 26, 1, -54 },
  { 13444, 34, 56, 41, 3, -39 },
  { 13682, 34, 53, 42, 4, -53 },
  { 13908, 12, 54, 20, 4, -54 },
  { 13989, 19, 71, 20, -3, -54 },
  { 14158, 36, 53, 41, 5, -53 },
  { 14397, 12, 53, 20, 4, -53 },
  { 14477, 55, 39, 63, 4, -39 },
  { 14746, 34, 39, 42, 4, -39 },
  { 14912, 35, 40, 41, 3, -39 },
  { 15087, 35, 56, 41, 4, -39 },
  { 15332, 34, 56, 41, 3, -39 },
  { 15570, 25, 39, 30, 4, -39 },
  { 15692, 27, 40, 32, 3, -39 },
  { 15827, 26, 47, 28, 1, -46 },
  { 15980, 34, 40, 42, 4, -39 },
  { 16150, 38, 39, 38, 0, -39 },
  { 16336, 56, 38, 57, 1, -38 },
  { 16602, 38, 38, 38, 0, -38 },
  { 16783, 38, 56, 38, 0, -39 },
  { 17049, 28, 39, 32, 2, -39 },
  { 17186, 24, 61, 27, 1, -50 },
  { 17369, 9, 69, 35, 13, -53 },
  { 17447, 24, 61, 27, 2, -50 },
  { 17630, 32, 13, 38, 3, -31 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold70pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD70PT7B_H_
