#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD31PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xE7,
  0x80, 0x01, 0xE7, 0xFF, 0x7D, 0xE0, 0xF9, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80,
  0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE1, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF,
  0x87, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xE7, 0x87, 0xFF, 0xFB, 0xFF,
  0xFD, 0xFF, 0xFE, 0x1C, 0x70, 0x0E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03,
  0xCF, 0x01, 0xC7, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0xFF, 0xC3,
  0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0x7D, 0xC4, 0xFB, 0x81, 0xF7, 0x01, 0xFE,
  0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xBF,
  0x07, 0x7F, 0x8E, 0xF7, 0xFF, 0xEF, 0xFF, 0x9F, 0xFE, 0x07, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x3F, 0x00, 0xF0, 0x3F, 0xC0, 0xF0, 0x3F,
  0xE0, 0x78, 0x1E, 0x78, 0x78, 0x0F, 0x3C, 0x3C, 0x07, 0x9E, 0x3C, 0x03,
  0xCF, 0x1E, 0x01, 0xE7, 0x9E, 0x00, 0xF3, 0xCF, 0x08, 0x79, 0xEF, 0x3F,
  0x1F, 0xE7, 0xBF, 0xCF, 0xF7, 0x9F, 0xF3, 0xF3, 0xDE, 0x78, 0x03, 0xCF,
  0x3C, 0x01, 0xE7, 0x8E, 0x01, 0xE3, 0xC7, 0x00, 0xF1, 0xE3, 0x80, 0xF0,
  0xF3, 0xC0, 0x78, 0x39, 0xE0, 0x78, 0x1F, 0xF0, 0x3C, 0x07, 0xF0, 0x3C,
  0x01, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7C, 0xF8,
  0x03, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF9, 0xF0, 0x07, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x7C, 0x7F, 0xC3, 0xE7, 0xFF, 0x3E,
  0x7E, 0xFD, 0xF3, 0xE3, 0xFF, 0x9F, 0x0F, 0xF8, 0xF8, 0x3F, 0x87, 0xE1,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xBF, 0x0F, 0xF9, 0xFC,
  0xFF, 0xBD, 0xEF, 0x7B, 0xDE, 0x0F, 0x8F, 0x87, 0x87, 0xC3, 0xC3, 0xE1,
  0xF0, 0xF0, 0x78, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x3C, 0x1E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0,
  0xF8, 0x78, 0x7C, 0x3C, 0x3E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C,
  0x78, 0x78, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xC7, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x7F, 0x01, 0xFE, 0x0F, 0x3C,
  0x7C, 0xF8, 0x61, 0x80, 0x84, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x7D,
  0xF7, 0xDE, 0x7B, 0xEF, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0x79, 0xFF, 0xDF,
  0x78, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80,
  0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C,
  0x00, 0x0F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE3, 0xFF, 0xC7, 0xC7, 0xCF, 0x8F,
  0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x1F, 0x7C, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xFF,
  0xE1, 0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x0F, 0xF1,
  0xFF, 0x3F, 0xF7, 0xFF, 0xFD, 0xF3, 0x9F, 0x11, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x1F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xE7,
  0x87, 0xC4, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xE1,
  0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xE2, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7D, 0x81, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF,
  0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0x7C, 0x0F, 0x7C, 0x1E, 0x7C,
  0x1E, 0x7C, 0x3C, 0x7C, 0x78, 0x7C, 0x78, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x3F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7F, 0xE1, 0xFF, 0xE7, 0xFF, 0x9F, 0xFF, 0x00, 0xFC, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xF1, 0xFF, 0x80, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC3, 0xE0,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x20, 0xFB, 0xF1, 0xFF, 0xF3, 0xFF, 0xF7,
  0xF7, 0xEF, 0xC7, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3E, 0xF8,
  0xF9, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0x81, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xF3, 0xF7, 0xE7, 0xC7,
  0xCF, 0x0F, 0x9F, 0x1F, 0x3F, 0x7E, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x81,
  0xFF, 0x87, 0xFF, 0x8F, 0x9F, 0xBE, 0x1F, 0x7C, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xFB, 0xF3, 0xFF, 0xE3, 0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0x7F,
  0xE1, 0xFF, 0xE3, 0xFF, 0xEF, 0xC7, 0xDF, 0x0F, 0xBE, 0x0F, 0x7C, 0x1F,
  0xF8, 0x3F, 0xF0, 0xFF, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE7, 0xF7, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF1, 0xFF, 0xE3, 0xFF, 0x87, 0xFE,
  0x0F, 0xF0, 0x00, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x7F,
  0xFF, 0xF0, 0x79, 0xF7, 0xDF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF7, 0xDF, 0x79, 0xEF, 0xBC, 0xF0, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7E, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x03, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x01, 0xE0, 0x03, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFE,
  0x07, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x1F, 0x00, 0x38, 0x00, 0x40,
  0x00, 0x3F, 0xE7, 0xFF, 0x9F, 0xFE, 0xFF, 0xF6, 0x0F, 0x80, 0x3C, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07,
  0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x0F, 0x80,
  0x7C, 0x1E, 0x00, 0x3C, 0x3C, 0x1E, 0x1E, 0x38, 0x7F, 0xCE, 0x78, 0xFF,
  0xCE, 0x71, 0xF3, 0xCF, 0x71, 0xC3, 0xCF, 0xF3, 0xC3, 0xCF, 0xF3, 0xC3,
  0xCF, 0xF3, 0xC3, 0x8F, 0xF3, 0xC3, 0x8E, 0xF3, 0xC7, 0x8E, 0xF1, 0xEF,
  0xDE, 0x71, 0xFF, 0xFC, 0x78, 0xFC, 0xF8, 0x78, 0x10, 0x20, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x60, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xFE, 0x00, 0x7D, 0xE0, 0x07, 0x9E, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x00,
  0xF9, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xE0, 0x7E, 0x7C, 0x03,
  0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFC,
  0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E,
  0xF8, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xFC, 0xF8, 0xFE, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF0, 0x07, 0xFC, 0x3F, 0xFC, 0xFF, 0xFB, 0xFF, 0xF7,
  0xE0, 0xDF, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0x0D, 0xFF, 0xF9, 0xFF, 0xF1, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xE0,
  0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0x87, 0xF7, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0x7C, 0x7F,
  0xBF, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0x07, 0xFF, 0x07, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xE7,
  0xF0, 0x27, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x7F,
  0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xBF, 0x07, 0xDF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFF, 0xF8,
  0x3F, 0xF0, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7C, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87,
  0xFB, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0xFF,
  0xBF, 0xEF, 0xF3, 0xF8, 0xF8, 0x00, 0xF8, 0x1F, 0xFC, 0x0F, 0xBE, 0x0F,
  0xDF, 0x0F, 0xCF, 0x87, 0xC7, 0xC7, 0xE3, 0xE7, 0xE1, 0xF3, 0xE0, 0xFB,
  0xF0, 0x7D, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xC3,
  0xE3, 0xE1, 0xF1, 0xF8, 0xF8, 0x7C, 0x7C, 0x3F, 0x3E, 0x0F, 0x9F, 0x07,
  0xEF, 0x81, 0xFF, 0xC0, 0xFC, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0xF7, 0xFF, 0xC1, 0xEF, 0xFB, 0xC3, 0xDF, 0xF7, 0x87, 0xBF, 0xEF, 0x1E,
  0x7F, 0xDF, 0x3C, 0xFF, 0x9E, 0x79, 0xFF, 0x3D, 0xE3, 0xFE, 0x7B, 0xC7,
  0xFC, 0x7F, 0x8F, 0xF8, 0xFE, 0x1F, 0xF1, 0xFC, 0x3F, 0xE3, 0xF8, 0x7F,
  0xC3, 0xF0, 0xFF, 0x87, 0xC1, 0xFF, 0x0F, 0x83, 0xC0, 0xFE, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF,
  0xF0, 0xFF, 0xFF, 0x1F, 0xFB, 0xE3, 0xFF, 0x7E, 0x7F, 0xE7, 0xCF, 0xFC,
  0xFC, 0xFF, 0x8F, 0x9F, 0xF1, 0xFB, 0xFE, 0x1F, 0x7F, 0xC3, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7,
  0xE0, 0xFD, 0xF8, 0x1F, 0xBF, 0x01, 0xF7, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xE0, 0x3E, 0xFC, 0x0F, 0xCF, 0xC3, 0xF9, 0xFF, 0xFE, 0x1F,
  0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF,
  0xF7, 0xFF, 0xEF, 0x87, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0x9F, 0xFC, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x00, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xE0,
  0xFD, 0xF8, 0x1F, 0xBF, 0x01, 0xF7, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xE0, 0x3E, 0xFC, 0x0F, 0xCF, 0xC3, 0xF9, 0xFF, 0xFE, 0x1F, 0xFF,
  0x81, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF,
  0x1F, 0xFF, 0xCF, 0x87, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8,
  0x7E, 0x7C, 0x7E, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x83,
  0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C, 0x7C, 0x3F, 0x3E, 0x0F, 0x9F, 0x07,
  0xEF, 0x81, 0xF7, 0xC0, 0xFC, 0x1F, 0xF8, 0xFF, 0xF7, 0xFF, 0x9F, 0xFE,
  0xFC, 0x1B, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFE,
  0x07, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0xC3,
  0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF0, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xFC, 0x0F, 0xBF, 0x0F, 0xDF, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F,
  0xC0, 0xF8, 0x03, 0xFF, 0x80, 0xFD, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xE0,
  0x7C, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE3,
  0xE0, 0x7C, 0x7C, 0x07, 0x8F, 0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF,
  0x80, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0x81, 0xFF, 0x80, 0xF8,
  0x1F, 0x7C, 0x1F, 0x81, 0xF7, 0xC1, 0xF8, 0x1F, 0x7C, 0x1F, 0xC3, 0xE7,
  0xC1, 0xFC, 0x3E, 0x3C, 0x3F, 0xC3, 0xE3, 0xE3, 0xFC, 0x3E, 0x3E, 0x3D,
  0xC3, 0xC3, 0xE3, 0xDE, 0x7C, 0x1E, 0x7D, 0xE7, 0xC1, 0xE7, 0x9E, 0x7C,
  0x1F, 0x79, 0xE7, 0xC1, 0xF7, 0x8F, 0x78, 0x1F, 0x78, 0xFF, 0x80, 0xF7,
  0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F,
  0x00, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0xFC,
  0x07, 0xEF, 0xC1, 0xF8, 0xF8, 0x3E, 0x1F, 0x8F, 0xC1, 0xF1, 0xF0, 0x1F,
  0x7E, 0x03, 0xEF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x7D,
  0xF0, 0x1F, 0x9F, 0x03, 0xE3, 0xF0, 0xFC, 0x3E, 0x3F, 0x07, 0xE7, 0xC0,
  0x7D, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xDF, 0x03, 0xF7, 0xE0, 0xF8, 0xF8,
  0x7E, 0x3E, 0x1F, 0x07, 0xCF, 0xC1, 0xF3, 0xE0, 0x3E, 0xF8, 0x0F, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFF, 0xFF, 0xF8,
  0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x7C,
  0xFF, 0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0xFF, 0xFF, 0xF8,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x3D, 0xE0, 0x3C, 0xF0, 0x1E, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x87,
  0x03, 0xC7, 0x80, 0xF7, 0xC0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFC, 0x3F, 0x0F, 0x81, 0xE0, 0x78, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0,
  0xF7, 0xE1, 0x07, 0xC0, 0x0F, 0x81, 0xFF, 0x9F, 0xFF, 0x7F, 0xFF, 0xFC,
  0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xDF,
  0x3F, 0x1E, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7D, 0xF8, 0xFF, 0xF9, 0xFF, 0xFB, 0xFF, 0xF7, 0xE3,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xE3, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0x79, 0xF8, 0x0F,
  0xF8, 0xFF, 0xCF, 0xFE, 0xFF, 0xE7, 0xC1, 0x3E, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0xBF, 0xFC, 0xFF, 0xE3,
  0xFF, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x8F, 0xDF, 0x3F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB,
  0xE1, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x7F, 0xF0, 0xFB, 0xE1, 0xF7, 0xFF, 0xEF, 0xFF, 0xCF, 0xF7, 0x8F, 0xCF,
  0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF3, 0xF3, 0xE7, 0xC3, 0xEF, 0x87, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x4F, 0xFF, 0x8F, 0xFF, 0x0F, 0xFE, 0x0F, 0xF8, 0x03, 0xE0, 0xFF, 0x1F,
  0xF1, 0xFF, 0x1F, 0x11, 0xF0, 0x1F, 0x03, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF,
  0xE1, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x9E, 0x7F, 0xBC,
  0xFF, 0xFB, 0xFF, 0xF7, 0xC3, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xE1, 0xF7, 0xC3, 0xEF, 0xFF, 0xDF, 0xFF,
  0x9F, 0xFF, 0x1F, 0xBE, 0x00, 0x7C, 0x00, 0xFA, 0x01, 0xF7, 0xFF, 0xEF,
  0xFF, 0x9F, 0xFE, 0x3F, 0xF8, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7D, 0xF8, 0xFF, 0xFD, 0xFF, 0xFB,
  0xFF, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0x77, 0xFF, 0xF7, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFE, 0xFE, 0xFC,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x3F, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0xF8, 0xF9, 0xF0,
  0xFB, 0xF0, 0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0,
  0xFD, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xF8, 0xFC, 0xF7, 0xFD, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x3E, 0x1F,
  0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F,
  0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F,
  0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF3, 0xF9, 0xEF, 0xFB, 0xFF, 0xF7,
  0xFF, 0xFF, 0xC7, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3E, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E,
  0x7C, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0x7C, 0x3E, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0,
  0xF3, 0xF1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0xC7, 0xFF, 0x07, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC7,
  0xFF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFC, 0xFB, 0xF1, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1F, 0x9E, 0x7F,
  0xBC, 0xFF, 0xFB, 0xFF, 0xF7, 0xC3, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xE1, 0xF7, 0xC3, 0xEF, 0xFF, 0xDF,
  0xFF, 0x9F, 0xFF, 0x1F, 0xBE, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xF1, 0xFE, 0x7F, 0xDF, 0xFF, 0xEF,
  0xFD, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0xE7, 0xFF, 0x7F, 0xFF, 0xCE,
  0xF8, 0x2F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x03, 0xF0, 0x1F,
  0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xC0, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xFC, 0xFF, 0x9F, 0xF1,
  0xFE, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF,
  0xC7, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xEF, 0x3F, 0x1E, 0xF8, 0x1F, 0xBE,
  0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE3, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8,
  0x3C, 0x78, 0x1F, 0x7C, 0x0F, 0xBE, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xFF,
  0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x3F,
  0x0F, 0xBE, 0x1F, 0x87, 0xDF, 0x1F, 0xC3, 0xCF, 0x8F, 0xE3, 0xE7, 0xC7,
  0x71, 0xF1, 0xE3, 0xBC, 0xF8, 0xFB, 0xDE, 0x78, 0x7D, 0xEF, 0x7C, 0x3E,
  0xF3, 0xBE, 0x0F, 0x79, 0xDF, 0x07, 0xB8, 0xFF, 0x03, 0xDC, 0x7F, 0x81,
  0xFE, 0x3F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x1F, 0x83, 0xF0,
  0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0xBF, 0x1F, 0x8F, 0x8F, 0x87, 0xEF,
  0xC1, 0xF7, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x81, 0xF7, 0xC1, 0xF3, 0xF0, 0xF8, 0xF8,
  0xF8, 0x7E, 0xFC, 0x1F, 0x80, 0xF8, 0x0F, 0xBE, 0x0F, 0x9F, 0x07, 0xCF,
  0x83, 0xE3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x3C, 0x78, 0x1F, 0x7C,
  0x0F, 0xBE, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x07,
  0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3E,
  0x07, 0xE0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC3,
  0xF1, 0xFC, 0x7F, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE3,
  0xF8, 0xFC, 0x3C, 0x0F, 0xE1, 0xF8, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7F, 0x1F, 0xC3, 0xF0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x7C, 0x0F, 0xF0, 0xFE, 0x07, 0xC3, 0xF8, 0xFC, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x87, 0xF0, 0xFE, 0x1F, 0x83,
  0xE0, 0x00, 0x18, 0x02, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xD0,
  0x0E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 22, 9, 1, -22 },
  { 18, 11, 8, 15, 2, -22 },
  { 29, 17, 22, 19, 1, -22 },
  { 76, 15, 26, 17, 1, -24 },
  { 125, 25, 22, 27, 1, -22 },
  { 194, 21, 22, 22, 1, -22 },
  { 252, 5, 8, 8, 2, -22 },
  { 257, 9, 27, 10, 1, -22 },
  { 288, 8, 27, 10, 1, -22 },
  { 315, 14, 15, 16, 1, -24 },
  { 342, 15, 15, 17, 1, -18 },
  { 371, 6, 8, 9, 1, -4 },
  { 377, 8, 4, 10, 1, -10 },
  { 381, 6, 5, 9, 1, -5 },
  { 385, 13, 22, 13, 0, -22 },
  { 421, 15, 22, 17, 1, -22 },
  { 463, 12, 22, 17, 1, -22 },
  { 496, 15, 22, 17, 1, -22 },
  { 538, 15, 22, 17, 1, -22 },
  { 580, 16, 22, 17, 0, -22 },
  { 624, 14, 22, 17, 1, -22 },
  { 663, 15, 22, 17, 1, -22 },
  { 705, 15, 22, 17, 1, -22 },
  { 747, 15, 22, 17, 1, -22 },
  { 789, 15, 22, 17, 1, -22 },
  { 831, 5, 17, 9, 2, -17 },
  { 842, 6, 21, 9, 1, -17 },
  { 858, 15, 16, 17, 1, -19 },
  { 888, 15, 10, 17, 1, -16 },
  { 907, 15, 16, 17, 1, -19 },
  { 937, 13, 22, 14, 0, -22 },
  { 973, 24, 24, 26, 1, -22 },
  { 1045, 20, 22, 20, 0, -22 },
  { 1100, 16, 22, 19, 2, -22 },
  { 1144, 15, 22, 18, 2, -22 },
  { 1186, 17, 22, 21, 2, -22 },
  { 1233, 12, 22, 16, 2, -22 },
  { 1266, 12, 22, 16, 2, -22 },
  { 1299, 17, 22, 21, 2, -22 },
  { 1346, 17, 22, 22, 2, -22 },
  { 1393, 10, 22, 12, 1, -22 },
  { 1421, 10, 29, 10, -2, -22 },
  { 1458, 17, 22, 19, 2, -22 },
  { 1505, 13, 22, 16, 2, -22 },
  { 1541, 23, 22, 28, 2, -22 },
  { 1605, 19, 22, 23, 2, -22 },
  { 1658, 19, 22, 22, 2, -22 },
  { 1711, 15, 22, 18, 2, -22 },
  { 1753, 19, 27, 22, 2, -22 },
  { 1818, 17, 22, 19, 2, -22 },
  { 1865, 14, 22, 16, 1, -22 },
  { 1904, 15, 22, 16, 1, -22 },
  { 1946, 17, 22, 21, 2, -22 },
  { 1993, 19, 22, 19, 0, -22 },
  { 2046, 28, 22, 28, 0, -22 },
  { 2123, 19, 22, 19, 0, -22 },
  { 2176, 18, 22, 18, 0, -22 },
  { 2226, 15, 22, 17, 1, -22 },
  { 2268, 7, 27, 10, 2, -22 },
  { 2292, 13, 22, 13, 0, -22 },
  { 2328, 7, 27, 10, 1, -22 },
  { 2352, 17, 14, 17, 0, -22 },
  { 2382, 14, 3, 14, 0, 2 },
  { 2388, 9, 5, 11, 1, -24 },
  { 2394, 15, 17, 17, 1, -17 },
  { 2426, 15, 24, 18, 2, -24 },
  { 2471, 13, 17, 15, 1, -17 },
  { 2499, 15, 24, 18, 1, -24 },
  { 2544, 15, 17, 17, 1, -17 },
  { 2576, 12, 24, 11, 0, -24 },
  { 2612, 15, 24, 18, 1, -17 },
  { 2657, 15, 24, 19, 2, -24 },
  { 2702, 5, 24, 9, 2, -24 },
  { 2717, 8, 31, 9, -1, -24 },
  { 2748, 16, 24, 18, 2, -24 },
  { 2796, 5, 24, 9, 2, -24 },
  { 2811, 24, 17, 28, 2, -17 },
  { 2862, 15, 17, 19, 2, -17 },
  { 2894, 16, 17, 18, 1, -17 },
  { 2928, 15, 24, 18, 2, -17 },
  { 2973, 15, 24, 18, 1, -17 },
  { 3018, 11, 17, 13, 2, -17 },
  { 3042, 12, 17, 14, 1, -17 },
  { 3068, 11, 21, 13, 1, -21 },
  { 3097, 15, 17, 19, 2, -17 },
  { 3129, 17, 17, 17, 0, -17 },
  { 3166, 25, 17, 25, 0, -17 },
  { 3220, 17, 17, 17, 0, -17 },
  { 3257, 17, 24, 17, 0, -17 },
  { 3308, 12, 17, 14, 1, -17 },
  { 3334, 10, 27, 12, 1, -22 },
  { 3368, 4, 31, 15, 6, -24 },
  { 3384, 11, 27, 12, 1, -22 },
  { 3422, 15, 6, 17, 1, -14 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold31pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD31PT7B_H_
