#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD63PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold63pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F,
  0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC7, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xF3, 0xFC, 0x1C, 0x00, 0xFF, 0xC3, 0xFF, 0x7F, 0xC3, 0xFF, 0x7F,
  0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F,
  0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F,
  0xC1, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x3F,
  0x81, 0xFE, 0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC1,
  0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0x9E, 0x0F, 0x87, 0xFC, 0x78, 0x04,
  0x3F, 0xE1, 0xE0, 0x00, 0xFF, 0xC7, 0x80, 0x01, 0xFF, 0x1E, 0x00, 0x07,
  0xFE, 0x78, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xE7, 0xFE, 0x00, 0x07, 0x8F, 0xFC, 0x00, 0x1E, 0x1F, 0xF0,
  0x00, 0x78, 0x7F, 0xD8, 0x01, 0xE1, 0xFF, 0x78, 0x07, 0x8F, 0xF9, 0xFE,
  0x1E, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFC, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x81, 0xFC,
  0x00, 0x00, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x83,
  0xF8, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x7F,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x01, 0xE0, 0x0F, 0xF0,
  0xFF, 0x0F, 0xE0, 0xFF, 0xC0, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xFE, 0x07,
  0xF9, 0xFF, 0x1F, 0xC3, 0xFF, 0xF0, 0x7F, 0xFF, 0xE3, 0xFC, 0x7F, 0xFF,
  0x83, 0xFF, 0xFE, 0x3F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF8, 0xFF,
  0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x0F, 0xFF, 0x0F, 0xF1,
  0xFE, 0x1F, 0xE0, 0x7F, 0xE0, 0xFF, 0x1F, 0xE1, 0xFE, 0x00, 0x60, 0x1F,
  0xE1, 0xFE, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0xFF, 0x00, 0x00,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x00,
  0x00, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0xFF,
  0x00, 0x00, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F,
  0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF3,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x1F, 0xF8, 0x3F, 0xFD, 0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0x3F, 0xFC, 0xFF,
  0xE0, 0xFF, 0xC3, 0xFF, 0xDF, 0xF8, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xF8,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x7F, 0xF0, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE7, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF,
  0x7F, 0xDF, 0xF7, 0xFD, 0xFE, 0x7F, 0x9F, 0xE3, 0xF8, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x08, 0x03, 0xF8, 0x04, 0x3C, 0x0F, 0xC0,
  0xF8, 0xFE, 0x3F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF8, 0x7F,
  0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x18, 0x07, 0x00,
  0x00, 0x20, 0x10, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3,
  0xFE, 0x7F, 0xC7, 0xFC, 0x7F, 0xC7, 0xF8, 0x7F, 0x8F, 0xF8, 0xFF, 0x0F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x8F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE7, 0xF8, 0x38, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x1F, 0xFC, 0x0F, 0xFC,
  0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0x9F,
  0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xFB, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xF7, 0xFE, 0x01, 0xFF, 0x9F,
  0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xE7, 0xFE,
  0x01, 0xFF, 0x8F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xEF, 0xFC, 0xFF, 0xCF, 0xF1, 0xFF, 0x8F, 0xC3, 0xFF, 0x1F, 0x07,
  0xFE, 0x1C, 0x0F, 0xFC, 0x10, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0xC1,
  0xF8, 0x07, 0xFF, 0x87, 0xC0, 0x0F, 0xFE, 0x0C, 0x00, 0x3F, 0xF8, 0x10,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF0, 0x7E, 0x03, 0xFF, 0xC0, 0xE0, 0x03, 0xFF, 0x02, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xA0, 0x00, 0x0F, 0xFE, 0xE0, 0x00, 0x7F, 0xFB, 0xF0, 0x03,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xD0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFE, 0x7F, 0xE0,
  0x03, 0xFC, 0x7F, 0xE0, 0x03, 0xFC, 0x7F, 0xE0, 0x07, 0xF8, 0x7F, 0xE0,
  0x0F, 0xF8, 0x7F, 0xE0, 0x0F, 0xF0, 0x7F, 0xE0, 0x1F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0,
  0x7F, 0x80, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE,
  0x1F, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x60, 0x01, 0xFF, 0x0F, 0xFC,
  0x07, 0xFC, 0xFF, 0xF8, 0x1F, 0xF7, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0xFF, 0xEF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F,
  0xF7, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0x3F, 0xF0, 0x1F, 0xF8,
  0xFF, 0xE0, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x7F,
  0xF1, 0xFF, 0xC0, 0xFF, 0xE7, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE,
  0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x0F,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x3F, 0xFC,
  0x7F, 0xF8, 0x7F, 0xF1, 0xFF, 0x80, 0xFF, 0xE7, 0xFE, 0x01, 0xFF, 0xBF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xF7, 0xFF, 0x03, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xC1,
  0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0x3F, 0xF8, 0x0F, 0xFE, 0xFF, 0xC0, 0x1F,
  0xFB, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xF7, 0xFF,
  0xDF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xDF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFB, 0xFE, 0x07, 0xFF, 0xCF,
  0xF8, 0x0F, 0xFE, 0x3F, 0xE0, 0x03, 0xC0, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE7, 0xF8, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF1, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFC, 0xFF, 0x07, 0x00, 0x0F,
  0xC1, 0xFE, 0x3F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF3, 0xFF, 0x3F,
  0xF1, 0xFE, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x1F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F,
  0xE3, 0xFE, 0x3F, 0xE7, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0x87, 0xF8, 0xFF,
  0x8F, 0xF0, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE3, 0xF0, 0x1F,
  0xFC, 0x70, 0x01, 0xFF, 0x88, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x3F, 0xE0, 0x1F, 0xC1, 0xFE, 0x01, 0xFF, 0xFC, 0x3F, 0xC7, 0xF8,
  0x0F, 0xFF, 0xFC, 0x3F, 0x8F, 0xE0, 0x3F, 0xFF, 0xF8, 0x7F, 0x3F, 0xC0,
  0xFF, 0xFF, 0xF0, 0xFF, 0x7F, 0x83, 0xFF, 0xFF, 0xE0, 0xFE, 0xFE, 0x0F,
  0xFC, 0x1F, 0xC1, 0xFF, 0xFC, 0x1F, 0xE0, 0x3F, 0x83, 0xFF, 0xF8, 0x7F,
  0x80, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xFF, 0xC1, 0xFC,
  0x03, 0xFC, 0x1F, 0xFF, 0x83, 0xF8, 0x07, 0xF8, 0x3F, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0x7F, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0xFC, 0x3F, 0xC0,
  0x3F, 0xC1, 0xFF, 0xF8, 0x7F, 0x80, 0x7F, 0x83, 0xFF, 0xF0, 0xFF, 0x00,
  0xFF, 0x07, 0xFF, 0xE0, 0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0xC1, 0xFC, 0x07,
  0xFC, 0x3F, 0xBF, 0x83, 0xFC, 0x0F, 0xF8, 0x7F, 0x7F, 0x07, 0xFC, 0x3F,
  0xF1, 0xFC, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFC, 0x0F, 0xFF, 0xEF, 0xFF, 0x83, 0xFC, 0x0F, 0xFF, 0x8F,
  0xFE, 0x07, 0xF8, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x10,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x0F,
  0xFB, 0xFE, 0x00, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x9F,
  0xFC, 0x00, 0x01, 0xFF, 0xDF, 0xFE, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0,
  0x7F, 0xFD, 0xFF, 0x80, 0x3F, 0xFB, 0xFF, 0x00, 0x7F, 0xF7, 0xFE, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0xBF, 0xF0, 0x03,
  0xFF, 0x7F, 0xE0, 0x0F, 0xFE, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0x81, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x00, 0xFF, 0xF7,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0xFC, 0x1F, 0xFF, 0x00, 0x1C, 0x3F, 0xFC, 0x00, 0x04, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x02, 0x3F, 0xFE,
  0x00, 0x0E, 0x1F, 0xFF, 0xC0, 0x7E, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xF0, 0x0F, 0xFF,
  0xCF, 0xFC, 0x00, 0xFF, 0xF3, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xC0, 0x07,
  0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xC0,
  0x07, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0xF3, 0xFF,
  0x01, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xE0, 0x7F, 0xFE, 0x00, 0x0C,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xDF,
  0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x7F,
  0xEF, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0x9F, 0xFE, 0x00,
  0x3F, 0xF1, 0xFF, 0xE0, 0x07, 0xFE, 0x3F, 0xFF, 0x00, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xE0, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x7F, 0xFB, 0xFF, 0x00,
  0x1F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF0, 0x07, 0xFF, 0x8F, 0xFC,
  0x01, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x80,
  0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFC, 0x7F, 0xF8,
  0x03, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xF3, 0xFF,
  0x80, 0x0F, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x80,
  0x3F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x07,
  0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0xFC, 0x3F, 0xF0,
  0x07, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0xE3, 0xFF, 0x00, 0x3F, 0xF8, 0xFF,
  0xC0, 0x07, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xFB,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xDF, 0xFF, 0xFB, 0xFC, 0x00,
  0xFF, 0x7F, 0xFF, 0xEF, 0xF0, 0x03, 0xFD, 0xFF, 0xFF, 0xBF, 0xE0, 0x0F,
  0xF7, 0xFF, 0xFE, 0xFF, 0x80, 0x7F, 0x9F, 0xFF, 0xF9, 0xFE, 0x01, 0xFE,
  0x7F, 0xFF, 0xE7, 0xF8, 0x07, 0xF9, 0xFF, 0xFF, 0x9F, 0xF0, 0x3F, 0xC7,
  0xFF, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0x03, 0xFC, 0x7F,
  0xFF, 0xE3, 0xFE, 0x0F, 0xF1, 0xFF, 0xFF, 0x8F, 0xF8, 0x7F, 0x87, 0xFF,
  0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0xFF,
  0xE1, 0xFF, 0x3F, 0xC1, 0xFF, 0xFF, 0x83, 0xFC, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xF3, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFB, 0xFF, 0x00, 0xFF, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0xFF,
  0x9F, 0xF8, 0x0F, 0xFF, 0xFE, 0x7F, 0xF0, 0x3F, 0xFF, 0xF8, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFE, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xE1,
  0xFF, 0xFF, 0x81, 0xFF, 0x87, 0xFF, 0xFE, 0x07, 0xFF, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFC, 0x7F, 0xFF, 0xE0, 0x3F, 0xF9, 0xFF, 0xFF, 0x80, 0x7F, 0xE7,
  0xFF, 0xFE, 0x01, 0xFF, 0xDF, 0xFF, 0xF8, 0x03, 0xFF, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x7F, 0xF8,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x7F, 0xF8,
  0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00,
  0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xFC,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFE,
  0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F,
  0xFC, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00,
  0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0xF8,
  0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F,
  0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFC,
  0x3F, 0xF0, 0x07, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x7F,
  0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFC, 0x07,
  0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xE0,
  0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFF, 0x0F, 0xFC,
  0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F,
  0xF0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xFB, 0xFF, 0x00, 0x0F, 0xFE,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xC1, 0xFC, 0x7F, 0xF0, 0x03, 0xC7, 0xFE, 0x00, 0x08, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFB, 0xFF, 0xC0, 0x1F, 0xFE, 0x7F, 0xFC, 0x0F, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFD, 0xFF,
  0x80, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x01,
  0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x03, 0xFF, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x0F,
  0xF9, 0xFF, 0x80, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00,
  0xFF, 0xBF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x0F, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFF,
  0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x0F, 0xF7, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFC,
  0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x80, 0x1F,
  0xF0, 0x3F, 0xCF, 0xF0, 0x7F, 0xE0, 0x07, 0xFC, 0x0F, 0xF3, 0xFC, 0x1F,
  0xF8, 0x01, 0xFF, 0x87, 0xFC, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE1, 0xFE,
  0x3F, 0xE1, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0xC0, 0x03,
  0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x7F, 0x8F,
  0xFC, 0x00, 0x3F, 0xF3, 0xFE, 0x1F, 0xE3, 0xFF, 0x00, 0x0F, 0xFC, 0xFF,
  0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xE0, 0x00,
  0x7F, 0xCF, 0xF0, 0x3F, 0xCF, 0xF8, 0x00, 0x1F, 0xF3, 0xFC, 0x0F, 0xF7,
  0xFE, 0x00, 0x07, 0xFD, 0xFE, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xFC, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0xFF,
  0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x03,
  0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00,
  0x1F, 0xFD, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0xC7, 0xFF,
  0x00, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F,
  0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x00,
  0xFF, 0xF3, 0xFF, 0x80, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0xFF, 0xE0, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x03, 0xFF, 0x9F, 0xFC, 0x00,
  0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFE, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0,
  0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xFB,
  0xFF, 0x80, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x07,
  0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFE, 0x3F, 0xFE, 0x03, 0x80, 0x3F,
  0xF8, 0x08, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xC7, 0xFF, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xCF,
  0xFF, 0xF9, 0xFF, 0x1F, 0xFF, 0xC7, 0xFC, 0x3F, 0xFE, 0x0F, 0xF0, 0x7F,
  0xF0, 0x3F, 0xC0, 0x1C, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xC0,
  0x3F, 0xF1, 0xFF, 0xE0, 0x7F, 0xE7, 0xFF, 0xE0, 0xFF, 0xDF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0x0F, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0x7F,
  0xF0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0xFB, 0xFF,
  0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x00,
  0x7F, 0xEF, 0xFE, 0x00, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xBF, 0xFC, 0x07,
  0xFF, 0x7F, 0xFC, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xF3, 0xFF, 0xF8, 0x3F, 0xE3, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0x1F, 0xFC, 0x00,
  0x87, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x67, 0xFF, 0x80, 0x79, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0xFF, 0xC3, 0xFF, 0xF3,
  0xFF, 0x0F, 0xFF, 0xEF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xDF, 0xFC, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF7, 0xFC, 0x3F, 0xFF, 0x9F, 0xF0, 0x7F, 0xFC, 0x3F, 0xC0, 0x7F, 0xC0,
  0xFF, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F,
  0xF0, 0x1F, 0xF1, 0xFF, 0x80, 0x7F, 0xEF, 0xFC, 0x00, 0xFF, 0xBF, 0xF0,
  0x03, 0xFE, 0xFF, 0xC0, 0x0F, 0xFB, 0xFF, 0x00, 0x3F, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x47, 0xFF, 0x00, 0x07, 0x1F, 0xFF,
  0x00, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0x04, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x07, 0xFC,
  0x0F, 0xFE, 0x1F, 0xF0, 0xFF, 0xFE, 0x7F, 0xC3, 0xFF, 0xFD, 0xFF, 0x1F,
  0xFF, 0xF7, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xF8, 0x3F, 0xFD, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xF7, 0xFF, 0x03,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFB, 0xFF, 0x0F, 0xFF, 0xEF, 0xFC,
  0x1F, 0xFF, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1C, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xD0, 0x00,
  0x07, 0xFF, 0x70, 0x00, 0x3F, 0xF9, 0xFC, 0x03, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x07, 0xF8, 0x0F, 0xFC, 0x7F, 0xFC,
  0x3F, 0xF3, 0xFF, 0xF8, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0x3F, 0x9F, 0xFB, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFE, 0x7F, 0x80, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xBF,
  0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7,
  0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE,
  0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF,
  0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE8,
  0x7F, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF,
  0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0x80,
  0x1F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xE0, 0x1F, 0xFC, 0x3F, 0xF0,
  0x1F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE,
  0x0F, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF,
  0xC7, 0xFF, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x1F,
  0xFB, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x7F, 0xF0,
  0x0F, 0xFF, 0x1F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F,
  0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x8F, 0xFC, 0x00,
  0xFF, 0xE7, 0xFE, 0x00, 0x7F, 0xFB, 0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x83, 0xFF, 0xE0,
  0x7F, 0xFC, 0x3F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xF7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xCF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0x0F, 0xF1, 0xFF, 0xFE,
  0x3F, 0xE7, 0xFF, 0xFC, 0xFF, 0xBF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xF8, 0x3F, 0xF8,
  0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0x80, 0x3F, 0xF7, 0xFF, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0xE0,
  0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0xE3,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x01, 0xFE,
  0x01, 0xFF, 0x0F, 0xFF, 0x03, 0xFE, 0x3F, 0xFF, 0x07, 0xFC, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xF9, 0xFF, 0xE0, 0x3F, 0xFB,
  0xFF, 0x80, 0x7F, 0xF7, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0xFF, 0xDF,
  0xF8, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xBF, 0xF0,
  0x03, 0xFF, 0x7F, 0xF0, 0x07, 0xFE, 0xFF, 0xE0, 0x1F, 0xFD, 0xFF, 0xE0,
  0x3F, 0xFB, 0xFF, 0xE0, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xDF, 0xFF, 0xC1, 0xFF, 0x9F, 0xFF, 0x03, 0xFF, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xF0, 0xFF, 0xFE, 0x7F, 0xC3, 0xFF,
  0xF9, 0xFF, 0x1F, 0xFF, 0xF7, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x3F, 0xFD, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xF7, 0xFF, 0x03, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xEF, 0xFC, 0x1F, 0xFF, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1C,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x01, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFB, 0xFE, 0xFF, 0xEF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xC1, 0xFC, 0xFF, 0xC0, 0x1C,
  0x7F, 0xE0, 0x02, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x04, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0x1E, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0x1F, 0xFF, 0xE3, 0xFC, 0x3F, 0xFF, 0x0F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xC0, 0x0E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x07,
  0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x1F, 0xF8, 0x7F, 0xE0, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFB, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x0F, 0xFF,
  0x80, 0x7F, 0xE7, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xF1, 0xFF, 0x80, 0xFF,
  0xFC, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x1F,
  0xDF, 0xC0, 0xFF, 0xC3, 0xFF, 0x07, 0xF7, 0xF8, 0x3F, 0xE0, 0xFF, 0xC1,
  0xFD, 0xFE, 0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0x7F, 0x87, 0xFE, 0x07, 0xFC,
  0x3F, 0xCF, 0xE1, 0xFF, 0x81, 0xFF, 0x8F, 0xE3, 0xF8, 0x7F, 0xC0, 0x7F,
  0xE3, 0xF8, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFE, 0x3F, 0xCF, 0xFC, 0x03,
  0xFE, 0x7F, 0x8F, 0xF3, 0xFE, 0x00, 0xFF, 0x9F, 0xE1, 0xFC, 0xFF, 0x80,
  0x3F, 0xE7, 0xF0, 0x7F, 0x3F, 0xE0, 0x07, 0xFD, 0xFC, 0x1F, 0xCF, 0xF8,
  0x01, 0xFF, 0x7F, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0xDF, 0xC0, 0xFF, 0xFF,
  0x00, 0x1F, 0xF7, 0xF0, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0xFF,
  0xE3, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F,
  0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xFC,
  0x7F, 0xF0, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x1F,
  0xF8, 0x7F, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF,
  0x9F, 0xFC, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0xC0,
  0x07, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0xFF,
  0x80, 0x0F, 0xF8, 0x7F, 0xE0, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xC7,
  0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x04, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x04, 0x7F,
  0xF0, 0x00, 0x33, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFB, 0x80, 0x0F, 0xFF, 0xC8, 0x00, 0x07, 0xFC,
  0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 11, 46, 17, 3, -45 },
  { 65, 24, 16, 31, 3, -45 },
  { 113, 36, 45, 38, 1, -45 },
  { 316, 30, 52, 34, 2, -48 },
  { 511, 52, 47, 55, 2, -46 },
  { 817, 43, 47, 45, 2, -46 },
  { 1070, 10, 16, 17, 3, -45 },
  { 1090, 17, 56, 21, 3, -46 },
  { 1209, 18, 56, 21, 1, -46 },
  { 1335, 30, 29, 32, 1, -48 },
  { 1444, 30, 31, 34, 2, -38 },
  { 1561, 12, 16, 18, 2, -8 },
  { 1585, 16, 8, 20, 2, -21 },
  { 1601, 11, 11, 17, 3, -10 },
  { 1617, 26, 46, 27, 0, -45 },
  { 1767, 30, 47, 34, 2, -46 },
  { 1944, 23, 45, 34, 3, -45 },
  { 2074, 30, 46, 34, 2, -46 },
  { 2247, 30, 47, 34, 2, -46 },
  { 2424, 32, 45, 34, 1, -45 },
  { 2604, 28, 46, 34, 3, -45 },
  { 2765, 30, 47, 34, 2, -46 },
  { 2942, 30, 45, 34, 2, -45 },
  { 3111, 30, 47, 34, 2, -46 },
  { 3288, 30, 47, 34, 2, -46 },
  { 3465, 11, 36, 18, 3, -35 },
  { 3515, 12, 43, 18, 2, -35 },
  { 3580, 30, 33, 34, 2, -39 },
  { 3704, 30, 20, 34, 2, -32 },
  { 3779, 30, 33, 34, 2, -39 },
  { 3903, 27, 47, 28, 0, -46 },
  { 4062, 47, 50, 53, 3, -45 },
  { 4356, 41, 45, 41, 0, -45 },
  { 4587, 31, 45, 39, 5, -45 },
  { 4762, 32, 47, 37, 3, -46 },
  { 4950, 34, 45, 42, 5, -45 },
  { 5142, 24, 45, 32, 5, -45 },
  { 5277, 24, 45, 32, 5, -45 },
  { 5412, 35, 47, 43, 3, -46 },
  { 5618, 35, 45, 44, 5, -45 },
  { 5815, 20, 45, 24, 2, -45 },
  { 5928, 19, 59, 20, -4, -45 },
  { 6069, 34, 45, 39, 5, -45 },
  { 6261, 26, 45, 32, 5, -45 },
  { 6408, 46, 45, 56, 5, -45 },
  { 6667, 38, 45, 48, 5, -45 },
  { 6881, 40, 47, 46, 3, -46 },
  { 7116, 29, 45, 37, 5, -45 },
  { 7280, 40, 57, 46, 3, -46 },
  { 7565, 34, 45, 39, 5, -45 },
  { 7757, 28, 47, 33, 2, -46 },
  { 7922, 31, 45, 34, 1, -45 },
  { 8097, 34, 46, 44, 5, -45 },
  { 8293, 39, 45, 39, 0, -45 },
  { 8513, 58, 45, 58, 0, -45 },
  { 8840, 39, 45, 39, 0, -45 },
  { 9060, 37, 45, 37, 0, -45 },
  { 9269, 31, 45, 34, 1, -45 },
  { 9444, 15, 56, 20, 4, -46 },
  { 9549, 26, 46, 27, 0, -45 },
  { 9699, 16, 56, 20, 1, -46 },
  { 9811, 33, 29, 34, 1, -45 },
  { 9931, 29, 6, 28, 0, 5 },
  { 9953, 17, 10, 23, 3, -48 },
  { 9975, 30, 36, 35, 2, -35 },
  { 10110, 31, 49, 37, 4, -48 },
  { 10300, 26, 36, 31, 3, -35 },
  { 10417, 30, 49, 37, 3, -48 },
  { 10601, 30, 36, 35, 3, -35 },
  { 10736, 24, 48, 23, 1, -48 },
  { 10880, 30, 50, 37, 3, -35 },
  { 11068, 30, 48, 38, 4, -48 },
  { 11248, 11, 48, 18, 4, -48 },
  { 11314, 18, 63, 18, -3, -48 },
  { 11456, 33, 48, 37, 4, -48 },
  { 11654, 10, 48, 18, 4, -48 },
  { 11714, 49, 35, 57, 4, -35 },
  { 11929, 30, 35, 38, 4, -35 },
  { 12061, 31, 36, 37, 3, -35 },
  { 12201, 31, 50, 37, 4, -35 },
  { 12395, 30, 50, 37, 3, -35 },
  { 12583, 22, 35, 27, 4, -35 },
  { 12680, 25, 36, 29, 2, -35 },
  { 12793, 23, 43, 26, 1, -42 },
  { 12917, 30, 36, 38, 4, -35 },
  { 13052, 34, 35, 34, 0, -35 },
  { 13201, 50, 35, 51, 1, -35 },
  { 13420, 34, 35, 34, 0, -35 },
  { 13569, 34, 50, 34, 0, -35 },
  { 13782, 25, 35, 29, 2, -35 },
  { 13892, 22, 55, 25, 1, -45 },
  { 14044, 7, 62, 31, 12, -48 },
  { 14099, 22, 55, 25, 2, -45 },
  { 14251, 30, 11, 34, 2, -28 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold63pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD63PT7B_H_
