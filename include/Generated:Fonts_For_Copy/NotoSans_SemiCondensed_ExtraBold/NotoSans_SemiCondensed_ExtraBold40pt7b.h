#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD40PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xEF, 0xDF, 0xBE, 0x7C, 0xF9, 0xF0, 0x00, 0x00, 0x04, 0x3E, 0xFF, 0xFF,
  0xFF, 0xF7, 0xC0, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7,
  0xEF, 0x8F, 0xDF, 0x1F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xF8,
  0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x78, 0x78, 0x01,
  0xE3, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF0, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC,
  0x1F, 0x1E, 0x00, 0x7C, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x83, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x3C, 0x3C,
  0x00, 0xF1, 0xF0, 0x03, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x78, 0x01,
  0xF1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x3F, 0xFC, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFD, 0xC1, 0x3E, 0x70, 0x0F, 0xDC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0xFC, 0x07, 0x7F, 0x01, 0xCF, 0xE0, 0x73, 0xFC, 0x1C, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF1, 0xFF, 0xF0, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x0F, 0xF0, 0x03, 0xE0, 0x0F, 0xFC, 0x03, 0xE0, 0x0F, 0xFE, 0x01, 0xF0,
  0x07, 0xDF, 0x81, 0xF0, 0x07, 0xC7, 0xC0, 0xF8, 0x03, 0xE3, 0xE0, 0xF8,
  0x01, 0xF1, 0xF0, 0x7C, 0x00, 0xF8, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x3E,
  0x00, 0x3E, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x1F, 0x0E, 0x0F, 0x8F, 0x9F,
  0x1F, 0xC3, 0xEF, 0xCF, 0x9F, 0xF1, 0xFF, 0xCF, 0x9F, 0xFC, 0x7F, 0xE7,
  0xCF, 0xFE, 0x1F, 0xE7, 0xCF, 0x8F, 0x87, 0xC3, 0xE7, 0xC7, 0xC0, 0x03,
  0xE3, 0xE3, 0xE0, 0x01, 0xF1, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0xF8, 0x00,
  0xF8, 0x7C, 0x7C, 0x00, 0xF8, 0x3E, 0x3E, 0x00, 0x7C, 0x1F, 0x1F, 0x00,
  0x7C, 0x0F, 0x8F, 0x80, 0x3E, 0x03, 0xFF, 0x80, 0x3E, 0x01, 0xFF, 0xC0,
  0x1F, 0x00, 0x7F, 0xC0, 0x1F, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x8F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0x87, 0xFF, 0x07, 0xF1, 0xFF,
  0xF0, 0xFE, 0x3F, 0xFF, 0x1F, 0x8F, 0xEF, 0xF7, 0xF1, 0xF8, 0xFF, 0xFE,
  0x7F, 0x0F, 0xFF, 0x8F, 0xE0, 0xFF, 0xF1, 0xFC, 0x0F, 0xFC, 0x3F, 0x80,
  0xFF, 0x03, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xDF, 0xE0, 0x7F, 0xE1, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0xC0, 0x07, 0xE1, 0xF8, 0x3E, 0x0F,
  0xC3, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7E,
  0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0x81, 0xF8,
  0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x03,
  0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8,
  0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x04, 0x1E, 0x0C, 0xF3, 0xCF, 0xBF,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF4, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0x7C, 0x0F, 0xCF, 0xC0, 0xF8, 0xFC, 0x0E,
  0x1C, 0x00, 0x41, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x3F, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF,
  0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x7F, 0x7F, 0x9F, 0xC3, 0xF3, 0xF8, 0x7E, 0x7E, 0x0F,
  0xEF, 0xC1, 0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFD, 0xF8, 0x1F,
  0xBF, 0x03, 0xF7, 0xE0, 0xFE, 0xFC, 0x1F, 0xDF, 0xC3, 0xF1, 0xF8, 0xFE,
  0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xCF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFD, 0xFC, 0xE3, 0xF8, 0x87, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0x07, 0xF0,
  0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC7, 0xFF, 0xFC, 0x7E, 0xFF, 0x86, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0xFF, 0xF0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x83, 0xFF,
  0xC0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x7D, 0xF8, 0x07, 0xDF, 0x80, 0xF9, 0xF8, 0x1F, 0x9F, 0x81, 0xF1, 0xF8,
  0x3E, 0x1F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x8F, 0xC1, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F,
  0xFF, 0x1F, 0xFF, 0xC7, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xF9,
  0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x81, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x3F,
  0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xE0, 0x8F, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0xF0, 0x3E, 0x7F,
  0x87, 0xDF, 0xF9, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFC, 0xFF, 0xFF, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F,
  0xDF, 0xC3, 0xFB, 0xF8, 0x7F, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFE,
  0x07, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFE, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7F, 0x7E, 0x0F, 0xCF,
  0xE1, 0xF8, 0xFE, 0x7F, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xF7, 0xF9, 0xFC, 0x3F, 0xBF,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0x7F,
  0xFF, 0xEF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x7F, 0xE0, 0x03,
  0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF,
  0x7F, 0x9F, 0x83, 0xF7, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFE, 0xFE, 0x3F, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE3, 0xFE, 0xFC, 0x3F, 0x9F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xF8, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7D, 0xFF, 0xFF, 0xFF,
  0xEF, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x7D, 0xFF,
  0xFF, 0xFF, 0xEF, 0x80, 0x3E, 0x7F, 0x7F, 0x7F, 0x7F, 0x3F, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F,
  0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x70,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F,
  0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xF0,
  0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF,
  0x80, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x80, 0x03, 0x80, 0x00, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x1F, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xFB,
  0xF3, 0xFC, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x60, 0x3E, 0x3E, 0x1F, 0xFC,
  0xF9, 0xF0, 0xFF, 0xF1, 0xE7, 0xC7, 0xFF, 0xC7, 0xFE, 0x3F, 0x1F, 0x1F,
  0xF8, 0xF8, 0x7C, 0x7F, 0xE3, 0xC1, 0xF1, 0xFF, 0x1F, 0x07, 0xC7, 0xFC,
  0x7C, 0x1F, 0x1F, 0xF1, 0xF0, 0x7C, 0x7F, 0xC7, 0xC1, 0xF1, 0xFF, 0x1F,
  0x07, 0xC7, 0xBC, 0x7C, 0x3F, 0x1E, 0xF8, 0xF9, 0xFE, 0xFB, 0xE3, 0xFF,
  0xFF, 0xCF, 0x87, 0xFD, 0xFE, 0x1F, 0x0F, 0xE3, 0xF0, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x10, 0x07, 0xF0, 0x03, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E,
  0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x3F,
  0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xFB, 0xFC, 0x00, 0xFE, 0xFE, 0x00,
  0x1F, 0xC0, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0x7E, 0xFE, 0x07,
  0xEF, 0xE0, 0x7E, 0xFE, 0x0F, 0xEF, 0xE1, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xE0, 0xFE, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xC0, 0x67, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x13, 0xFE, 0x0E, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xE0, 0xFF, 0x3F,
  0x81, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFE, 0xFE,
  0x03, 0xFB, 0xF8, 0x1F, 0xEF, 0xE0, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFC, 0x01, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0x7F, 0x00, 0xFD,
  0xFC, 0x03, 0xF7, 0xF8, 0x0F, 0xCF, 0xF8, 0x3F, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0xFF, 0xF7,
  0xFF, 0x3F, 0xF9, 0xFF, 0x8F, 0xF8, 0x1E, 0x00, 0xFE, 0x01, 0xFF, 0xF8,
  0x0F, 0xEF, 0xE0, 0x7F, 0xBF, 0x81, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F,
  0x8F, 0xE1, 0xFC, 0x3F, 0x8F, 0xE0, 0xFE, 0x7F, 0x83, 0xF9, 0xFC, 0x0F,
  0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xF7, 0xF0,
  0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x83, 0xF8, 0xFE, 0x0F, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0xBF, 0x80,
  0xFE, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3E, 0xFF,
  0xFF, 0xC0, 0xFB, 0xFF, 0xDF, 0x03, 0xEF, 0xFF, 0x7C, 0x0F, 0xBF, 0xFD,
  0xF0, 0x7C, 0xFF, 0xF7, 0xE1, 0xF3, 0xFF, 0xCF, 0x87, 0xCF, 0xFF, 0x3E,
  0x3E, 0x3F, 0xFC, 0xFC, 0xF8, 0xFF, 0xF3, 0xF3, 0xE3, 0xFF, 0xC7, 0xDF,
  0x8F, 0xFF, 0x1F, 0x7C, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xC3,
  0xFF, 0xC3, 0xFE, 0x0F, 0xFF, 0x0F, 0xF8, 0x3F, 0xFC, 0x3F, 0xE0, 0xFF,
  0xF0, 0x7F, 0x03, 0xFF, 0xC1, 0xFC, 0x0F, 0xFF, 0x07, 0xF0, 0x3F, 0xFC,
  0x0F, 0xC0, 0xFC, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFD, 0xF8, 0x3F,
  0xFD, 0xFC, 0x3F, 0xFC, 0xFC, 0x3F, 0xFC, 0xFE, 0x3F, 0xFC, 0x7E, 0x3F,
  0xFC, 0x7F, 0x3F, 0xFC, 0x3F, 0x3F, 0xFC, 0x3F, 0xBF, 0xFC, 0x1F, 0xBF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF1, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x7F, 0x80,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xF7, 0xF0, 0x07, 0xF3,
  0xF8, 0x03, 0xF9, 0xFE, 0x03, 0xFC, 0x7F, 0xC7, 0xFC, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xBF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFD, 0xFC, 0xFF, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFE, 0x7F,
  0x00, 0x7F, 0x7F, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xF7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFE, 0x03, 0xFC, 0x7F, 0xC7,
  0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xE1, 0xFE, 0x3F, 0x83,
  0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8,
  0xFE, 0x1F, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x3F,
  0x83, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3,
  0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x80, 0xFE, 0xFE, 0x03, 0xFC, 0x03,
  0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF7, 0xFF, 0xFB,
  0xF8, 0x1D, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x00,
  0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0x83, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x3F, 0x9F, 0xE1, 0xFE, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0x9F, 0x80, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF1, 0xF8, 0x03,
  0xF0, 0xFC, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFC, 0x0F, 0xC0,
  0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E,
  0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03,
  0xF3, 0xF8, 0x01, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00,
  0x1F, 0xBE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x01, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0x9F, 0x80,
  0x7F, 0x00, 0xFC, 0xFC, 0x03, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0xC0, 0x7F,
  0x3F, 0x81, 0xFE, 0x03, 0xF1, 0xFC, 0x0F, 0xF8, 0x1F, 0x87, 0xE0, 0x7F,
  0xC0, 0xFC, 0x3F, 0x03, 0xFE, 0x0F, 0xE1, 0xF8, 0x3F, 0xF0, 0x7F, 0x0F,
  0xE1, 0xF7, 0xC3, 0xF0, 0x3F, 0x0F, 0xBE, 0x1F, 0x81, 0xF8, 0x7D, 0xF0,
  0xFC, 0x0F, 0xC7, 0xEF, 0x8F, 0xE0, 0x7E, 0x3E, 0x7C, 0x7E, 0x01, 0xF9,
  0xF3, 0xF3, 0xF0, 0x0F, 0xCF, 0x8F, 0x9F, 0x80, 0x7E, 0x7C, 0x7C, 0xFC,
  0x03, 0xF7, 0xE3, 0xEF, 0xE0, 0x1F, 0xBE, 0x1F, 0x7E, 0x00, 0x7D, 0xF0,
  0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0x0F, 0xE0,
  0x3F, 0x87, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0x3F,
  0x8F, 0xE0, 0x0F, 0xCF, 0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x3F,
  0x80, 0x3F, 0x8F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0,
  0xFF, 0x1F, 0xE0, 0x3F, 0x8F, 0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xF8, 0xFE,
  0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFC, 0x3F,
  0x81, 0xFC, 0x3F, 0x83, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF0, 0x0F,
  0xC7, 0xF0, 0x0F, 0xE7, 0xE0, 0x07, 0xEF, 0xE0, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0x7C, 0x03, 0xE3, 0xE0,
  0x1F, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0xFC, 0x0F, 0x87, 0xC0,
  0x3E, 0x3E, 0x01, 0xF3, 0xE0, 0x07, 0xFF, 0x00, 0x3E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xE1, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0x80, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F,
  0xFF, 0xE0, 0xFB, 0xFE, 0x10, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x01,
  0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xF8, 0x7E, 0xFC,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xEF, 0xE7, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF3, 0xFF, 0x3E, 0x3F, 0xC7, 0xC0, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0xFE, 0x1F, 0xBF, 0xE3, 0xFF, 0xFE, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFC, 0x3F, 0xBF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xCF, 0x9F, 0xF1, 0xF1, 0xFC, 0x00, 0x07, 0xFE, 0x0F,
  0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F, 0x06, 0xFE, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0x03, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F,
  0xFF, 0x1F, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x0F, 0xE7, 0xE3, 0xFE, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x7F, 0xFF, 0x0F, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3,
  0xFF, 0x7E, 0x1F, 0xC7, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC7, 0xF1, 0xFD, 0xFC, 0x1F, 0xBF, 0x83, 0xF7, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x8F, 0xFB, 0xF0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0x60,
  0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7F, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xE7, 0xE3,
  0xFE, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFF,
  0x0F, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x9F, 0xFB, 0xF3, 0xFF, 0x7E, 0x1F,
  0xCF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xEC, 0x03, 0xFD, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x00, 0x0D,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0xFE, 0x1F, 0xBF,
  0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFE, 0x3F, 0xFF, 0x83,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xC0, 0x38, 0xFF, 0xFF, 0xFF, 0xEF, 0xC4, 0x00, 0x00, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0x80, 0x03, 0x80, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x0F, 0xC0, 0x40, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE1, 0xFC, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xBF, 0xE7, 0xF8,
  0x38, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x07, 0xF7, 0xE0, 0x7F, 0x3F, 0x07, 0xF1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8,
  0x7E, 0x3F, 0x83, 0xF3, 0xF8, 0x1F, 0xBF, 0x80, 0xFD, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xF9, 0xFC, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x87, 0xE0, 0xFE, 0x3F, 0x07,
  0xF1, 0xF8, 0x1F, 0xCF, 0xC0, 0xFF, 0x7E, 0x03, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0xFE, 0x0F, 0xF1,
  0xF3, 0xFF, 0x3F, 0xF3, 0xEF, 0xFE, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xE3, 0xFE, 0x3F, 0xFF, 0x83, 0xF8, 0x3F, 0xFE,
  0x07, 0xF0, 0x7F, 0xFC, 0x0F, 0xE0, 0xFF, 0xF8, 0x1F, 0x81, 0xFF, 0xF0,
  0x3F, 0x03, 0xFF, 0xE0, 0x7E, 0x07, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x81,
  0xF8, 0x1F, 0xFF, 0x03, 0xF0, 0x3F, 0xFE, 0x07, 0xE0, 0x7F, 0xFC, 0x0F,
  0xC0, 0xFF, 0xF8, 0x1F, 0x81, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xE0, 0x7E,
  0x07, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x81, 0xF8, 0x1F, 0xC0, 0xF8, 0xFE,
  0x1F, 0x3F, 0xF3, 0xEF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFE, 0x3F,
  0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC7, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0x7E, 0xFC,
  0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7E, 0xFE, 0x07, 0xEF, 0xE0, 0xFE, 0x7F, 0x0F, 0xE7, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0xF8, 0xFE,
  0x1F, 0x3F, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFC, 0x3F,
  0xBF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F,
  0xFE, 0x1F, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xDF, 0xF1,
  0xF9, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE7, 0xE3, 0xFE, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x9F,
  0xFB, 0xF3, 0xFF, 0x7E, 0x1F, 0xCF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0xFF, 0xCF, 0xFE, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xEF, 0xE7, 0xDF, 0x81, 0x3F, 0x00, 0x7F, 0x80, 0xFF, 0xC1, 0xFF,
  0xE1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x3F,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x9F, 0xFE, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x13, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xF7, 0xE0, 0xFF, 0x7F, 0x0F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3,
  0xFF, 0xBF, 0x3F, 0xFB, 0xF0, 0xFE, 0x1F, 0xFE, 0x01, 0xFD, 0xF8, 0x07,
  0xE7, 0xE0, 0x3F, 0x9F, 0xC0, 0xFE, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0xC3,
  0xF0, 0x7F, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x00, 0xFC,
  0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0x80, 0x1F, 0x7E, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x3F,
  0x7E, 0x0F, 0xF0, 0x3F, 0x7E, 0x0F, 0xF0, 0x7F, 0x7E, 0x0F, 0xF8, 0x7E,
  0x7F, 0x0F, 0xF8, 0x7E, 0x3F, 0x0F, 0xF8, 0x7E, 0x3F, 0x1F, 0x78, 0x7E,
  0x3F, 0x1F, 0x78, 0xFC, 0x1F, 0x9F, 0x7C, 0xFC, 0x1F, 0x9E, 0x7C, 0xFC,
  0x1F, 0x9E, 0x7C, 0xFC, 0x1F, 0xBE, 0x3C, 0xF8, 0x0F, 0xBE, 0x3D, 0xF8,
  0x0F, 0xBE, 0x3F, 0xF8, 0x0F, 0xBC, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0,
  0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0,
  0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0,
  0xFF, 0x03, 0xF9, 0xFC, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x1F,
  0xCF, 0xE0, 0x3F, 0x7F, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xCF, 0xC0, 0x7F,
  0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x03, 0xFB, 0xFC, 0x0F,
  0xF0, 0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x9F, 0xC0, 0xFE,
  0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF8, 0x7F, 0x07, 0xE1, 0xF8, 0x1F,
  0x87, 0xE0, 0x7F, 0x3F, 0x80, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xCF,
  0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F,
  0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x78, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xF0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x7F, 0x1F, 0xF0, 0xFF, 0x87, 0xF0, 0x3F, 0x81, 0xFF, 0x0F, 0xFC, 0x0F,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x7E, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0x7E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFF,
  0x0F, 0xF8, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x03, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFC,
  0x0F, 0xE0, 0x30, 0x00, 0x0C, 0x00, 0x27, 0xF8, 0x07, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xF0, 0x0F, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 29, 11, 2, -29 },
  { 27, 15, 11, 19, 2, -29 },
  { 48, 22, 29, 24, 1, -29 },
  { 128, 18, 32, 22, 2, -30 },
  { 200, 33, 29, 35, 1, -29 },
  { 320, 27, 29, 28, 1, -29 },
  { 418, 6, 11, 11, 2, -29 },
  { 427, 11, 35, 14, 2, -29 },
  { 476, 11, 35, 14, 1, -29 },
  { 525, 19, 18, 20, 1, -30 },
  { 568, 18, 20, 22, 2, -24 },
  { 613, 8, 10, 11, 1, -5 },
  { 623, 11, 5, 13, 1, -13 },
  { 630, 7, 7, 11, 2, -7 },
  { 637, 17, 29, 17, 0, -29 },
  { 699, 19, 29, 22, 1, -29 },
  { 768, 15, 29, 22, 2, -29 },
  { 823, 19, 29, 22, 1, -29 },
  { 892, 19, 29, 22, 1, -29 },
  { 961, 20, 29, 22, 1, -29 },
  { 1034, 18, 29, 22, 2, -29 },
  { 1100, 19, 29, 22, 1, -29 },
  { 1169, 19, 29, 22, 1, -29 },
  { 1238, 19, 29, 22, 1, -29 },
  { 1307, 19, 29, 22, 1, -29 },
  { 1376, 7, 22, 11, 2, -22 },
  { 1396, 8, 27, 11, 1, -22 },
  { 1423, 18, 21, 22, 2, -25 },
  { 1471, 18, 13, 22, 2, -21 },
  { 1501, 18, 21, 22, 2, -25 },
  { 1549, 17, 29, 18, 0, -29 },
  { 1611, 30, 32, 34, 2, -29 },
  { 1731, 26, 29, 26, 0, -29 },
  { 1826, 20, 29, 25, 3, -29 },
  { 1899, 20, 29, 24, 2, -29 },
  { 1972, 22, 29, 27, 3, -29 },
  { 2052, 15, 29, 20, 3, -29 },
  { 2107, 15, 29, 20, 3, -29 },
  { 2162, 22, 29, 27, 2, -29 },
  { 2242, 22, 29, 28, 3, -29 },
  { 2322, 13, 29, 15, 1, -29 },
  { 2370, 13, 38, 13, -3, -29 },
  { 2432, 22, 29, 25, 3, -29 },
  { 2512, 16, 29, 21, 3, -29 },
  { 2570, 30, 29, 36, 3, -29 },
  { 2679, 24, 29, 30, 3, -29 },
  { 2766, 25, 29, 29, 2, -29 },
  { 2857, 19, 29, 23, 3, -29 },
  { 2926, 25, 36, 29, 2, -29 },
  { 3039, 22, 29, 25, 3, -29 },
  { 3119, 17, 29, 21, 2, -29 },
  { 3181, 19, 29, 21, 1, -29 },
  { 3250, 22, 29, 28, 3, -29 },
  { 3330, 25, 29, 25, 0, -29 },
  { 3421, 37, 29, 37, 0, -29 },
  { 3556, 25, 29, 25, 0, -29 },
  { 3647, 24, 29, 24, 0, -29 },
  { 3734, 20, 29, 21, 1, -29 },
  { 3807, 10, 36, 13, 2, -29 },
  { 3852, 17, 29, 17, 0, -29 },
  { 3914, 9, 36, 13, 1, -29 },
  { 3955, 21, 19, 22, 0, -29 },
  { 4005, 18, 4, 18, 0, 3 },
  { 4014, 11, 7, 15, 2, -31 },
  { 4024, 19, 22, 22, 1, -22 },
  { 4077, 19, 30, 24, 3, -30 },
  { 4149, 16, 22, 19, 2, -22 },
  { 4193, 19, 30, 24, 2, -30 },
  { 4265, 19, 22, 22, 2, -22 },
  { 4318, 15, 31, 15, 1, -31 },
  { 4377, 19, 32, 24, 2, -22 },
  { 4453, 19, 30, 24, 3, -30 },
  { 4525, 7, 31, 12, 2, -31 },
  { 4553, 11, 41, 12, -2, -31 },
  { 4610, 21, 30, 24, 3, -30 },
  { 4689, 6, 30, 12, 3, -30 },
  { 4712, 31, 22, 36, 3, -22 },
  { 4798, 19, 22, 24, 3, -22 },
  { 4851, 20, 22, 23, 2, -22 },
  { 4906, 19, 32, 24, 3, -22 },
  { 4982, 19, 32, 24, 2, -22 },
  { 5058, 13, 22, 17, 3, -22 },
  { 5094, 15, 22, 19, 2, -22 },
  { 5136, 14, 27, 16, 1, -27 },
  { 5184, 20, 22, 24, 2, -22 },
  { 5239, 22, 22, 22, 0, -22 },
  { 5300, 32, 22, 33, 0, -22 },
  { 5388, 22, 22, 22, 0, -22 },
  { 5449, 22, 32, 22, 0, -22 },
  { 5537, 16, 22, 18, 1, -22 },
  { 5581, 13, 36, 16, 1, -29 },
  { 5640, 5, 39, 20, 7, -30 },
  { 5665, 14, 36, 16, 1, -29 },
  { 5728, 19, 7, 22, 1, -18 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold40pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD40PT7B_H_
