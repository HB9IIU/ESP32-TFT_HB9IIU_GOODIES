#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD7PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xC0, 0xB4, 0x5F, 0x6F, 0x60, 0x6C, 0x6D, 0xE0, 0xCA, 0xCD,
  0xCB, 0x6C, 0x63, 0x1B, 0x6F, 0x80, 0xC0, 0x6A, 0x90, 0x95, 0x60, 0xEB,
  0x80, 0x4F, 0x40, 0xE0, 0xC0, 0xC0, 0x29, 0x28, 0x6A, 0xBA, 0x60, 0x7C,
  0x92, 0xE2, 0x24, 0xF0, 0xE2, 0x63, 0xE0, 0x26, 0xAF, 0x20, 0x7B, 0x9E,
  0x68, 0xEB, 0x60, 0xF2, 0x24, 0x40, 0x6E, 0x6B, 0xE0, 0x6A, 0xF2, 0x60,
  0xC3, 0xC3, 0x80, 0x3C, 0x30, 0xF0, 0xF0, 0xC3, 0xC0, 0xE5, 0x04, 0x79,
  0xDB, 0x6E, 0x40, 0xC0, 0x63, 0x15, 0xE9, 0x80, 0xF7, 0x5E, 0x7C, 0xCC,
  0x70, 0xF6, 0xDE, 0xEE, 0xC0, 0xEE, 0x80, 0x7C, 0xFD, 0x70, 0xB7, 0xDA,
  0xD5, 0xC0, 0x55, 0x78, 0xBB, 0x7A, 0xAA, 0xC0, 0x9E, 0xFB, 0xDE, 0x80,
  0x9D, 0xDB, 0xB0, 0x76, 0xF3, 0xB7, 0x00, 0xD7, 0xC8, 0x76, 0xF3, 0xB7,
  0x0C, 0xF7, 0x6A, 0x71, 0x9E, 0xF4, 0x44, 0x40, 0xB6, 0xDE, 0x9D, 0x76,
  0x60, 0x96, 0xD7, 0x5B, 0x68, 0xD6, 0x66, 0xD0, 0x96, 0x66, 0x60, 0xF2,
  0x44, 0xF0, 0xEA, 0xB0, 0x89, 0x22, 0xD5, 0x70, 0x46, 0xB0, 0xE0, 0xC0,
  0x63, 0xFD, 0xCE, 0xDD, 0xF0, 0x7A, 0x30, 0x17, 0x99, 0x70, 0x69, 0xE6,
  0x7D, 0x24, 0x79, 0x97, 0xB6, 0xCF, 0xDD, 0xD0, 0xFF, 0xC0, 0xFF, 0xF8,
  0xCD, 0xEE, 0xD0, 0xFF, 0xC0, 0xBF, 0x5D, 0x75, 0xBD, 0xDD, 0x69, 0x96,
  0xAD, 0xDF, 0xCC, 0x79, 0x97, 0x11, 0xBB, 0x60, 0x79, 0xF0, 0x5D, 0x26,
  0xDD, 0xD7, 0x9E, 0x66, 0xBE, 0xE7, 0x96, 0xF6, 0x6F, 0x9E, 0x66, 0x4C,
  0xED, 0x70, 0x69, 0x64, 0xC0, 0xFE, 0xC9, 0x35, 0x80, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 3, 2, 3, 0, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 5, 4, 0, -5 },
  { 10, 6, 5, 6, 0, -5 },
  { 14, 5, 5, 5, 0, -5 },
  { 18, 1, 2, 2, 0, -5 },
  { 19, 2, 6, 2, 0, -5 },
  { 21, 2, 6, 2, 0, -5 },
  { 23, 3, 3, 4, 0, -5 },
  { 25, 4, 3, 4, 0, -4 },
  { 27, 2, 2, 2, 0, -1 },
  { 28, 2, 1, 2, 0, -2 },
  { 29, 2, 1, 2, 0, -1 },
  { 30, 3, 5, 3, 0, -5 },
  { 32, 4, 5, 4, 0, -5 },
  { 35, 3, 5, 4, 0, -5 },
  { 37, 4, 5, 4, 0, -5 },
  { 40, 4, 5, 4, 0, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 3, 5, 4, 0, -5 },
  { 48, 4, 5, 4, 0, -5 },
  { 51, 4, 5, 4, 0, -5 },
  { 54, 4, 5, 4, 0, -5 },
  { 57, 4, 5, 4, 0, -5 },
  { 60, 2, 4, 2, 0, -4 },
  { 61, 2, 5, 2, 0, -4 },
  { 63, 4, 3, 4, 0, -4 },
  { 65, 4, 3, 4, 0, -4 },
  { 67, 4, 3, 4, 0, -4 },
  { 69, 3, 5, 3, 0, -5 },
  { 71, 6, 6, 6, 0, -5 },
  { 76, 5, 5, 5, 0, -5 },
  { 80, 3, 5, 4, 1, -5 },
  { 82, 4, 5, 4, 0, -5 },
  { 85, 3, 5, 5, 1, -5 },
  { 87, 2, 5, 4, 1, -5 },
  { 89, 2, 5, 4, 1, -5 },
  { 91, 4, 5, 5, 0, -5 },
  { 94, 3, 5, 5, 1, -5 },
  { 96, 2, 5, 3, 0, -5 },
  { 98, 2, 7, 2, 0, -5 },
  { 100, 3, 5, 4, 1, -5 },
  { 102, 2, 5, 4, 1, -5 },
  { 104, 5, 5, 6, 1, -5 },
  { 108, 4, 5, 5, 1, -5 },
  { 111, 5, 5, 5, 0, -5 },
  { 115, 3, 5, 4, 1, -5 },
  { 117, 5, 6, 5, 0, -5 },
  { 121, 3, 5, 4, 1, -5 },
  { 123, 3, 5, 4, 0, -5 },
  { 125, 4, 5, 4, 0, -5 },
  { 128, 3, 5, 5, 1, -5 },
  { 130, 4, 5, 4, 0, -5 },
  { 133, 6, 5, 6, 0, -5 },
  { 137, 4, 5, 4, 0, -5 },
  { 140, 4, 5, 4, 0, -5 },
  { 143, 4, 5, 4, 0, -5 },
  { 146, 2, 6, 2, 0, -5 },
  { 148, 3, 5, 3, 0, -5 },
  { 150, 2, 6, 2, 0, -5 },
  { 152, 4, 3, 4, 0, -5 },
  { 154, 3, 1, 3, 0, 0 },
  { 155, 2, 1, 3, 0, -5 },
  { 156, 4, 4, 4, 0, -4 },
  { 158, 4, 5, 4, 0, -5 },
  { 161, 3, 4, 3, 0, -4 },
  { 163, 4, 5, 4, 0, -5 },
  { 166, 4, 4, 4, 0, -4 },
  { 168, 3, 5, 3, 0, -5 },
  { 170, 4, 6, 4, 0, -4 },
  { 173, 4, 5, 4, 0, -5 },
  { 176, 2, 5, 2, 0, -5 },
  { 178, 2, 7, 2, 0, -5 },
  { 180, 4, 5, 4, 0, -5 },
  { 183, 2, 5, 2, 0, -5 },
  { 185, 6, 4, 6, 0, -4 },
  { 188, 4, 4, 4, 0, -4 },
  { 190, 4, 4, 4, 0, -4 },
  { 192, 4, 6, 4, 0, -4 },
  { 195, 4, 6, 4, 0, -4 },
  { 198, 3, 4, 3, 0, -4 },
  { 200, 3, 4, 3, 0, -4 },
  { 202, 3, 5, 3, 0, -5 },
  { 204, 4, 4, 4, 0, -4 },
  { 206, 4, 4, 4, 0, -4 },
  { 208, 6, 4, 6, 0, -4 },
  { 211, 4, 4, 4, 0, -4 },
  { 213, 4, 6, 4, 0, -4 },
  { 216, 3, 4, 3, 0, -4 },
  { 218, 3, 6, 3, 0, -5 },
  { 221, 1, 7, 3, 1, -5 },
  { 222, 3, 6, 3, 0, -5 },
  { 225, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold7pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD7PT7B_H_
