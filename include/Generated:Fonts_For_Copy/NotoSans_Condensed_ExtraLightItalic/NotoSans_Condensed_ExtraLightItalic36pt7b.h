#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC36PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x10, 0x20, 0x41, 0x83, 0x04, 0x08, 0x30, 0x60, 0x81,
  0x02, 0x0C, 0x10, 0x20, 0x40, 0x83, 0x00, 0x00, 0x00, 0x40, 0xC1, 0x80,
  0x62, 0xC5, 0x0A, 0x34, 0x58, 0xA1, 0x42, 0x89, 0x10, 0x00, 0x41, 0x00,
  0x21, 0x80, 0x30, 0x80, 0x10, 0x40, 0x08, 0x60, 0x0C, 0x20, 0x04, 0x10,
  0x02, 0x08, 0x1F, 0xFF, 0x81, 0x04, 0x00, 0x82, 0x00, 0x43, 0x00, 0x61,
  0x00, 0x20, 0x80, 0x10, 0xC0, 0x18, 0x40, 0x08, 0x20, 0x7F, 0xFE, 0x06,
  0x10, 0x02, 0x08, 0x01, 0x04, 0x00, 0x84, 0x00, 0x82, 0x00, 0x41, 0x00,
  0x21, 0x80, 0x30, 0x80, 0x00, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x1F,
  0xE0, 0x64, 0x61, 0x88, 0x02, 0x10, 0x04, 0x20, 0x08, 0xC0, 0x11, 0x00,
  0x22, 0x00, 0x64, 0x00, 0x68, 0x00, 0x60, 0x00, 0x70, 0x00, 0xB0, 0x01,
  0x20, 0x02, 0x60, 0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x00, 0x88,
  0x42, 0x30, 0xFF, 0x80, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x0F, 0x00, 0x86, 0x40, 0x63, 0x18, 0x10, 0x82, 0x08, 0x60, 0x82, 0x10,
  0x61, 0x04, 0x18, 0xC1, 0x04, 0x20, 0xC1, 0x18, 0x30, 0x44, 0x08, 0x32,
  0x3A, 0x08, 0x9B, 0x82, 0x4C, 0x61, 0x32, 0x1C, 0xC9, 0x05, 0xE6, 0x41,
  0x01, 0x30, 0x40, 0x88, 0x10, 0x22, 0x04, 0x10, 0x83, 0x0C, 0x20, 0x82,
  0x08, 0x21, 0x82, 0x18, 0x40, 0x84, 0x20, 0x23, 0x18, 0x0F, 0x80, 0x00,
  0xF0, 0x02, 0x30, 0x08, 0x20, 0x10, 0x40, 0x60, 0x80, 0x81, 0x01, 0x06,
  0x02, 0x08, 0x06, 0x30, 0x0C, 0xC0, 0x0B, 0x00, 0x1C, 0x00, 0x30, 0x01,
  0xA0, 0x06, 0x60, 0x18, 0x41, 0x20, 0xC6, 0xC0, 0x89, 0x01, 0x36, 0x03,
  0x4C, 0x03, 0x98, 0x06, 0x30, 0x0C, 0x60, 0x28, 0x61, 0x98, 0x7E, 0x10,
  0x6D, 0x25, 0xA4, 0x90, 0x00, 0x40, 0x20, 0x10, 0x08, 0x06, 0x01, 0x00,
  0xC0, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00,
  0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x30,
  0x0C, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x02, 0x00, 0x40, 0x10,
  0x06, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0,
  0x20, 0x18, 0x04, 0x03, 0x01, 0x80, 0x40, 0x30, 0x18, 0x04, 0x02, 0x00,
  0x02, 0x00, 0x42, 0x08, 0x72, 0x03, 0x42, 0x1F, 0xC3, 0x00, 0x90, 0x22,
  0x08, 0x20, 0x06, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x46, 0x23, 0x10,
  0x88, 0xC0, 0xFF, 0xBC, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x0C, 0x40,
  0x60, 0x83, 0x02, 0x08, 0x08, 0x60, 0x31, 0x00, 0xCC, 0x03, 0x20, 0x08,
  0x80, 0x26, 0x00, 0x98, 0x02, 0x40, 0x09, 0x00, 0x64, 0x01, 0x90, 0x04,
  0xC0, 0x13, 0x00, 0xCC, 0x02, 0x30, 0x08, 0xC0, 0x63, 0x01, 0x0C, 0x0C,
  0x10, 0x60, 0x63, 0x00, 0xF8, 0x00, 0x06, 0x1C, 0x73, 0x2C, 0x51, 0x83,
  0x04, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x18, 0x30, 0x40, 0x81, 0x06,
  0x08, 0x10, 0x20, 0xC1, 0x80, 0x00, 0xF8, 0x0F, 0x18, 0x08, 0x18, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0xFF, 0xE0, 0x01, 0xF0, 0x0E, 0x30, 0x30, 0x10,
  0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x03, 0x80, 0x7C, 0x00, 0x38, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x81, 0xC1, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x50, 0x01, 0xA0, 0x02, 0xC0, 0x09, 0x00, 0x32, 0x00, 0x44, 0x01, 0x18,
  0x06, 0x30, 0x08, 0x40, 0x20, 0x80, 0xC1, 0x03, 0x06, 0x04, 0x0C, 0x18,
  0x10, 0x60, 0x20, 0x80, 0xC2, 0x01, 0x97, 0xFF, 0xC0, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x03, 0xFE, 0x07, 0xFC,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x00, 0xFE, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x81, 0xC1, 0xFE, 0x00, 0x00, 0x7C, 0x07,
  0x10, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x38, 0x1B, 0xB8, 0x70, 0x31, 0x80, 0x46, 0x01, 0x10,
  0x04, 0xC0, 0x13, 0x00, 0x4C, 0x01, 0x30, 0x0C, 0xC0, 0x23, 0x00, 0x84,
  0x06, 0x10, 0x30, 0x61, 0x80, 0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x00, 0x01, 0xF0, 0x06, 0x18, 0x18, 0x10, 0x60,
  0x30, 0x80, 0x61, 0x00, 0xC2, 0x01, 0x84, 0x02, 0x0C, 0x0C, 0x08, 0x10,
  0x18, 0xC0, 0x1B, 0x00, 0x18, 0x00, 0xD8, 0x06, 0x18, 0x18, 0x18, 0x60,
  0x10, 0x80, 0x23, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x98, 0x02, 0x30, 0x04,
  0x20, 0x10, 0x70, 0x60, 0x3F, 0x00, 0x01, 0xF0, 0x0C, 0x60, 0x60, 0xC3,
  0x01, 0x08, 0x04, 0x60, 0x11, 0x00, 0x44, 0x01, 0x10, 0x04, 0xC0, 0x13,
  0x00, 0xCC, 0x03, 0x10, 0x1C, 0x40, 0x71, 0xC6, 0x81, 0xF2, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60,
  0x03, 0x03, 0xF8, 0x00, 0x0C, 0x30, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x43, 0x8C, 0x00, 0x03, 0x03, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x18,
  0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0x80, 0x00, 0x08, 0x00, 0xC0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x18, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00,
  0x10, 0x00, 0x0F, 0x87, 0x18, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18,
  0x02, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80,
  0x30, 0x04, 0x00, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0xC0,
  0x18, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xDE, 0x00, 0x60, 0x18, 0x06, 0x00,
  0x40, 0x60, 0x01, 0x06, 0x00, 0x08, 0x20, 0x00, 0x43, 0x00, 0x02, 0x10,
  0x3F, 0x19, 0x82, 0x10, 0xC8, 0x20, 0x86, 0x43, 0x0C, 0x24, 0x10, 0x41,
  0x21, 0x82, 0x09, 0x08, 0x10, 0x48, 0x41, 0x86, 0xC2, 0x08, 0x26, 0x30,
  0x41, 0x31, 0x86, 0x11, 0x04, 0x31, 0x88, 0x26, 0xD8, 0x60, 0xE3, 0x83,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x20, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x0A, 0x00, 0x28, 0x01, 0xA0, 0x04, 0xC0, 0x33, 0x00, 0x8C, 0x06,
  0x30, 0x10, 0xC0, 0xC3, 0x02, 0x0C, 0x18, 0x30, 0x40, 0xC1, 0xFF, 0x0C,
  0x04, 0x20, 0x11, 0x80, 0x44, 0x01, 0x30, 0x04, 0x80, 0x16, 0x00, 0x50,
  0x01, 0xC0, 0x07, 0x00, 0x10, 0x07, 0xE0, 0x0F, 0xF8, 0x10, 0x10, 0x60,
  0x30, 0xC0, 0x21, 0x00, 0x42, 0x00, 0x8C, 0x03, 0x18, 0x06, 0x20, 0x18,
  0x40, 0x20, 0x81, 0x83, 0xFC, 0x06, 0x0E, 0x08, 0x04, 0x10, 0x0C, 0x20,
  0x08, 0xC0, 0x11, 0x80, 0x22, 0x00, 0xC4, 0x01, 0x88, 0x02, 0x30, 0x0C,
  0x60, 0x30, 0x81, 0xC1, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0x83, 0x06, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x40, 0x1F, 0xC0, 0x07, 0xE0,
  0x07, 0xF8, 0x04, 0x0C, 0x0C, 0x06, 0x0C, 0x02, 0x08, 0x03, 0x08, 0x03,
  0x18, 0x01, 0x18, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x03, 0x30, 0x03,
  0x30, 0x03, 0x20, 0x02, 0x20, 0x02, 0x20, 0x06, 0x60, 0x04, 0x60, 0x0C,
  0x40, 0x0C, 0x40, 0x18, 0x40, 0x30, 0xC0, 0x60, 0x80, 0xC0, 0x83, 0x80,
  0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x03, 0xFF, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x41, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x07, 0xFE, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xE1, 0xC1, 0xC0, 0x21, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x03, 0xF2, 0x00, 0x09,
  0x00, 0x0C, 0x80, 0x06, 0x40, 0x02, 0x20, 0x01, 0x10, 0x01, 0x88, 0x00,
  0xC6, 0x00, 0x41, 0x00, 0x20, 0xC0, 0x10, 0x30, 0x18, 0x0F, 0xF8, 0x00,
  0x04, 0x00, 0x41, 0x00, 0x30, 0x40, 0x0C, 0x30, 0x02, 0x0C, 0x00, 0x82,
  0x00, 0x20, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x04, 0x00, 0x41, 0x00,
  0x10, 0x40, 0x0C, 0x3F, 0xFE, 0x0C, 0x00, 0x82, 0x00, 0x20, 0x80, 0x18,
  0x20, 0x06, 0x18, 0x01, 0x06, 0x00, 0x41, 0x00, 0x10, 0x40, 0x0C, 0x10,
  0x03, 0x0C, 0x00, 0x82, 0x00, 0x20, 0x80, 0x08, 0x20, 0x06, 0x00, 0x07,
  0xE0, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x1F, 0x80, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x0F, 0x00, 0x04,
  0x01, 0x82, 0x01, 0x81, 0x01, 0x81, 0x81, 0x80, 0x81, 0x80, 0x40, 0x80,
  0x20, 0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x08, 0xC0, 0x04, 0xC0, 0x02, 0x40,
  0x03, 0x70, 0x01, 0xD8, 0x00, 0xC4, 0x00, 0x42, 0x00, 0x21, 0x80, 0x30,
  0x40, 0x18, 0x20, 0x08, 0x18, 0x04, 0x04, 0x02, 0x02, 0x03, 0x01, 0x81,
  0x00, 0xC0, 0x80, 0x20, 0x40, 0x18, 0x00, 0x04, 0x02, 0x01, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80,
  0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x7F,
  0xC0, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x70, 0x00,
  0xF0, 0xA0, 0x01, 0x41, 0x40, 0x06, 0x82, 0x80, 0x09, 0x0D, 0x80, 0x36,
  0x1B, 0x00, 0x4C, 0x26, 0x01, 0x90, 0x44, 0x02, 0x20, 0x88, 0x0C, 0xC3,
  0x10, 0x11, 0x86, 0x20, 0x62, 0x08, 0x40, 0x84, 0x10, 0x83, 0x08, 0x21,
  0x04, 0x30, 0xC2, 0x18, 0x61, 0x06, 0x20, 0x82, 0x0C, 0xC1, 0x04, 0x19,
  0x02, 0x08, 0x36, 0x0C, 0x30, 0x28, 0x18, 0x40, 0x70, 0x20, 0x80, 0xC0,
  0x41, 0x01, 0x81, 0x80, 0x06, 0x00, 0x60, 0xC0, 0x08, 0x18, 0x01, 0x07,
  0x00, 0x20, 0xB0, 0x0C, 0x12, 0x01, 0x02, 0x40, 0x20, 0xC8, 0x04, 0x19,
  0x81, 0x82, 0x10, 0x30, 0x42, 0x04, 0x08, 0x40, 0x83, 0x0C, 0x10, 0x60,
  0x86, 0x08, 0x10, 0xC1, 0x02, 0x10, 0x20, 0x62, 0x0C, 0x04, 0x41, 0x80,
  0x98, 0x20, 0x13, 0x04, 0x03, 0x40, 0x80, 0x28, 0x30, 0x05, 0x04, 0x00,
  0xE0, 0x80, 0x18, 0x10, 0x01, 0x00, 0x00, 0xF8, 0x03, 0x8C, 0x06, 0x06,
  0x0C, 0x03, 0x18, 0x01, 0x10, 0x01, 0x30, 0x01, 0x20, 0x01, 0x60, 0x01,
  0x60, 0x01, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x08,
  0xC0, 0x18, 0xC0, 0x10, 0x40, 0x30, 0x70, 0xE0, 0x1F, 0x80, 0x07, 0xE0,
  0x0F, 0xF0, 0x10, 0x30, 0x60, 0x20, 0xC0, 0x41, 0x00, 0xC2, 0x01, 0x8C,
  0x02, 0x18, 0x04, 0x20, 0x08, 0x40, 0x30, 0x80, 0x43, 0x01, 0x06, 0x0C,
  0x0F, 0xF0, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x00, 0x00,
  0xF8, 0x03, 0x8C, 0x06, 0x06, 0x0C, 0x03, 0x18, 0x01, 0x10, 0x01, 0x30,
  0x01, 0x20, 0x01, 0x60, 0x01, 0x60, 0x01, 0x40, 0x01, 0x40, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80,
  0x04, 0x80, 0x0C, 0x80, 0x08, 0xC0, 0x18, 0xC0, 0x10, 0x40, 0x20, 0x70,
  0xE0, 0x3F, 0x80, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x10, 0x30, 0x60, 0x20, 0xC0,
  0x41, 0x00, 0xC2, 0x01, 0x8C, 0x02, 0x18, 0x04, 0x20, 0x18, 0x40, 0x30,
  0x80, 0xC3, 0x03, 0x07, 0xFC, 0x0F, 0xE0, 0x10, 0xC0, 0x20, 0x80, 0xC1,
  0x01, 0x83, 0x02, 0x06, 0x04, 0x04, 0x08, 0x08, 0x30, 0x10, 0x40, 0x30,
  0x80, 0x61, 0x00, 0x40, 0x00, 0xFE, 0x03, 0x87, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x40, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC1,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x84, 0x00, 0xC6, 0x00, 0x43, 0x00, 0x21,
  0x00, 0x10, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x04, 0x20, 0x02, 0x10, 0x01,
  0x08, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x42, 0x00, 0x21, 0x00, 0x30, 0x80,
  0x18, 0xC0, 0x08, 0x60, 0x04, 0x20, 0x02, 0x10, 0x03, 0x08, 0x01, 0x04,
  0x00, 0x82, 0x00, 0xC1, 0x80, 0xC0, 0x60, 0xC0, 0x1F, 0xC0, 0x00, 0xC0,
  0x07, 0x80, 0x0B, 0x00, 0x36, 0x00, 0x4C, 0x01, 0x98, 0x02, 0x30, 0x0C,
  0x20, 0x10, 0x40, 0x60, 0x80, 0x81, 0x03, 0x02, 0x04, 0x04, 0x08, 0x08,
  0x30, 0x10, 0x40, 0x21, 0x80, 0x42, 0x00, 0x8C, 0x01, 0x10, 0x02, 0x60,
  0x04, 0x80, 0x0B, 0x00, 0x14, 0x00, 0x28, 0x00, 0x70, 0x00, 0xC0, 0x00,
  0xC0, 0x18, 0x03, 0xC0, 0x18, 0x02, 0xC0, 0x18, 0x02, 0xC0, 0x28, 0x06,
  0xC0, 0x28, 0x04, 0xC0, 0x68, 0x0C, 0xC0, 0x48, 0x08, 0xC0, 0x48, 0x18,
  0xC0, 0x88, 0x18, 0xC0, 0x88, 0x10, 0xC1, 0x88, 0x30, 0xC1, 0x08, 0x20,
  0xC3, 0x08, 0x60, 0xC2, 0x08, 0x40, 0xC2, 0x08, 0x40, 0x46, 0x08, 0xC0,
  0x44, 0x08, 0x80, 0x4C, 0x09, 0x80, 0x48, 0x09, 0x00, 0x48, 0x09, 0x00,
  0x50, 0x0B, 0x00, 0x50, 0x0A, 0x00, 0x70, 0x0E, 0x00, 0x60, 0x0C, 0x00,
  0x60, 0x0C, 0x00, 0x40, 0x08, 0x00, 0x03, 0x00, 0xC0, 0xC0, 0x20, 0x10,
  0x18, 0x04, 0x0C, 0x01, 0x02, 0x00, 0x61, 0x80, 0x18, 0x40, 0x02, 0x20,
  0x00, 0x98, 0x00, 0x24, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x1E, 0x00, 0x05, 0x80, 0x02, 0x20, 0x01, 0x88, 0x00, 0x42,
  0x00, 0x30, 0x80, 0x18, 0x30, 0x04, 0x04, 0x03, 0x01, 0x00, 0x80, 0x40,
  0x40, 0x10, 0x30, 0x06, 0x00, 0xC0, 0x1E, 0x00, 0xB0, 0x0C, 0x80, 0x44,
  0x06, 0x20, 0x21, 0x02, 0x0C, 0x30, 0x61, 0x01, 0x18, 0x08, 0x80, 0x4C,
  0x02, 0x40, 0x14, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x00,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF8, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0xF8, 0x1F, 0xC0,
  0x84, 0x21, 0x0C, 0x61, 0x08, 0x42, 0x10, 0xC2, 0x10, 0x84, 0x21, 0x8C,
  0x21, 0x08, 0x42, 0x18, 0xC0, 0x03, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x03, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x90, 0x06, 0x60, 0x10, 0x80, 0xC2, 0x02, 0x0C, 0x18,
  0x10, 0x40, 0x62, 0x00, 0x98, 0x02, 0x40, 0x0F, 0x00, 0x10, 0xFF, 0xFF,
  0xFC, 0xC4, 0x42, 0x21, 0x03, 0xE4, 0x30, 0xD1, 0x81, 0xC4, 0x06, 0x30,
  0x18, 0x80, 0x66, 0x01, 0x98, 0x06, 0x40, 0x11, 0x00, 0x4C, 0x01, 0x30,
  0x0C, 0xC0, 0x33, 0x00, 0x8C, 0x06, 0x30, 0x18, 0x40, 0xE1, 0x85, 0x03,
  0xE4, 0x00, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0xF8, 0x16, 0x18, 0x28, 0x10, 0x60,
  0x20, 0xC0, 0x63, 0x00, 0xC6, 0x01, 0x88, 0x02, 0x10, 0x04, 0x60, 0x08,
  0xC0, 0x31, 0x00, 0x62, 0x00, 0x84, 0x03, 0x18, 0x04, 0x30, 0x18, 0x50,
  0x20, 0xA1, 0x83, 0x3E, 0x00, 0x03, 0xF0, 0xC0, 0x18, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x08, 0x3F, 0x00, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x03, 0xE4, 0x0C, 0x34, 0x18, 0x1C, 0x10, 0x0C, 0x30, 0x08,
  0x20, 0x08, 0x60, 0x18, 0x60, 0x18, 0x40, 0x18, 0x40, 0x10, 0xC0, 0x10,
  0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x20, 0xC0, 0x60, 0xC0, 0xE0, 0x40, 0xA0,
  0x61, 0x60, 0x3E, 0x40, 0x03, 0xE0, 0xC3, 0x18, 0x11, 0x01, 0x30, 0x12,
  0x03, 0x60, 0x64, 0x0C, 0x43, 0x87, 0xE0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x08, 0x3F, 0x80, 0x00, 0x01, 0x00,
  0x07, 0xC0, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0xFE, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x1F,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xF2, 0x0C, 0x34, 0x30, 0x28, 0x40, 0x31,
  0x80, 0x42, 0x00, 0x8C, 0x03, 0x18, 0x06, 0x20, 0x0C, 0x40, 0x11, 0x80,
  0x23, 0x00, 0xC6, 0x01, 0x8C, 0x06, 0x18, 0x0C, 0x30, 0x38, 0x20, 0x50,
  0x61, 0x60, 0x7C, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC1, 0x03, 0x03, 0xFC, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0D,
  0xF8, 0x2C, 0x30, 0xA0, 0xC3, 0x01, 0x08, 0x0C, 0x60, 0x31, 0x80, 0x84,
  0x02, 0x10, 0x08, 0xC0, 0x63, 0x01, 0x88, 0x04, 0x20, 0x10, 0x80, 0x46,
  0x03, 0x18, 0x0C, 0x40, 0x21, 0x00, 0x8C, 0x06, 0x00, 0x02, 0x0C, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x0C, 0x10, 0x20, 0x41, 0x82, 0x04, 0x08, 0x30,
  0x60, 0x81, 0x02, 0x0C, 0x18, 0x20, 0x41, 0x80, 0x00, 0x10, 0x01, 0xC0,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80,
  0x08, 0x07, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x0C, 0x20, 0x60, 0x83,
  0x02, 0x18, 0x08, 0x40, 0x62, 0x01, 0x10, 0x04, 0xC0, 0x17, 0x00, 0xF4,
  0x03, 0x90, 0x0C, 0x40, 0x21, 0x80, 0x82, 0x06, 0x08, 0x18, 0x30, 0x40,
  0xC1, 0x01, 0x0C, 0x04, 0x00, 0x03, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04,
  0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30,
  0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0xC0, 0x0D, 0xF1, 0xF8, 0x2C,
  0x6C, 0x30, 0xE0, 0xA0, 0xC3, 0x03, 0x03, 0x08, 0x0C, 0x0C, 0x60, 0x20,
  0x31, 0x80, 0x80, 0x84, 0x06, 0x02, 0x10, 0x18, 0x08, 0xC0, 0x40, 0x63,
  0x01, 0x01, 0x88, 0x04, 0x04, 0x20, 0x30, 0x10, 0x80, 0x80, 0x46, 0x02,
  0x03, 0x18, 0x08, 0x08, 0x40, 0x60, 0x21, 0x01, 0x80, 0x8C, 0x04, 0x06,
  0x00, 0x0D, 0xF8, 0x2C, 0x30, 0xE0, 0xC3, 0x01, 0x18, 0x0C, 0x60, 0x31,
  0x80, 0x84, 0x02, 0x10, 0x08, 0xC0, 0x63, 0x01, 0x88, 0x04, 0x20, 0x10,
  0x80, 0x46, 0x03, 0x18, 0x0C, 0x40, 0x21, 0x00, 0x8C, 0x06, 0x00, 0x03,
  0xE0, 0x61, 0x86, 0x06, 0x20, 0x33, 0x00, 0x90, 0x05, 0x80, 0x2C, 0x01,
  0x40, 0x1A, 0x00, 0xF0, 0x07, 0x80, 0x2C, 0x01, 0x60, 0x1B, 0x00, 0x98,
  0x0C, 0x40, 0xC3, 0x0C, 0x0F, 0xC0, 0x06, 0x7C, 0x04, 0x86, 0x05, 0x02,
  0x06, 0x02, 0x06, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x08, 0x02, 0x08, 0x02,
  0x18, 0x02, 0x18, 0x02, 0x10, 0x06, 0x10, 0x04, 0x10, 0x0C, 0x30, 0x0C,
  0x30, 0x18, 0x28, 0x10, 0x28, 0x70, 0x27, 0xC0, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x07, 0xE4, 0x30, 0xD1, 0x81, 0x44, 0x07, 0x30, 0x08, 0x80, 0x26, 0x00,
  0x98, 0x06, 0x40, 0x19, 0x00, 0x4C, 0x01, 0x30, 0x0C, 0xC0, 0x33, 0x00,
  0xCC, 0x06, 0x30, 0x38, 0x40, 0xA1, 0x85, 0x83, 0xE4, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x0D, 0xF0, 0xB0, 0x0A, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x00, 0x0F, 0xF1, 0x82, 0x10, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x88, 0x30, 0xFE, 0x00, 0x04, 0x08,
  0x08, 0x08, 0x18, 0x7F, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x60,
  0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x80, 0x80, 0xC0, 0x78, 0x18, 0x0C,
  0x40, 0x21, 0x00, 0x84, 0x02, 0x30, 0x18, 0xC0, 0x62, 0x01, 0x08, 0x04,
  0x20, 0x11, 0x80, 0xC4, 0x02, 0x10, 0x08, 0x40, 0x23, 0x01, 0x8C, 0x06,
  0x30, 0x30, 0xC1, 0xC1, 0x0D, 0x07, 0xE4, 0x00, 0x80, 0x38, 0x06, 0x80,
  0x48, 0x0C, 0xC0, 0x8C, 0x18, 0xC1, 0x0C, 0x30, 0xC2, 0x0C, 0x20, 0xC4,
  0x04, 0x40, 0x4C, 0x04, 0x80, 0x58, 0x05, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x00, 0x80, 0x40, 0x70, 0x18, 0x0A, 0x03, 0x03, 0x40, 0xE0, 0x48, 0x14,
  0x19, 0x06, 0x82, 0x30, 0x90, 0x46, 0x12, 0x18, 0xC4, 0x42, 0x18, 0x88,
  0xC3, 0x31, 0x10, 0x64, 0x22, 0x0D, 0x84, 0x81, 0xA0, 0x90, 0x34, 0x16,
  0x07, 0x02, 0x80, 0xE0, 0x50, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x00, 0x08,
  0x04, 0x30, 0x20, 0x41, 0x81, 0x04, 0x04, 0x20, 0x19, 0x80, 0x2C, 0x00,
  0xA0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x60, 0x0C, 0x80, 0x62, 0x01,
  0x08, 0x08, 0x30, 0x60, 0x41, 0x01, 0x08, 0x06, 0x00, 0x03, 0x00, 0xC0,
  0x40, 0x20, 0x10, 0x18, 0x04, 0x04, 0x01, 0x03, 0x00, 0x40, 0x80, 0x10,
  0x60, 0x04, 0x10, 0x01, 0x04, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x40,
  0x01, 0x10, 0x00, 0x6C, 0x00, 0x1A, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x06, 0x00, 0x3F, 0xE0, 0x00, 0x18, 0x07, 0x80, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x60, 0x1E, 0x00, 0xE0, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xF0, 0x01, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x3C, 0x00, 0x60, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0xC0, 0x07, 0x00, 0xF0, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x01,
  0x80, 0xF0, 0x08, 0x00, 0x7C, 0x0C, 0x1C, 0xE0, 0x3C,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 26, 8, 1, -26 },
  { 24, 7, 10, 10, 4, -26 },
  { 33, 17, 26, 16, 0, -26 },
  { 89, 15, 29, 15, 0, -27 },
  { 144, 18, 26, 22, 2, -26 },
  { 203, 15, 26, 16, 0, -26 },
  { 252, 3, 10, 6, 4, -26 },
  { 256, 10, 32, 9, 1, -26 },
  { 296, 10, 32, 9, -2, -26 },
  { 336, 11, 11, 14, 4, -27 },
  { 352, 13, 17, 16, 2, -21 },
  { 380, 5, 9, 6, -2, -4 },
  { 386, 8, 1, 10, 1, -10 },
  { 387, 2, 3, 6, 1, -3 },
  { 388, 16, 26, 11, -2, -26 },
  { 440, 14, 26, 15, 1, -26 },
  { 486, 7, 26, 15, 5, -26 },
  { 509, 15, 26, 15, -1, -26 },
  { 558, 15, 26, 15, 0, -26 },
  { 607, 15, 26, 15, 0, -26 },
  { 656, 15, 26, 15, 0, -26 },
  { 705, 14, 26, 15, 1, -26 },
  { 751, 14, 26, 15, 2, -26 },
  { 797, 15, 26, 15, 0, -26 },
  { 846, 14, 26, 15, 0, -26 },
  { 892, 6, 19, 6, 0, -19 },
  { 907, 8, 24, 7, -2, -19 },
  { 931, 13, 16, 16, 2, -21 },
  { 957, 13, 9, 16, 2, -17 },
  { 972, 13, 16, 16, 2, -21 },
  { 998, 11, 26, 11, 1, -26 },
  { 1034, 21, 29, 22, 1, -26 },
  { 1111, 14, 26, 15, -2, -26 },
  { 1157, 15, 26, 16, 1, -26 },
  { 1206, 16, 26, 15, 2, -26 },
  { 1258, 16, 26, 18, 1, -26 },
  { 1310, 15, 26, 14, 1, -26 },
  { 1359, 15, 26, 13, 1, -26 },
  { 1408, 17, 26, 19, 2, -26 },
  { 1464, 18, 26, 19, 1, -26 },
  { 1523, 11, 26, 8, -1, -26 },
  { 1559, 12, 32, 7, -5, -26 },
  { 1607, 17, 26, 15, 1, -26 },
  { 1663, 9, 26, 13, 1, -26 },
  { 1693, 23, 26, 24, 1, -26 },
  { 1768, 19, 26, 19, 1, -26 },
  { 1830, 16, 26, 19, 2, -26 },
  { 1882, 15, 26, 15, 1, -26 },
  { 1931, 16, 32, 19, 2, -26 },
  { 1995, 15, 26, 15, 1, -26 },
  { 2044, 16, 26, 14, -1, -26 },
  { 2096, 13, 26, 13, 3, -26 },
  { 2139, 17, 26, 18, 2, -26 },
  { 2195, 15, 26, 15, 3, -26 },
  { 2244, 24, 26, 24, 3, -26 },
  { 2322, 18, 26, 13, -2, -26 },
  { 2381, 13, 26, 13, 3, -26 },
  { 2424, 17, 26, 14, -1, -26 },
  { 2480, 13, 32, 10, -1, -26 },
  { 2532, 5, 26, 12, 4, -26 },
  { 2549, 13, 32, 10, -2, -26 },
  { 2601, 14, 14, 16, 1, -26 },
  { 2626, 11, 2, 11, -3, 3 },
  { 2629, 4, 6, 8, 5, -28 },
  { 2632, 14, 19, 16, 1, -19 },
  { 2666, 15, 27, 16, 0, -27 },
  { 2717, 12, 19, 12, 1, -19 },
  { 2746, 16, 27, 16, 1, -27 },
  { 2800, 12, 19, 14, 1, -19 },
  { 2829, 17, 37, 8, -5, -28 },
  { 2908, 15, 28, 16, 0, -19 },
  { 2961, 14, 27, 15, 0, -27 },
  { 3009, 7, 26, 6, 0, -26 },
  { 3032, 13, 35, 7, -5, -26 },
  { 3089, 14, 27, 13, 0, -27 },
  { 3137, 8, 27, 6, 0, -27 },
  { 3164, 22, 19, 23, 0, -19 },
  { 3217, 14, 19, 15, 0, -19 },
  { 3251, 13, 19, 15, 1, -19 },
  { 3282, 16, 27, 16, -1, -19 },
  { 3336, 14, 27, 16, 1, -19 },
  { 3384, 12, 19, 10, 0, -19 },
  { 3413, 12, 19, 12, 0, -19 },
  { 3442, 8, 24, 8, 1, -24 },
  { 3466, 14, 19, 15, 1, -19 },
  { 3500, 12, 19, 12, 2, -19 },
  { 3529, 19, 19, 19, 2, -19 },
  { 3575, 14, 19, 12, -1, -19 },
  { 3609, 18, 28, 12, -4, -19 },
  { 3672, 13, 19, 11, -1, -19 },
  { 3703, 13, 32, 11, 1, -26 },
  { 3755, 1, 36, 15, 7, -27 },
  { 3760, 12, 32, 11, -2, -26 },
  { 3808, 13, 3, 16, 2, -14 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC36PT7B_H_
