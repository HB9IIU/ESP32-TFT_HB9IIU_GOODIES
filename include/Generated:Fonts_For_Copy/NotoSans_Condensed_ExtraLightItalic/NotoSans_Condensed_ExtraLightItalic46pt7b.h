#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC46PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x80, 0xC0, 0x60, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x81,
  0xC0, 0xC0, 0x00, 0x30, 0xC8, 0x66, 0x19, 0x86, 0x61, 0x90, 0x44, 0x13,
  0x0C, 0xC3, 0x20, 0x88, 0x22, 0x08, 0x00, 0x30, 0x20, 0x03, 0x06, 0x00,
  0x20, 0x60, 0x06, 0x04, 0x00, 0x60, 0xC0, 0x04, 0x0C, 0x00, 0x40, 0x80,
  0x0C, 0x08, 0x00, 0xC1, 0x80, 0x08, 0x10, 0x1F, 0xFF, 0xF0, 0x18, 0x30,
  0x01, 0x03, 0x00, 0x30, 0x20, 0x03, 0x06, 0x00, 0x20, 0x60, 0x06, 0x04,
  0x00, 0x60, 0xC0, 0x04, 0x0C, 0x00, 0x40, 0x80, 0x0C, 0x08, 0x0F, 0xFF,
  0xF8, 0x08, 0x18, 0x01, 0x81, 0x00, 0x18, 0x30, 0x01, 0x03, 0x00, 0x30,
  0x20, 0x03, 0x06, 0x00, 0x20, 0x60, 0x02, 0x04, 0x00, 0x60, 0x40, 0x06,
  0x0C, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x07, 0xF8, 0x03, 0xF7, 0xC0, 0xE2, 0x08, 0x30, 0x40,
  0x06, 0x18, 0x00, 0x83, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x41, 0x00,
  0x0C, 0x60, 0x01, 0x8C, 0x00, 0x19, 0x00, 0x01, 0xA0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x05, 0xC0, 0x00, 0x9C, 0x00, 0x11, 0x80,
  0x06, 0x18, 0x00, 0x83, 0x00, 0x10, 0x60, 0x02, 0x0C, 0x00, 0xC1, 0x00,
  0x18, 0x60, 0x02, 0x18, 0x20, 0x47, 0x07, 0xFF, 0xC0, 0x3F, 0xC0, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x80, 0x0C, 0x19, 0x80, 0x30, 0x61, 0x80, 0x41, 0x83, 0x01, 0x83,
  0x06, 0x06, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x30, 0x20, 0x30, 0x40, 0xC0,
  0x41, 0x81, 0x80, 0x82, 0x03, 0x03, 0x0C, 0x06, 0x06, 0x30, 0x08, 0x0C,
  0x60, 0x10, 0x11, 0x8F, 0x20, 0x62, 0x3B, 0x40, 0xCC, 0xC3, 0x83, 0x11,
  0x07, 0x86, 0x66, 0x0F, 0x19, 0x88, 0x1B, 0xE3, 0x30, 0x30, 0x0C, 0x60,
  0x60, 0x10, 0x80, 0xC0, 0x61, 0x01, 0x80, 0x86, 0x02, 0x03, 0x0C, 0x0C,
  0x0C, 0x18, 0x18, 0x18, 0x30, 0x30, 0x60, 0x40, 0x40, 0x80, 0x81, 0x83,
  0x01, 0x82, 0x04, 0x03, 0x0C, 0x18, 0x06, 0x30, 0x60, 0x07, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x3E, 0x00, 0x0C, 0x60, 0x03, 0x06, 0x00, 0xC0, 0xC0,
  0x18, 0x18, 0x02, 0x03, 0x00, 0x40, 0x60, 0x18, 0x08, 0x03, 0x03, 0x00,
  0x20, 0x60, 0x04, 0x18, 0x00, 0xC6, 0x00, 0x19, 0x80, 0x03, 0x60, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0xCC, 0x00, 0x31, 0x80, 0x0C,
  0x18, 0x33, 0x03, 0x06, 0x60, 0x30, 0x98, 0x06, 0x33, 0x00, 0xC4, 0x40,
  0x0D, 0x98, 0x01, 0xE3, 0x00, 0x1C, 0x60, 0x03, 0x0C, 0x00, 0xE0, 0x80,
  0x36, 0x18, 0x0C, 0xC1, 0x87, 0x0C, 0x1F, 0xC1, 0x80, 0x32, 0x66, 0x64,
  0x4C, 0xC8, 0x88, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x00, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0xE1, 0x01, 0xC4, 0x01,
  0xD0, 0xC1, 0xFF, 0x03, 0x00, 0x16, 0x01, 0x88, 0x0C, 0x30, 0x60, 0x41,
  0x01, 0x80, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x30, 0xC6, 0x18, 0x43, 0x08, 0x61, 0x0C,
  0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0xE7, 0x00, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x10, 0x60,
  0x08, 0x20, 0x06, 0x30, 0x03, 0x10, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x44,
  0x00, 0x26, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0x80, 0x06, 0xC0, 0x03,
  0x60, 0x01, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x64, 0x00, 0x22, 0x00,
  0x31, 0x00, 0x18, 0x80, 0x08, 0x40, 0x0C, 0x20, 0x06, 0x10, 0x06, 0x0C,
  0x03, 0x06, 0x03, 0x03, 0x03, 0x00, 0xE3, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0x81, 0xC3, 0xE3, 0xB3, 0x13, 0x1B, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80,
  0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40,
  0x00, 0x00, 0x7F, 0x80, 0x3E, 0x78, 0x06, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x78,
  0x70, 0x1C, 0x03, 0x01, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x20, 0x0E, 0x07, 0x07, 0x80,
  0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0x60, 0x00, 0x6C, 0x00, 0x19, 0x00, 0x02, 0x20, 0x00, 0xCC,
  0x00, 0x31, 0x80, 0x04, 0x30, 0x01, 0x84, 0x00, 0x61, 0x80, 0x08, 0x30,
  0x03, 0x06, 0x00, 0xC0, 0x80, 0x30, 0x10, 0x06, 0x06, 0x01, 0x80, 0xC0,
  0x60, 0x18, 0x0C, 0x02, 0x03, 0x00, 0x40, 0xC0, 0x18, 0x10, 0x03, 0x07,
  0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1B, 0x80, 0x03, 0xFE, 0x00,
  0x40, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x20,
  0x0E, 0x07, 0x07, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x1E, 0x20,
  0x1C, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0xFC, 0x06, 0xF3, 0x81, 0xE0, 0x30, 0x50, 0x04, 0x38, 0x01, 0x8E,
  0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x62, 0x00,
  0x18, 0x80, 0x04, 0x20, 0x03, 0x08, 0x00, 0xC3, 0x00, 0x20, 0xC0, 0x18,
  0x30, 0x0C, 0x06, 0x07, 0x01, 0xC3, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0xFF,
  0x9F, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x1C, 0x70, 0x06, 0x03, 0x01, 0x80, 0x30, 0x20, 0x06, 0x0C, 0x00, 0xC1,
  0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x08, 0x18, 0x03, 0x01,
  0x80, 0xC0, 0x30, 0x30, 0x03, 0x0C, 0x00, 0x37, 0x00, 0x03, 0x80, 0x01,
  0xF0, 0x00, 0xE3, 0x00, 0x38, 0x30, 0x0C, 0x03, 0x03, 0x00, 0x60, 0xC0,
  0x06, 0x18, 0x00, 0xC2, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00,
  0x0C, 0x60, 0x01, 0x84, 0x00, 0x60, 0xC0, 0x0C, 0x1C, 0x03, 0x01, 0xC1,
  0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x38, 0xE0, 0x18, 0x18, 0x0C,
  0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0xC0, 0x04, 0x30, 0x01, 0x08, 0x00,
  0x46, 0x00, 0x11, 0x80, 0x04, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31,
  0x80, 0x1C, 0x60, 0x07, 0x08, 0x03, 0x83, 0x01, 0xA0, 0x71, 0xD8, 0x0F,
  0xC6, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x03, 0x07, 0x00, 0xFF, 0x00, 0x00, 0x02, 0x07, 0x07, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE0, 0x60, 0x00, 0x80, 0x70, 0x1C,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x10, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xE1, 0xE3, 0x84, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x86, 0x00, 0x40, 0x21, 0x00, 0xFE, 0x0C,
  0xC0, 0x61, 0x83, 0x30, 0x30, 0x60, 0xC8, 0x18, 0x10, 0x26, 0x0C, 0x0C,
  0x09, 0x83, 0x03, 0x02, 0x40, 0x80, 0x81, 0xB0, 0x60, 0x20, 0x6C, 0x10,
  0x18, 0x1B, 0x04, 0x06, 0x04, 0x83, 0x01, 0x03, 0x20, 0xC0, 0xC0, 0xC8,
  0x30, 0x30, 0x22, 0x0C, 0x1C, 0x18, 0x83, 0x05, 0x0C, 0x20, 0x43, 0x42,
  0x08, 0x1F, 0x9F, 0x02, 0x03, 0x83, 0x80, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x20, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x60, 0x00,
  0x6C, 0x00, 0x09, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x03,
  0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x02, 0x0C, 0x00, 0xC1, 0x80, 0x10,
  0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x0C, 0x00, 0x81, 0x80, 0x10, 0x60, 0x02, 0x0C, 0x00,
  0x41, 0x00, 0x08, 0x60, 0x01, 0x0C, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00,
  0xD8, 0x00, 0x1B, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x01, 0xFE, 0x00, 0x3F,
  0xF8, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x00, 0x60, 0x20, 0x03, 0x06,
  0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x20, 0x40, 0x06, 0x04, 0x00, 0x60,
  0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x18, 0x08, 0x07, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0x80, 0x70, 0x18, 0x03, 0x01, 0x00, 0x18, 0x30, 0x01,
  0x83, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x18, 0x20, 0x01, 0x86, 0x00,
  0x18, 0x60, 0x03, 0x06, 0x00, 0x30, 0x40, 0x06, 0x04, 0x00, 0xE0, 0xC0,
  0x1C, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xC7,
  0x00, 0xE0, 0x10, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE1, 0xC0, 0x0F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0xC0, 0x70, 0x06, 0x00, 0xC0, 0x30, 0x07, 0x01, 0x00, 0x18, 0x18, 0x00,
  0xC0, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x20, 0x00, 0xC3, 0x00, 0x06, 0x18,
  0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x20, 0x00, 0x63, 0x00, 0x02,
  0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x20, 0x00, 0x63, 0x00,
  0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x18, 0x20, 0x00, 0xC3,
  0x00, 0x0C, 0x18, 0x00, 0xC0, 0xC0, 0x0E, 0x04, 0x00, 0xE0, 0x60, 0x0E,
  0x03, 0x01, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0xF8, 0x7C, 0x03, 0x80, 0x10, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x1F, 0xE3, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x18,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x41, 0x80,
  0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x08, 0x06, 0x00,
  0x10, 0x06, 0x00, 0x60, 0x0F, 0x03, 0xC0, 0x07, 0xFF, 0x00, 0x01, 0x00,
  0x02, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00,
  0x40, 0x40, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C,
  0x08, 0x00, 0x10, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81,
  0x80, 0x02, 0x02, 0x00, 0x04, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x30,
  0x00, 0x60, 0x60, 0x00, 0x80, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x0C, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x20, 0x20, 0x00, 0xC0, 0xC0, 0x01,
  0x81, 0x80, 0x03, 0x03, 0x00, 0x06, 0x04, 0x00, 0x08, 0x18, 0x00, 0x30,
  0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x00, 0x01, 0xFE, 0x00,
  0xE0, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0x00, 0x1C,
  0x0C, 0x00, 0xE0, 0x30, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x08,
  0x06, 0x00, 0x60, 0x30, 0x01, 0x81, 0x80, 0x06, 0x0E, 0x00, 0x10, 0x30,
  0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x00, 0x00,
  0x9C, 0x00, 0x06, 0x70, 0x00, 0x1B, 0xC0, 0x00, 0x79, 0x00, 0x01, 0xC6,
  0x00, 0x06, 0x18, 0x00, 0x30, 0x20, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00,
  0x08, 0x0C, 0x00, 0x20, 0x18, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x18,
  0x02, 0x00, 0x40, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x01,
  0x80, 0xC0, 0x06, 0x00, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0A, 0x02, 0xC0, 0x00,
  0x78, 0x0B, 0x00, 0x01, 0x60, 0x6C, 0x00, 0x0D, 0x81, 0xB0, 0x00, 0x24,
  0x06, 0xC0, 0x01, 0xB0, 0x13, 0x00, 0x0C, 0xC0, 0xCC, 0x00, 0x33, 0x03,
  0x30, 0x01, 0x8C, 0x0C, 0x40, 0x06, 0x20, 0x31, 0x00, 0x31, 0x80, 0x84,
  0x00, 0xC6, 0x06, 0x10, 0x06, 0x18, 0x18, 0x60, 0x18, 0x60, 0x61, 0x80,
  0xC1, 0x01, 0x86, 0x03, 0x0C, 0x04, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60,
  0xC0, 0xC1, 0x83, 0x02, 0x03, 0x06, 0x0C, 0x18, 0x08, 0x08, 0x60, 0x60,
  0x20, 0x21, 0x81, 0x81, 0x80, 0x8C, 0x06, 0x06, 0x02, 0x30, 0x10, 0x18,
  0x09, 0x80, 0xC0, 0x40, 0x36, 0x03, 0x03, 0x00, 0xF0, 0x0C, 0x0C, 0x03,
  0xC0, 0x30, 0x30, 0x0E, 0x00, 0x80, 0xC0, 0x38, 0x06, 0x00, 0x01, 0x80,
  0x03, 0x03, 0x80, 0x03, 0x03, 0x80, 0x03, 0x03, 0x80, 0x02, 0x02, 0xC0,
  0x06, 0x02, 0xC0, 0x06, 0x06, 0x40, 0x06, 0x06, 0x40, 0x04, 0x06, 0x60,
  0x04, 0x04, 0x60, 0x0C, 0x0C, 0x20, 0x0C, 0x0C, 0x20, 0x0C, 0x0C, 0x30,
  0x08, 0x0C, 0x30, 0x18, 0x08, 0x10, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x10, 0x18, 0x08, 0x30, 0x10, 0x0C, 0x30, 0x30, 0x0C,
  0x30, 0x30, 0x0C, 0x30, 0x30, 0x04, 0x20, 0x20, 0x06, 0x60, 0x20, 0x06,
  0x60, 0x60, 0x06, 0x60, 0x60, 0x02, 0x40, 0x60, 0x03, 0x40, 0x40, 0x03,
  0xC0, 0xC0, 0x03, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x01,
  0x80, 0x00, 0x3F, 0x80, 0x07, 0x8F, 0x00, 0x70, 0x1C, 0x07, 0x00, 0x60,
  0x30, 0x01, 0x83, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x01, 0x18, 0x00,
  0x08, 0xC0, 0x00, 0x4C, 0x00, 0x02, 0x60, 0x00, 0x13, 0x00, 0x01, 0x90,
  0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00,
  0xD0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00,
  0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x46, 0x00, 0x06, 0x30, 0x00, 0x60,
  0xC0, 0x03, 0x06, 0x00, 0x30, 0x30, 0x03, 0x80, 0xC0, 0x38, 0x03, 0x87,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x0C, 0x06, 0x01,
  0x80, 0x60, 0x30, 0x0C, 0x04, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x06,
  0x00, 0x60, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x20, 0xC0, 0x0C, 0x18,
  0x01, 0x82, 0x00, 0x60, 0xC0, 0x18, 0x18, 0x06, 0x03, 0x0F, 0x80, 0x7F,
  0xC0, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x07, 0x8F, 0x00, 0x70, 0x1C, 0x07, 0x00, 0x60, 0x30, 0x01,
  0x83, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x01, 0x18, 0x00, 0x08, 0xC0,
  0x00, 0x4C, 0x00, 0x02, 0x60, 0x00, 0x13, 0x00, 0x01, 0x90, 0x00, 0x0D,
  0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD0, 0x00,
  0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x13, 0x00, 0x01, 0x98,
  0x00, 0x0C, 0xC0, 0x00, 0x46, 0x00, 0x06, 0x30, 0x00, 0x60, 0xC0, 0x03,
  0x06, 0x00, 0x30, 0x30, 0x03, 0x80, 0xC0, 0x38, 0x03, 0x87, 0x80, 0x0F,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0xE0, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x04,
  0x00, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x60, 0x80, 0x0C, 0x30,
  0x01, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03, 0x02, 0x00, 0x60, 0xC0,
  0x38, 0x18, 0x0E, 0x03, 0xFF, 0x00, 0x61, 0x80, 0x08, 0x18, 0x03, 0x03,
  0x00, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0x80, 0x80, 0x20, 0x18, 0x0C, 0x03,
  0x01, 0x80, 0x60, 0x30, 0x04, 0x04, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x03,
  0x06, 0x00, 0x60, 0xC0, 0x06, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0x9F, 0x01,
  0xC0, 0x10, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x80, 0x1C, 0x0F,
  0x07, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x02, 0x04, 0x00,
  0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x08, 0x00, 0x10,
  0x60, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x40,
  0x00, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01,
  0x02, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x04,
  0x00, 0x08, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00,
  0x30, 0x30, 0x00, 0xC0, 0xC0, 0x06, 0x01, 0x80, 0x18, 0x07, 0x00, 0xC0,
  0x0E, 0x0E, 0x00, 0x1F, 0xF0, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x1B, 0x00,
  0x02, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00,
  0x30, 0xC0, 0x06, 0x18, 0x01, 0x81, 0x00, 0x30, 0x20, 0x0C, 0x04, 0x01,
  0x80, 0x80, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x00, 0x40, 0x60, 0x08, 0x0C,
  0x01, 0x03, 0x00, 0x30, 0x60, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0xC0,
  0x03, 0x18, 0x00, 0x62, 0x00, 0x0C, 0xC0, 0x01, 0x90, 0x00, 0x36, 0x00,
  0x06, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00,
  0xB0, 0x01, 0xC0, 0x06, 0xC0, 0x05, 0x00, 0x1B, 0x00, 0x34, 0x00, 0xCC,
  0x00, 0xD0, 0x03, 0x30, 0x02, 0x40, 0x08, 0xC0, 0x19, 0x00, 0x63, 0x00,
  0x44, 0x01, 0x8C, 0x03, 0x10, 0x0C, 0x30, 0x0C, 0x40, 0x30, 0xC0, 0x61,
  0x01, 0x83, 0x01, 0x84, 0x06, 0x0C, 0x04, 0x10, 0x10, 0x30, 0x30, 0x40,
  0xC0, 0xC0, 0x81, 0x03, 0x03, 0x06, 0x04, 0x18, 0x0C, 0x18, 0x10, 0x60,
  0x30, 0x40, 0x41, 0x00, 0xC3, 0x01, 0x0C, 0x03, 0x08, 0x04, 0x30, 0x0C,
  0x60, 0x11, 0x80, 0x31, 0x80, 0x46, 0x00, 0xCC, 0x01, 0x30, 0x03, 0x30,
  0x04, 0xC0, 0x0C, 0x80, 0x12, 0x00, 0x16, 0x00, 0x58, 0x00, 0x50, 0x01,
  0x60, 0x01, 0xC0, 0x05, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x80, 0x0C, 0x01,
  0x80, 0x30, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x08,
  0x08, 0x00, 0x10, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC6,
  0x00, 0x00, 0x98, 0x00, 0x01, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x18, 0x80, 0x00, 0x61, 0x80, 0x01,
  0x83, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x30, 0x08, 0x00, 0x60,
  0x18, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x30, 0x00,
  0x80, 0xE0, 0x01, 0x80, 0xC0, 0x03, 0xE0, 0x01, 0xB0, 0x01, 0x98, 0x00,
  0xC4, 0x00, 0xC3, 0x00, 0x41, 0x80, 0x60, 0xC0, 0x60, 0x60, 0x30, 0x30,
  0x30, 0x08, 0x18, 0x04, 0x18, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xCC, 0x00,
  0x66, 0x00, 0x16, 0x00, 0x0B, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0xFF, 0x00, 0x82, 0x0C, 0x30, 0xC3, 0x04,
  0x10, 0x61, 0x86, 0x18, 0x20, 0x82, 0x0C, 0x30, 0xC3, 0x04, 0x10, 0x61,
  0x86, 0x18, 0x20, 0x82, 0x0C, 0x30, 0xC3, 0x04, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x01, 0xFE, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0xE0, 0x00, 0x6C, 0x00, 0x0C, 0x80, 0x03, 0x18, 0x00,
  0x43, 0x00, 0x18, 0x30, 0x02, 0x06, 0x00, 0xC0, 0x40, 0x30, 0x0C, 0x06,
  0x01, 0x81, 0x80, 0x18, 0x20, 0x03, 0x0C, 0x00, 0x21, 0x00, 0x06, 0x60,
  0x00, 0xD8, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xF0, 0xC6, 0x18, 0xC3, 0x08,
  0x60, 0x00, 0xF0, 0x01, 0xFC, 0x41, 0xC3, 0x21, 0x80, 0xF1, 0x80, 0x38,
  0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x60, 0x03, 0x30, 0x01, 0x90, 0x00,
  0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x33, 0x00, 0x11, 0x00, 0x18, 0x80,
  0x0C, 0x40, 0x06, 0x20, 0x07, 0x10, 0x03, 0x0C, 0x03, 0x86, 0x03, 0xC3,
  0x01, 0x60, 0xE3, 0x30, 0x3F, 0x10, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x41, 0xC0, 0x11, 0xFC, 0x0D, 0xC3,
  0x03, 0x40, 0x60, 0xE0, 0x18, 0x38, 0x02, 0x1C, 0x00, 0xC7, 0x00, 0x31,
  0x80, 0x0C, 0x60, 0x02, 0x10, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0,
  0x06, 0x20, 0x01, 0x88, 0x00, 0x46, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x06,
  0x18, 0x01, 0x86, 0x00, 0xC3, 0xC0, 0x30, 0xD0, 0x18, 0x26, 0x1C, 0x08,
  0xFE, 0x00, 0x00, 0xF8, 0x0F, 0xF0, 0x70, 0x43, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x10, 0x3F, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0xF0, 0xC0, 0x3F, 0xC8, 0x07, 0x0C, 0x80, 0xC0, 0x78, 0x18, 0x03, 0x81,
  0x80, 0x38, 0x30, 0x03, 0x03, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30,
  0x40, 0x03, 0x0C, 0x00, 0x20, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06,
  0x08, 0x00, 0xC0, 0x80, 0x0C, 0x08, 0x00, 0xC0, 0x80, 0x1C, 0x0C, 0x01,
  0xC0, 0xC0, 0x38, 0x0C, 0x06, 0x80, 0xC0, 0xD8, 0x07, 0x19, 0x80, 0x3F,
  0x18, 0x00, 0x00, 0xF0, 0x07, 0xF8, 0x18, 0x30, 0x60, 0x31, 0x80, 0x63,
  0x00, 0xCC, 0x01, 0x10, 0x06, 0x60, 0x0C, 0xC0, 0x31, 0x01, 0xC6, 0x0F,
  0x0F, 0xF8, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x30, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x07, 0x20, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x10, 0x0F,
  0xF2, 0x01, 0xC3, 0x20, 0x30, 0x1A, 0x06, 0x00, 0xE0, 0x60, 0x0E, 0x0C,
  0x00, 0xC0, 0xC0, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x10, 0x00, 0xC3,
  0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01, 0x82, 0x00, 0x30,
  0x20, 0x03, 0x02, 0x00, 0x30, 0x20, 0x07, 0x02, 0x00, 0x70, 0x30, 0x0E,
  0x03, 0x01, 0xA0, 0x30, 0x36, 0x01, 0xC6, 0x60, 0x0F, 0xC6, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x08, 0x06, 0x00, 0xFF, 0xC0, 0x03,
  0xF0, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x0F, 0x00, 0x9F, 0xE0, 0xD8, 0x30, 0x78, 0x0C, 0x38, 0x06, 0x18, 0x03,
  0x0C, 0x01, 0x8C, 0x00, 0x86, 0x00, 0x43, 0x00, 0x61, 0x00, 0x31, 0x80,
  0x18, 0xC0, 0x08, 0x60, 0x04, 0x30, 0x06, 0x10, 0x03, 0x18, 0x01, 0x8C,
  0x00, 0x86, 0x00, 0xC2, 0x00, 0x61, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x08,
  0x60, 0x0C, 0x20, 0x06, 0x00, 0x03, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10,
  0x30, 0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0,
  0xC0, 0x80, 0x00, 0x06, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x20, 0x80, 0x60, 0xC0, 0x60, 0x60, 0x70,
  0x30, 0x30, 0x10, 0x30, 0x18, 0x30, 0x0C, 0x30, 0x06, 0x30, 0x03, 0x30,
  0x01, 0x18, 0x01, 0x9C, 0x00, 0xDE, 0x00, 0x79, 0x00, 0x38, 0xC0, 0x18,
  0x60, 0x18, 0x30, 0x0C, 0x08, 0x06, 0x06, 0x02, 0x03, 0x03, 0x01, 0x81,
  0x80, 0x40, 0xC0, 0x30, 0x60, 0x18, 0x20, 0x0C, 0x00, 0x01, 0x80, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0,
  0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20,
  0x00, 0x00, 0x3C, 0x07, 0x00, 0x9F, 0xC3, 0xF8, 0x36, 0x1D, 0xC3, 0x07,
  0x81, 0xA0, 0x30, 0xA0, 0x38, 0x06, 0x18, 0x07, 0x00, 0xC7, 0x00, 0xC0,
  0x18, 0xC0, 0x18, 0x03, 0x18, 0x03, 0x00, 0x43, 0x00, 0x40, 0x18, 0x40,
  0x08, 0x03, 0x18, 0x03, 0x00, 0x63, 0x00, 0x60, 0x0C, 0x60, 0x0C, 0x01,
  0x0C, 0x01, 0x00, 0x61, 0x00, 0x60, 0x0C, 0x60, 0x0C, 0x01, 0x8C, 0x01,
  0x80, 0x31, 0x80, 0x30, 0x04, 0x20, 0x04, 0x01, 0x84, 0x01, 0x80, 0x31,
  0x80, 0x30, 0x06, 0x30, 0x06, 0x00, 0x86, 0x00, 0x80, 0x10, 0x80, 0x30,
  0x06, 0x00, 0x00, 0x3C, 0x02, 0x7F, 0x83, 0x60, 0xC1, 0xE0, 0x30, 0xA0,
  0x18, 0x60, 0x0C, 0x70, 0x06, 0x30, 0x02, 0x18, 0x01, 0x0C, 0x01, 0x84,
  0x00, 0xC6, 0x00, 0x63, 0x00, 0x21, 0x80, 0x10, 0xC0, 0x18, 0x40, 0x0C,
  0x60, 0x06, 0x30, 0x02, 0x18, 0x03, 0x08, 0x01, 0x8C, 0x00, 0xC6, 0x00,
  0x63, 0x00, 0x21, 0x80, 0x30, 0x80, 0x18, 0x00, 0x00, 0xF0, 0x03, 0xFC,
  0x07, 0x0E, 0x0C, 0x06, 0x18, 0x03, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03,
  0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02,
  0xC0, 0x06, 0x80, 0x06, 0x80, 0x06, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x08,
  0xC0, 0x18, 0xC0, 0x30, 0x60, 0x70, 0x70, 0xE0, 0x3F, 0x80, 0x00, 0x03,
  0x80, 0x04, 0x7F, 0x00, 0x6E, 0x18, 0x03, 0x40, 0x60, 0x1C, 0x03, 0x00,
  0xE0, 0x08, 0x06, 0x00, 0x60, 0x70, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00,
  0xC0, 0xC0, 0x04, 0x0C, 0x00, 0x20, 0x60, 0x03, 0x03, 0x00, 0x18, 0x18,
  0x00, 0xC0, 0x80, 0x04, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x30,
  0x18, 0x01, 0x80, 0xC0, 0x18, 0x0F, 0x00, 0xC0, 0x68, 0x0C, 0x03, 0x61,
  0xC0, 0x11, 0xFC, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x40,
  0xFE, 0x20, 0x70, 0xC8, 0x30, 0x1E, 0x18, 0x03, 0x86, 0x00, 0xE3, 0x00,
  0x30, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x08,
  0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x10, 0x80, 0x0C, 0x20,
  0x03, 0x08, 0x01, 0xC2, 0x00, 0x70, 0xC0, 0x38, 0x30, 0x1A, 0x0C, 0x0D,
  0x81, 0xC6, 0x60, 0x3F, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x38, 0x13, 0xF0, 0xD8, 0x03,
  0xC0, 0x0A, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x00, 0x01, 0xF0, 0x0F, 0xFC, 0x38, 0x10, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x20, 0x18, 0x60, 0xE0, 0xFF,
  0x80, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x4F, 0xF0, 0x60,
  0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18,
  0x03, 0x00, 0x60, 0x0E, 0x20, 0xF8, 0x00, 0x18, 0x01, 0x8C, 0x00, 0x86,
  0x00, 0xC2, 0x00, 0x61, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x08, 0x60, 0x0C,
  0x20, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0x86, 0x00, 0xC2, 0x00,
  0x63, 0x00, 0x31, 0x80, 0x10, 0xC0, 0x18, 0x60, 0x0C, 0x20, 0x0E, 0x10,
  0x07, 0x08, 0x05, 0x06, 0x06, 0x83, 0x86, 0x40, 0xFE, 0x60, 0x80, 0x0E,
  0x00, 0x28, 0x01, 0xA0, 0x04, 0x80, 0x32, 0x00, 0x8C, 0x06, 0x30, 0x18,
  0xC0, 0xC3, 0x03, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x03, 0x0C, 0x0C, 0x60,
  0x31, 0x80, 0xCC, 0x03, 0x30, 0x0D, 0x80, 0x36, 0x00, 0x50, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x80, 0x18, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x14, 0x03, 0xC0, 0x68, 0x05, 0x80, 0x90, 0x1B, 0x03, 0x20, 0x36, 0x06,
  0x40, 0xCC, 0x18, 0x81, 0x98, 0x31, 0x02, 0x30, 0x42, 0x0C, 0x61, 0x86,
  0x10, 0xC3, 0x0C, 0x61, 0x8C, 0x18, 0x83, 0x18, 0x33, 0x06, 0x20, 0x66,
  0x0C, 0xC0, 0xD8, 0x19, 0x01, 0xB0, 0x36, 0x03, 0x40, 0x6C, 0x07, 0x80,
  0xD0, 0x0A, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0x03, 0x00, 0x60, 0x60, 0x18, 0x0C, 0x06, 0x00, 0x80, 0xC0, 0x18,
  0x30, 0x03, 0x0C, 0x00, 0x21, 0x00, 0x06, 0x60, 0x00, 0xD8, 0x00, 0x1A,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x40, 0x00, 0x6C,
  0x00, 0x19, 0x80, 0x06, 0x10, 0x00, 0xC3, 0x00, 0x30, 0x60, 0x0C, 0x0C,
  0x01, 0x00, 0x80, 0x60, 0x18, 0x18, 0x03, 0x06, 0x00, 0x60, 0x00, 0xC0,
  0x06, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x08, 0x06, 0x00, 0x10, 0x0C, 0x00, 0x20, 0x30, 0x00, 0x40, 0x60,
  0x00, 0x81, 0x80, 0x01, 0x03, 0x00, 0x02, 0x0C, 0x00, 0x06, 0x18, 0x00,
  0x0C, 0x20, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x00, 0x00, 0x66, 0x00, 0x00,
  0xC8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x40, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x01, 0xB8, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xFF,
  0xE0, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0xF8, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x78, 0xF0, 0x38, 0x07, 0xFA, 0x00, 0x78,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 33, 10, 1, -33 },
  { 39, 10, 12, 13, 5, -33 },
  { 54, 20, 33, 21, 1, -33 },
  { 137, 19, 38, 19, 0, -35 },
  { 228, 23, 34, 28, 3, -33 },
  { 326, 19, 33, 20, 0, -33 },
  { 405, 4, 12, 7, 5, -33 },
  { 411, 13, 40, 11, 1, -33 },
  { 476, 13, 40, 11, -3, -33 },
  { 541, 14, 15, 18, 5, -35 },
  { 568, 18, 21, 21, 2, -27 },
  { 616, 6, 11, 8, -2, -5 },
  { 625, 10, 1, 13, 1, -13 },
  { 627, 3, 3, 8, 1, -3 },
  { 629, 19, 33, 14, -2, -33 },
  { 708, 17, 33, 19, 2, -33 },
  { 779, 9, 33, 19, 6, -33 },
  { 817, 19, 33, 19, -1, -33 },
  { 896, 19, 34, 19, 0, -33 },
  { 977, 19, 33, 19, 0, -33 },
  { 1056, 19, 33, 19, 0, -33 },
  { 1135, 18, 33, 19, 2, -33 },
  { 1210, 17, 33, 19, 3, -33 },
  { 1281, 19, 33, 19, 0, -33 },
  { 1360, 18, 33, 19, 0, -33 },
  { 1435, 8, 25, 8, 0, -25 },
  { 1460, 10, 31, 8, -2, -25 },
  { 1499, 18, 20, 21, 2, -26 },
  { 1544, 18, 11, 21, 2, -22 },
  { 1569, 18, 20, 21, 2, -26 },
  { 1614, 13, 33, 14, 2, -33 },
  { 1668, 26, 37, 28, 2, -33 },
  { 1789, 19, 33, 19, -3, -33 },
  { 1868, 20, 33, 21, 1, -33 },
  { 1951, 20, 33, 19, 2, -33 },
  { 2034, 21, 33, 23, 1, -33 },
  { 2121, 19, 33, 18, 1, -33 },
  { 2200, 19, 33, 17, 1, -33 },
  { 2279, 23, 33, 24, 2, -33 },
  { 2374, 23, 33, 24, 1, -33 },
  { 2469, 15, 33, 10, -2, -33 },
  { 2531, 16, 41, 9, -7, -33 },
  { 2613, 22, 33, 19, 1, -33 },
  { 2704, 12, 33, 17, 1, -33 },
  { 2754, 30, 33, 31, 1, -33 },
  { 2878, 24, 33, 25, 1, -33 },
  { 2977, 21, 33, 25, 2, -33 },
  { 3064, 19, 33, 19, 1, -33 },
  { 3143, 21, 41, 25, 2, -33 },
  { 3251, 19, 33, 20, 1, -33 },
  { 3330, 20, 33, 18, -1, -33 },
  { 3413, 16, 33, 17, 4, -33 },
  { 3479, 22, 33, 23, 2, -33 },
  { 3570, 19, 33, 19, 4, -33 },
  { 3649, 30, 33, 31, 4, -33 },
  { 3773, 23, 33, 17, -3, -33 },
  { 3868, 17, 33, 17, 4, -33 },
  { 3939, 21, 33, 17, -1, -33 },
  { 4026, 17, 40, 13, -1, -33 },
  { 4111, 6, 33, 15, 5, -33 },
  { 4136, 17, 40, 13, -3, -33 },
  { 4221, 19, 18, 20, 1, -33 },
  { 4264, 14, 2, 14, -4, 4 },
  { 4268, 5, 7, 10, 7, -35 },
  { 4273, 17, 25, 20, 2, -25 },
  { 4327, 18, 35, 20, 1, -35 },
  { 4406, 14, 25, 15, 2, -25 },
  { 4450, 20, 35, 20, 2, -35 },
  { 4538, 15, 25, 18, 2, -25 },
  { 4585, 22, 46, 10, -6, -35 },
  { 4712, 20, 36, 20, 0, -25 },
  { 4802, 17, 35, 20, 1, -35 },
  { 4877, 8, 33, 8, 1, -33 },
  { 4910, 16, 44, 8, -6, -33 },
  { 4998, 17, 35, 16, 1, -35 },
  { 5073, 9, 35, 8, 1, -35 },
  { 5113, 27, 25, 30, 1, -25 },
  { 5198, 17, 25, 20, 1, -25 },
  { 5252, 16, 25, 20, 2, -25 },
  { 5302, 21, 36, 20, -2, -25 },
  { 5397, 18, 36, 20, 2, -25 },
  { 5478, 14, 25, 13, 1, -25 },
  { 5522, 15, 25, 15, 0, -25 },
  { 5569, 11, 30, 11, 1, -30 },
  { 5611, 17, 24, 20, 2, -24 },
  { 5662, 14, 24, 15, 3, -24 },
  { 5704, 23, 24, 25, 3, -24 },
  { 5773, 19, 24, 16, -2, -24 },
  { 5830, 23, 35, 16, -5, -24 },
  { 5931, 16, 24, 14, -1, -24 },
  { 5979, 16, 40, 15, 1, -33 },
  { 6059, 1, 46, 19, 9, -35 },
  { 6065, 16, 40, 15, -3, -33 },
  { 6145, 18, 4, 21, 2, -18 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC46PT7B_H_
