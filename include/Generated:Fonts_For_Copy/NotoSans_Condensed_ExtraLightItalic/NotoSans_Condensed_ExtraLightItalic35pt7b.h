#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC35PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x18, 0x30, 0x40, 0x81,
  0x06, 0x08, 0x10, 0x20, 0x41, 0x00, 0x00, 0x00, 0x20, 0x60, 0xC0, 0x31,
  0x23, 0x23, 0x22, 0x62, 0x42, 0x46, 0x44, 0xC4, 0x00, 0x42, 0x00, 0x82,
  0x00, 0x82, 0x00, 0x84, 0x01, 0x84, 0x01, 0x04, 0x01, 0x08, 0x1F, 0xFF,
  0x1F, 0xFF, 0x02, 0x18, 0x02, 0x10, 0x04, 0x10, 0x04, 0x30, 0x04, 0x20,
  0x0C, 0x20, 0x08, 0x20, 0xFF, 0xFC, 0x18, 0x40, 0x10, 0x40, 0x10, 0xC0,
  0x30, 0x80, 0x20, 0x80, 0x21, 0x80, 0x21, 0x00, 0x61, 0x00, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x07, 0x00, 0x3F, 0xE0, 0x88, 0x82, 0x10, 0x04,
  0x20, 0x18, 0x80, 0x31, 0x00, 0x22, 0x00, 0x44, 0x00, 0x48, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x01, 0x60, 0x04, 0x60, 0x08, 0x40, 0x10, 0x80,
  0x21, 0x00, 0x46, 0x01, 0x08, 0x42, 0x30, 0xFF, 0x80, 0x18, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x80, 0x00, 0x0F, 0x01, 0x84, 0x40, 0x42, 0x10, 0x20,
  0x84, 0x18, 0x41, 0x04, 0x10, 0x43, 0x04, 0x10, 0x83, 0x04, 0x40, 0x81,
  0x10, 0x20, 0xC8, 0x08, 0x26, 0x7A, 0x09, 0x32, 0x84, 0xD8, 0xF3, 0x24,
  0x17, 0x91, 0x04, 0x04, 0x83, 0x02, 0x20, 0xC1, 0x88, 0x20, 0x42, 0x08,
  0x31, 0x82, 0x08, 0x61, 0x84, 0x18, 0x41, 0x06, 0x30, 0x80, 0x88, 0x60,
  0x3C, 0x00, 0x01, 0xF0, 0x06, 0x30, 0x08, 0x60, 0x30, 0x40, 0x41, 0x80,
  0x83, 0x01, 0x04, 0x02, 0x18, 0x04, 0x60, 0x0D, 0x80, 0x0E, 0x00, 0x18,
  0x00, 0x50, 0x03, 0x20, 0x04, 0x61, 0x90, 0x42, 0x60, 0xCC, 0x80, 0x93,
  0x01, 0x66, 0x03, 0x8C, 0x03, 0x18, 0x0E, 0x30, 0x34, 0x30, 0xC8, 0x3F,
  0x18, 0x69, 0x2D, 0x24, 0x80, 0x00, 0xC0, 0x60, 0x30, 0x08, 0x04, 0x03,
  0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC0,
  0x30, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x02, 0x00, 0x80, 0x40,
  0x30, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x60, 0x20, 0x10, 0x18, 0x08, 0x08,
  0x0C, 0x04, 0x04, 0x06, 0x06, 0x02, 0x00, 0x04, 0x00, 0x40, 0x18, 0x42,
  0x06, 0x40, 0x3B, 0xC1, 0x80, 0xE0, 0x32, 0x0C, 0x41, 0x04, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x1F,
  0xFF, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x11, 0x32, 0x64, 0xC8, 0xFF, 0xBC, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x30, 0x81, 0x06,
  0x10, 0x11, 0x80, 0x88, 0x04, 0xC0, 0x26, 0x01, 0x20, 0x09, 0x00, 0x58,
  0x06, 0x80, 0x34, 0x01, 0x20, 0x09, 0x00, 0x58, 0x06, 0xC0, 0x26, 0x01,
  0x20, 0x19, 0x00, 0x8C, 0x0C, 0x60, 0x41, 0x06, 0x0C, 0x60, 0x3E, 0x00,
  0x03, 0x0E, 0x1A, 0x32, 0xC6, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08,
  0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60,
  0x40, 0x01, 0xF8, 0x0E, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0,
  0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF, 0xF0,
  0x03, 0xF0, 0x38, 0x20, 0x80, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x01, 0xF0, 0x07, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x20, 0x60, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x50,
  0x01, 0xC0, 0x0A, 0x00, 0x48, 0x03, 0x20, 0x09, 0x80, 0x46, 0x03, 0x10,
  0x08, 0x40, 0x41, 0x03, 0x0C, 0x08, 0x20, 0x40, 0x83, 0x02, 0x08, 0x18,
  0x40, 0x63, 0x01, 0x0F, 0xFF, 0x80, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x03, 0xFC, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0xF8, 0x06,
  0x38, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x20, 0x60, 0xFF, 0x00,
  0x00, 0xFC, 0x0E, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x00, 0x80, 0x06, 0x7C, 0x16, 0x18, 0x70, 0x31, 0x80,
  0xC4, 0x01, 0x30, 0x04, 0xC0, 0x33, 0x00, 0xCC, 0x02, 0x30, 0x08, 0xC0,
  0x63, 0x01, 0x04, 0x0C, 0x18, 0x60, 0x3F, 0x00, 0x3F, 0xF8, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x00, 0x01, 0xF8, 0x18, 0x30, 0x40, 0x43, 0x01, 0x08, 0x04, 0x20, 0x10,
  0x80, 0x42, 0x03, 0x0C, 0x08, 0x10, 0x40, 0x66, 0x00, 0xF0, 0x07, 0x80,
  0x31, 0x03, 0x06, 0x08, 0x0C, 0x40, 0x11, 0x00, 0x4C, 0x01, 0x30, 0x04,
  0xC0, 0x13, 0x00, 0xC4, 0x02, 0x18, 0x30, 0x1F, 0x80, 0x01, 0xF0, 0x18,
  0x60, 0x40, 0x82, 0x03, 0x18, 0x04, 0x40, 0x11, 0x00, 0x44, 0x01, 0x30,
  0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x06, 0x10, 0x18, 0x61, 0xA0, 0xFD, 0x80,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0xFE, 0x00, 0x04, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x43, 0x8C, 0x00, 0x01, 0x03, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x18, 0x10, 0x10, 0x30, 0x20, 0x60, 0xC0, 0x00, 0x08, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x02, 0x00, 0x00,
  0x3F, 0x82, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x20, 0x04,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x10, 0x06, 0x00, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x0C, 0x1C, 0x01, 0x00, 0x40, 0x20, 0x02, 0x04, 0x00, 0x20,
  0x80, 0x03, 0x18, 0x00, 0x11, 0x03, 0xE1, 0x30, 0x62, 0x12, 0x08, 0x61,
  0x21, 0x84, 0x14, 0x10, 0x41, 0x42, 0x04, 0x34, 0x20, 0xC2, 0x42, 0x08,
  0x2C, 0x60, 0x86, 0xC6, 0x18, 0x48, 0x41, 0x84, 0x86, 0x28, 0x88, 0x26,
  0x98, 0x83, 0xCF, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x10, 0x00, 0xFE, 0x00, 0x00, 0x18, 0x00,
  0x60, 0x02, 0x80, 0x0A, 0x00, 0x68, 0x01, 0x20, 0x0C, 0x80, 0x22, 0x01,
  0x88, 0x04, 0x20, 0x30, 0x80, 0x82, 0x02, 0x08, 0x10, 0x20, 0x7F, 0xC3,
  0xFF, 0x08, 0x0C, 0x60, 0x31, 0x00, 0xCC, 0x03, 0x20, 0x0D, 0x80, 0x14,
  0x00, 0x70, 0x01, 0xC0, 0x04, 0x07, 0xF0, 0x08, 0x38, 0x30, 0x10, 0x40,
  0x30, 0x80, 0x61, 0x00, 0xC6, 0x01, 0x8C, 0x02, 0x10, 0x0C, 0x20, 0x10,
  0x40, 0xC1, 0xFF, 0x03, 0x1E, 0x04, 0x06, 0x08, 0x04, 0x10, 0x0C, 0x60,
  0x18, 0xC0, 0x31, 0x00, 0x62, 0x00, 0x84, 0x01, 0x18, 0x06, 0x20, 0x18,
  0x40, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x06, 0x04, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x20, 0x1F, 0xC0, 0x07, 0xF0, 0x04, 0x38, 0x0C, 0x0C, 0x08, 0x06, 0x08,
  0x02, 0x08, 0x02, 0x18, 0x03, 0x18, 0x03, 0x10, 0x03, 0x10, 0x03, 0x10,
  0x02, 0x30, 0x02, 0x30, 0x02, 0x20, 0x06, 0x20, 0x06, 0x20, 0x04, 0x60,
  0x04, 0x40, 0x0C, 0x40, 0x08, 0x40, 0x18, 0x40, 0x30, 0xC0, 0x60, 0x80,
  0xC0, 0x83, 0x80, 0xFE, 0x00, 0x07, 0xFC, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x0F, 0xF8, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x3F, 0xE0,
  0xFF, 0x82, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x00, 0xFF, 0x01,
  0x80, 0xC1, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x07,
  0xE4, 0x03, 0xF2, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x06, 0x20,
  0x03, 0x10, 0x01, 0x0C, 0x00, 0x82, 0x00, 0x41, 0x80, 0x60, 0x60, 0x20,
  0x1F, 0xF0, 0x00, 0x04, 0x00, 0x82, 0x00, 0x43, 0x00, 0x21, 0x00, 0x30,
  0x80, 0x18, 0x40, 0x08, 0x60, 0x04, 0x30, 0x02, 0x10, 0x03, 0x08, 0x01,
  0x04, 0x00, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0x00, 0x30, 0x80, 0x10, 0x40,
  0x08, 0x60, 0x04, 0x20, 0x06, 0x10, 0x03, 0x08, 0x01, 0x04, 0x00, 0x86,
  0x00, 0x42, 0x00, 0x61, 0x00, 0x30, 0x80, 0x10, 0x00, 0x07, 0xE0, 0x20,
  0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0xFC, 0x00, 0x00, 0x10, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0xF0, 0x00, 0x04, 0x03, 0x04, 0x06, 0x0C,
  0x04, 0x08, 0x08, 0x08, 0x10, 0x08, 0x30, 0x18, 0x60, 0x18, 0xC0, 0x11,
  0x80, 0x11, 0x00, 0x12, 0x00, 0x36, 0x00, 0x3A, 0x00, 0x3B, 0x00, 0x31,
  0x00, 0x21, 0x00, 0x61, 0x80, 0x40, 0x80, 0x40, 0x80, 0x40, 0xC0, 0x40,
  0xC0, 0xC0, 0x40, 0x80, 0x60, 0x80, 0x60, 0x80, 0x20, 0x04, 0x02, 0x03,
  0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01,
  0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00,
  0xFF, 0x80, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x38, 0x00, 0x70, 0x50,
  0x00, 0xA0, 0xA0, 0x03, 0xC1, 0x40, 0x05, 0x06, 0x80, 0x1A, 0x0D, 0x00,
  0x24, 0x12, 0x00, 0xD8, 0x26, 0x01, 0x30, 0x4C, 0x06, 0x41, 0x98, 0x08,
  0x83, 0x10, 0x31, 0x04, 0x20, 0x46, 0x08, 0x41, 0x0C, 0x10, 0x82, 0x10,
  0x61, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x41, 0x82, 0x08, 0x82, 0x04,
  0x12, 0x04, 0x18, 0x34, 0x08, 0x20, 0x70, 0x30, 0x40, 0xE0, 0x60, 0x80,
  0x80, 0x80, 0x04, 0x00, 0x41, 0x80, 0x30, 0xE0, 0x0C, 0x28, 0x02, 0x0A,
  0x00, 0x82, 0xC0, 0x21, 0x90, 0x18, 0x64, 0x04, 0x11, 0x01, 0x04, 0x60,
  0x41, 0x08, 0x10, 0xC2, 0x0C, 0x30, 0x82, 0x08, 0x30, 0x82, 0x04, 0x20,
  0x81, 0x18, 0x60, 0x46, 0x10, 0x19, 0x04, 0x02, 0x41, 0x00, 0x90, 0x40,
  0x3C, 0x30, 0x0F, 0x08, 0x01, 0x82, 0x00, 0x60, 0x80, 0x18, 0x00, 0x01,
  0xF8, 0x06, 0x0C, 0x0C, 0x06, 0x08, 0x02, 0x10, 0x03, 0x30, 0x03, 0x20,
  0x03, 0x20, 0x03, 0x60, 0x03, 0x40, 0x03, 0x40, 0x03, 0xC0, 0x02, 0xC0,
  0x02, 0x80, 0x02, 0x80, 0x06, 0x80, 0x06, 0x80, 0x04, 0x80, 0x0C, 0x80,
  0x0C, 0x80, 0x08, 0x80, 0x18, 0xC0, 0x30, 0x40, 0x60, 0x60, 0xC0, 0x3F,
  0x80, 0x07, 0xE0, 0x10, 0xE0, 0xC0, 0x82, 0x03, 0x08, 0x04, 0x20, 0x11,
  0x80, 0x46, 0x01, 0x10, 0x0C, 0x40, 0x21, 0x01, 0x8C, 0x04, 0x30, 0x60,
  0xFF, 0x03, 0xC0, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x01, 0xF8, 0x06,
  0x0C, 0x0C, 0x06, 0x08, 0x02, 0x10, 0x03, 0x30, 0x03, 0x20, 0x03, 0x20,
  0x03, 0x60, 0x03, 0x40, 0x03, 0x40, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0x80,
  0x02, 0x80, 0x06, 0x80, 0x06, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x0C, 0x80,
  0x08, 0x80, 0x18, 0xC0, 0x30, 0x40, 0x60, 0x60, 0xC0, 0x3F, 0x80, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x07,
  0xE0, 0x10, 0xE0, 0xC0, 0x82, 0x03, 0x08, 0x04, 0x20, 0x11, 0x80, 0x46,
  0x03, 0x10, 0x0C, 0x40, 0x21, 0x01, 0x8C, 0x0C, 0x30, 0xE0, 0xFE, 0x02,
  0x10, 0x08, 0x60, 0x60, 0x81, 0x02, 0x04, 0x08, 0x10, 0x30, 0x40, 0xC3,
  0x01, 0x08, 0x04, 0x20, 0x18, 0x80, 0x60, 0x03, 0xFE, 0x0C, 0x08, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x40, 0xE0, 0xFF, 0x00, 0xFF, 0xF0, 0x60, 0x04, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x00, 0x08, 0x01, 0x18, 0x01,
  0x10, 0x01, 0x10, 0x03, 0x10, 0x02, 0x30, 0x02, 0x30, 0x02, 0x20, 0x06,
  0x20, 0x06, 0x20, 0x04, 0x60, 0x04, 0x60, 0x04, 0x40, 0x0C, 0x40, 0x08,
  0x40, 0x08, 0xC0, 0x08, 0x80, 0x18, 0x80, 0x18, 0x80, 0x10, 0x80, 0x10,
  0x80, 0x30, 0x80, 0x20, 0xC0, 0x60, 0x60, 0xC0, 0x3F, 0x80, 0xC0, 0x0F,
  0x00, 0x2C, 0x00, 0xB0, 0x06, 0xC0, 0x13, 0x00, 0xCC, 0x02, 0x30, 0x18,
  0xC0, 0x41, 0x03, 0x04, 0x08, 0x10, 0x60, 0x41, 0x01, 0x04, 0x04, 0x30,
  0x10, 0x80, 0x46, 0x01, 0x10, 0x04, 0xC0, 0x12, 0x00, 0x58, 0x01, 0x40,
  0x05, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x10, 0x03, 0x80, 0x20, 0x0F,
  0x00, 0xC0, 0x16, 0x01, 0x80, 0x6C, 0x07, 0x00, 0x98, 0x0A, 0x01, 0x30,
  0x34, 0x04, 0x60, 0x48, 0x08, 0xC0, 0x90, 0x31, 0x82, 0x20, 0x43, 0x04,
  0x41, 0x86, 0x18, 0x82, 0x0C, 0x21, 0x04, 0x18, 0x42, 0x18, 0x31, 0x04,
  0x20, 0x62, 0x08, 0xC0, 0xCC, 0x11, 0x01, 0x90, 0x22, 0x03, 0x60, 0x48,
  0x06, 0x80, 0x90, 0x0D, 0x01, 0x60, 0x1C, 0x02, 0x80, 0x38, 0x05, 0x00,
  0x70, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0x02, 0x00, 0xC0, 0xC0, 0x60, 0x10,
  0x10, 0x04, 0x08, 0x01, 0x06, 0x00, 0x41, 0x00, 0x18, 0x80, 0x02, 0x60,
  0x00, 0x90, 0x00, 0x2C, 0x00, 0x0A, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x14, 0x00, 0x0D, 0x80, 0x06, 0x20, 0x01, 0x08, 0x00, 0xC2,
  0x00, 0x60, 0x80, 0x10, 0x30, 0x0C, 0x0C, 0x02, 0x01, 0x01, 0x00, 0x40,
  0xC0, 0x10, 0x00, 0x80, 0x1E, 0x01, 0xB0, 0x08, 0x80, 0xC4, 0x04, 0x20,
  0x41, 0x06, 0x08, 0x20, 0x63, 0x03, 0x10, 0x09, 0x80, 0x48, 0x02, 0x80,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xF8,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x84, 0x21, 0x08, 0x61, 0x08, 0x42, 0x10, 0xC6, 0x10, 0x84, 0x21,
  0x0C, 0x21, 0x08, 0x42, 0x18, 0x03, 0xF0, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04,
  0x0F, 0xC0, 0xFC, 0x00, 0x01, 0x80, 0x06, 0x00, 0x3C, 0x00, 0x90, 0x04,
  0x40, 0x30, 0x80, 0x82, 0x06, 0x0C, 0x10, 0x10, 0xC0, 0x42, 0x01, 0x90,
  0x02, 0xC0, 0x0C, 0xFF, 0xE0, 0xC4, 0x42, 0x21, 0x03, 0xC4, 0x19, 0xB0,
  0x83, 0x86, 0x06, 0x30, 0x18, 0x80, 0x62, 0x01, 0x18, 0x04, 0x40, 0x11,
  0x00, 0x4C, 0x03, 0x30, 0x08, 0xC0, 0x23, 0x01, 0x8C, 0x06, 0x30, 0x38,
  0x40, 0xC1, 0x8D, 0x03, 0xE4, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0xF0, 0x26, 0xE0,
  0xA0, 0xC3, 0x01, 0x1C, 0x04, 0x60, 0x11, 0x80, 0x44, 0x01, 0x10, 0x04,
  0xC0, 0x33, 0x00, 0xC8, 0x02, 0x20, 0x08, 0x80, 0x66, 0x01, 0x18, 0x0C,
  0x50, 0x61, 0x43, 0x0C, 0xF8, 0x00, 0x03, 0xE0, 0xE4, 0x20, 0x0C, 0x03,
  0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x10, 0xFC, 0x00, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x03, 0xC4, 0x06, 0x6C, 0x08, 0x1C, 0x18, 0x18, 0x30, 0x18, 0x20,
  0x18, 0x20, 0x18, 0x60, 0x10, 0x40, 0x10, 0x40, 0x10, 0xC0, 0x30, 0xC0,
  0x30, 0xC0, 0x20, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0xA0, 0x40, 0xE0, 0x63,
  0x40, 0x3E, 0x40, 0x03, 0xC0, 0x66, 0x08, 0x31, 0x03, 0x30, 0x32, 0x02,
  0x60, 0x64, 0x0C, 0x41, 0x87, 0xE0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x40, 0x06, 0x08, 0x3F, 0x80, 0x00, 0x07, 0x80, 0x06,
  0x40, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x3C, 0x00, 0xFE, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xE2, 0x06, 0x64, 0x18, 0x30, 0x60, 0x61, 0x80, 0xC2, 0x01, 0x84, 0x03,
  0x18, 0x04, 0x20, 0x08, 0x40, 0x11, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x0C,
  0x06, 0x18, 0x0C, 0x30, 0x28, 0x20, 0xF0, 0x63, 0x40, 0x7C, 0x80, 0x01,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x81, 0x02, 0x03,
  0xF8, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x70, 0x26, 0x60, 0xA0, 0x83, 0x03, 0x08,
  0x0C, 0x60, 0x21, 0x80, 0x84, 0x02, 0x10, 0x18, 0xC0, 0x63, 0x01, 0x08,
  0x04, 0x20, 0x10, 0x80, 0xC6, 0x02, 0x18, 0x08, 0x40, 0x21, 0x00, 0x8C,
  0x06, 0x00, 0x06, 0x0C, 0x10, 0x00, 0x00, 0x03, 0x04, 0x08, 0x10, 0x20,
  0xC1, 0x02, 0x04, 0x18, 0x30, 0x40, 0x81, 0x06, 0x0C, 0x10, 0x20, 0xC0,
  0x00, 0x30, 0x03, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0xF0, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x0C, 0x20, 0x60, 0x83, 0x02, 0x08, 0x08,
  0x40, 0x62, 0x01, 0x18, 0x04, 0xC0, 0x16, 0x00, 0xFC, 0x02, 0x90, 0x0C,
  0x40, 0x21, 0x00, 0x86, 0x06, 0x08, 0x10, 0x20, 0x40, 0xC1, 0x03, 0x0C,
  0x04, 0x00, 0x02, 0x04, 0x08, 0x30, 0x60, 0x81, 0x02, 0x0C, 0x10, 0x20,
  0x40, 0x83, 0x04, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x18, 0x20, 0x40,
  0x83, 0x00, 0x08, 0xE0, 0xF0, 0x59, 0x9D, 0xC2, 0x86, 0x82, 0x18, 0x18,
  0x11, 0x80, 0x80, 0x8C, 0x04, 0x04, 0x60, 0x60, 0x22, 0x02, 0x03, 0x10,
  0x10, 0x11, 0x80, 0x80, 0x8C, 0x0C, 0x04, 0x40, 0x60, 0x62, 0x02, 0x03,
  0x10, 0x10, 0x11, 0x80, 0x80, 0x8C, 0x0C, 0x04, 0x40, 0x60, 0x62, 0x02,
  0x03, 0x30, 0x10, 0x10, 0x08, 0xF0, 0x26, 0x60, 0xA0, 0x83, 0x03, 0x18,
  0x0C, 0x60, 0x21, 0x80, 0x84, 0x02, 0x10, 0x18, 0xC0, 0x63, 0x01, 0x08,
  0x04, 0x20, 0x10, 0x80, 0xC6, 0x02, 0x18, 0x08, 0x40, 0x21, 0x00, 0x8C,
  0x06, 0x00, 0x03, 0xC0, 0x33, 0x02, 0x0C, 0x30, 0x23, 0x01, 0x90, 0x0D,
  0x80, 0x6C, 0x03, 0x40, 0x1A, 0x00, 0xB0, 0x05, 0x80, 0x2C, 0x03, 0x60,
  0x13, 0x01, 0x98, 0x08, 0x40, 0xC3, 0x0C, 0x0F, 0xC0, 0x04, 0x78, 0x09,
  0x98, 0x14, 0x18, 0x30, 0x10, 0x60, 0x21, 0x80, 0x43, 0x00, 0x84, 0x01,
  0x08, 0x02, 0x30, 0x0C, 0x60, 0x18, 0x80, 0x21, 0x00, 0x42, 0x01, 0x8C,
  0x02, 0x18, 0x0C, 0x30, 0x30, 0x50, 0xC0, 0x9F, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x00,
  0x03, 0xC4, 0x19, 0x90, 0x81, 0xC6, 0x06, 0x30, 0x18, 0x80, 0x62, 0x01,
  0x98, 0x04, 0x40, 0x11, 0x00, 0x4C, 0x03, 0x30, 0x0C, 0xC0, 0x23, 0x01,
  0x8C, 0x06, 0x30, 0x28, 0x40, 0xE1, 0x8D, 0x03, 0xE4, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x08, 0xE1, 0x34, 0x28, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0x80, 0x10,
  0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x00, 0x07, 0xC1, 0x9C, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x90, 0x63, 0xF8, 0x00, 0x08, 0x08, 0x08, 0x18, 0x1F, 0x7F,
  0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0,
  0xC0, 0x80, 0x80, 0x80, 0x78, 0x18, 0x08, 0x80, 0x44, 0x02, 0x20, 0x33,
  0x01, 0x10, 0x08, 0x80, 0x44, 0x06, 0x20, 0x33, 0x01, 0x10, 0x08, 0x80,
  0x44, 0x06, 0x60, 0x33, 0x01, 0x18, 0x18, 0xC1, 0x46, 0x1A, 0x1F, 0xB0,
  0x80, 0x30, 0x0E, 0x01, 0x40, 0x68, 0x09, 0x03, 0x20, 0x46, 0x18, 0xC2,
  0x18, 0xC3, 0x10, 0x66, 0x04, 0x80, 0x90, 0x14, 0x02, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x00, 0x80, 0x40, 0x60, 0x30, 0x38, 0x0C, 0x0A, 0x05, 0x02,
  0x81, 0x41, 0x20, 0xD0, 0x48, 0x24, 0x32, 0x19, 0x08, 0x84, 0x46, 0x21,
  0x11, 0x08, 0x84, 0x42, 0x21, 0x30, 0x98, 0x48, 0x24, 0x16, 0x0B, 0x05,
  0x02, 0x81, 0x40, 0xA0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x08, 0x04,
  0x20, 0x20, 0xC1, 0x81, 0x04, 0x04, 0x20, 0x11, 0x80, 0x6C, 0x00, 0xA0,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x40, 0x0D, 0x80, 0x62, 0x01, 0x08,
  0x08, 0x20, 0x60, 0xC1, 0x01, 0x08, 0x04, 0x00, 0x03, 0x00, 0xC0, 0xC0,
  0x20, 0x10, 0x18, 0x04, 0x04, 0x01, 0x03, 0x00, 0x40, 0x80, 0x10, 0x60,
  0x04, 0x10, 0x01, 0x0C, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x40, 0x01,
  0x10, 0x00, 0x48, 0x00, 0x12, 0x00, 0x05, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x0F, 0x80, 0x01, 0x00, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60,
  0x04, 0x00, 0xFF, 0x80, 0x00, 0x70, 0x1C, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x30, 0x0E, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03,
  0xC0, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xE0, 0x07, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x18, 0x0F, 0x00, 0x80, 0x00, 0x78, 0x0E, 0x30, 0xE0, 0x7C,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 25, 7, 1, -25 },
  { 23, 8, 9, 10, 3, -25 },
  { 32, 16, 25, 16, 0, -25 },
  { 82, 15, 29, 14, 0, -27 },
  { 137, 18, 25, 21, 2, -25 },
  { 194, 15, 25, 16, 0, -25 },
  { 241, 3, 9, 6, 4, -25 },
  { 245, 10, 31, 9, 1, -25 },
  { 284, 9, 31, 9, -2, -25 },
  { 319, 11, 12, 14, 4, -27 },
  { 336, 13, 16, 16, 2, -20 },
  { 362, 4, 8, 6, -1, -4 },
  { 366, 8, 1, 10, 1, -10 },
  { 367, 2, 3, 6, 1, -3 },
  { 368, 15, 25, 11, -2, -25 },
  { 415, 13, 25, 14, 1, -25 },
  { 456, 8, 25, 14, 4, -25 },
  { 481, 15, 25, 14, -1, -25 },
  { 528, 14, 25, 14, 0, -25 },
  { 572, 14, 25, 14, 0, -25 },
  { 616, 14, 25, 14, 0, -25 },
  { 660, 14, 25, 14, 1, -25 },
  { 704, 13, 25, 14, 2, -25 },
  { 745, 14, 25, 14, 0, -25 },
  { 789, 14, 25, 14, 0, -25 },
  { 833, 6, 19, 6, 0, -19 },
  { 848, 8, 23, 6, -2, -19 },
  { 871, 13, 15, 16, 2, -20 },
  { 896, 13, 9, 16, 2, -17 },
  { 911, 13, 15, 16, 2, -20 },
  { 936, 11, 25, 10, 1, -25 },
  { 971, 20, 28, 22, 1, -25 },
  { 1041, 14, 25, 14, -2, -25 },
  { 1085, 15, 25, 16, 1, -25 },
  { 1132, 15, 25, 15, 2, -25 },
  { 1179, 16, 25, 17, 1, -25 },
  { 1229, 14, 25, 14, 1, -25 },
  { 1273, 14, 25, 13, 1, -25 },
  { 1317, 17, 25, 18, 2, -25 },
  { 1371, 17, 25, 18, 1, -25 },
  { 1425, 11, 25, 8, -1, -25 },
  { 1460, 12, 31, 7, -5, -25 },
  { 1507, 16, 25, 15, 1, -25 },
  { 1557, 9, 25, 13, 1, -25 },
  { 1586, 23, 25, 23, 1, -25 },
  { 1658, 18, 25, 19, 1, -25 },
  { 1715, 16, 25, 19, 2, -25 },
  { 1765, 14, 25, 15, 1, -25 },
  { 1809, 16, 31, 19, 2, -25 },
  { 1871, 14, 25, 15, 1, -25 },
  { 1915, 15, 25, 14, 0, -25 },
  { 1962, 12, 25, 13, 3, -25 },
  { 2000, 16, 25, 18, 2, -25 },
  { 2050, 14, 25, 14, 3, -25 },
  { 2094, 23, 25, 24, 3, -25 },
  { 2166, 18, 25, 13, -2, -25 },
  { 2223, 13, 25, 13, 3, -25 },
  { 2264, 16, 25, 13, -1, -25 },
  { 2314, 13, 31, 10, -1, -25 },
  { 2365, 5, 25, 11, 4, -25 },
  { 2381, 12, 31, 10, -2, -25 },
  { 2428, 14, 13, 15, 1, -25 },
  { 2451, 11, 1, 11, -3, 3 },
  { 2453, 4, 6, 8, 5, -27 },
  { 2456, 14, 19, 15, 1, -19 },
  { 2490, 14, 27, 15, 0, -27 },
  { 2538, 11, 19, 12, 1, -19 },
  { 2565, 16, 27, 15, 1, -27 },
  { 2619, 12, 19, 13, 1, -19 },
  { 2648, 17, 35, 8, -5, -27 },
  { 2723, 15, 27, 15, 0, -19 },
  { 2774, 14, 27, 15, 0, -27 },
  { 2822, 7, 25, 6, 0, -25 },
  { 2844, 12, 33, 6, -5, -25 },
  { 2894, 14, 27, 12, 0, -27 },
  { 2942, 7, 27, 6, 0, -27 },
  { 2966, 21, 19, 23, 0, -19 },
  { 3016, 14, 19, 15, 0, -19 },
  { 3050, 13, 19, 15, 1, -19 },
  { 3081, 15, 27, 15, -1, -19 },
  { 3132, 14, 27, 16, 1, -19 },
  { 3180, 11, 19, 10, 0, -19 },
  { 3207, 11, 19, 11, 0, -19 },
  { 3234, 8, 23, 8, 1, -23 },
  { 3257, 13, 19, 15, 1, -19 },
  { 3288, 11, 19, 11, 2, -19 },
  { 3315, 18, 19, 19, 2, -19 },
  { 3358, 14, 19, 12, -1, -19 },
  { 3392, 18, 28, 12, -4, -19 },
  { 3455, 12, 19, 11, -1, -19 },
  { 3484, 12, 31, 11, 1, -25 },
  { 3531, 1, 35, 14, 7, -27 },
  { 3536, 12, 31, 11, -2, -25 },
  { 3583, 13, 3, 16, 2, -14 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC35PT7B_H_
