#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC67PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0x1C, 0x1C, 0x60, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x18, 0xC0, 0x63,
  0x03, 0x8C, 0x0E, 0x70, 0x31, 0x80, 0xC6, 0x03, 0x18, 0x1C, 0x60, 0x63,
  0x01, 0x8C, 0x06, 0x30, 0x18, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xE0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x70,
  0x0C, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x07,
  0x00, 0x00, 0xE0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x70, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x01, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C,
  0x03, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x38, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x38, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7C,
  0x43, 0xE0, 0x1E, 0x18, 0x08, 0x07, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x38, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x38, 0x30, 0x00, 0x03, 0x86, 0x00, 0x00, 0x70, 0x80,
  0x00, 0x07, 0x30, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1B, 0xC0,
  0x00, 0x03, 0x3C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x18, 0x38, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x60, 0x70, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x60, 0x38, 0x00, 0x0C, 0x07, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x30,
  0x18, 0x00, 0x06, 0x07, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x38, 0x08,
  0x06, 0x1E, 0x01, 0xF0, 0xDF, 0x80, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xC0, 0x3F, 0xE0,
  0x00, 0x60, 0x1C, 0x18, 0x00, 0x30, 0x06, 0x07, 0x00, 0x1C, 0x03, 0x80,
  0xC0, 0x06, 0x01, 0xC0, 0x30, 0x03, 0x80, 0x60, 0x0C, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x0C, 0x00,
  0xC0, 0x1C, 0x07, 0x00, 0x70, 0x07, 0x01, 0x80, 0x18, 0x01, 0xC0, 0xE0,
  0x06, 0x00, 0x60, 0x30, 0x01, 0x80, 0x18, 0x1C, 0x00, 0xE0, 0x06, 0x06,
  0x00, 0x38, 0x03, 0x83, 0x00, 0x0C, 0x00, 0xE1, 0xC0, 0x03, 0x00, 0x30,
  0x60, 0x00, 0xC0, 0x0C, 0x38, 0x3E, 0x30, 0x07, 0x0C, 0x3F, 0xEC, 0x01,
  0x87, 0x1E, 0x3B, 0x00, 0xE1, 0x86, 0x06, 0xC0, 0x30, 0xC3, 0x81, 0xF0,
  0x1C, 0x71, 0xC0, 0x7E, 0x06, 0x18, 0x60, 0x0D, 0x83, 0x0E, 0x38, 0x03,
  0x7F, 0xC3, 0x0C, 0x00, 0xCF, 0xC1, 0xC3, 0x00, 0x70, 0xC0, 0x61, 0xC0,
  0x1C, 0x00, 0x30, 0x70, 0x07, 0x00, 0x1C, 0x18, 0x01, 0x80, 0x06, 0x06,
  0x00, 0x60, 0x03, 0x83, 0x80, 0x18, 0x00, 0xC0, 0xE0, 0x0E, 0x00, 0x70,
  0x30, 0x03, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x07,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80,
  0x30, 0x03, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x30, 0x1C,
  0x03, 0x80, 0x0C, 0x06, 0x01, 0xC0, 0x03, 0x83, 0x00, 0x60, 0x00, 0x7B,
  0xC0, 0x38, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x18, 0x03, 0x80, 0x03,
  0x80, 0x38, 0x00, 0x30, 0x03, 0x80, 0x03, 0x00, 0x38, 0x00, 0x30, 0x03,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x70, 0x0E, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x38, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x07, 0x03, 0x80, 0x30, 0xE0, 0x38, 0x07, 0x0C, 0x01, 0xC0, 0x61, 0xC0,
  0x1C, 0x0E, 0x38, 0x00, 0xC0, 0xE3, 0x80, 0x0E, 0x0C, 0x70, 0x00, 0xE1,
  0xC7, 0x00, 0x07, 0x18, 0x60, 0x00, 0x73, 0x86, 0x00, 0x03, 0x70, 0xE0,
  0x00, 0x3F, 0x0E, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x3C, 0x06, 0x00, 0x07, 0xE0, 0x70, 0x00, 0xE6, 0x07,
  0x80, 0x1C, 0x70, 0x3C, 0x07, 0x87, 0x01, 0xFF, 0xF0, 0x30, 0x0F, 0xFC,
  0x03, 0x80, 0x1E, 0x00, 0x00, 0x1C, 0x61, 0x8E, 0x38, 0xC3, 0x0C, 0x71,
  0x86, 0x18, 0x63, 0x8C, 0x30, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x08, 0x03, 0x00, 0xE0, 0x30, 0x0F, 0x82, 0x00, 0x3C, 0x60, 0x00, 0xF6,
  0x0F, 0x03, 0xFF, 0xF0, 0x0F, 0xE0, 0x01, 0xE0, 0x00, 0x3B, 0x00, 0x07,
  0x30, 0x00, 0xE1, 0x80, 0x1C, 0x18, 0x03, 0x80, 0xC0, 0x70, 0x0C, 0x02,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x03, 0x81, 0xC0, 0xE0,
  0x60, 0x70, 0x30, 0x38, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x03, 0x01,
  0x81, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x77, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0x81, 0xC0, 0x03, 0x80,
  0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x0C, 0x01, 0x80, 0x07, 0x01, 0xC0,
  0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x60, 0x00, 0x70, 0x70,
  0x00, 0x38, 0x30, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0C,
  0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x31, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x0C, 0x60, 0x00, 0x0E,
  0x30, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x71, 0x80, 0x00, 0x38, 0xC0, 0x00,
  0x18, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x06, 0x1C, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0x83, 0x80, 0x01, 0xC1, 0xC0,
  0x00, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x60, 0x18, 0x00, 0x70, 0x0C,
  0x00, 0x70, 0x07, 0x00, 0x30, 0x01, 0xC0, 0x38, 0x00, 0xF0, 0x78, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x03, 0xC0, 0x3E, 0x07, 0xF0, 0x7B, 0x07, 0x18, 0xF1, 0xCF, 0x0E, 0xE0,
  0x66, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xE0, 0x3C, 0x00, 0x38, 0x01, 0xE0, 0x02, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x06, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x08, 0x00, 0x0F,
  0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x1C, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x38, 0x00,
  0x07, 0x03, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x38, 0x07, 0x00, 0x03, 0x00, 0x60, 0x00, 0x70, 0x06, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0,
  0x1C, 0x00, 0x1C, 0x01, 0x80, 0x01, 0x80, 0x38, 0x00, 0x18, 0x07, 0x00,
  0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x02, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1E, 0x01, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x3F, 0xC0, 0x06, 0x3F, 0xFC, 0x03, 0x9E, 0x07, 0x80, 0xEE, 0x00,
  0xE0, 0x36, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xC1, 0xE0,
  0x00, 0x38, 0x78, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x38, 0x60, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0x83, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x07,
  0x00, 0x07, 0x01, 0xC0, 0x03, 0x80, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x01, 0xC0, 0x78, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xE0, 0x3C, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x60, 0x0E, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x60,
  0x1C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x0C, 0x00, 0xC0,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x07, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x38, 0x1C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xDC, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x3C, 0x07, 0x00, 0x07, 0x80, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x1C,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0C, 0x07, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x38, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x06, 0x00, 0x06, 0x03,
  0x80, 0x01, 0x80, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07,
  0x06, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x30, 0x00,
  0x07, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x70,
  0x00, 0x0E, 0x1C, 0x00, 0x03, 0x83, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x78,
  0x30, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x03, 0x80, 0x06, 0xC0, 0x70, 0x03,
  0xB0, 0x1E, 0x03, 0xDC, 0x03, 0xFF, 0xC7, 0x00, 0x3F, 0xE1, 0x80, 0x01,
  0x80, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x08, 0x07, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0xF0, 0x3C, 0x0F, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0xC0, 0x70, 0x1E, 0x04, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x70, 0x01, 0xFF, 0x00,
  0xC1, 0x80, 0x0F, 0xFE, 0x03, 0x0E, 0x00, 0x70, 0x30, 0x0C, 0x30, 0x03,
  0x80, 0xC0, 0x30, 0xC0, 0x1C, 0x07, 0x00, 0xC7, 0x00, 0xE0, 0x1C, 0x03,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x60, 0x18, 0x01, 0x80, 0x73, 0x80, 0x60,
  0x0E, 0x01, 0xCC, 0x03, 0x00, 0x38, 0x06, 0x30, 0x0C, 0x00, 0xC0, 0x18,
  0xC0, 0x70, 0x03, 0x00, 0x67, 0x01, 0x80, 0x1C, 0x03, 0x98, 0x06, 0x00,
  0x60, 0x0E, 0x60, 0x18, 0x01, 0x80, 0x31, 0x80, 0xE0, 0x0E, 0x00, 0xC6,
  0x03, 0x80, 0x38, 0x07, 0x18, 0x0C, 0x00, 0xE0, 0x18, 0xE0, 0x30, 0x07,
  0x00, 0xE3, 0x80, 0xC0, 0x1C, 0x03, 0x0E, 0x03, 0x00, 0xF0, 0x1C, 0x38,
  0x0E, 0x03, 0xC0, 0x60, 0xE0, 0x38, 0x1B, 0x03, 0x83, 0x80, 0x60, 0xC6,
  0x1C, 0x0E, 0x01, 0xFF, 0x1F, 0xE0, 0x38, 0x03, 0xF8, 0x3F, 0x00, 0xE0,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x20, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x06, 0x60, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x0E, 0x30, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x0E, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0C, 0x0E,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x00, 0x70,
  0x00, 0xE0, 0x0E, 0x00, 0x18, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x38, 0x00, 0x60, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x38, 0x00, 0x30, 0x0E, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xC0, 0x70, 0x00,
  0x18, 0x0E, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x70, 0x00, 0x0C, 0x0C,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x38, 0x60, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x01, 0x80,
  0x00, 0xE0, 0x0C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x60, 0x0C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x07,
  0x00, 0x30, 0x00, 0xF0, 0x01, 0x80, 0x7F, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0x00, 0x7C, 0x00, 0x30, 0x00, 0x70, 0x01, 0x80,
  0x01, 0xC0, 0x1C, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x1C, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x06, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0xF0, 0x06, 0x00, 0x0F, 0x00, 0x30, 0x0F, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xF0, 0x0E, 0x00, 0x0F, 0x00,
  0x08, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8,
  0x03, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0x80, 0x1F, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xE0, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x07,
  0x80, 0x30, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x78, 0x01, 0xC0, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x80, 0x06, 0x00, 0x3E, 0x00, 0x0C, 0x0F, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x02,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xF8, 0x03,
  0xF0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xFC, 0x18, 0x00, 0x0F, 0xFE, 0x0C,
  0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x60, 0x07, 0x80, 0x00, 0x30, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x18, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0x60, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00,
  0xC0, 0x3C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0x07, 0x3E, 0x00, 0x00, 0x07, 0x7E, 0x00, 0x00, 0x07,
  0xE6, 0x00, 0x00, 0x06, 0xC7, 0x00, 0x00, 0x07, 0x87, 0x00, 0x00, 0x0F,
  0x03, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x60, 0x00, 0x38, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x38, 0x00, 0x60, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x06, 0xC0, 0x00, 0x00, 0x76, 0x00, 0x6C, 0x00, 0x00,
  0x07, 0xE0, 0x06, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0xEE, 0x00, 0x00, 0x0E,
  0xC0, 0x0E, 0xE0, 0x00, 0x01, 0xCC, 0x00, 0xCE, 0x00, 0x00, 0x1D, 0xC0,
  0x0C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0xCE, 0x00, 0x00, 0x39, 0x80, 0x1C,
  0x60, 0x00, 0x07, 0x18, 0x01, 0xC6, 0x00, 0x00, 0x61, 0x80, 0x18, 0x60,
  0x00, 0x0E, 0x38, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x80, 0x18, 0x60, 0x00,
  0x1C, 0x30, 0x03, 0x86, 0x00, 0x01, 0x83, 0x00, 0x38, 0x60, 0x00, 0x38,
  0x70, 0x03, 0x07, 0x00, 0x03, 0x07, 0x00, 0x30, 0x70, 0x00, 0x70, 0x70,
  0x07, 0x07, 0x00, 0x06, 0x06, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x60, 0x07,
  0x03, 0x00, 0x0C, 0x0E, 0x00, 0x60, 0x30, 0x01, 0xC0, 0xE0, 0x06, 0x03,
  0x00, 0x18, 0x0E, 0x00, 0xE0, 0x30, 0x03, 0x80, 0xC0, 0x0E, 0x03, 0x00,
  0x30, 0x0C, 0x00, 0xC0, 0x30, 0x07, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x60,
  0x1C, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x1C, 0x03, 0x80, 0xC0, 0x18,
  0x01, 0xC0, 0x38, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x81, 0x80, 0x38, 0x01,
  0x80, 0x38, 0x38, 0x03, 0x80, 0x38, 0x01, 0x83, 0x00, 0x30, 0x03, 0x80,
  0x18, 0x70, 0x03, 0x00, 0x38, 0x01, 0x86, 0x00, 0x70, 0x03, 0x00, 0x18,
  0xE0, 0x07, 0x00, 0x30, 0x01, 0x8C, 0x00, 0x70, 0x07, 0x00, 0x19, 0xC0,
  0x06, 0x00, 0x70, 0x01, 0x98, 0x00, 0x60, 0x06, 0x00, 0x1F, 0x80, 0x0E,
  0x00, 0x60, 0x01, 0xF0, 0x00, 0xE0, 0x06, 0x00, 0x1F, 0x00, 0x0E, 0x00,
  0xE0, 0x01, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x3E, 0x00, 0x00, 0x70, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0xD8, 0x00,
  0x01, 0x80, 0x1B, 0x80, 0x00, 0x30, 0x03, 0x70, 0x00, 0x0E, 0x00, 0xE6,
  0x00, 0x01, 0xC0, 0x1C, 0xC0, 0x00, 0x30, 0x03, 0x9C, 0x00, 0x06, 0x00,
  0x63, 0x80, 0x00, 0xC0, 0x0C, 0x30, 0x00, 0x38, 0x03, 0x86, 0x00, 0x07,
  0x00, 0x70, 0xE0, 0x00, 0xC0, 0x0C, 0x1C, 0x00, 0x18, 0x01, 0x81, 0x80,
  0x07, 0x00, 0x30, 0x30, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x1C, 0x01, 0xC0,
  0xE0, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x06, 0x01, 0x80, 0x1C, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x70, 0x07, 0x00, 0x38,
  0x0E, 0x00, 0xE0, 0x03, 0x01, 0x80, 0x18, 0x00, 0x60, 0x30, 0x03, 0x00,
  0x0E, 0x06, 0x00, 0x60, 0x01, 0xC1, 0xC0, 0x1C, 0x00, 0x18, 0x38, 0x03,
  0x80, 0x03, 0x06, 0x00, 0x60, 0x00, 0x70, 0xC0, 0x0C, 0x00, 0x0E, 0x38,
  0x03, 0x80, 0x00, 0xC7, 0x00, 0x70, 0x00, 0x18, 0xE0, 0x0E, 0x00, 0x03,
  0x98, 0x01, 0x80, 0x00, 0x73, 0x00, 0x30, 0x00, 0x06, 0xE0, 0x0E, 0x00,
  0x00, 0xDC, 0x01, 0xC0, 0x00, 0x1F, 0x80, 0x38, 0x00, 0x03, 0xE0, 0x06,
  0x00, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xC0, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x60, 0x00, 0xE0, 0x06, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0C, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70,
  0x1C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0xE0, 0x38, 0x00, 0x1C, 0x03, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x38,
  0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x60,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x01,
  0xC0, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x03,
  0x38, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x01, 0x9C,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x18, 0x38, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0xE0, 0x06, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x1C, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xE0,
  0x18, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x78, 0x07, 0x00, 0x0F, 0x00, 0x70, 0x03, 0xE0,
  0x07, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xE0,
  0x38, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x1C,
  0x00, 0xE0, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x06,
  0x00, 0x38, 0x00, 0x70, 0x03, 0x00, 0x07, 0x00, 0x30, 0x00, 0x70, 0x07,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x38, 0x06, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x3E, 0x01, 0xF0, 0x03, 0xC0, 0x01, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x40, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x01, 0x80, 0x70, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x70, 0x70, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x70, 0x18,
  0x00, 0x0C, 0x03, 0x00, 0x03, 0x80, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x1C,
  0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0xE0, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x38, 0x00, 0x60, 0x07, 0x00,
  0x0C, 0x00, 0xC0, 0x01, 0x80, 0x38, 0x00, 0x30, 0x06, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0xE0, 0x30, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0x80, 0x00,
  0x70, 0x70, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x01,
  0x9C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xCE, 0x00, 0x01,
  0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0x8E, 0x00, 0x03, 0x70,
  0x00, 0x38, 0xE0, 0x00, 0x37, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x70, 0x00,
  0x30, 0xE0, 0x00, 0x67, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x70, 0x00, 0x60,
  0xE0, 0x00, 0xC7, 0x00, 0x0E, 0x0E, 0x00, 0x0C, 0x70, 0x00, 0xE0, 0xE0,
  0x01, 0xC7, 0x00, 0x1C, 0x0E, 0x00, 0x18, 0x70, 0x01, 0xC0, 0xE0, 0x03,
  0x87, 0x00, 0x18, 0x0E, 0x00, 0x30, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x07,
  0x00, 0x30, 0x0E, 0x00, 0x70, 0x70, 0x07, 0x00, 0xE0, 0x06, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x06, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x60, 0x0C, 0x00, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x06,
  0x01, 0x80, 0x60, 0x1C, 0x00, 0x60, 0x38, 0x06, 0x01, 0x80, 0x06, 0x03,
  0x00, 0x60, 0x38, 0x00, 0x60, 0x70, 0x06, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x60, 0x70, 0x00, 0x60, 0xE0, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x60,
  0xE0, 0x00, 0x60, 0xC0, 0x06, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x60, 0xC0,
  0x00, 0x61, 0x80, 0x06, 0x1C, 0x00, 0x06, 0x38, 0x00, 0x61, 0x80, 0x00,
  0x63, 0x00, 0x06, 0x38, 0x00, 0x06, 0x70, 0x00, 0x63, 0x80, 0x00, 0x67,
  0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x67, 0x00, 0x00, 0x6E, 0x00,
  0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x6E, 0x00, 0x00, 0x7C, 0x00, 0x06,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x6C, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x1C,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x06,
  0x1C, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x38, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x38,
  0x60, 0x00, 0x70, 0x60, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xC0,
  0x70, 0x01, 0xC0, 0x30, 0x01, 0x80, 0x30, 0x03, 0x80, 0x30, 0x07, 0x00,
  0x30, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0C, 0x00, 0x38, 0x1C, 0x00,
  0x18, 0x18, 0x00, 0x18, 0x38, 0x00, 0x18, 0x70, 0x00, 0x1C, 0x70, 0x00,
  0x1C, 0xE0, 0x00, 0x1C, 0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x0D, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xC0, 0x60, 0x30,
  0x1C, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x38,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xE0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x18,
  0x0C, 0x06, 0x03, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x01, 0x86, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x30, 0x70, 0x00, 0x1C, 0x0C, 0x00, 0x06, 0x03, 0x80,
  0x03, 0x80, 0xE0, 0x01, 0xC0, 0x18, 0x00, 0x60, 0x07, 0x00, 0x38, 0x00,
  0xC0, 0x0C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0x80, 0x01, 0x80, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x19, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xC1, 0x83, 0x83, 0x07, 0x06,
  0x06, 0x0C, 0x0C, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFC, 0x30, 0x07, 0xC7,
  0x8C, 0x03, 0xC0, 0x77, 0x01, 0xC0, 0x0D, 0x80, 0xE0, 0x03, 0x60, 0x30,
  0x00, 0x58, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x01, 0xC1,
  0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x18, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x0E, 0x1C, 0x00,
  0x03, 0x87, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18,
  0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x38,
  0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x01, 0xE0, 0xE0, 0x00,
  0xF0, 0x18, 0x00, 0x3C, 0x06, 0x00, 0x1B, 0x01, 0xC0, 0x0D, 0xC0, 0x38,
  0x07, 0x70, 0x0F, 0x03, 0x98, 0x01, 0xFF, 0xC6, 0x00, 0x3F, 0xC1, 0x80,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x07, 0xE0, 0x01, 0xC7, 0xFE, 0x00,
  0x63, 0xC7, 0xC0, 0x19, 0xC0, 0x78, 0x0E, 0xE0, 0x0E, 0x03, 0xF0, 0x01,
  0x80, 0xD8, 0x00, 0x70, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x07, 0x80,
  0x01, 0xC1, 0xE0, 0x00, 0x30, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x06,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x30, 0x00, 0x07,
  0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x38, 0x70, 0x00,
  0x0E, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x70, 0xE0,
  0x00, 0x1C, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1,
  0xE0, 0x00, 0x70, 0x78, 0x00, 0x38, 0x1A, 0x00, 0x0E, 0x06, 0xC0, 0x07,
  0x01, 0xB8, 0x03, 0x80, 0xE7, 0x03, 0xC0, 0x30, 0xFF, 0xE0, 0x0C, 0x1F,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0x07,
  0xC1, 0x80, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x0C, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xF8, 0x38, 0x00,
  0x3F, 0xF0, 0xC0, 0x01, 0xF1, 0xE3, 0x00, 0x0F, 0x01, 0xDC, 0x00, 0x70,
  0x03, 0x70, 0x03, 0x80, 0x07, 0xC0, 0x0C, 0x00, 0x1E, 0x00, 0x70, 0x00,
  0x78, 0x03, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0x70, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x70, 0x06, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x01, 0xE0,
  0x0E, 0x00, 0x07, 0x80, 0x38, 0x00, 0x3E, 0x00, 0x60, 0x00, 0xF0, 0x01,
  0x80, 0x06, 0xC0, 0x07, 0x00, 0x3B, 0x00, 0x0E, 0x01, 0xCC, 0x00, 0x3C,
  0x0E, 0x70, 0x00, 0x7F, 0xF1, 0x80, 0x00, 0xFF, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xC7, 0x80, 0x38,
  0x07, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x30, 0x70, 0x00, 0xC1, 0xC0, 0x03,
  0x0E, 0x00, 0x0C, 0x30, 0x00, 0x71, 0xC0, 0x01, 0xC6, 0x00, 0x0E, 0x18,
  0x00, 0x38, 0xE0, 0x01, 0xC3, 0x00, 0x1E, 0x0C, 0x00, 0xF0, 0x70, 0x1F,
  0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x40, 0x70, 0x06, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0x82, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x87, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x08, 0x00, 0x7F, 0xE1, 0x80, 0x07, 0xC7, 0x8C, 0x00,
  0x78, 0x0E, 0x60, 0x07, 0x00, 0x33, 0x00, 0x70, 0x00, 0xF8, 0x03, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x60, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0x80, 0x00, 0x30, 0x1C, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x07,
  0x00, 0x01, 0xE0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x3C, 0x03, 0x80, 0x03, 0xE0, 0x0C, 0x00, 0x3E,
  0x00, 0x70, 0x01, 0xB0, 0x03, 0x80, 0x1D, 0x80, 0x1C, 0x01, 0xDC, 0x00,
  0x70, 0x1C, 0xE0, 0x01, 0xFF, 0xC6, 0x00, 0x07, 0xF8, 0x30, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x80, 0x07, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x83, 0xF0, 0x01,
  0xC7, 0xFE, 0x00, 0xC7, 0x8F, 0x80, 0x67, 0x01, 0xC0, 0x36, 0x00, 0x70,
  0x3E, 0x00, 0x38, 0x1A, 0x00, 0x1C, 0x0F, 0x00, 0x0E, 0x07, 0x00, 0x07,
  0x07, 0x80, 0x03, 0x83, 0x80, 0x01, 0x81, 0xC0, 0x00, 0xC0, 0xE0, 0x00,
  0x60, 0x60, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x18, 0x1C, 0x00,
  0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80,
  0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x70, 0x70,
  0x00, 0x38, 0x38, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0x81, 0x80, 0x00, 0xC0,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x30, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x10, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x01, 0x01, 0xC0, 0x07, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x03, 0x80, 0x30,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x0C, 0x03, 0x80, 0x06,
  0x03, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0x81, 0xC0, 0x00,
  0xC1, 0xC0, 0x00, 0x61, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x39, 0xE0, 0x00,
  0x18, 0xF0, 0x00, 0x0C, 0xDC, 0x00, 0x06, 0xEE, 0x00, 0x07, 0xE3, 0x00,
  0x03, 0xE1, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x18,
  0x00, 0x70, 0x0C, 0x00, 0x38, 0x07, 0x00, 0x18, 0x03, 0x80, 0x0C, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x03, 0x00, 0x1C, 0x01, 0x80,
  0x06, 0x00, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x30,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x01, 0x87, 0xFC, 0x0F, 0xFC,
  0x01, 0x9E, 0x1E, 0x1E, 0x3E, 0x01, 0xB8, 0x0E, 0x30, 0x0E, 0x03, 0xB0,
  0x07, 0x60, 0x06, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x03, 0x80, 0x07, 0x80, 0x07, 0x07,
  0x80, 0x07, 0x00, 0x06, 0x07, 0x00, 0x07, 0x00, 0x06, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x18,
  0x00, 0x18, 0x00, 0x38, 0x18, 0x00, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x38, 0x00, 0x38, 0x00, 0x30, 0x38, 0x00, 0x30, 0x00, 0x30,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x30, 0x00, 0x70, 0x00, 0x70, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x70, 0x00, 0x70, 0x00, 0x60, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0xE0,
  0x00, 0xE0, 0x00, 0xC0, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0,
  0x01, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0xC3, 0xFF, 0x00, 0x63, 0xC7, 0xC0,
  0x33, 0x80, 0xE0, 0x3B, 0x00, 0x38, 0x1F, 0x00, 0x1C, 0x0D, 0x00, 0x0E,
  0x07, 0x80, 0x07, 0x03, 0x80, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xC0, 0x00,
  0xC0, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x30, 0x30, 0x00, 0x38, 0x38, 0x00,
  0x1C, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x07, 0x00,
  0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60,
  0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0C, 0x0C,
  0x00, 0x06, 0x06, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0x81,
  0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x70, 0x70, 0x00, 0x38,
  0x38, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x7C, 0x7C, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x0E, 0x03, 0x80,
  0x06, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x0E, 0x00,
  0x03, 0x1C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x38, 0x00,
  0x03, 0x38, 0x00, 0x03, 0x30, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0x60, 0x00, 0x70, 0x60, 0x00,
  0x70, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x38, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x01, 0x87, 0xFE, 0x00, 0x0C, 0x78, 0x78, 0x00, 0x67, 0x01,
  0xE0, 0x03, 0x70, 0x07, 0x00, 0x3B, 0x00, 0x18, 0x01, 0xB0, 0x00, 0xE0,
  0x0F, 0x00, 0x07, 0x00, 0x78, 0x00, 0x38, 0x07, 0x80, 0x00, 0xC0, 0x3C,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38,
  0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x70,
  0x0E, 0x00, 0x03, 0x00, 0xF0, 0x00, 0x38, 0x07, 0x80, 0x03, 0x80, 0x34,
  0x00, 0x1C, 0x01, 0xB0, 0x01, 0xC0, 0x0D, 0x80, 0x1C, 0x00, 0xE7, 0x03,
  0xC0, 0x07, 0x3F, 0xFC, 0x00, 0x38, 0x7F, 0xC0, 0x01, 0x80, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x20, 0x07, 0xFE, 0x18, 0x01, 0xF1,
  0xE3, 0x00, 0x70, 0x0E, 0x60, 0x1C, 0x00, 0xCC, 0x07, 0x00, 0x0F, 0x80,
  0xC0, 0x01, 0xE0, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0xF0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x70,
  0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06,
  0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x07, 0x06, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x01, 0xE0, 0x70, 0x00,
  0x3C, 0x0E, 0x00, 0x0F, 0x80, 0xC0, 0x01, 0xE0, 0x18, 0x00, 0x6C, 0x03,
  0x80, 0x1D, 0x80, 0x70, 0x07, 0x70, 0x07, 0x01, 0xCE, 0x00, 0x7F, 0xF1,
  0x80, 0x07, 0xF8, 0x30, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x0C, 0x3F, 0x80, 0x63, 0xE4, 0x03, 0x38, 0x00, 0x3B, 0x00,
  0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0x07, 0xC0, 0xE0, 0x02, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x80, 0x07, 0x03, 0x00, 0x78, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x7F, 0xFC, 0xFF,
  0xF0, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xFE,
  0x03, 0xFC, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x01, 0x81, 0x80, 0x01, 0xC1,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x30, 0x30, 0x00, 0x18,
  0x18, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x03,
  0x03, 0x00, 0x01, 0x81, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x1C, 0x00,
  0x0E, 0x0E, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x03, 0x83, 0x80,
  0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x60, 0x60, 0x00, 0x70, 0x30,
  0x00, 0x38, 0x18, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x07,
  0x00, 0x1B, 0x03, 0x80, 0x0D, 0x80, 0xC0, 0x0D, 0xC0, 0x70, 0x1C, 0xC0,
  0x1F, 0xFC, 0x60, 0x07, 0xFC, 0x30, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xB0, 0x00, 0x1D, 0x80, 0x00, 0xCC, 0x00, 0x0E, 0x60,
  0x00, 0x63, 0x00, 0x07, 0x1C, 0x00, 0x30, 0xE0, 0x03, 0x87, 0x00, 0x18,
  0x38, 0x01, 0xC1, 0xC0, 0x0C, 0x0E, 0x00, 0xE0, 0x70, 0x06, 0x03, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0x60, 0x38, 0x03, 0x01, 0xC0, 0x18, 0x1C, 0x00,
  0xC0, 0xE0, 0x06, 0x0E, 0x00, 0x30, 0x70, 0x01, 0x83, 0x00, 0x0C, 0x38,
  0x00, 0x61, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x00, 0xCE, 0x00, 0x06,
  0x60, 0x00, 0x37, 0x00, 0x01, 0xB0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x3B, 0x00, 0x07, 0x80, 0x06, 0x60, 0x01, 0xF0, 0x01, 0xCC,
  0x00, 0x36, 0x00, 0x31, 0x80, 0x06, 0xC0, 0x06, 0x38, 0x01, 0x98, 0x01,
  0xC7, 0x00, 0x33, 0x00, 0x30, 0xE0, 0x0E, 0x60, 0x0E, 0x1C, 0x01, 0x8C,
  0x01, 0x83, 0x80, 0x71, 0x80, 0x70, 0x70, 0x0C, 0x30, 0x0E, 0x0E, 0x01,
  0x86, 0x01, 0x81, 0xC0, 0x60, 0xC0, 0x70, 0x38, 0x0C, 0x18, 0x0C, 0x07,
  0x03, 0x83, 0x03, 0x80, 0xE0, 0x60, 0x60, 0x60, 0x1C, 0x1C, 0x0C, 0x0C,
  0x03, 0x83, 0x01, 0x83, 0x80, 0x70, 0xE0, 0x30, 0x60, 0x0E, 0x18, 0x06,
  0x1C, 0x01, 0xC3, 0x00, 0xC3, 0x00, 0x38, 0xE0, 0x18, 0x60, 0x07, 0x18,
  0x03, 0x1C, 0x00, 0xE7, 0x00, 0x63, 0x00, 0x1C, 0xC0, 0x0C, 0xE0, 0x03,
  0xB8, 0x01, 0x98, 0x00, 0x76, 0x00, 0x33, 0x00, 0x0E, 0xC0, 0x06, 0xC0,
  0x01, 0xF8, 0x00, 0xD8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x06, 0x00, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x30, 0x03, 0x80, 0x03, 0x80,
  0x70, 0x00, 0x38, 0x0E, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x18, 0x1C, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0C,
  0xE0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x39, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0x60, 0x00, 0xE0, 0x06,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x03, 0x00, 0x38, 0x00, 0x30, 0x07,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x07, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x87, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x5F, 0xFF, 0x00, 0x3C, 0x03, 0xE0, 0x7C, 0x00, 0x7F, 0xF4,
  0x00, 0x0F, 0xF0,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 14, 48, 14, 1, -48 },
  { 85, 14, 17, 19, 7, -48 },
  { 115, 30, 48, 30, 1, -48 },
  { 295, 27, 55, 28, 1, -51 },
  { 481, 34, 50, 41, 4, -49 },
  { 694, 28, 50, 30, 0, -49 },
  { 869, 6, 17, 11, 7, -48 },
  { 882, 19, 59, 16, 2, -48 },
  { 1023, 19, 59, 17, -5, -48 },
  { 1164, 20, 22, 26, 8, -51 },
  { 1219, 25, 31, 30, 3, -39 },
  { 1316, 9, 16, 12, -3, -7 },
  { 1334, 15, 2, 19, 2, -19 },
  { 1338, 4, 5, 12, 1, -5 },
  { 1341, 28, 48, 20, -3, -48 },
  { 1509, 25, 50, 28, 2, -49 },
  { 1666, 13, 48, 28, 9, -48 },
  { 1744, 28, 49, 28, -1, -49 },
  { 1916, 28, 50, 28, -1, -49 },
  { 2091, 28, 48, 28, -1, -48 },
  { 2259, 28, 49, 28, 0, -48 },
  { 2431, 26, 50, 28, 2, -49 },
  { 2594, 26, 48, 28, 4, -48 },
  { 2750, 28, 50, 28, 0, -49 },
  { 2925, 26, 50, 28, 1, -49 },
  { 3088, 10, 36, 12, 1, -36 },
  { 3133, 15, 45, 12, -3, -36 },
  { 3218, 25, 29, 30, 3, -38 },
  { 3309, 25, 17, 30, 3, -32 },
  { 3363, 25, 29, 30, 3, -38 },
  { 3454, 20, 49, 20, 2, -49 },
  { 3577, 38, 54, 41, 2, -48 },
  { 3834, 27, 48, 27, -4, -48 },
  { 3996, 29, 48, 30, 1, -48 },
  { 4170, 30, 50, 28, 3, -49 },
  { 4358, 31, 48, 33, 1, -48 },
  { 4544, 28, 48, 27, 1, -48 },
  { 4712, 28, 48, 25, 1, -48 },
  { 4880, 33, 50, 35, 3, -49 },
  { 5087, 34, 48, 35, 1, -48 },
  { 5291, 22, 48, 14, -3, -48 },
  { 5423, 24, 60, 12, -10, -48 },
  { 5603, 32, 48, 28, 1, -48 },
  { 5795, 18, 48, 24, 1, -48 },
  { 5903, 44, 48, 44, 1, -48 },
  { 6167, 35, 48, 36, 1, -48 },
  { 6377, 31, 50, 36, 3, -49 },
  { 6571, 28, 48, 28, 1, -48 },
  { 6739, 31, 60, 36, 3, -49 },
  { 6972, 28, 48, 29, 1, -48 },
  { 7140, 29, 50, 26, -1, -49 },
  { 7322, 23, 48, 24, 6, -48 },
  { 7460, 32, 49, 34, 3, -48 },
  { 7656, 27, 48, 28, 6, -48 },
  { 7818, 44, 48, 45, 6, -48 },
  { 8082, 34, 48, 25, -4, -48 },
  { 8286, 24, 48, 24, 6, -48 },
  { 8430, 31, 48, 25, -2, -48 },
  { 8616, 24, 59, 19, -1, -48 },
  { 8793, 9, 48, 22, 7, -48 },
  { 8847, 24, 59, 19, -4, -48 },
  { 9024, 26, 25, 30, 2, -48 },
  { 9106, 20, 3, 20, -5, 6 },
  { 9114, 7, 10, 15, 10, -51 },
  { 9123, 26, 37, 29, 2, -36 },
  { 9244, 26, 52, 29, 1, -51 },
  { 9413, 22, 37, 22, 2, -36 },
  { 9515, 30, 52, 30, 2, -51 },
  { 9710, 22, 37, 26, 2, -36 },
  { 9812, 32, 67, 15, -9, -51 },
  { 10080, 29, 52, 30, 0, -36 },
  { 10269, 25, 51, 29, 1, -51 },
  { 10429, 13, 48, 12, 1, -48 },
  { 10507, 23, 64, 12, -9, -48 },
  { 10691, 25, 51, 24, 1, -51 },
  { 10851, 13, 51, 12, 1, -51 },
  { 10934, 40, 36, 43, 1, -36 },
  { 11114, 25, 36, 28, 1, -36 },
  { 11227, 24, 37, 29, 2, -36 },
  { 11338, 29, 51, 29, -2, -36 },
  { 11523, 27, 52, 30, 2, -36 },
  { 11699, 21, 36, 19, 1, -36 },
  { 11794, 22, 37, 22, 0, -36 },
  { 11896, 15, 45, 15, 2, -44 },
  { 11981, 25, 36, 29, 2, -35 },
  { 12094, 21, 35, 22, 4, -35 },
  { 12186, 35, 35, 36, 4, -35 },
  { 12340, 28, 35, 23, -3, -35 },
  { 12463, 33, 51, 23, -7, -35 },
  { 12674, 24, 35, 20, -2, -35 },
  { 12779, 23, 59, 21, 2, -48 },
  { 12949, 2, 67, 27, 13, -51 },
  { 12966, 23, 59, 21, -4, -48 },
  { 13136, 25, 6, 30, 3, -27 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic67pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC67PT7B_H_
