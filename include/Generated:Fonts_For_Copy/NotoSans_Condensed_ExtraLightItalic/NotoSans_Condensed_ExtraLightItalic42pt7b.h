#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC42PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C,
  0x0C, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0xC0, 0x30, 0x98, 0xC8, 0x64, 0x36,
  0x13, 0x09, 0x0C, 0x86, 0x42, 0x61, 0x20, 0x80, 0x00, 0x30, 0x60, 0x02,
  0x04, 0x00, 0x20, 0xC0, 0x06, 0x08, 0x00, 0x60, 0x80, 0x04, 0x18, 0x00,
  0xC1, 0x80, 0x0C, 0x10, 0x00, 0x81, 0x01, 0xFF, 0xFF, 0x01, 0x82, 0x00,
  0x10, 0x20, 0x01, 0x06, 0x00, 0x30, 0x40, 0x03, 0x04, 0x00, 0x20, 0xC0,
  0x06, 0x0C, 0x00, 0x60, 0x80, 0x04, 0x08, 0x07, 0xFF, 0xF8, 0x8C, 0x10,
  0x00, 0x81, 0x00, 0x08, 0x30, 0x01, 0x82, 0x00, 0x10, 0x20, 0x01, 0x06,
  0x00, 0x30, 0x60, 0x03, 0x04, 0x00, 0x20, 0x40, 0x06, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x0F, 0xF8, 0x1C, 0x8C,
  0x18, 0x40, 0x08, 0x20, 0x0C, 0x30, 0x06, 0x10, 0x03, 0x08, 0x01, 0x84,
  0x00, 0xC6, 0x00, 0x32, 0x00, 0x1D, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x2C, 0x00, 0x13, 0x00, 0x08, 0xC0, 0x04, 0x20, 0x06, 0x10,
  0x02, 0x08, 0x01, 0x04, 0x00, 0x86, 0x00, 0x43, 0x10, 0x63, 0x0F, 0x27,
  0x01, 0xFE, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00,
  0x07, 0xC0, 0x10, 0x33, 0x00, 0xC1, 0x84, 0x06, 0x04, 0x18, 0x10, 0x30,
  0x60, 0xC0, 0x81, 0x82, 0x06, 0x04, 0x18, 0x18, 0x10, 0x40, 0x60, 0x43,
  0x01, 0x03, 0x18, 0x04, 0x0C, 0x40, 0x10, 0x23, 0x00, 0xC0, 0x88, 0xFB,
  0x06, 0x66, 0x2C, 0x11, 0x30, 0xD0, 0xCC, 0x83, 0x66, 0x66, 0x0D, 0xF1,
  0x10, 0x30, 0x0C, 0x40, 0xC0, 0x23, 0x02, 0x01, 0x8C, 0x08, 0x04, 0x20,
  0x20, 0x30, 0x81, 0x81, 0x82, 0x06, 0x04, 0x08, 0x10, 0x30, 0x20, 0xC0,
  0x80, 0x82, 0x06, 0x02, 0x18, 0x10, 0x0C, 0x40, 0xC0, 0x1E, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x7C, 0x00, 0x31, 0x80, 0x18, 0x20, 0x04, 0x08, 0x03,
  0x02, 0x00, 0xC0, 0x80, 0x20, 0x60, 0x08, 0x18, 0x03, 0x04, 0x00, 0xC3,
  0x00, 0x31, 0x80, 0x04, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1B, 0x00, 0x0C, 0x40, 0x06, 0x18, 0x33, 0x06, 0x08, 0x80, 0x86, 0x60,
  0x31, 0x10, 0x04, 0xCC, 0x01, 0xA3, 0x00, 0x78, 0xC0, 0x0C, 0x30, 0x07,
  0x0C, 0x01, 0x41, 0x80, 0xD8, 0x70, 0xC6, 0x0F, 0xE0, 0xC0, 0x33, 0x22,
  0x66, 0x44, 0x4C, 0x80, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00,
  0x30, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x18, 0x00,
  0xC1, 0x04, 0x0E, 0x20, 0x19, 0x04, 0x3F, 0xE0, 0xC0, 0x0A, 0x00, 0x88,
  0x08, 0x41, 0x81, 0x04, 0x0C, 0x00, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0C,
  0x21, 0x86, 0x10, 0xC2, 0x18, 0xC0, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFC, 0x01, 0x86, 0x03, 0x02, 0x06,
  0x03, 0x04, 0x03, 0x0C, 0x03, 0x08, 0x03, 0x18, 0x03, 0x18, 0x03, 0x10,
  0x03, 0x30, 0x03, 0x30, 0x03, 0x20, 0x03, 0x20, 0x02, 0x60, 0x02, 0x60,
  0x06, 0x60, 0x06, 0x40, 0x06, 0x40, 0x04, 0x40, 0x0C, 0xC0, 0x0C, 0xC0,
  0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x30, 0x40, 0x30, 0x40, 0x60, 0x60,
  0xC0, 0x31, 0x80, 0x1F, 0x00, 0x01, 0x83, 0xC3, 0x43, 0x27, 0x36, 0x18,
  0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x08,
  0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08, 0x04,
  0x06, 0x03, 0x00, 0x00, 0xFE, 0x00, 0xF0, 0xE0, 0x10, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFE, 0x03, 0xC3, 0x81, 0x80, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x0F, 0x00, 0x08, 0xE0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x0C, 0x0E,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x01, 0xA0,
  0x00, 0xB0, 0x00, 0x98, 0x00, 0xCC, 0x00, 0x44, 0x00, 0x42, 0x00, 0x63,
  0x00, 0x61, 0x80, 0x20, 0x80, 0x30, 0x40, 0x30, 0x20, 0x10, 0x30, 0x18,
  0x18, 0x18, 0x08, 0x08, 0x04, 0x0C, 0x06, 0x0C, 0x03, 0x04, 0x01, 0x87,
  0xFF, 0xFB, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xFF, 0x80, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x10, 0x06, 0x0C, 0x0E, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x01, 0xC1, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x67,
  0xE0, 0x5C, 0x30, 0x50, 0x18, 0xE0, 0x08, 0xC0, 0x08, 0xC0, 0x0C, 0xC0,
  0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x18, 0x80, 0x18, 0x80,
  0x10, 0x80, 0x30, 0xC0, 0x60, 0xC0, 0x60, 0x61, 0xC0, 0x3F, 0x00, 0x1F,
  0xFF, 0x90, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xC1, 0x80, 0xC0, 0x60, 0xC0, 0x30,
  0x60, 0x08, 0x20, 0x04, 0x10, 0x02, 0x08, 0x01, 0x04, 0x01, 0x83, 0x00,
  0x81, 0x80, 0xC0, 0x60, 0xC0, 0x11, 0xC0, 0x0F, 0x80, 0x07, 0x80, 0x0E,
  0x60, 0x0C, 0x18, 0x0C, 0x0C, 0x0C, 0x03, 0x0C, 0x00, 0x84, 0x00, 0x66,
  0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x04, 0x60, 0x06, 0x10, 0x03,
  0x0C, 0x03, 0x03, 0x87, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0xC3, 0x00,
  0xC0, 0xC0, 0xC0, 0x20, 0x40, 0x18, 0x60, 0x0C, 0x20, 0x06, 0x30, 0x03,
  0x18, 0x01, 0x8C, 0x00, 0xC4, 0x00, 0x62, 0x00, 0x21, 0x00, 0x30, 0xC0,
  0x18, 0x60, 0x1C, 0x30, 0x1E, 0x0C, 0x1B, 0x03, 0xF9, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x08, 0x38, 0x07, 0xF8, 0x00, 0x06,
  0x1C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x0E, 0x1C, 0x00, 0x01, 0x80, 0xC0, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20,
  0x30, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x0F, 0xE0,
  0xC1, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x80, 0x08, 0x00, 0xC0,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x06, 0x01,
  0x00, 0x02, 0x02, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x08,
  0x02, 0x01, 0x18, 0x0F, 0xC1, 0x10, 0x30, 0xC1, 0x30, 0x20, 0xC1, 0x30,
  0x60, 0x81, 0x20, 0xC0, 0x83, 0x20, 0x81, 0x83, 0x61, 0x81, 0x83, 0x61,
  0x81, 0x02, 0x41, 0x01, 0x02, 0x41, 0x03, 0x06, 0x41, 0x03, 0x04, 0xC1,
  0x02, 0x0C, 0xC1, 0x06, 0x08, 0xC1, 0x0E, 0x18, 0xC1, 0x9B, 0x30, 0xC0,
  0xF1, 0xE0, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x02, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x40,
  0x00, 0xA0, 0x00, 0xD0, 0x00, 0x48, 0x00, 0x64, 0x00, 0x22, 0x00, 0x31,
  0x00, 0x10, 0xC0, 0x18, 0x60, 0x08, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x06,
  0x06, 0x03, 0x03, 0x01, 0x01, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xC0, 0x30,
  0x40, 0x18, 0x60, 0x0C, 0x30, 0x06, 0x30, 0x01, 0x18, 0x00, 0x98, 0x00,
  0x4C, 0x00, 0x2C, 0x00, 0x16, 0x00, 0x0E, 0x00, 0x04, 0x03, 0xFC, 0x00,
  0x87, 0xC0, 0x60, 0x18, 0x18, 0x02, 0x06, 0x00, 0xC1, 0x00, 0x30, 0x40,
  0x0C, 0x30, 0x03, 0x0C, 0x00, 0x83, 0x00, 0x60, 0x80, 0x18, 0x20, 0x0C,
  0x18, 0x06, 0x06, 0x1F, 0x01, 0xFF, 0x00, 0x40, 0x70, 0x10, 0x06, 0x0C,
  0x01, 0x83, 0x00, 0x20, 0xC0, 0x08, 0x20, 0x02, 0x18, 0x00, 0x86, 0x00,
  0x21, 0x80, 0x18, 0x40, 0x06, 0x10, 0x03, 0x0C, 0x01, 0xC3, 0x00, 0xE0,
  0xC3, 0xE0, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x38, 0x30, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x10, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x47, 0xE0, 0x18, 0x0E, 0x03, 0x00, 0xE0, 0x60,
  0x0C, 0x08, 0x00, 0x81, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80,
  0x0C, 0x20, 0x01, 0x84, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00,
  0x10, 0x80, 0x02, 0x10, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00,
  0xC2, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x30, 0x40, 0x06,
  0x08, 0x01, 0x83, 0x00, 0xE0, 0x60, 0x38, 0x0C, 0x7C, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x81, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x20, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x81, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x3F, 0xF8, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x07, 0x03, 0xC0, 0x60, 0x04, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x03, 0xF8, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x21, 0x80,
  0x01, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x20,
  0x40, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x60, 0x04, 0x01, 0xC0,
  0xE0, 0x07, 0xFE, 0x00, 0x03, 0x00, 0x08, 0x10, 0x00, 0xC1, 0x80, 0x06,
  0x0C, 0x00, 0x20, 0x60, 0x01, 0x02, 0x00, 0x18, 0x10, 0x00, 0xC1, 0x80,
  0x06, 0x0C, 0x00, 0x20, 0x60, 0x01, 0x02, 0x00, 0x18, 0x10, 0x00, 0xC1,
  0x80, 0x06, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x02, 0x00, 0x18, 0x10, 0x00,
  0xC1, 0x80, 0x04, 0x0C, 0x00, 0x20, 0x40, 0x03, 0x02, 0x00, 0x18, 0x30,
  0x00, 0xC1, 0x80, 0x04, 0x0C, 0x00, 0x20, 0x40, 0x03, 0x02, 0x00, 0x18,
  0x30, 0x00, 0xC1, 0x80, 0x04, 0x0C, 0x00, 0x20, 0x40, 0x03, 0x00, 0x01,
  0xFC, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x19, 0x03, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x04, 0x60, 0x0F,
  0x80, 0x00, 0x03, 0x00, 0x70, 0x20, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x18,
  0x06, 0x03, 0x00, 0x40, 0x60, 0x04, 0x0C, 0x00, 0xC1, 0x80, 0x0C, 0x18,
  0x00, 0xC3, 0x00, 0x08, 0x60, 0x00, 0x8C, 0x00, 0x19, 0x80, 0x01, 0xB8,
  0x00, 0x1B, 0x80, 0x01, 0x48, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0x30,
  0x40, 0x02, 0x06, 0x00, 0x20, 0x60, 0x06, 0x06, 0x00, 0x60, 0x20, 0x06,
  0x03, 0x00, 0x40, 0x30, 0x04, 0x01, 0x00, 0xC0, 0x18, 0x0C, 0x01, 0x80,
  0xC0, 0x08, 0x08, 0x00, 0xC0, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF, 0xC0, 0x03,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x34, 0x0B, 0x00, 0x06, 0x81, 0x60, 0x01, 0xB0, 0x6C,
  0x00, 0x36, 0x0C, 0x80, 0x0C, 0x81, 0x90, 0x01, 0x90, 0x22, 0x00, 0x66,
  0x04, 0x40, 0x0C, 0xC1, 0x88, 0x03, 0x18, 0x31, 0x00, 0x62, 0x06, 0x30,
  0x18, 0x40, 0x86, 0x03, 0x18, 0x10, 0xC0, 0xC3, 0x06, 0x18, 0x18, 0x60,
  0xC3, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x30, 0x60, 0xC0, 0x84,
  0x0C, 0x18, 0x11, 0x81, 0x83, 0x02, 0x20, 0x20, 0x40, 0x4C, 0x0C, 0x08,
  0x09, 0x01, 0x83, 0x01, 0xE0, 0x30, 0x60, 0x38, 0x04, 0x0C, 0x07, 0x00,
  0x81, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x70,
  0x00, 0x81, 0xE0, 0x02, 0x07, 0x80, 0x18, 0x12, 0x00, 0x60, 0x48, 0x01,
  0x03, 0x30, 0x04, 0x0C, 0xC0, 0x30, 0x31, 0x00, 0xC0, 0x84, 0x03, 0x02,
  0x18, 0x08, 0x18, 0x60, 0x20, 0x60, 0x81, 0x81, 0x82, 0x06, 0x04, 0x0C,
  0x18, 0x10, 0x30, 0x40, 0xC0, 0x41, 0x03, 0x01, 0x0C, 0x08, 0x06, 0x30,
  0x20, 0x18, 0xC1, 0x80, 0x22, 0x06, 0x00, 0x88, 0x18, 0x03, 0x60, 0x40,
  0x0D, 0x81, 0x00, 0x14, 0x0C, 0x00, 0x50, 0x30, 0x01, 0xC0, 0xC0, 0x07,
  0x02, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0x00, 0x38, 0x30, 0x0C, 0x03, 0x03,
  0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC6, 0x00, 0x08, 0xC0, 0x01, 0x30,
  0x00, 0x26, 0x00, 0x04, 0x80, 0x00, 0xB0, 0x00, 0x16, 0x00, 0x06, 0xC0,
  0x00, 0xD0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x58, 0x00, 0x1B, 0x00,
  0x03, 0x60, 0x00, 0x6C, 0x00, 0x09, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00,
  0x18, 0xC0, 0x03, 0x08, 0x00, 0xC1, 0x80, 0x30, 0x30, 0x0C, 0x03, 0x83,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x01, 0x1F, 0x01, 0x80, 0xC0, 0xC0,
  0x30, 0x60, 0x18, 0x20, 0x0C, 0x10, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x86,
  0x00, 0xC2, 0x00, 0x61, 0x00, 0x21, 0x80, 0x30, 0xC0, 0x30, 0x60, 0x30,
  0x20, 0x70, 0x1F, 0xF0, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x38,
  0x30, 0x0C, 0x03, 0x03, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC6, 0x00,
  0x08, 0xC0, 0x01, 0x30, 0x00, 0x26, 0x00, 0x04, 0x80, 0x00, 0xB0, 0x00,
  0x16, 0x00, 0x06, 0xC0, 0x00, 0xD0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x58, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x09, 0x80, 0x03,
  0x30, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x03, 0x08, 0x00, 0xC1, 0x80, 0x30,
  0x30, 0x0C, 0x03, 0x83, 0x00, 0x3F, 0xC0, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x03, 0xF8, 0x01, 0x1F, 0x01, 0x80, 0xC0, 0xC0, 0x30, 0x60, 0x18, 0x20,
  0x0C, 0x10, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x00, 0xC2, 0x00, 0x41,
  0x00, 0x61, 0x80, 0x30, 0xC0, 0x30, 0x60, 0x70, 0x3F, 0xF0, 0x1F, 0xC0,
  0x18, 0x20, 0x0C, 0x18, 0x06, 0x0C, 0x02, 0x06, 0x03, 0x01, 0x01, 0x80,
  0xC0, 0xC0, 0x60, 0x40, 0x30, 0x20, 0x08, 0x30, 0x06, 0x18, 0x03, 0x0C,
  0x01, 0x84, 0x00, 0xC0, 0x00, 0x7F, 0x80, 0x38, 0x1C, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x40, 0x0C, 0x0E, 0x07,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x04, 0x00, 0x30,
  0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x02, 0x08, 0x00, 0x20, 0x80, 0x06,
  0x18, 0x00, 0x61, 0x80, 0x04, 0x18, 0x00, 0x41, 0x00, 0x0C, 0x10, 0x00,
  0xC3, 0x00, 0x0C, 0x30, 0x00, 0x83, 0x00, 0x08, 0x20, 0x01, 0x86, 0x00,
  0x18, 0x60, 0x01, 0x86, 0x00, 0x10, 0x40, 0x03, 0x04, 0x00, 0x30, 0xC0,
  0x03, 0x0C, 0x00, 0x20, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x04, 0x0C,
  0x00, 0xC0, 0xC0, 0x08, 0x06, 0x01, 0x80, 0x70, 0x70, 0x01, 0xFC, 0x00,
  0x80, 0x01, 0xC0, 0x01, 0xA0, 0x00, 0x90, 0x00, 0xCC, 0x00, 0x66, 0x00,
  0x63, 0x00, 0x31, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x08, 0x30, 0x0C, 0x18,
  0x04, 0x0C, 0x06, 0x06, 0x02, 0x03, 0x03, 0x01, 0x81, 0x00, 0xC1, 0x80,
  0x60, 0xC0, 0x30, 0xC0, 0x08, 0x60, 0x04, 0x20, 0x02, 0x30, 0x01, 0x10,
  0x00, 0x98, 0x00, 0x48, 0x00, 0x2C, 0x00, 0x14, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0x60, 0x07, 0x00, 0x6C, 0x01, 0xE0, 0x0D, 0x80, 0x2C, 0x03,
  0x30, 0x0D, 0x80, 0x66, 0x01, 0x30, 0x08, 0xC0, 0x66, 0x03, 0x18, 0x0C,
  0xC0, 0x43, 0x01, 0x18, 0x18, 0x60, 0x63, 0x03, 0x0C, 0x08, 0x60, 0x41,
  0x83, 0x0C, 0x18, 0x30, 0x41, 0x02, 0x06, 0x08, 0x20, 0xC0, 0xC3, 0x04,
  0x18, 0x18, 0x40, 0x86, 0x03, 0x18, 0x10, 0xC0, 0x62, 0x02, 0x10, 0x0C,
  0xC0, 0x46, 0x01, 0x98, 0x08, 0x80, 0x32, 0x01, 0x30, 0x06, 0xC0, 0x26,
  0x00, 0xD0, 0x04, 0x80, 0x1E, 0x00, 0xB0, 0x03, 0x80, 0x14, 0x00, 0x50,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x18, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x01, 0x00, 0x80, 0x08, 0x0C, 0x00,
  0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x60, 0x00, 0x42, 0x00, 0x02, 0x30,
  0x00, 0x1B, 0x00, 0x00, 0xD0, 0x00, 0x07, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x04, 0x80, 0x00, 0x64, 0x00,
  0x06, 0x30, 0x00, 0x21, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x20, 0x01, 0x01,
  0x00, 0x18, 0x08, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x04,
  0x00, 0x40, 0x60, 0x03, 0x00, 0x80, 0x07, 0x00, 0x1B, 0x00, 0x26, 0x00,
  0xCC, 0x03, 0x18, 0x06, 0x10, 0x18, 0x20, 0x20, 0x60, 0xC0, 0xC1, 0x01,
  0x86, 0x03, 0x18, 0x02, 0x30, 0x04, 0xC0, 0x09, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0xC1, 0x04, 0x10, 0x41, 0x86, 0x18, 0x20, 0x82,
  0x08, 0x30, 0xC3, 0x04, 0x10, 0x41, 0x86, 0x18, 0x20, 0x82, 0x08, 0x30,
  0xC3, 0x04, 0x10, 0x00, 0xFF, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x3C, 0x00,
  0x36, 0x00, 0x11, 0x00, 0x18, 0xC0, 0x08, 0x20, 0x0C, 0x18, 0x0C, 0x0C,
  0x06, 0x02, 0x06, 0x01, 0x82, 0x00, 0x43, 0x00, 0x31, 0x00, 0x19, 0x80,
  0x05, 0x80, 0x03, 0xFF, 0xF0, 0xC2, 0x18, 0x43, 0x08, 0x20, 0x00, 0x60,
  0x01, 0xFC, 0xC1, 0xC3, 0x41, 0x80, 0xA0, 0xC0, 0x50, 0xC0, 0x38, 0x40,
  0x08, 0x60, 0x0C, 0x30, 0x06, 0x10, 0x03, 0x18, 0x01, 0x8C, 0x00, 0x84,
  0x00, 0x42, 0x00, 0x61, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x18, 0x60, 0x0C,
  0x10, 0x0E, 0x08, 0x07, 0x06, 0x05, 0x81, 0x8C, 0x80, 0xFC, 0x40, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x30, 0x0C, 0xFC, 0x09, 0x86, 0x0A,
  0x02, 0x1E, 0x03, 0x1C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x10, 0x03, 0x30,
  0x03, 0x30, 0x03, 0x30, 0x03, 0x20, 0x02, 0x20, 0x06, 0x60, 0x06, 0x60,
  0x04, 0x60, 0x0C, 0x60, 0x0C, 0xE0, 0x18, 0xE0, 0x18, 0xB0, 0x30, 0x98,
  0xE0, 0x8F, 0xC0, 0x00, 0xE0, 0x1F, 0xC3, 0x82, 0x30, 0x01, 0x80, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x40, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x0C, 0x30, 0x07, 0xE6, 0x03, 0x86, 0xC0, 0xC0, 0x50,
  0x18, 0x0E, 0x06, 0x00, 0xC0, 0x80, 0x18, 0x30, 0x02, 0x06, 0x00, 0x40,
  0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x60, 0x80, 0x08, 0x10, 0x03, 0x02,
  0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03, 0x83, 0x00, 0x60, 0x20, 0x1C, 0x04,
  0x03, 0x80, 0xC0, 0xB0, 0x0C, 0x76, 0x01, 0xF8, 0x80, 0x00, 0xC0, 0x1F,
  0x83, 0x86, 0x30, 0x31, 0x80, 0x98, 0x04, 0x80, 0x6C, 0x03, 0x40, 0x36,
  0x03, 0x30, 0x71, 0xFE, 0x0E, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x60, 0xFE, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0xE4, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x07,
  0xFC, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0xB8, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3F, 0x30, 0x38, 0x6C, 0x18, 0x0A,
  0x06, 0x03, 0x83, 0x00, 0x60, 0x80, 0x18, 0x60, 0x04, 0x18, 0x01, 0x04,
  0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x20, 0x02, 0x08, 0x01, 0x82, 0x00,
  0x61, 0x80, 0x18, 0x60, 0x0E, 0x18, 0x03, 0x02, 0x01, 0xC0, 0x80, 0x70,
  0x30, 0x2C, 0x06, 0x3B, 0x01, 0xF8, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x08, 0x0C,
  0x03, 0x9E, 0x00, 0x7F, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x60, 0x33, 0xF0, 0x58, 0x30, 0xA0, 0x23, 0x80, 0x47, 0x00, 0x8C, 0x01,
  0x18, 0x06, 0x20, 0x0C, 0xC0, 0x11, 0x80, 0x23, 0x00, 0xC4, 0x01, 0x88,
  0x03, 0x30, 0x04, 0x60, 0x08, 0x80, 0x31, 0x00, 0x66, 0x00, 0xCC, 0x01,
  0x18, 0x02, 0x20, 0x0C, 0x40, 0x18, 0x03, 0x07, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30,
  0x30, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0x80,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x27,
  0x00, 0x7C, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x03, 0x04, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x0C, 0x10, 0x0C, 0x30, 0x08,
  0x60, 0x08, 0xC0, 0x19, 0x80, 0x1B, 0x80, 0x16, 0x80, 0x14, 0x80, 0x18,
  0xC0, 0x30, 0xC0, 0x30, 0x40, 0x20, 0x40, 0x20, 0x60, 0x60, 0x60, 0x60,
  0x20, 0x60, 0x30, 0x40, 0x30, 0xC0, 0x30, 0x01, 0x80, 0xC0, 0x40, 0x20,
  0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30,
  0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x10,
  0x08, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0x04, 0x70, 0x18, 0x04, 0xFE,
  0x3F, 0x02, 0xC3, 0x30, 0xC1, 0x40, 0xA0, 0x21, 0xC0, 0x70, 0x18, 0xE0,
  0x30, 0x08, 0x60, 0x18, 0x04, 0x30, 0x08, 0x02, 0x10, 0x04, 0x03, 0x18,
  0x06, 0x01, 0x8C, 0x03, 0x00, 0xC6, 0x01, 0x00, 0x42, 0x00, 0x80, 0x61,
  0x00, 0xC0, 0x31, 0x80, 0x60, 0x18, 0xC0, 0x30, 0x08, 0x40, 0x10, 0x04,
  0x20, 0x08, 0x06, 0x30, 0x0C, 0x03, 0x18, 0x06, 0x01, 0x8C, 0x03, 0x00,
  0x84, 0x01, 0x00, 0x42, 0x01, 0x80, 0x60, 0x02, 0x18, 0x04, 0x7E, 0x05,
  0x83, 0x05, 0x03, 0x0E, 0x01, 0x0E, 0x01, 0x0C, 0x03, 0x0C, 0x03, 0x08,
  0x03, 0x18, 0x02, 0x18, 0x02, 0x18, 0x06, 0x10, 0x06, 0x30, 0x06, 0x30,
  0x04, 0x30, 0x04, 0x20, 0x0C, 0x20, 0x0C, 0x60, 0x0C, 0x60, 0x08, 0x60,
  0x08, 0x40, 0x18, 0xC0, 0x18, 0x00, 0x60, 0x07, 0xF0, 0x1C, 0x30, 0x60,
  0x30, 0xC0, 0x63, 0x00, 0x44, 0x00, 0x98, 0x01, 0x30, 0x02, 0xC0, 0x05,
  0x80, 0x0B, 0x00, 0x34, 0x00, 0x68, 0x00, 0xD0, 0x01, 0x60, 0x06, 0xC0,
  0x0D, 0x80, 0x11, 0x00, 0x63, 0x01, 0x86, 0x03, 0x06, 0x1C, 0x07, 0xE0,
  0x00, 0x01, 0x0C, 0x00, 0x8F, 0xC0, 0x26, 0x18, 0x0A, 0x02, 0x07, 0x80,
  0xC1, 0xC0, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x30,
  0xC0, 0x0C, 0x30, 0x03, 0x08, 0x00, 0x82, 0x00, 0x61, 0x80, 0x18, 0x60,
  0x06, 0x18, 0x03, 0x06, 0x00, 0xC3, 0x80, 0x60, 0xE0, 0x18, 0x38, 0x0C,
  0x09, 0x8E, 0x02, 0x3F, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x01, 0xFC, 0xC1, 0xC3, 0x61, 0x80,
  0xA0, 0xC0, 0x70, 0xC0, 0x18, 0x40, 0x0C, 0x60, 0x04, 0x30, 0x02, 0x10,
  0x03, 0x18, 0x01, 0x8C, 0x00, 0xC4, 0x00, 0x42, 0x00, 0x21, 0x00, 0x31,
  0x80, 0x18, 0xC0, 0x1C, 0x60, 0x0C, 0x10, 0x0E, 0x08, 0x07, 0x06, 0x05,
  0x81, 0x8E, 0xC0, 0xFC, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x8F, 0x0B, 0x00, 0xA0, 0x1C, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x00, 0x01, 0xE0, 0x1F, 0xF0, 0xC0, 0x86, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xC3, 0x06, 0x0F, 0xF0, 0x00, 0x02, 0x01, 0x80, 0x40, 0x10,
  0x0C, 0x03, 0x17, 0xF8, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C,
  0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x01, 0xF0, 0x0C, 0x03, 0x08, 0x03, 0x18, 0x03,
  0x18, 0x02, 0x18, 0x02, 0x10, 0x06, 0x10, 0x06, 0x30, 0x06, 0x30, 0x04,
  0x30, 0x04, 0x20, 0x0C, 0x20, 0x0C, 0x60, 0x08, 0x60, 0x08, 0x60, 0x18,
  0x40, 0x18, 0x40, 0x18, 0xC0, 0x30, 0xC0, 0x70, 0x40, 0xD0, 0x61, 0xB0,
  0x3F, 0x30, 0xC0, 0x0F, 0x00, 0x6C, 0x01, 0x30, 0x0C, 0x40, 0x31, 0x01,
  0x84, 0x06, 0x10, 0x30, 0x40, 0xC1, 0x06, 0x04, 0x18, 0x10, 0xC0, 0x43,
  0x01, 0x08, 0x06, 0x60, 0x19, 0x00, 0x6C, 0x01, 0xA0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x00, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xA0, 0x38,
  0x0D, 0x01, 0x40, 0x68, 0x0A, 0x02, 0x40, 0xD0, 0x32, 0x04, 0x81, 0x10,
  0x64, 0x18, 0x82, 0x20, 0xC4, 0x31, 0x04, 0x21, 0x08, 0x61, 0x08, 0x42,
  0x08, 0xC2, 0x30, 0x44, 0x11, 0x02, 0x60, 0x88, 0x12, 0x04, 0xC0, 0xB0,
  0x34, 0x05, 0x01, 0x60, 0x28, 0x0A, 0x01, 0xC0, 0x50, 0x0C, 0x03, 0x80,
  0x60, 0x18, 0x00, 0x06, 0x01, 0xC0, 0x80, 0x60, 0x30, 0x30, 0x0C, 0x18,
  0x01, 0x04, 0x00, 0x43, 0x00, 0x19, 0x80, 0x06, 0x40, 0x00, 0xB0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x00, 0xD8, 0x00, 0x62,
  0x00, 0x18, 0x80, 0x0C, 0x30, 0x06, 0x0C, 0x01, 0x01, 0x00, 0xC0, 0x60,
  0x60, 0x18, 0x30, 0x02, 0x00, 0x00, 0x80, 0x18, 0x06, 0x00, 0xC0, 0x30,
  0x0C, 0x01, 0x80, 0x60, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x00,
  0x18, 0x18, 0x00, 0xC0, 0x80, 0x06, 0x0C, 0x00, 0x10, 0x40, 0x00, 0x86,
  0x00, 0x04, 0x20, 0x00, 0x23, 0x00, 0x01, 0x10, 0x00, 0x09, 0x80, 0x00,
  0x48, 0x00, 0x02, 0xC0, 0x00, 0x14, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x02,
  0x30, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0xF8, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x38, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x03, 0xC0, 0x0E, 0x00,
  0x00, 0x3C, 0x01, 0x7F, 0x01, 0x81, 0xE7, 0x80, 0x7C,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 30, 9, 1, -30 },
  { 31, 9, 11, 12, 4, -30 },
  { 44, 20, 30, 19, 0, -30 },
  { 119, 17, 34, 17, 0, -32 },
  { 192, 22, 31, 26, 2, -30 },
  { 278, 18, 30, 19, 0, -30 },
  { 346, 4, 11, 7, 4, -30 },
  { 352, 12, 37, 10, 1, -30 },
  { 408, 12, 37, 10, -3, -30 },
  { 464, 13, 14, 16, 5, -32 },
  { 487, 16, 20, 19, 2, -25 },
  { 527, 6, 9, 7, -2, -4 },
  { 534, 9, 1, 12, 1, -12 },
  { 536, 2, 3, 8, 1, -3 },
  { 537, 18, 30, 13, -2, -30 },
  { 605, 16, 30, 17, 1, -30 },
  { 665, 9, 30, 17, 5, -30 },
  { 699, 18, 30, 17, -1, -30 },
  { 767, 17, 30, 17, 0, -30 },
  { 831, 17, 30, 17, 0, -30 },
  { 895, 17, 30, 17, 0, -30 },
  { 959, 16, 30, 17, 2, -30 },
  { 1019, 17, 30, 17, 2, -30 },
  { 1083, 17, 30, 17, 0, -30 },
  { 1147, 17, 30, 17, 0, -30 },
  { 1211, 7, 22, 8, 0, -22 },
  { 1231, 9, 27, 8, -2, -22 },
  { 1262, 16, 18, 19, 2, -24 },
  { 1298, 16, 10, 19, 2, -20 },
  { 1318, 16, 18, 19, 2, -24 },
  { 1354, 13, 30, 13, 1, -30 },
  { 1403, 24, 34, 26, 1, -30 },
  { 1505, 17, 30, 17, -3, -30 },
  { 1569, 18, 30, 19, 1, -30 },
  { 1637, 18, 30, 18, 2, -30 },
  { 1705, 19, 30, 21, 1, -30 },
  { 1777, 17, 30, 17, 1, -30 },
  { 1841, 17, 30, 16, 1, -30 },
  { 1905, 21, 30, 22, 2, -30 },
  { 1984, 21, 30, 22, 1, -30 },
  { 2063, 14, 30, 9, -2, -30 },
  { 2116, 15, 37, 8, -6, -30 },
  { 2186, 20, 30, 17, 1, -30 },
  { 2261, 11, 30, 15, 1, -30 },
  { 2303, 27, 30, 28, 1, -30 },
  { 2405, 22, 30, 22, 1, -30 },
  { 2488, 19, 30, 22, 2, -30 },
  { 2560, 17, 30, 18, 1, -30 },
  { 2624, 19, 37, 22, 2, -30 },
  { 2712, 17, 30, 18, 1, -30 },
  { 2776, 19, 30, 17, -1, -30 },
  { 2848, 14, 30, 15, 4, -30 },
  { 2901, 20, 30, 21, 2, -30 },
  { 2976, 17, 30, 17, 4, -30 },
  { 3040, 27, 30, 28, 4, -30 },
  { 3142, 21, 30, 16, -2, -30 },
  { 3221, 15, 30, 15, 4, -30 },
  { 3278, 19, 30, 16, -1, -30 },
  { 3350, 16, 37, 12, -1, -30 },
  { 3424, 6, 30, 13, 4, -30 },
  { 3447, 16, 37, 12, -3, -30 },
  { 3521, 17, 16, 19, 1, -30 },
  { 3555, 12, 1, 13, -3, 4 },
  { 3557, 5, 7, 9, 6, -32 },
  { 3562, 17, 23, 18, 1, -23 },
  { 3611, 16, 32, 18, 1, -32 },
  { 3675, 13, 23, 14, 2, -23 },
  { 3713, 19, 32, 19, 1, -32 },
  { 3789, 13, 23, 16, 2, -23 },
  { 3827, 19, 42, 9, -5, -32 },
  { 3927, 18, 33, 19, 0, -23 },
  { 4002, 15, 32, 18, 1, -32 },
  { 4062, 8, 30, 8, 1, -30 },
  { 4092, 15, 40, 8, -6, -30 },
  { 4167, 16, 32, 15, 0, -32 },
  { 4231, 9, 32, 7, 0, -32 },
  { 4267, 25, 23, 27, 1, -23 },
  { 4339, 16, 23, 18, 0, -23 },
  { 4385, 15, 23, 18, 1, -23 },
  { 4429, 18, 33, 18, -1, -23 },
  { 4504, 17, 33, 19, 1, -23 },
  { 4575, 12, 23, 12, 1, -23 },
  { 4610, 14, 23, 14, 0, -23 },
  { 4651, 10, 28, 10, 1, -28 },
  { 4686, 16, 22, 18, 1, -22 },
  { 4730, 14, 22, 14, 2, -22 },
  { 4769, 21, 22, 22, 3, -22 },
  { 4827, 18, 22, 15, -2, -22 },
  { 4877, 21, 32, 14, -5, -22 },
  { 4961, 15, 22, 13, -1, -22 },
  { 5003, 15, 37, 13, 1, -30 },
  { 5073, 1, 42, 17, 8, -32 },
  { 5079, 15, 37, 13, -3, -30 },
  { 5149, 16, 4, 19, 2, -17 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC42PT7B_H_
