#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC32PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x30, 0xC2, 0x08, 0x21, 0x84, 0x10, 0x43, 0x08, 0x20, 0x82,
  0x18, 0x40, 0x00, 0x00, 0x03, 0x08, 0x00, 0x22, 0xC5, 0x9A, 0x24, 0x48,
  0x91, 0x44, 0x00, 0x84, 0x01, 0x08, 0x04, 0x20, 0x08, 0x40, 0x10, 0x80,
  0x43, 0x00, 0x84, 0x0F, 0xFF, 0x06, 0x10, 0x08, 0x40, 0x10, 0x80, 0x21,
  0x00, 0x84, 0x01, 0x08, 0x02, 0x10, 0x7F, 0xFC, 0x10, 0x80, 0x21, 0x00,
  0xC2, 0x01, 0x08, 0x02, 0x10, 0x04, 0x20, 0x10, 0x80, 0x00, 0x00, 0x40,
  0x02, 0x00, 0x30, 0x0F, 0x70, 0xC8, 0x0C, 0x40, 0x42, 0x02, 0x10, 0x11,
  0x00, 0xC8, 0x03, 0x40, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x09, 0x00, 0x4C,
  0x02, 0x20, 0x21, 0x01, 0x08, 0x08, 0x80, 0x4C, 0x7B, 0xC0, 0x70, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x00, 0x1E, 0x02, 0x32, 0x04, 0x23, 0x04, 0x43,
  0x08, 0x43, 0x18, 0x42, 0x10, 0x82, 0x20, 0x82, 0x20, 0x82, 0x40, 0x86,
  0x4E, 0x84, 0x93, 0x85, 0xB1, 0x89, 0x21, 0x72, 0x61, 0x02, 0x41, 0x04,
  0x41, 0x04, 0x43, 0x08, 0xC2, 0x18, 0xC2, 0x10, 0x82, 0x20, 0x84, 0x20,
  0x4C, 0x40, 0x78, 0x01, 0xE0, 0x11, 0x01, 0x0C, 0x08, 0x20, 0x43, 0x02,
  0x10, 0x10, 0x80, 0x88, 0x04, 0xC0, 0x2C, 0x00, 0x80, 0x1C, 0x01, 0xB0,
  0x18, 0x85, 0x86, 0x28, 0x13, 0x40, 0x96, 0x07, 0xA0, 0x19, 0x00, 0xCC,
  0x0A, 0x20, 0x90, 0xF8, 0xC0, 0x25, 0xA4, 0x94, 0x01, 0x81, 0x80, 0x80,
  0x80, 0xC0, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x04, 0x06, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x10, 0x04, 0x00, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x06,
  0x03, 0x00, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x01, 0x01,
  0x00, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x10, 0x10, 0x10, 0x00,
  0x04, 0x01, 0x08, 0x81, 0x20, 0x3F, 0xC2, 0x03, 0x41, 0x90, 0xC2, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x1F, 0xFF, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x32, 0x26, 0x4C, 0x80, 0xFE, 0xE0, 0x00, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x00, 0x03, 0xC0,
  0x42, 0x08, 0x31, 0x81, 0x10, 0x13, 0x01, 0x20, 0x12, 0x01, 0x60, 0x34,
  0x03, 0x40, 0x24, 0x02, 0x40, 0x2C, 0x02, 0x80, 0x68, 0x04, 0x80, 0x48,
  0x0C, 0x80, 0x88, 0x18, 0xC1, 0x04, 0x20, 0x3C, 0x00, 0x06, 0x18, 0xD3,
  0x28, 0xC1, 0x82, 0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x0C, 0x10, 0x20,
  0x40, 0x83, 0x04, 0x08, 0x10, 0x00, 0x01, 0xF0, 0x18, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xE0, 0x60, 0x82, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x03, 0x00, 0xF0, 0x1F, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x40, 0xC3, 0xF8,
  0x00, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xA0, 0x09, 0x00, 0xC8, 0x04,
  0xC0, 0x44, 0x06, 0x20, 0x21, 0x02, 0x08, 0x30, 0x81, 0x04, 0x10, 0x21,
  0x81, 0x08, 0x18, 0xFF, 0xF7, 0xFF, 0x80, 0x20, 0x01, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x07, 0xF8, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0xB8, 0x0E, 0xF0, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x40, 0xC3, 0xF8, 0x00, 0x01, 0xF8, 0x18, 0x01, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x7C, 0x16, 0x30, 0xC0,
  0x86, 0x06, 0x60, 0x13, 0x00, 0x90, 0x0C, 0x80, 0x64, 0x02, 0x20, 0x11,
  0x81, 0x84, 0x08, 0x30, 0x80, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x00, 0x03, 0xE0, 0x30, 0x83, 0x02, 0x10,
  0x10, 0x80, 0x8C, 0x04, 0x20, 0x21, 0x02, 0x0C, 0x30, 0x23, 0x00, 0xE0,
  0x0E, 0x01, 0x88, 0x18, 0x21, 0x81, 0x88, 0x04, 0xC0, 0x24, 0x01, 0x20,
  0x09, 0x80, 0x44, 0x04, 0x30, 0x60, 0xFC, 0x00, 0x03, 0xE0, 0x31, 0x83,
  0x04, 0x30, 0x31, 0x00, 0x88, 0x04, 0xC0, 0x24, 0x03, 0x20, 0x19, 0x00,
  0x88, 0x0C, 0x60, 0x61, 0x85, 0x07, 0xD8, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x03, 0xF0, 0x00, 0x08, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x06, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x10, 0x20,
  0x81, 0x04, 0x08, 0x00, 0x00, 0x18, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x1F, 0x08, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x03,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x7C, 0x00, 0x60, 0xC0, 0x20,
  0x18, 0x10, 0x02, 0x08, 0x00, 0x46, 0x00, 0x11, 0x00, 0x04, 0x83, 0xF1,
  0x21, 0x88, 0x58, 0x42, 0x14, 0x20, 0x85, 0x08, 0x61, 0x44, 0x10, 0xF1,
  0x04, 0x28, 0x41, 0x0A, 0x10, 0xC6, 0x84, 0x21, 0x21, 0x14, 0xC8, 0x79,
  0xE2, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x60, 0x01, 0xE0, 0x00, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xA0,
  0x0D, 0x00, 0x48, 0x02, 0x40, 0x22, 0x01, 0x10, 0x10, 0x80, 0x84, 0x0C,
  0x20, 0x41, 0x07, 0xFC, 0x20, 0x63, 0x03, 0x10, 0x18, 0x80, 0x48, 0x02,
  0x40, 0x14, 0x00, 0xA0, 0x07, 0x00, 0x20, 0x0F, 0xE0, 0x41, 0x82, 0x06,
  0x10, 0x11, 0x80, 0x88, 0x04, 0x40, 0x22, 0x03, 0x10, 0x11, 0x81, 0x0F,
  0xF0, 0x7F, 0x82, 0x06, 0x10, 0x11, 0x80, 0x88, 0x06, 0x40, 0x32, 0x01,
  0x30, 0x09, 0x00, 0xC8, 0x0C, 0x40, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x18,
  0x20, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x21, 0xC0, 0x81, 0x82, 0x02, 0x18, 0x0C, 0x40,
  0x11, 0x00, 0x44, 0x01, 0x10, 0x04, 0xC0, 0x12, 0x00, 0x48, 0x03, 0x20,
  0x0C, 0x80, 0x26, 0x00, 0x90, 0x06, 0x40, 0x11, 0x00, 0xCC, 0x02, 0x20,
  0x10, 0x81, 0x82, 0x1C, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0F,
  0xF0, 0x7F, 0x82, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x03, 0xFC, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x00, 0x01,
  0xFC, 0x0E, 0x0C, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x0F, 0x90,
  0x01, 0x20, 0x06, 0x40, 0x0C, 0x80, 0x11, 0x00, 0x22, 0x00, 0x46, 0x01,
  0x84, 0x02, 0x0C, 0x04, 0x07, 0xF8, 0x00, 0x0C, 0x01, 0x08, 0x03, 0x08,
  0x02, 0x08, 0x02, 0x18, 0x02, 0x10, 0x02, 0x10, 0x06, 0x10, 0x04, 0x10,
  0x04, 0x30, 0x04, 0x3F, 0xFC, 0x3F, 0xFC, 0x20, 0x08, 0x20, 0x08, 0x60,
  0x08, 0x40, 0x18, 0x40, 0x10, 0x40, 0x10, 0xC0, 0x10, 0x80, 0x10, 0x80,
  0x30, 0x80, 0x20, 0x80, 0x20, 0x0F, 0xC0, 0xC0, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x0F, 0x80, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x0C, 0x0F, 0x80, 0x60, 0x00, 0x0C, 0x06, 0x10, 0x18, 0x20, 0x60,
  0x41, 0x81, 0x82, 0x02, 0x08, 0x04, 0x20, 0x08, 0xC0, 0x13, 0x00, 0x6C,
  0x00, 0xB0, 0x01, 0x50, 0x03, 0x20, 0x04, 0x40, 0x10, 0xC0, 0x20, 0x80,
  0x41, 0x00, 0x83, 0x03, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x18, 0x20,
  0x10, 0x00, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30,
  0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80,
  0xFF, 0x0C, 0x00, 0x38, 0x60, 0x01, 0x83, 0x00, 0x1C, 0x18, 0x00, 0xA1,
  0xC0, 0x0F, 0x0B, 0x00, 0x50, 0x58, 0x06, 0x82, 0x40, 0x24, 0x12, 0x03,
  0x21, 0x90, 0x13, 0x08, 0x81, 0x90, 0x44, 0x08, 0x82, 0x20, 0xC4, 0x11,
  0x04, 0x61, 0x08, 0x63, 0x08, 0x42, 0x10, 0x42, 0x30, 0x82, 0x19, 0x04,
  0x30, 0xD8, 0x61, 0x02, 0x82, 0x08, 0x1C, 0x10, 0x40, 0xC0, 0x82, 0x06,
  0x0C, 0x00, 0x0C, 0x01, 0x0C, 0x01, 0x0C, 0x01, 0x0E, 0x03, 0x1A, 0x02,
  0x12, 0x02, 0x12, 0x02, 0x13, 0x02, 0x11, 0x06, 0x31, 0x04, 0x21, 0x04,
  0x21, 0x84, 0x20, 0x84, 0x20, 0x8C, 0x60, 0x88, 0x40, 0xC8, 0x40, 0x48,
  0x40, 0x48, 0xC0, 0x58, 0x80, 0x70, 0x80, 0x30, 0x80, 0x30, 0x80, 0x30,
  0x03, 0xF0, 0x18, 0x60, 0x80, 0xC4, 0x01, 0x30, 0x04, 0x80, 0x16, 0x00,
  0x50, 0x01, 0x40, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x28, 0x00, 0xA0, 0x06, 0x80, 0x12, 0x00, 0x48, 0x03, 0x20, 0x08, 0xC0,
  0x41, 0x86, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x43, 0x82, 0x04, 0x10, 0x31,
  0x80, 0x88, 0x04, 0x40, 0x62, 0x03, 0x10, 0x11, 0x80, 0x88, 0x08, 0x41,
  0x83, 0xF8, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x00, 0x03, 0xF0, 0x18, 0x60, 0x80,
  0xC4, 0x01, 0x30, 0x04, 0x80, 0x16, 0x00, 0x50, 0x01, 0x40, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x28, 0x00, 0xA0, 0x06, 0x80,
  0x12, 0x00, 0x48, 0x03, 0x20, 0x08, 0xC0, 0x41, 0x86, 0x03, 0xF0, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x0F, 0xC0, 0x43, 0x82,
  0x04, 0x10, 0x31, 0x81, 0x88, 0x0C, 0x40, 0x62, 0x03, 0x10, 0x11, 0x81,
  0x88, 0x18, 0x41, 0x83, 0xF0, 0x11, 0x81, 0x84, 0x08, 0x20, 0x41, 0x02,
  0x0C, 0x30, 0x21, 0x01, 0x08, 0x08, 0x40, 0x62, 0x03, 0x00, 0x03, 0xF8,
  0x30, 0x42, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x40, 0xC3, 0xF8, 0x00,
  0xFF, 0xE0, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x00, 0x10, 0x02, 0x20, 0x0C,
  0x40, 0x11, 0x80, 0x22, 0x00, 0x44, 0x01, 0x88, 0x02, 0x10, 0x04, 0x60,
  0x08, 0x80, 0x11, 0x00, 0x62, 0x00, 0x84, 0x01, 0x18, 0x02, 0x20, 0x0C,
  0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x01, 0x84, 0x02, 0x08, 0x0C, 0x18,
  0x30, 0x1F, 0xC0, 0x00, 0x80, 0x1C, 0x00, 0xA0, 0x0D, 0x00, 0x48, 0x06,
  0x40, 0x22, 0x03, 0x10, 0x10, 0x80, 0x84, 0x08, 0x20, 0x41, 0x04, 0x08,
  0x20, 0x63, 0x03, 0x10, 0x19, 0x80, 0x48, 0x02, 0xC0, 0x14, 0x00, 0xA0,
  0x06, 0x00, 0x30, 0x01, 0x00, 0x00, 0x80, 0x20, 0x1C, 0x03, 0x00, 0xA0,
  0x18, 0x05, 0x00, 0xC0, 0x68, 0x0A, 0x02, 0x40, 0x50, 0x32, 0x04, 0x81,
  0x10, 0x24, 0x08, 0x83, 0x20, 0x84, 0x11, 0x04, 0x20, 0x88, 0x61, 0x08,
  0x42, 0x08, 0x42, 0x10, 0x46, 0x11, 0x02, 0x20, 0x88, 0x11, 0x04, 0xC0,
  0x90, 0x24, 0x04, 0x81, 0x60, 0x28, 0x0A, 0x01, 0x40, 0x50, 0x0E, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x00, 0x02, 0x01, 0x02, 0x02, 0x02,
  0x06, 0x03, 0x04, 0x01, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x30, 0x01,
  0xA0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0xC0, 0x03, 0x40, 0x02,
  0x40, 0x04, 0x40, 0x0C, 0x40, 0x08, 0x40, 0x10, 0x60, 0x30, 0x20, 0x20,
  0x20, 0x40, 0x20, 0xC0, 0x30, 0x80, 0x30, 0x0E, 0x01, 0x40, 0x4C, 0x18,
  0x82, 0x10, 0xC2, 0x10, 0x44, 0x08, 0x81, 0xA0, 0x1C, 0x03, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20,
  0x00, 0x07, 0xFE, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF0, 0x20,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x0F, 0xC0, 0x86, 0x10, 0x84, 0x21, 0x08, 0x21, 0x08, 0x42, 0x10,
  0xC2, 0x10, 0x84, 0x21, 0x0C, 0x20, 0x03, 0xF0, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x0F, 0xC0,
  0x01, 0x00, 0x18, 0x00, 0xA0, 0x09, 0x00, 0xCC, 0x04, 0x20, 0x41, 0x02,
  0x0C, 0x20, 0x21, 0x01, 0x90, 0x05, 0x80, 0x30, 0xFF, 0xC0, 0x89, 0x12,
  0x07, 0x90, 0x85, 0x10, 0x33, 0x03, 0x20, 0x36, 0x02, 0x40, 0x24, 0x02,
  0xC0, 0x2C, 0x06, 0x80, 0x48, 0x04, 0x80, 0xC8, 0x0C, 0xC1, 0x84, 0x28,
  0x3C, 0x80, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x01, 0x3C, 0x0A, 0x10, 0xE0, 0xC6, 0x02, 0x30, 0x11, 0x00, 0x88,
  0x04, 0xC0, 0x64, 0x03, 0x20, 0x11, 0x00, 0x88, 0x0C, 0xC0, 0x46, 0x06,
  0x30, 0x21, 0x42, 0x1B, 0xE0, 0x07, 0xC3, 0x01, 0x00, 0xC0, 0x20, 0x18,
  0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x3E, 0x00, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x81, 0xF6, 0x08, 0x50, 0x40, 0xC3, 0x03, 0x08, 0x0C,
  0x60, 0x31, 0x00, 0x84, 0x02, 0x30, 0x08, 0xC0, 0x62, 0x01, 0x08, 0x04,
  0x20, 0x30, 0x80, 0xC3, 0x07, 0x04, 0x28, 0x0F, 0x20, 0x07, 0xC1, 0x08,
  0x41, 0x98, 0x32, 0x04, 0x80, 0x90, 0x22, 0x18, 0xFC, 0x18, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x80, 0x10, 0x03, 0x08, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x01, 0xF8,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x02, 0x00, 0x2C, 0x00, 0x70, 0x00, 0x03, 0xE4, 0x10,
  0xA0, 0x81, 0x86, 0x06, 0x10, 0x18, 0xC0, 0x42, 0x01, 0x08, 0x04, 0x60,
  0x11, 0x80, 0xC4, 0x02, 0x10, 0x08, 0x40, 0x61, 0x01, 0x86, 0x0E, 0x08,
  0x50, 0x3E, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x3B, 0x80, 0x38, 0x00, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x08, 0x00, 0x9E, 0x0A, 0x11, 0xC1, 0x18, 0x11, 0x81, 0x10,
  0x11, 0x01, 0x30, 0x32, 0x02, 0x20, 0x22, 0x02, 0x20, 0x26, 0x06, 0x40,
  0x44, 0x04, 0x40, 0x4C, 0x0C, 0x06, 0x08, 0x00, 0x00, 0x00, 0x02, 0x04,
  0x18, 0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0x41, 0x82, 0x04, 0x08,
  0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x20, 0x0C, 0x01, 0x01, 0xE0, 0x30, 0x00, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x81, 0x08, 0x21, 0x84,
  0x10, 0xC1, 0x18, 0x13, 0x01, 0x20, 0x36, 0x02, 0xA0, 0x32, 0x02, 0x30,
  0x21, 0x06, 0x10, 0x41, 0x04, 0x18, 0x40, 0x8C, 0x08, 0x06, 0x08, 0x10,
  0x20, 0x41, 0x82, 0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x0C, 0x10, 0x20,
  0x40, 0x83, 0x04, 0x08, 0x10, 0x60, 0x09, 0xE3, 0xC1, 0xC6, 0x84, 0x70,
  0x60, 0x8C, 0x08, 0x11, 0x81, 0x02, 0x20, 0x60, 0x44, 0x08, 0x09, 0x81,
  0x03, 0x20, 0x20, 0x44, 0x04, 0x08, 0x81, 0x81, 0x10, 0x20, 0x26, 0x04,
  0x0C, 0x80, 0x81, 0x10, 0x30, 0x22, 0x04, 0x04, 0xC0, 0x81, 0x80, 0x09,
  0xE0, 0xA1, 0x1C, 0x11, 0x81, 0x18, 0x11, 0x01, 0x10, 0x13, 0x03, 0x20,
  0x22, 0x02, 0x20, 0x22, 0x02, 0x60, 0x64, 0x04, 0x40, 0x44, 0x04, 0xC0,
  0xC0, 0x07, 0xC0, 0x86, 0x10, 0x23, 0x02, 0x20, 0x36, 0x03, 0x40, 0x24,
  0x02, 0xC0, 0x2C, 0x02, 0x80, 0x68, 0x04, 0x80, 0x48, 0x0C, 0xC0, 0x84,
  0x10, 0x3E, 0x00, 0x04, 0xF0, 0x14, 0x20, 0xE0, 0xC3, 0x01, 0x0C, 0x04,
  0x20, 0x10, 0x80, 0x46, 0x01, 0x10, 0x0C, 0x40, 0x21, 0x00, 0x84, 0x06,
  0x30, 0x10, 0xC0, 0xC3, 0x02, 0x0A, 0x10, 0x2F, 0x81, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x07, 0xC8, 0x42,
  0x84, 0x0C, 0x60, 0x62, 0x03, 0x30, 0x11, 0x00, 0x88, 0x04, 0xC0, 0x26,
  0x03, 0x20, 0x11, 0x00, 0x88, 0x0C, 0x40, 0x63, 0x07, 0x08, 0x50, 0x7C,
  0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x09, 0xC2, 0x81, 0xC0, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x00,
  0x0F, 0xC4, 0x13, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x01, 0x00, 0x40, 0x12, 0x08, 0xFC, 0x00, 0x08, 0x10,
  0x40, 0x87, 0xE2, 0x0C, 0x10, 0x20, 0x41, 0x82, 0x04, 0x08, 0x10, 0x60,
  0x81, 0x02, 0x04, 0x0F, 0x00, 0x10, 0x11, 0x01, 0x30, 0x32, 0x02, 0x20,
  0x22, 0x02, 0x60, 0x26, 0x06, 0x40, 0x44, 0x04, 0x40, 0x4C, 0x0C, 0x80,
  0x88, 0x18, 0x81, 0x8C, 0x28, 0x7C, 0x80, 0x80, 0x60, 0x28, 0x0A, 0x04,
  0x81, 0x20, 0x88, 0x22, 0x10, 0x84, 0x23, 0x08, 0x82, 0x60, 0xD0, 0x3C,
  0x0E, 0x01, 0x80, 0x40, 0x00, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82,
  0x82, 0x82, 0x86, 0x84, 0x84, 0x84, 0x84, 0x8C, 0x88, 0x88, 0x88, 0x88,
  0x90, 0x90, 0x90, 0x90, 0xB0, 0xA0, 0xA0, 0xA0, 0xA0, 0xE0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x08, 0x18, 0x40, 0x82, 0x08, 0x08, 0xC0, 0x44, 0x02,
  0x40, 0x1E, 0x00, 0x60, 0x02, 0x00, 0x38, 0x03, 0x40, 0x32, 0x01, 0x10,
  0x10, 0xC1, 0x82, 0x08, 0x10, 0x80, 0xC0, 0x02, 0x01, 0x02, 0x01, 0x03,
  0x02, 0x03, 0x02, 0x03, 0x04, 0x01, 0x04, 0x01, 0x08, 0x01, 0x08, 0x01,
  0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x60, 0x01, 0x40, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x98, 0x00, 0x70, 0x00, 0x0F, 0xE0, 0x0C,
  0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x20,
  0x08, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0xFF, 0x00, 0x00, 0xE0, 0x30,
  0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x80, 0xE0, 0x38, 0x01, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x80, 0x1C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x38, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x01, 0xC0,
  0x38, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x20, 0x0C, 0x01, 0x00, 0x60, 0x70, 0x00, 0x38, 0x0B, 0x30, 0xE0, 0x7C,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 23, 7, 1, -23 },
  { 19, 7, 8, 9, 3, -23 },
  { 26, 15, 23, 14, 0, -23 },
  { 70, 13, 26, 13, 0, -24 },
  { 113, 16, 23, 19, 2, -23 },
  { 159, 13, 23, 14, 0, -23 },
  { 197, 3, 8, 5, 3, -23 },
  { 200, 9, 28, 8, 1, -23 },
  { 232, 9, 28, 8, -2, -23 },
  { 264, 10, 10, 12, 4, -24 },
  { 277, 13, 15, 15, 1, -19 },
  { 302, 4, 7, 6, -1, -3 },
  { 306, 7, 1, 9, 1, -9 },
  { 307, 2, 2, 6, 1, -2 },
  { 308, 13, 23, 10, -1, -23 },
  { 346, 12, 23, 13, 1, -23 },
  { 381, 7, 23, 13, 4, -23 },
  { 402, 14, 23, 13, -1, -23 },
  { 443, 13, 23, 13, 0, -23 },
  { 481, 13, 23, 13, 0, -23 },
  { 519, 13, 23, 13, 0, -23 },
  { 557, 13, 23, 13, 1, -23 },
  { 595, 12, 23, 13, 2, -23 },
  { 630, 13, 23, 13, 0, -23 },
  { 668, 13, 23, 13, 0, -23 },
  { 706, 5, 17, 6, 0, -17 },
  { 717, 7, 21, 6, -1, -17 },
  { 736, 13, 13, 15, 1, -18 },
  { 758, 13, 8, 15, 1, -15 },
  { 771, 13, 13, 15, 1, -18 },
  { 793, 10, 23, 10, 1, -23 },
  { 822, 18, 26, 20, 1, -23 },
  { 881, 13, 23, 13, -2, -23 },
  { 919, 13, 23, 14, 1, -23 },
  { 957, 14, 23, 13, 2, -23 },
  { 998, 14, 23, 16, 1, -23 },
  { 1039, 13, 23, 13, 1, -23 },
  { 1077, 13, 23, 12, 1, -23 },
  { 1115, 15, 23, 17, 2, -23 },
  { 1159, 16, 23, 17, 1, -23 },
  { 1205, 10, 23, 7, -1, -23 },
  { 1234, 12, 29, 6, -5, -23 },
  { 1278, 15, 23, 13, 1, -23 },
  { 1322, 8, 23, 12, 1, -23 },
  { 1345, 21, 23, 21, 1, -23 },
  { 1406, 16, 23, 17, 1, -23 },
  { 1452, 14, 23, 17, 2, -23 },
  { 1493, 13, 23, 14, 1, -23 },
  { 1531, 14, 28, 17, 2, -23 },
  { 1580, 13, 23, 14, 1, -23 },
  { 1618, 13, 23, 13, 0, -23 },
  { 1656, 11, 23, 11, 3, -23 },
  { 1688, 15, 23, 16, 2, -23 },
  { 1732, 13, 23, 13, 3, -23 },
  { 1770, 21, 23, 22, 3, -23 },
  { 1831, 16, 23, 12, -2, -23 },
  { 1877, 11, 23, 11, 3, -23 },
  { 1909, 15, 23, 12, -1, -23 },
  { 1953, 12, 28, 9, -1, -23 },
  { 1995, 5, 23, 10, 3, -23 },
  { 2010, 12, 28, 9, -2, -23 },
  { 2052, 13, 12, 14, 1, -23 },
  { 2072, 10, 1, 10, -3, 3 },
  { 2074, 3, 5, 7, 5, -24 },
  { 2076, 12, 17, 14, 1, -17 },
  { 2102, 13, 24, 14, 0, -24 },
  { 2141, 10, 17, 11, 1, -17 },
  { 2163, 14, 24, 14, 1, -24 },
  { 2205, 11, 17, 12, 1, -17 },
  { 2229, 15, 32, 7, -4, -24 },
  { 2289, 14, 25, 14, 0, -17 },
  { 2333, 12, 24, 14, 0, -24 },
  { 2369, 7, 23, 6, 0, -23 },
  { 2390, 11, 31, 6, -4, -23 },
  { 2433, 12, 24, 11, 0, -24 },
  { 2469, 7, 24, 6, 0, -24 },
  { 2490, 19, 17, 21, 0, -17 },
  { 2531, 12, 17, 14, 0, -17 },
  { 2557, 12, 17, 14, 1, -17 },
  { 2583, 14, 24, 14, -1, -17 },
  { 2625, 13, 25, 14, 1, -17 },
  { 2666, 10, 17, 9, 0, -17 },
  { 2688, 10, 17, 10, 0, -17 },
  { 2710, 7, 21, 7, 1, -21 },
  { 2729, 12, 17, 14, 1, -17 },
  { 2755, 10, 17, 10, 2, -17 },
  { 2777, 16, 17, 17, 2, -17 },
  { 2811, 13, 17, 11, -1, -17 },
  { 2839, 16, 25, 11, -4, -17 },
  { 2889, 11, 17, 10, -1, -17 },
  { 2913, 11, 28, 10, 1, -23 },
  { 2952, 1, 32, 13, 6, -24 },
  { 2956, 11, 28, 10, -2, -23 },
  { 2995, 13, 3, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC32PT7B_H_
