#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC55PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x18, 0x31, 0x83, 0x18, 0x33,
  0x03, 0x30, 0x63, 0x06, 0x30, 0x63, 0x06, 0x60, 0x46, 0x0C, 0x60, 0xC6,
  0x0C, 0x40, 0x8C, 0x08, 0x00, 0x0E, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x01, 0x00, 0x01, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00,
  0x60, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x0C, 0x03, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x02, 0x03, 0x00,
  0x03, 0x01, 0x80, 0x01, 0x80, 0x80, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0x60, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x0C, 0x04, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60,
  0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x08, 0x00, 0x18,
  0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x02, 0x00, 0x02, 0x03, 0x00, 0x03,
  0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x71, 0x86, 0x01, 0x83, 0x00, 0x07, 0x04, 0x00, 0x0C,
  0x08, 0x00, 0x18, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81,
  0x00, 0x03, 0x82, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x30,
  0x00, 0x0E, 0x40, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x17, 0x00, 0x00, 0x67, 0x00, 0x00, 0xC7, 0x00,
  0x01, 0x86, 0x00, 0x02, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0x81, 0x80, 0x01, 0x03, 0x00, 0x06,
  0x0C, 0x08, 0x0C, 0x38, 0x0F, 0x1B, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x0C, 0x06,
  0x18, 0x01, 0x80, 0xC1, 0x80, 0x18, 0x1C, 0x18, 0x03, 0x01, 0x80, 0x80,
  0x30, 0x18, 0x08, 0x06, 0x03, 0x01, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x06,
  0x01, 0x81, 0x80, 0x60, 0x18, 0x18, 0x06, 0x01, 0x83, 0x00, 0x60, 0x18,
  0x30, 0x06, 0x01, 0x86, 0x00, 0xC0, 0x30, 0x40, 0x0C, 0x03, 0x0C, 0x00,
  0xC0, 0x31, 0x83, 0xCC, 0x06, 0x18, 0xFE, 0xC0, 0x63, 0x1C, 0x7C, 0x06,
  0x31, 0x83, 0xC0, 0xC6, 0x30, 0x3E, 0x1C, 0x66, 0x03, 0x63, 0x8C, 0x60,
  0x37, 0xF1, 0x86, 0x03, 0x1C, 0x18, 0xC0, 0x30, 0x03, 0x0C, 0x03, 0x00,
  0x30, 0xC0, 0x30, 0x06, 0x0C, 0x03, 0x00, 0x61, 0x80, 0x60, 0x0C, 0x18,
  0x06, 0x01, 0x81, 0x80, 0x60, 0x18, 0x18, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x30, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x18, 0x0C, 0x01,
  0x81, 0x81, 0x80, 0x18, 0x30, 0x18, 0x00, 0xC6, 0x03, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0xE1,
  0x80, 0x03, 0x81, 0x80, 0x06, 0x03, 0x00, 0x1C, 0x06, 0x00, 0x30, 0x0C,
  0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x03, 0x01, 0x80,
  0x06, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x38, 0x00, 0x30, 0xE0, 0x00,
  0x33, 0x80, 0x00, 0x6E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x73, 0x00, 0x01, 0xC6, 0x00, 0x07, 0x06,
  0x03, 0x1C, 0x0C, 0x0E, 0x70, 0x1C, 0x18, 0xC0, 0x18, 0x33, 0x80, 0x30,
  0xC6, 0x00, 0x31, 0x8C, 0x00, 0x66, 0x18, 0x00, 0xEC, 0x60, 0x00, 0xF0,
  0xC0, 0x01, 0xE1, 0x80, 0x01, 0x83, 0x80, 0x07, 0x03, 0x00, 0x1B, 0x06,
  0x00, 0x66, 0x0E, 0x01, 0x8E, 0x0F, 0x1E, 0x0C, 0x0F, 0xF8, 0x1C, 0x01,
  0x00, 0x00, 0x33, 0x37, 0x66, 0x66, 0x4C, 0xCC, 0x88, 0x00, 0x07, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x04, 0x04, 0x03, 0x02, 0x03, 0xE3, 0x00,
  0x39, 0x81, 0x07, 0x9F, 0x80, 0xFE, 0x00, 0x70, 0x00, 0xC8, 0x00, 0xC6,
  0x00, 0xC1, 0x00, 0xC0, 0xC0, 0xC0, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x06, 0x0C, 0x38, 0x60, 0xC3, 0x06,
  0x18, 0x30, 0xC1, 0x86, 0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0x00, 0x71,
  0xE0, 0x0C, 0x06, 0x01, 0x80, 0x70, 0x30, 0x03, 0x03, 0x00, 0x30, 0x60,
  0x03, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x31, 0x80, 0x03, 0x18,
  0x00, 0x31, 0x80, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x37,
  0x00, 0x07, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06,
  0x60, 0x00, 0xEC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01,
  0xCC, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x38, 0xC0, 0x03, 0x0C, 0x00,
  0x30, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x0C, 0x0E, 0x01, 0xC0, 0x60,
  0x18, 0x07, 0x03, 0x00, 0x3D, 0xE0, 0x01, 0xFC, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xE0, 0x3C, 0x0D, 0x87, 0x61, 0xCC, 0x71, 0xB8, 0x32, 0x06, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xE0,
  0x03, 0xE0, 0xE0, 0x07, 0x00, 0xE0, 0x08, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xE0, 0xF0, 0x0E, 0x00,
  0x60, 0x08, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x18,
  0x00, 0xE0, 0x3E, 0x0F, 0x80, 0x1F, 0xFC, 0x00, 0x05, 0x80, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xB0, 0x00,
  0x03, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x01,
  0x8C, 0x00, 0x06, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xC1,
  0x80, 0x03, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x30,
  0x01, 0x80, 0xE0, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x0F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x08, 0x01, 0xE0, 0x1E, 0x1F, 0x80, 0x1F, 0xFC, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0x02, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0xFC, 0x01, 0x9F, 0xF8,
  0x0D, 0xC0, 0xE0, 0xD8, 0x03, 0x07, 0x80, 0x1C, 0x38, 0x00, 0x61, 0xC0,
  0x03, 0x0C, 0x00, 0x18, 0xE0, 0x00, 0xC7, 0x00, 0x06, 0x30, 0x00, 0x31,
  0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x06, 0x18, 0x00,
  0x30, 0xC0, 0x01, 0x86, 0x00, 0x18, 0x30, 0x00, 0xC0, 0xC0, 0x0C, 0x06,
  0x00, 0xE0, 0x18, 0x0E, 0x00, 0xF3, 0xE0, 0x03, 0xFC, 0x00, 0x01, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0xE0, 0x01, 0xE1, 0xE0, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x30,
  0x01, 0xC0, 0xE0, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x0C, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x01, 0xC0, 0x30, 0x03,
  0x00, 0x60, 0x0C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0xE0, 0x00, 0xC7, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x78, 0xE0, 0x01,
  0xC0, 0xE0, 0x07, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0,
  0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0xC0, 0x00, 0xC1, 0x80, 0x03,
  0x03, 0x00, 0x06, 0x07, 0x00, 0x18, 0x07, 0x00, 0xE0, 0x07, 0xC7, 0x80,
  0x07, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00,
  0x38, 0x38, 0x03, 0x80, 0xE0, 0x38, 0x03, 0x01, 0x80, 0x18, 0x18, 0x00,
  0x60, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC7, 0x00, 0x06, 0x30,
  0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x07,
  0x18, 0x00, 0x38, 0xC0, 0x01, 0x86, 0x00, 0x1C, 0x30, 0x01, 0xE1, 0xC0,
  0x0B, 0x06, 0x00, 0xD8, 0x3C, 0x1D, 0x80, 0xFF, 0x8C, 0x01, 0xF0, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x03, 0x9F, 0x00,
  0x1F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x07, 0x07, 0x07, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0xE0, 0xC0, 0x00,
  0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x07,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xFC, 0x1E, 0x1E,
  0x08, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x78,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x18, 0x60, 0x07, 0xF0,
  0x30, 0xC0, 0x3F, 0xE0, 0x63, 0x00, 0xC0, 0xC0, 0xC6, 0x03, 0x01, 0x81,
  0x98, 0x0E, 0x06, 0x03, 0x30, 0x18, 0x0C, 0x06, 0x60, 0x60, 0x18, 0x0D,
  0x80, 0xC0, 0x20, 0x13, 0x03, 0x00, 0xC0, 0x66, 0x06, 0x01, 0x80, 0xCC,
  0x0C, 0x03, 0x01, 0xB0, 0x30, 0x0C, 0x02, 0x60, 0x60, 0x18, 0x0C, 0xC0,
  0xC0, 0x30, 0x19, 0x81, 0x80, 0xE0, 0x23, 0x03, 0x01, 0xC0, 0xC6, 0x06,
  0x03, 0x01, 0x8C, 0x0C, 0x0E, 0x06, 0x18, 0x18, 0x36, 0x18, 0x30, 0x38,
  0xCC, 0x70, 0x60, 0x3F, 0x0F, 0xC0, 0xC0, 0x3C, 0x0E, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x39,
  0x00, 0x00, 0xC4, 0x00, 0x03, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80,
  0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x0C,
  0x06, 0x00, 0x30, 0x18, 0x01, 0xC0, 0x60, 0x06, 0x01, 0x80, 0x38, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03,
  0x00, 0x18, 0x0C, 0x00, 0x60, 0x70, 0x01, 0x81, 0x80, 0x06, 0x0E, 0x00,
  0x18, 0x30, 0x00, 0x61, 0xC0, 0x01, 0x86, 0x00, 0x07, 0x18, 0x00, 0x1C,
  0xC0, 0x00, 0x73, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x01, 0x80, 0x06, 0x01, 0x80, 0x06, 0x01,
  0x80, 0x07, 0x01, 0x80, 0x07, 0x03, 0x00, 0x07, 0x03, 0x00, 0x06, 0x03,
  0x00, 0x06, 0x03, 0x00, 0x06, 0x07, 0x00, 0x0E, 0x06, 0x00, 0x0C, 0x06,
  0x00, 0x1C, 0x06, 0x00, 0x38, 0x06, 0x00, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x0C, 0x07, 0xC0, 0x0C, 0x00, 0xE0, 0x0C, 0x00, 0x70, 0x18,
  0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x38, 0x18,
  0x00, 0x38, 0x30, 0x00, 0x38, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30,
  0x00, 0x30, 0x30, 0x00, 0x70, 0x60, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x60,
  0x01, 0xC0, 0x60, 0x03, 0x80, 0xE0, 0x0F, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x3E, 0x06, 0x00,
  0x70, 0x02, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x01, 0x00, 0x1F, 0x9F, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x30, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x38,
  0x06, 0x00, 0x0C, 0x03, 0x00, 0x07, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x70, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x87, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C,
  0x00, 0x07, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x83, 0x00, 0x01, 0x81,
  0x80, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0x60, 0x00, 0xE0,
  0x30, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x0C, 0x01, 0xE0, 0x0E, 0x03, 0xE0,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0xF8, 0x1F, 0x80, 0x38, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x3F, 0xE1, 0x80, 0x07, 0xFC, 0x30, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x06, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30, 0x30, 0x00,
  0x06, 0x06, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x0C, 0x00, 0x07, 0x01,
  0x80, 0x00, 0xC0, 0x38, 0x00, 0x18, 0x03, 0x80, 0x03, 0x00, 0x38, 0x00,
  0x60, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x1C,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x1C, 0x07, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x03, 0x80,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60,
  0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x1C,
  0x07, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0xFF, 0x80, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x01,
  0xF8, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x21, 0xC0, 0x07, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0x0C, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0x60, 0x06, 0x00, 0x18, 0x03, 0x00,
  0x06, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x00, 0xC0, 0x70, 0x00, 0x30, 0x38,
  0x00, 0x0C, 0x1C, 0x00, 0x07, 0x06, 0x00, 0x01, 0x83, 0x80, 0x00, 0x61,
  0xC0, 0x00, 0x18, 0xE0, 0x00, 0x06, 0x70, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0xCF, 0x00, 0x00, 0x36, 0xC0, 0x00, 0x0F, 0x18, 0x00, 0x03, 0x86, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x60, 0x70, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x06, 0x00, 0x0C,
  0x01, 0x80, 0x03, 0x00, 0x70, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xE0, 0x06, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x01,
  0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x1A, 0x00, 0x00, 0x1E, 0x01, 0xB0, 0x00, 0x03, 0xE0, 0x1B, 0x00, 0x00,
  0x36, 0x01, 0xB0, 0x00, 0x07, 0x60, 0x1B, 0x00, 0x00, 0x6C, 0x03, 0x30,
  0x00, 0x0C, 0xC0, 0x33, 0x00, 0x00, 0xCC, 0x03, 0x30, 0x00, 0x18, 0xC0,
  0x33, 0x00, 0x01, 0x9C, 0x07, 0x30, 0x00, 0x31, 0x80, 0x63, 0x00, 0x03,
  0x18, 0x06, 0x30, 0x00, 0x61, 0x80, 0x61, 0x00, 0x06, 0x18, 0x06, 0x18,
  0x00, 0xC3, 0x00, 0xC1, 0x80, 0x0C, 0x30, 0x0C, 0x18, 0x01, 0x83, 0x00,
  0xC1, 0x80, 0x18, 0x30, 0x0C, 0x18, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x30,
  0x60, 0x18, 0x18, 0x06, 0x06, 0x01, 0x81, 0x80, 0x60, 0x60, 0x18, 0x18,
  0x0C, 0x06, 0x01, 0x81, 0x80, 0xC0, 0xE0, 0x18, 0x18, 0x18, 0x0C, 0x03,
  0x00, 0xC1, 0x80, 0xC0, 0x30, 0x0C, 0x30, 0x0C, 0x03, 0x00, 0xC3, 0x00,
  0xC0, 0x30, 0x0C, 0x60, 0x1C, 0x06, 0x00, 0xC6, 0x01, 0x80, 0x60, 0x0C,
  0xC0, 0x18, 0x06, 0x00, 0xCC, 0x01, 0x80, 0x60, 0x0D, 0x80, 0x18, 0x06,
  0x00, 0xD8, 0x03, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x0C, 0x00, 0xF0, 0x03,
  0x00, 0xC0, 0x0E, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x07, 0x00,
  0x00, 0xC0, 0x38, 0x00, 0x0C, 0x03, 0xC0, 0x00, 0x60, 0x1B, 0x00, 0x03,
  0x00, 0xD8, 0x00, 0x18, 0x06, 0xC0, 0x01, 0xC0, 0x36, 0x00, 0x0C, 0x03,
  0x18, 0x00, 0x60, 0x18, 0xC0, 0x03, 0x00, 0xC6, 0x00, 0x18, 0x06, 0x30,
  0x01, 0x80, 0x70, 0xC0, 0x0C, 0x03, 0x06, 0x00, 0x60, 0x18, 0x30, 0x03,
  0x00, 0xC1, 0x80, 0x18, 0x06, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03,
  0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x38, 0x06, 0x01,
  0x81, 0x80, 0x60, 0x0C, 0x0C, 0x03, 0x00, 0x70, 0x60, 0x18, 0x01, 0x83,
  0x00, 0xC0, 0x0C, 0x30, 0x06, 0x00, 0x61, 0x80, 0x60, 0x03, 0x8C, 0x03,
  0x00, 0x0C, 0x60, 0x18, 0x00, 0x63, 0x00, 0xC0, 0x03, 0x30, 0x0E, 0x00,
  0x1D, 0x80, 0x60, 0x00, 0x6C, 0x03, 0x00, 0x03, 0x60, 0x18, 0x00, 0x1B,
  0x00, 0xC0, 0x00, 0xF0, 0x0C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x1E,
  0x0F, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x18, 0x0C,
  0x00, 0x0C, 0x0C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x19, 0x80, 0x00, 0x0C,
  0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x70, 0x00, 0x01, 0xB0, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00,
  0x03, 0x30, 0x00, 0x03, 0x98, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x30, 0x60,
  0x00, 0x38, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x18, 0x07, 0x00, 0x18, 0x01,
  0xC0, 0x38, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x03, 0x80, 0xC0, 0x03,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x70,
  0x70, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x07, 0x03, 0x00, 0x0C, 0x06,
  0x00, 0x38, 0x1C, 0x00, 0x60, 0x30, 0x03, 0x80, 0x60, 0x0E, 0x00, 0xC3,
  0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x1E, 0x0F, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x1C, 0x00,
  0x18, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0x86, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x19, 0x80,
  0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x70, 0x00, 0x01, 0xB0,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06,
  0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x98, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x70, 0xC0, 0x00,
  0x30, 0x60, 0x00, 0x38, 0x38, 0x00, 0x38, 0x0C, 0x00, 0x18, 0x07, 0x00,
  0x18, 0x01, 0xC0, 0x38, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x03,
  0x80, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x38,
  0x18, 0x00, 0x60, 0x70, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x07, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x30, 0x1C, 0x00, 0xE0, 0x30, 0x03, 0x80, 0x60,
  0x3E, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06,
  0x00, 0x18, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0x60, 0x18, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x38, 0x01, 0x80,
  0x60, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x0C, 0x0E,
  0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x70, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x7C, 0x1F, 0x00, 0xE0, 0x02, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0xC0, 0x07, 0x00, 0xFC, 0x3E, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C,
  0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x18,
  0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00,
  0x38, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x30, 0x70, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x60, 0x60, 0x00, 0x38, 0x38, 0x00, 0x0C, 0x0C, 0x00, 0x03,
  0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x18, 0x0C, 0x00,
  0x06, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x70, 0x0C,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x07, 0x00, 0x0F, 0x9F, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x6C, 0x00, 0x03, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x73, 0x00, 0x01, 0x8C,
  0x00, 0x06, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00,
  0x18, 0x30, 0x00, 0xE0, 0xC0, 0x03, 0x03, 0x00, 0x1C, 0x06, 0x00, 0x60,
  0x18, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x18,
  0x06, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x18,
  0x00, 0x60, 0xE0, 0x01, 0x83, 0x00, 0x06, 0x1C, 0x00, 0x18, 0x60, 0x00,
  0x61, 0x80, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x19, 0x80, 0x00, 0x66,
  0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3C,
  0x00, 0x06, 0x00, 0x06, 0xC0, 0x00, 0xE0, 0x00, 0x6C, 0x00, 0x0E, 0x00,
  0x0E, 0xC0, 0x01, 0xE0, 0x00, 0xCC, 0x00, 0x1E, 0x00, 0x0C, 0xC0, 0x03,
  0x60, 0x01, 0x8C, 0x00, 0x36, 0x00, 0x18, 0xC0, 0x03, 0x60, 0x03, 0x8C,
  0x00, 0x66, 0x00, 0x30, 0xC0, 0x06, 0x60, 0x07, 0x0C, 0x00, 0xC6, 0x00,
  0x60, 0xC0, 0x0C, 0x60, 0x06, 0x0C, 0x00, 0xC6, 0x00, 0xC0, 0xC0, 0x18,
  0x60, 0x0C, 0x0C, 0x01, 0x86, 0x01, 0xC0, 0xC0, 0x30, 0x60, 0x18, 0x0C,
  0x03, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x0C, 0x06, 0x06, 0x03,
  0x00, 0xC0, 0x60, 0x60, 0x60, 0x0C, 0x0C, 0x06, 0x06, 0x00, 0xC0, 0xC0,
  0x60, 0x60, 0x0C, 0x18, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x0C,
  0x18, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x06, 0x38,
  0x00, 0xC6, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x06, 0x30, 0x00, 0xCC, 0x00,
  0x66, 0x00, 0x0C, 0xC0, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x6C, 0x00, 0x0D,
  0x80, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x60, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x30, 0x06, 0x00,
  0x06, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x18, 0x18, 0x00, 0x06, 0x01, 0x80, 0x01, 0xC0, 0x30, 0x00,
  0x30, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x80, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x18, 0x00, 0x30, 0x07, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x30,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x0E, 0xC0, 0x00, 0xCC, 0x00,
  0x18, 0xE0, 0x03, 0x86, 0x00, 0x30, 0x60, 0x07, 0x06, 0x00, 0x60, 0x60,
  0x0C, 0x06, 0x00, 0xC0, 0x60, 0x18, 0x03, 0x03, 0x80, 0x30, 0x30, 0x03,
  0x07, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x18, 0x00,
  0x1B, 0x80, 0x01, 0xB0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60,
  0x20, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x07, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x7F, 0xC0,
  0x0F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xCC, 0x00, 0x06, 0x60, 0x00, 0x63, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x60,
  0x01, 0x81, 0x80, 0x18, 0x0C, 0x01, 0xC0, 0x60, 0x0C, 0x01, 0x80, 0xC0,
  0x0C, 0x06, 0x00, 0x70, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x30, 0x00, 0x33,
  0x80, 0x01, 0x98, 0x00, 0x0F, 0x80, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0x86, 0x0C, 0x30, 0x61, 0x83, 0x04, 0x00, 0x1C, 0x00, 0x07, 0xF8,
  0xC0, 0x78, 0xE6, 0x07, 0x03, 0x30, 0x70, 0x0D, 0x07, 0x00, 0x38, 0x30,
  0x01, 0xC3, 0x80, 0x0E, 0x18, 0x00, 0x71, 0xC0, 0x03, 0x0C, 0x00, 0x18,
  0x60, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x71, 0x80, 0x03, 0x0C, 0x00,
  0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C,
  0x00, 0x18, 0x60, 0x01, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0xE0, 0xC0, 0x07,
  0x07, 0x00, 0x78, 0x18, 0x06, 0xC0, 0xE0, 0x66, 0x03, 0xDE, 0x20, 0x0F,
  0xE3, 0x00, 0x08, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x30, 0x01, 0x8F, 0xE0, 0x1C, 0xE7, 0x80, 0xCC, 0x0E, 0x06,
  0xC0, 0x38, 0x3C, 0x00, 0xC1, 0xC0, 0x06, 0x1E, 0x00, 0x30, 0xE0, 0x01,
  0x87, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xC0,
  0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x71, 0x80, 0x03, 0x18, 0x00, 0x18,
  0xC0, 0x00, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x80, 0x03, 0x1C, 0x00,
  0x30, 0xE0, 0x01, 0x87, 0x00, 0x18, 0x28, 0x01, 0xC3, 0x60, 0x1C, 0x19,
  0x81, 0xC0, 0xCF, 0x3C, 0x04, 0x3F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x7F, 0xC0, 0x7C, 0x60, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x01, 0x03, 0xC7, 0x00,
  0xFF, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x08, 0x1C, 0x00, 0xFF, 0x18, 0x01, 0xE3,
  0x98, 0x03, 0x80, 0xD8, 0x07, 0x00, 0xD8, 0x0E, 0x00, 0x50, 0x0C, 0x00,
  0x70, 0x1C, 0x00, 0x70, 0x18, 0x00, 0x70, 0x30, 0x00, 0x70, 0x30, 0x00,
  0x60, 0x30, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00,
  0xE0, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x01,
  0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x80, 0xC0, 0x03,
  0x80, 0xC0, 0x07, 0x80, 0xC0, 0x05, 0x00, 0xC0, 0x0F, 0x00, 0x60, 0x1B,
  0x00, 0x70, 0x33, 0x00, 0x3C, 0xE3, 0x00, 0x1F, 0xC2, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x3F, 0xC0, 0x1E, 0x38, 0x0E, 0x07, 0x07, 0x00,
  0xC3, 0x80, 0x30, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x01, 0xCC, 0x00, 0x63,
  0x00, 0x39, 0xC0, 0x1C, 0x60, 0x0E, 0x18, 0x0F, 0x07, 0xFF, 0x03, 0xFE,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x10, 0x3E, 0x7C, 0x03, 0xFE, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x7F, 0x84, 0x01, 0xE3, 0x98, 0x07, 0x01, 0xB0, 0x1C, 0x03,
  0x60, 0x70, 0x02, 0x80, 0xC0, 0x07, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x1C,
  0x18, 0x00, 0x38, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC1, 0x80, 0x01, 0x83,
  0x00, 0x03, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60,
  0x00, 0x60, 0xC0, 0x01, 0xC1, 0x80, 0x03, 0x83, 0x00, 0x0E, 0x06, 0x00,
  0x1C, 0x0C, 0x00, 0x38, 0x18, 0x00, 0xF0, 0x30, 0x03, 0x40, 0x60, 0x07,
  0x80, 0x60, 0x1B, 0x00, 0xE0, 0x66, 0x00, 0xF3, 0x8C, 0x00, 0xFE, 0x30,
  0x00, 0x20, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0xC0, 0x38, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x03, 0x00, 0x31,
  0xFE, 0x03, 0x78, 0xE0, 0x6E, 0x07, 0x06, 0x80, 0x30, 0x78, 0x03, 0x07,
  0x00, 0x30, 0xE0, 0x03, 0x0E, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30,
  0xC0, 0x06, 0x1C, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06,
  0x18, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x01,
  0xC3, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00,
  0x38, 0xE0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x70, 0x00,
  0x40, 0x70, 0x1C, 0x07, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x06,
  0x01, 0x80, 0x60, 0x38, 0x06, 0x07, 0x00, 0xC0, 0xE0, 0x0C, 0x0C, 0x00,
  0xC1, 0x80, 0x0C, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xE0, 0x01, 0x9E, 0x00,
  0x1B, 0xE0, 0x01, 0xB6, 0x00, 0x16, 0x60, 0x03, 0xC3, 0x00, 0x38, 0x30,
  0x03, 0x03, 0x00, 0x30, 0x30, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x1C, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0,
  0x0E, 0x0C, 0x00, 0x60, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x00, 0x01, 0x06, 0x00, 0x30, 0x02, 0x3F, 0xC1, 0xFE, 0x06, 0x71,
  0xE3, 0x8F, 0x06, 0xC0, 0x66, 0x07, 0x06, 0x80, 0x6C, 0x03, 0x07, 0x00,
  0x78, 0x03, 0x07, 0x00, 0x70, 0x03, 0x0E, 0x00, 0x70, 0x03, 0x0E, 0x00,
  0x70, 0x03, 0x0C, 0x00, 0x60, 0x03, 0x0C, 0x00, 0x60, 0x03, 0x0C, 0x00,
  0x60, 0x07, 0x1C, 0x00, 0xE0, 0x06, 0x18, 0x00, 0xC0, 0x06, 0x18, 0x00,
  0xC0, 0x06, 0x18, 0x00, 0xC0, 0x06, 0x18, 0x00, 0xC0, 0x0C, 0x30, 0x01,
  0x80, 0x0C, 0x30, 0x01, 0x80, 0x0C, 0x30, 0x01, 0x80, 0x0C, 0x30, 0x01,
  0x80, 0x0C, 0x70, 0x03, 0x80, 0x18, 0x60, 0x03, 0x00, 0x18, 0x60, 0x03,
  0x00, 0x18, 0x60, 0x03, 0x00, 0x18, 0x60, 0x03, 0x00, 0x18, 0xE0, 0x06,
  0x00, 0x30, 0xC0, 0x06, 0x00, 0x30, 0xC0, 0x06, 0x00, 0x30, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x03, 0x00, 0x21, 0xFE, 0x06, 0x78, 0xE0, 0x6E, 0x07,
  0x06, 0xC0, 0x30, 0x78, 0x03, 0x07, 0x00, 0x30, 0xE0, 0x03, 0x0E, 0x00,
  0x30, 0xE0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x06, 0x1C, 0x00, 0x61, 0x80,
  0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x0C, 0x30,
  0x00, 0xC3, 0x00, 0x0C, 0x30, 0x01, 0xC7, 0x00, 0x18, 0x60, 0x01, 0x86,
  0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30,
  0xC0, 0x03, 0x0C, 0x00, 0x70, 0x00, 0x08, 0x00, 0x0F, 0xF0, 0x01, 0xE3,
  0xC0, 0x38, 0x0C, 0x07, 0x00, 0xE0, 0xE0, 0x06, 0x0C, 0x00, 0x61, 0x80,
  0x06, 0x18, 0x00, 0x73, 0x80, 0x07, 0x30, 0x00, 0x77, 0x00, 0x07, 0x60,
  0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x6E, 0x00, 0x06, 0xC0, 0x00, 0x6C,
  0x00, 0x0E, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x18,
  0xC0, 0x01, 0x8C, 0x00, 0x30, 0xC0, 0x03, 0x0E, 0x00, 0x60, 0x60, 0x0E,
  0x07, 0x01, 0xC0, 0x3C, 0xF8, 0x01, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x63, 0xF8, 0x00, 0x47, 0x1C, 0x00, 0xCC, 0x06, 0x00,
  0xD8, 0x07, 0x00, 0xF0, 0x03, 0x00, 0xE0, 0x03, 0x01, 0xE0, 0x03, 0x01,
  0xC0, 0x03, 0x01, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x03,
  0x80, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03,
  0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x0E, 0x06,
  0x00, 0x0C, 0x06, 0x00, 0x0C, 0x0E, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x0E,
  0x00, 0x30, 0x0E, 0x00, 0x70, 0x1B, 0x00, 0xE0, 0x19, 0x01, 0xC0, 0x19,
  0xE7, 0x80, 0x18, 0xFF, 0x00, 0x18, 0x10, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07,
  0xF8, 0x40, 0x79, 0xE6, 0x07, 0x01, 0xB0, 0x70, 0x0D, 0x87, 0x00, 0x28,
  0x30, 0x01, 0xC3, 0x80, 0x0E, 0x18, 0x00, 0x71, 0xC0, 0x03, 0x8C, 0x00,
  0x18, 0x60, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C,
  0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x71, 0x80, 0x03,
  0x8C, 0x00, 0x18, 0x60, 0x01, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0xF0, 0xC0,
  0x05, 0x06, 0x00, 0x78, 0x18, 0x06, 0xC0, 0xE0, 0x66, 0x03, 0xCE, 0x30,
  0x0F, 0xE3, 0x00, 0x08, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x01, 0x0F, 0xC1, 0x9E, 0x40, 0xDC, 0x00, 0x6C, 0x00,
  0x3C, 0x00, 0x14, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xE0, 0x3C, 0x7C,
  0x18, 0x02, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x82, 0x00, 0xE0, 0xF0, 0xF0, 0x1F, 0xF8,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x07, 0xFF, 0x3F, 0xF0, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x40,
  0x7E, 0x00, 0x80, 0x00, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30,
  0xC0, 0x03, 0x0C, 0x00, 0x61, 0xC0, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06,
  0x18, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00,
  0xC3, 0x00, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00,
  0x18, 0x60, 0x03, 0x8E, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x70, 0xC0,
  0x07, 0x0C, 0x00, 0xE0, 0xC0, 0x1E, 0x0C, 0x01, 0x60, 0xE0, 0x76, 0x07,
  0x9E, 0x60, 0x3F, 0x84, 0x00, 0x40, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x6C,
  0x00, 0x33, 0x00, 0x0C, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xC3, 0x00,
  0x30, 0xC0, 0x1C, 0x30, 0x06, 0x06, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70,
  0x18, 0x18, 0x06, 0x0E, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x60, 0x06,
  0x18, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0xB0,
  0x00, 0x6C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x07, 0x00, 0x3E, 0x00, 0x38, 0x01, 0xB0, 0x03, 0xC0, 0x1D,
  0x80, 0x1E, 0x00, 0xCC, 0x00, 0xB0, 0x06, 0x60, 0x0D, 0x80, 0x63, 0x00,
  0x6C, 0x03, 0x18, 0x06, 0x60, 0x30, 0xC0, 0x33, 0x01, 0x86, 0x03, 0x18,
  0x0C, 0x30, 0x18, 0xC0, 0xC1, 0x80, 0x86, 0x06, 0x0C, 0x0C, 0x30, 0x60,
  0x60, 0x61, 0x83, 0x03, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x61, 0x80, 0xC3,
  0x03, 0x0C, 0x02, 0x18, 0x18, 0xC0, 0x11, 0x80, 0xC6, 0x00, 0x8C, 0x06,
  0x60, 0x04, 0x60, 0x33, 0x00, 0x26, 0x01, 0x98, 0x01, 0x30, 0x0D, 0x80,
  0x0B, 0x00, 0x6C, 0x00, 0x58, 0x03, 0xC0, 0x02, 0x80, 0x1E, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0xE0, 0x07, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x0E, 0x03, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x0C,
  0x06, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x63,
  0x80, 0x00, 0xC6, 0x00, 0x01, 0x98, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0x98, 0x00, 0x06, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x30, 0xC0, 0x00,
  0xC0, 0xC0, 0x03, 0x81, 0x80, 0x06, 0x03, 0x00, 0x18, 0x07, 0x00, 0x60,
  0x06, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x60, 0x06, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x01,
  0x80, 0x18, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x30,
  0x00, 0x18, 0x06, 0x00, 0x01, 0x01, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x1F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xE0, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0x80, 0x09, 0xFF, 0x00, 0x58, 0x1E, 0x07, 0x80, 0x3F, 0xE8, 0x00,
  0x7E, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 39, 12, 1, -39 },
  { 55, 12, 14, 16, 5, -39 },
  { 76, 25, 39, 25, 1, -39 },
  { 198, 23, 45, 23, 0, -42 },
  { 328, 28, 41, 33, 3, -40 },
  { 472, 23, 41, 24, 0, -40 },
  { 590, 4, 14, 9, 6, -39 },
  { 597, 16, 48, 14, 1, -39 },
  { 693, 16, 48, 14, -4, -39 },
  { 789, 17, 18, 21, 6, -42 },
  { 828, 21, 25, 25, 2, -32 },
  { 894, 7, 13, 10, -2, -6 },
  { 906, 13, 2, 15, 1, -16 },
  { 910, 3, 4, 10, 1, -4 },
  { 912, 23, 39, 17, -2, -39 },
  { 1025, 20, 41, 23, 2, -40 },
  { 1128, 11, 39, 23, 7, -39 },
  { 1182, 23, 40, 23, -1, -40 },
  { 1297, 23, 41, 23, -1, -40 },
  { 1415, 23, 40, 23, -1, -40 },
  { 1530, 23, 40, 23, 0, -39 },
  { 1645, 21, 41, 23, 2, -40 },
  { 1753, 21, 39, 23, 3, -39 },
  { 1856, 23, 41, 23, 0, -40 },
  { 1974, 21, 41, 23, 1, -40 },
  { 2082, 8, 29, 10, 1, -29 },
  { 2111, 12, 36, 10, -3, -29 },
  { 2165, 21, 23, 25, 2, -31 },
  { 2226, 21, 13, 25, 2, -26 },
  { 2261, 21, 23, 25, 2, -31 },
  { 2322, 16, 40, 16, 2, -40 },
  { 2402, 31, 44, 34, 2, -39 },
  { 2573, 22, 39, 22, -3, -39 },
  { 2681, 24, 39, 25, 1, -39 },
  { 2798, 24, 41, 23, 3, -40 },
  { 2921, 25, 39, 27, 1, -39 },
  { 3043, 23, 39, 22, 1, -39 },
  { 3156, 23, 39, 20, 1, -39 },
  { 3269, 27, 41, 29, 3, -40 },
  { 3408, 28, 39, 28, 1, -39 },
  { 3545, 17, 39, 12, -2, -39 },
  { 3628, 19, 49, 10, -8, -39 },
  { 3745, 26, 39, 23, 1, -39 },
  { 3872, 15, 39, 20, 1, -39 },
  { 3946, 36, 39, 36, 1, -39 },
  { 4122, 29, 39, 29, 1, -39 },
  { 4264, 25, 41, 29, 3, -40 },
  { 4393, 23, 39, 23, 1, -39 },
  { 4506, 25, 49, 29, 3, -40 },
  { 4660, 23, 39, 24, 1, -39 },
  { 4773, 24, 41, 22, -1, -40 },
  { 4896, 19, 39, 20, 5, -39 },
  { 4989, 26, 40, 28, 3, -39 },
  { 5119, 22, 39, 23, 5, -39 },
  { 5227, 36, 39, 37, 5, -39 },
  { 5403, 27, 39, 20, -3, -39 },
  { 5535, 20, 39, 20, 5, -39 },
  { 5633, 26, 39, 21, -2, -39 },
  { 5760, 20, 48, 16, -1, -39 },
  { 5880, 8, 39, 18, 6, -39 },
  { 5919, 20, 48, 16, -4, -39 },
  { 6039, 21, 20, 24, 2, -39 },
  { 6092, 16, 2, 17, -4, 5 },
  { 6096, 6, 9, 12, 8, -42 },
  { 6103, 21, 31, 24, 2, -30 },
  { 6185, 21, 43, 24, 1, -42 },
  { 6298, 17, 31, 18, 2, -30 },
  { 6364, 24, 43, 24, 2, -42 },
  { 6493, 18, 31, 21, 2, -30 },
  { 6563, 26, 55, 12, -7, -42 },
  { 6742, 23, 43, 24, 0, -30 },
  { 6866, 20, 42, 23, 1, -42 },
  { 6971, 10, 40, 10, 1, -40 },
  { 7021, 19, 53, 10, -7, -40 },
  { 7147, 20, 42, 19, 1, -42 },
  { 7252, 11, 42, 10, 1, -42 },
  { 7310, 32, 30, 36, 1, -30 },
  { 7430, 20, 30, 23, 1, -30 },
  { 7505, 20, 31, 24, 2, -30 },
  { 7583, 24, 43, 24, -2, -30 },
  { 7712, 21, 43, 24, 2, -30 },
  { 7825, 17, 30, 16, 1, -30 },
  { 7889, 18, 31, 18, 0, -30 },
  { 7959, 13, 37, 13, 1, -36 },
  { 8020, 20, 30, 23, 2, -29 },
  { 8095, 18, 29, 18, 3, -29 },
  { 8161, 29, 29, 29, 3, -29 },
  { 8267, 23, 29, 19, -2, -29 },
  { 8351, 27, 42, 19, -6, -29 },
  { 8493, 20, 29, 17, -2, -29 },
  { 8566, 19, 48, 18, 2, -39 },
  { 8680, 2, 55, 22, 10, -42 },
  { 8694, 19, 48, 17, -3, -39 },
  { 8808, 21, 5, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic55pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC55PT7B_H_
