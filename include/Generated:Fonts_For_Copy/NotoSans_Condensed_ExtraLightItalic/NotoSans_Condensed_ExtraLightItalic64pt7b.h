#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC64PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x00, 0x1C, 0x0C, 0x70, 0x71, 0xC1, 0xC6, 0x07, 0x18,
  0x18, 0xE0, 0x63, 0x81, 0x8C, 0x0E, 0x30, 0x30, 0xC0, 0xC3, 0x03, 0x18,
  0x0C, 0x60, 0x61, 0x81, 0x86, 0x06, 0x10, 0x18, 0xC0, 0x40, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x70, 0x00, 0x0C, 0x03,
  0x00, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x0C, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x18, 0x06,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x60, 0x18, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x00, 0xE0, 0x18, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x0C,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x07, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18,
  0x06, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0xF8, 0xC7, 0x80, 0x78, 0x20, 0x20, 0x1C, 0x18, 0x00, 0x0E, 0x06, 0x00,
  0x03, 0x01, 0x80, 0x00, 0xC0, 0x40, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x0C,
  0x00, 0x07, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x20, 0x00, 0x0C,
  0x18, 0x00, 0x03, 0x86, 0x00, 0x00, 0x71, 0x80, 0x00, 0x1E, 0x60, 0x00,
  0x03, 0xD0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1B, 0xC0, 0x00, 0x06, 0x78, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x0E, 0x00,
  0x03, 0x03, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x08, 0x0E,
  0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x18,
  0x38, 0x08, 0x04, 0x1C, 0x03, 0x83, 0x1E, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x0C, 0x03, 0xFC, 0x00, 0x18, 0x07, 0x0E,
  0x00, 0x18, 0x0E, 0x06, 0x00, 0x30, 0x0C, 0x06, 0x00, 0x70, 0x18, 0x06,
  0x00, 0x60, 0x18, 0x06, 0x00, 0xE0, 0x38, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x70, 0x06, 0x03, 0x00, 0x60, 0x06,
  0x07, 0x00, 0x60, 0x0E, 0x06, 0x00, 0x60, 0x0C, 0x0E, 0x00, 0xE0, 0x0C,
  0x0C, 0x00, 0xC0, 0x0C, 0x18, 0x00, 0xC0, 0x0C, 0x18, 0x00, 0xC0, 0x1C,
  0x30, 0x00, 0xC0, 0x18, 0x70, 0x78, 0xC0, 0x18, 0x61, 0xFE, 0xC0, 0x38,
  0xE3, 0x8E, 0xC0, 0x30, 0xC7, 0x07, 0xC0, 0x71, 0xC6, 0x03, 0xC0, 0x61,
  0x8E, 0x03, 0xC0, 0xE3, 0x0C, 0x03, 0xE1, 0xC7, 0x1C, 0x03, 0x7F, 0x86,
  0x18, 0x03, 0x3F, 0x0E, 0x18, 0x03, 0x00, 0x0C, 0x38, 0x03, 0x00, 0x1C,
  0x30, 0x03, 0x00, 0x18, 0x30, 0x07, 0x00, 0x30, 0x30, 0x07, 0x00, 0x70,
  0x70, 0x06, 0x00, 0x60, 0x60, 0x06, 0x00, 0xE0, 0x60, 0x06, 0x00, 0xC0,
  0x60, 0x0E, 0x01, 0xC0, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x1C, 0x07, 0x00, 0x60, 0x18, 0x06, 0x00, 0x60, 0x18, 0x0E, 0x00,
  0x60, 0x30, 0x0C, 0x00, 0x60, 0x70, 0x1C, 0x00, 0x70, 0xE0, 0x18, 0x00,
  0x39, 0xC0, 0x30, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x07, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x70, 0x0E, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0x80,
  0x30, 0x00, 0x70, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x38, 0x00,
  0x30, 0x07, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x30, 0x70, 0x00, 0x06, 0x1C, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x70, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x1C, 0x1C, 0x03, 0x87, 0x01, 0x80, 0x61, 0xC0, 0x38, 0x0C,
  0x30, 0x03, 0x03, 0x8E, 0x00, 0x70, 0x61, 0x80, 0x0E, 0x1C, 0x70, 0x00,
  0xC3, 0x0C, 0x00, 0x1C, 0xE1, 0x80, 0x01, 0x98, 0x30, 0x00, 0x3F, 0x0E,
  0x00, 0x07, 0xC1, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x03,
  0xC0, 0x60, 0x00, 0xFC, 0x0E, 0x00, 0x39, 0x81, 0xC0, 0x0E, 0x30, 0x1C,
  0x03, 0x87, 0x01, 0xFF, 0xE0, 0x60, 0x1F, 0xF8, 0x0E, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x71, 0xC6, 0x18, 0x63, 0x8C, 0x30, 0xC3, 0x18, 0x61, 0x86,
  0x10, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x01, 0x00, 0xC0, 0x30, 0x18, 0x07, 0x83, 0x00, 0x3C, 0x40, 0x01,
  0xD8, 0x7C, 0x0F, 0xFF, 0x80, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0xC0, 0x03,
  0x8C, 0x00, 0xE1, 0x80, 0x38, 0x18, 0x1E, 0x03, 0x01, 0x80, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x03, 0x81, 0xC1, 0xC0, 0xE0,
  0x60, 0x70, 0x30, 0x38, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x07, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x37, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x06, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x07,
  0x00, 0x07, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C,
  0x00, 0x07, 0x0C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x18, 0x00, 0x07, 0x18,
  0x00, 0x06, 0x38, 0x00, 0x06, 0x38, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x1C, 0x60, 0x00, 0x1C, 0x60, 0x00, 0x18, 0xE0,
  0x00, 0x18, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0,
  0x00, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0x60, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x3E, 0x03, 0xF0,
  0x7B, 0x07, 0x98, 0x70, 0xCF, 0x0E, 0xF0, 0x72, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x38, 0x01, 0xC0, 0x02, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xF0, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x04, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x02, 0x00, 0x07, 0x80, 0x70, 0x01, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x06, 0x60, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x30, 0x00, 0x07, 0x06, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x0E, 0x06, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x60, 0x18, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xC0,
  0x18, 0x00, 0x38, 0x03, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0x80, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03,
  0x80, 0x38, 0x00, 0x70, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x70,
  0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xC0, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x08, 0x00, 0x3C, 0x03, 0x00, 0x3E, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x03, 0xE0, 0x20, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x0F, 0xE0, 0x03, 0x1F, 0xF8, 0x03, 0x9C,
  0x1E, 0x01, 0x98, 0x03, 0x80, 0xD8, 0x00, 0xE0, 0x78, 0x00, 0x70, 0x78,
  0x00, 0x18, 0x3C, 0x00, 0x0C, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x86,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x30,
  0xE0, 0x00, 0x18, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x06,
  0x0E, 0x00, 0x03, 0x07, 0x00, 0x03, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x01,
  0xC0, 0x70, 0x00, 0xC0, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x81,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x01, 0xC0, 0x06, 0x00, 0x1C, 0x01, 0xC0,
  0x03, 0x80, 0x30, 0x00, 0x30, 0x0E, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xE0,
  0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00,
  0x1C, 0x03, 0x80, 0x03, 0x00, 0x70, 0x00, 0xE0, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x07, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x1C, 0x3C,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xDC, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0x80, 0x70, 0x00, 0x38, 0x0C, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x30, 0x70, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x18, 0x38, 0x00, 0x07, 0x03, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x38, 0x0E,
  0x00, 0x06, 0x00, 0xE0, 0x01, 0xC0, 0x0F, 0x00, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x1E, 0x07, 0x00, 0x1E, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x0E, 0x00, 0x38, 0x0E, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x07, 0x00, 0x03,
  0x03, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xC0, 0x00,
  0x38, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x06, 0x1C, 0x00,
  0x03, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0xF0, 0x60, 0x00, 0x78, 0x30, 0x00, 0x78, 0x1C, 0x00, 0x6C, 0x07,
  0x00, 0x76, 0x03, 0xC0, 0xF7, 0x00, 0xFF, 0xE3, 0x00, 0x3F, 0xE1, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x10, 0x0F,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0x80, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x3C, 0x0F,
  0x02, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x00, 0x30, 0x70, 0x00, 0xF8, 0x03, 0x06, 0x00,
  0x3F, 0xE0, 0x30, 0xE0, 0x0F, 0x0E, 0x03, 0x0C, 0x01, 0xC0, 0x60, 0x31,
  0xC0, 0x38, 0x0E, 0x03, 0x18, 0x03, 0x00, 0xC0, 0x31, 0x80, 0x60, 0x0C,
  0x03, 0x38, 0x0E, 0x01, 0xC0, 0x33, 0x00, 0xC0, 0x1C, 0x03, 0x30, 0x1C,
  0x01, 0x80, 0x73, 0x01, 0x80, 0x18, 0x06, 0x70, 0x18, 0x03, 0x80, 0x66,
  0x03, 0x80, 0x30, 0x06, 0x60, 0x30, 0x03, 0x00, 0x66, 0x03, 0x00, 0x30,
  0x0C, 0x60, 0x30, 0x07, 0x00, 0xCE, 0x03, 0x00, 0x60, 0x0C, 0xE0, 0x30,
  0x06, 0x01, 0x8C, 0x03, 0x00, 0xE0, 0x18, 0xC0, 0x30, 0x0E, 0x03, 0x0C,
  0x03, 0x01, 0xE0, 0x30, 0xC0, 0x30, 0x36, 0x06, 0x0C, 0x03, 0x03, 0x60,
  0xE0, 0xC0, 0x38, 0xE3, 0x1C, 0x0C, 0x01, 0xFC, 0x3F, 0x80, 0xE0, 0x0F,
  0x01, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xE8, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0E,
  0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x38, 0x38, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x01, 0xC0, 0xE0,
  0x00, 0x60, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0C, 0x03, 0x80, 0x07, 0x00,
  0x60, 0x01, 0x80, 0x18, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C,
  0x00, 0x60, 0x07, 0x00, 0x18, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x30, 0x00, 0x60, 0x1C, 0x00, 0x18, 0x06, 0x00, 0x06, 0x03, 0x80, 0x01,
  0x80, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x18, 0x18, 0x00, 0x06, 0x0E, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x38,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07,
  0x60, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x01,
  0xE0, 0x06, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x60, 0x0E, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x1C, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xE0,
  0x38, 0x00, 0x0C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x03, 0x00,
  0x07, 0x00, 0x30, 0x00, 0xE0, 0x07, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x60, 0x0F, 0x80, 0x06, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0xE0, 0x0E, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x30, 0x18,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x70, 0x38, 0x00, 0x06, 0x03, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x07,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x06, 0x00, 0x07, 0x80, 0x60, 0x01,
  0xF0, 0x06, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0x80, 0x70, 0x01,
  0xE0, 0x02, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x06, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xC0, 0x0F, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x1C,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x30, 0x1C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x60, 0x70, 0x00, 0x03, 0x03, 0x80, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x30, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x38, 0x18, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x70, 0x03, 0x00, 0x0F, 0x00, 0x18, 0x01, 0xF0, 0x00, 0xC0, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x3F, 0xF8, 0x60, 0x00, 0x7F, 0xE1, 0xC0, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x38, 0x00, 0x03, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x30, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01,
  0x80, 0x1C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0C, 0x00,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x30, 0x03, 0x80,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x10, 0x70, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x60, 0x07, 0x00, 0x03, 0x80, 0x18, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0xC0, 0x07, 0x00, 0x03, 0x00, 0x38, 0x00, 0x0C, 0x01, 0xC0, 0x00,
  0x70, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x06, 0x03, 0x80, 0x00, 0x18,
  0x1E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0C, 0x1C,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x07, 0x3C, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x00, 0x66, 0xC0, 0x00, 0x01, 0xB3, 0x80, 0x00,
  0x07, 0xCE, 0x00, 0x00, 0x3E, 0x18, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x07,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x30, 0x00, 0xE0,
  0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x70, 0x00, 0x70, 0x01, 0x80, 0x01, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x03, 0x60, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x03, 0x70, 0x00, 0x00, 0x6E, 0x00, 0xCC, 0x00, 0x00, 0x3B,
  0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x0C, 0xC0, 0x00, 0x07, 0x30, 0x07,
  0x30, 0x00, 0x01, 0x9C, 0x01, 0x8C, 0x00, 0x00, 0xE7, 0x00, 0x63, 0x00,
  0x00, 0x31, 0x80, 0x18, 0xC0, 0x00, 0x1C, 0x60, 0x0E, 0x30, 0x00, 0x06,
  0x38, 0x03, 0x8E, 0x00, 0x03, 0x8E, 0x00, 0xC3, 0x80, 0x00, 0xC3, 0x00,
  0x30, 0xE0, 0x00, 0x70, 0xC0, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x07, 0x06,
  0x00, 0x0E, 0x1C, 0x01, 0xC1, 0x80, 0x03, 0x07, 0x00, 0x60, 0x60, 0x01,
  0xC1, 0x80, 0x18, 0x18, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x30, 0x18,
  0x03, 0x81, 0x80, 0x1C, 0x0E, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x80, 0x30,
  0x18, 0x03, 0x80, 0xC0, 0x0C, 0x07, 0x00, 0xC0, 0x30, 0x03, 0x01, 0xC0,
  0x70, 0x1C, 0x01, 0xC0, 0x70, 0x18, 0x07, 0x00, 0x60, 0x0C, 0x0E, 0x01,
  0x80, 0x18, 0x03, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC1, 0xC0, 0x18, 0x03,
  0x80, 0x30, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x38, 0x03, 0x80, 0x30, 0x03,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC7, 0x00, 0x30, 0x03, 0x00, 0x31, 0x80,
  0x0C, 0x01, 0xC0, 0x0C, 0xE0, 0x07, 0x00, 0x70, 0x03, 0xB0, 0x01, 0xC0,
  0x18, 0x00, 0xFC, 0x00, 0x60, 0x06, 0x00, 0x3E, 0x00, 0x18, 0x01, 0x80,
  0x07, 0x80, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x30, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x70,
  0x07, 0x80, 0x00, 0x18, 0x01, 0xE0, 0x00, 0x06, 0x00, 0x78, 0x00, 0x01,
  0x80, 0x1F, 0x00, 0x00, 0xE0, 0x0E, 0xC0, 0x00, 0x38, 0x03, 0xB0, 0x00,
  0x0C, 0x00, 0xCC, 0x00, 0x03, 0x00, 0x33, 0x80, 0x01, 0xC0, 0x0C, 0x60,
  0x00, 0x70, 0x07, 0x18, 0x00, 0x18, 0x01, 0xC6, 0x00, 0x06, 0x00, 0x61,
  0xC0, 0x01, 0x80, 0x18, 0x30, 0x00, 0xE0, 0x0E, 0x0C, 0x00, 0x38, 0x03,
  0x83, 0x00, 0x0C, 0x00, 0xC0, 0xE0, 0x03, 0x00, 0x30, 0x18, 0x00, 0xC0,
  0x0C, 0x06, 0x00, 0x70, 0x07, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x70, 0x06,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x0C, 0x00, 0xE0, 0x06, 0x03, 0x00, 0x30, 0x01,
  0x80, 0xC0, 0x0C, 0x00, 0x70, 0x70, 0x03, 0x00, 0x1C, 0x1C, 0x01, 0xC0,
  0x03, 0x06, 0x00, 0x60, 0x00, 0xC1, 0x80, 0x18, 0x00, 0x38, 0x60, 0x06,
  0x00, 0x0E, 0x38, 0x03, 0x80, 0x01, 0x8E, 0x00, 0xE0, 0x00, 0x63, 0x00,
  0x30, 0x00, 0x1C, 0xC0, 0x0C, 0x00, 0x07, 0x30, 0x03, 0x00, 0x00, 0xDC,
  0x01, 0xC0, 0x00, 0x37, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x18, 0x00, 0x03,
  0xE0, 0x06, 0x00, 0x00, 0x78, 0x01, 0x80, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x60, 0x70, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x0E, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x30, 0x03, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x80, 0x38, 0x00, 0x70, 0x07, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xE0, 0x18,
  0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0E,
  0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x1C, 0x00, 0x06, 0x03, 0x80,
  0x01, 0xC0, 0x70, 0x00, 0x30, 0x0C, 0x00, 0x0E, 0x01, 0x80, 0x01, 0xC0,
  0x70, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x01, 0x80, 0x07, 0x00, 0x30, 0x03,
  0xC0, 0x06, 0x0F, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x03,
  0x80, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0x60, 0x70, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0x60, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x30, 0x03, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x80, 0x38,
  0x00, 0x70, 0x07, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x1C,
  0x03, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0C, 0x03, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x30, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0,
  0x70, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x80, 0x70, 0x00,
  0xF0, 0x0E, 0x00, 0x3C, 0x01, 0x80, 0x0F, 0x00, 0x30, 0x1F, 0xC0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x38, 0x0C, 0x00, 0x06, 0x01, 0x80,
  0x00, 0xC0, 0x38, 0x00, 0x18, 0x07, 0x00, 0x07, 0x00, 0x60, 0x00, 0xE0,
  0x0C, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x00, 0x0E, 0x00, 0x60, 0x01, 0xC0, 0x0C, 0x00,
  0x38, 0x03, 0x80, 0x03, 0x00, 0x70, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x01,
  0x80, 0x01, 0xC0, 0x30, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x1E, 0x01,
  0xE0, 0x03, 0x80, 0x02, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x3C, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x18, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xC0, 0x1C,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x01, 0xE0,
  0x1E, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x0C, 0x38, 0x00,
  0x0E, 0x1C, 0x00, 0x06, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x03, 0x80,
  0x03, 0x81, 0xC0, 0x01, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xC0, 0x38,
  0x00, 0xE0, 0x1C, 0x00, 0x70, 0x06, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x1C, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x0E, 0x00,
  0x18, 0x06, 0x00, 0x0C, 0x07, 0x00, 0x06, 0x03, 0x00, 0x03, 0x03, 0x80,
  0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x30, 0x60,
  0x00, 0x18, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x38, 0x00, 0x03, 0x18,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x6C, 0x00, 0x01, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x30, 0x00, 0x0F, 0x00, 0x01, 0xCC, 0x00,
  0x07, 0xC0, 0x00, 0x63, 0x00, 0x01, 0xB0, 0x00, 0x38, 0xC0, 0x00, 0xEC,
  0x00, 0x0C, 0x30, 0x00, 0x33, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0xC0, 0x01,
  0xC3, 0x00, 0x07, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x8C, 0x00, 0x38, 0x30,
  0x00, 0xE3, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0xC0, 0x07, 0x03, 0x00, 0x0C,
  0x30, 0x01, 0xC0, 0xC0, 0x07, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x83, 0x00,
  0x38, 0x0C, 0x00, 0xE0, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x30, 0x07, 0x00,
  0xC0, 0x1C, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0xC0, 0x38, 0x03, 0x00, 0xE0, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x0C,
  0x07, 0x00, 0x30, 0x1C, 0x03, 0x01, 0x80, 0x0E, 0x06, 0x00, 0xC0, 0xE0,
  0x03, 0x81, 0x80, 0x30, 0x38, 0x00, 0xE0, 0xC0, 0x0C, 0x0C, 0x00, 0x38,
  0x30, 0x03, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0xC1, 0x80, 0x03, 0x86, 0x00,
  0x30, 0xE0, 0x00, 0xE3, 0x80, 0x0C, 0x30, 0x00, 0x38, 0xC0, 0x03, 0x0C,
  0x00, 0x0E, 0x30, 0x00, 0xC7, 0x00, 0x03, 0x9C, 0x00, 0x31, 0x80, 0x00,
  0xE6, 0x00, 0x0C, 0xE0, 0x00, 0x33, 0x80, 0x03, 0x30, 0x00, 0x0C, 0xC0,
  0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x37, 0x00, 0x00, 0xD8, 0x00, 0x0D,
  0x80, 0x00, 0x36, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x60, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x03, 0x80, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0C, 0x70,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xC0, 0x38,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0x03, 0x80, 0x18, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07,
  0x60, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x1C, 0x70, 0x00, 0x38,
  0x70, 0x00, 0x38, 0x70, 0x00, 0x70, 0x30, 0x00, 0x60, 0x30, 0x00, 0xE0,
  0x30, 0x00, 0xC0, 0x30, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x18, 0x07, 0x00, 0x18, 0x06, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x0C, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x70, 0x00,
  0x0C, 0x60, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x07, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x1C, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x38, 0x1C, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0xCE, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x70, 0x60, 0x00, 0x30, 0x30, 0x00, 0x30, 0x1C, 0x00, 0x38, 0x06, 0x00,
  0x18, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x0E, 0x00, 0x38,
  0x0E, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x07, 0x00, 0x03, 0x83, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x71, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x0D, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0xC1, 0xC1, 0x83, 0x83, 0x07,
  0x06, 0x06, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xE0, 0xC0, 0x1F, 0xF8,
  0x60, 0x1E, 0x06, 0x60, 0x1C, 0x01, 0xB0, 0x1C, 0x00, 0xD8, 0x1C, 0x00,
  0x2C, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x07, 0x00,
  0x03, 0x83, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x18, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x18,
  0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38,
  0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x03, 0x00, 0x1B,
  0x01, 0xC0, 0x0D, 0x80, 0xE0, 0x0D, 0xC0, 0x38, 0x1C, 0xC0, 0x0F, 0xFC,
  0x60, 0x03, 0xFC, 0x30, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x07, 0xF0, 0x01, 0x8F,
  0xFC, 0x01, 0xCE, 0x07, 0x00, 0xEE, 0x01, 0xC0, 0x6C, 0x00, 0xE0, 0x36,
  0x00, 0x30, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07,
  0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x38, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06,
  0x1C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x30, 0x70, 0x00,
  0x38, 0x38, 0x00, 0x18, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x0C, 0x0F, 0x00,
  0x0E, 0x06, 0xC0, 0x0E, 0x03, 0x60, 0x0E, 0x03, 0x38, 0x0E, 0x01, 0x8F,
  0xFE, 0x00, 0xC3, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xE0, 0x20, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x02, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0x80, 0x01, 0xFE, 0x18, 0x00, 0x7F, 0xF1, 0x80, 0x0F, 0x03, 0xB8, 0x01,
  0xC0, 0x1B, 0x80, 0x38, 0x00, 0xB0, 0x07, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0xF0, 0x0E, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x30, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0C, 0x07, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x1C, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x38, 0x0E, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x70,
  0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0xE0,
  0x01, 0xE0, 0x06, 0x00, 0x3E, 0x00, 0x70, 0x07, 0x60, 0x07, 0x00, 0x66,
  0x00, 0x38, 0x1C, 0x60, 0x01, 0xFF, 0x8C, 0x00, 0x0F, 0xF0, 0xC0, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x01,
  0xE0, 0xE0, 0x1C, 0x03, 0x81, 0xC0, 0x0C, 0x1C, 0x00, 0x60, 0xC0, 0x03,
  0x0E, 0x00, 0x18, 0x60, 0x01, 0xC7, 0x00, 0x0E, 0x30, 0x00, 0x63, 0x80,
  0x07, 0x18, 0x00, 0x70, 0xC0, 0x07, 0x0E, 0x00, 0xF0, 0x70, 0x7E, 0x03,
  0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x03, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xF8, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0x0C, 0x00, 0x7F, 0xF1,
  0x80, 0x1E, 0x07, 0x30, 0x07, 0x00, 0x66, 0x01, 0xC0, 0x05, 0x80, 0x70,
  0x00, 0xF0, 0x0E, 0x00, 0x1E, 0x03, 0x80, 0x03, 0xC0, 0x60, 0x00, 0x78,
  0x1C, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00,
  0x07, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x03,
  0x80, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00,
  0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0x38,
  0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x3E,
  0x03, 0x80, 0x07, 0x80, 0x30, 0x01, 0xF0, 0x07, 0x00, 0x76, 0x00, 0xE0,
  0x1C, 0xC0, 0x0E, 0x07, 0x38, 0x01, 0xFF, 0xC6, 0x00, 0x0F, 0xF0, 0xC0,
  0x00, 0x70, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x20, 0x01, 0xC0, 0x07, 0x00, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x87, 0xF8, 0x01, 0x8F, 0xFC, 0x03, 0x9C, 0x0E, 0x03, 0xB0, 0x06,
  0x03, 0x60, 0x07, 0x03, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x07, 0x80, 0x07,
  0x07, 0x00, 0x07, 0x07, 0x00, 0x06, 0x07, 0x00, 0x06, 0x06, 0x00, 0x06,
  0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C,
  0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x30, 0x00, 0x30,
  0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70,
  0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0xE0, 0x00, 0xE0,
  0xE0, 0x00, 0xE0, 0xC0, 0x00, 0xC0, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x07, 0x01, 0x80, 0x0E, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x70, 0x03, 0x00, 0x60, 0x03, 0x00, 0xE0, 0x07, 0x01, 0xC0,
  0x07, 0x03, 0x80, 0x06, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x1C, 0x00,
  0x0E, 0x18, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0xF8, 0x00,
  0x1D, 0xD8, 0x00, 0x1F, 0x98, 0x00, 0x1B, 0x1C, 0x00, 0x1E, 0x1C, 0x00,
  0x1C, 0x0C, 0x00, 0x38, 0x0C, 0x00, 0x38, 0x0E, 0x00, 0x30, 0x0E, 0x00,
  0x30, 0x06, 0x00, 0x30, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80,
  0xC0, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x80, 0x01, 0x00, 0x06, 0x1F, 0xC0, 0x3F, 0x80,
  0x19, 0xFF, 0x83, 0xFF, 0x00, 0xEE, 0x07, 0x1C, 0x0E, 0x03, 0x30, 0x0C,
  0xC0, 0x1C, 0x0D, 0x80, 0x3E, 0x00, 0x70, 0x3C, 0x00, 0xF8, 0x01, 0xC0,
  0xE0, 0x03, 0xC0, 0x07, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x70, 0x00, 0xE0, 0x01, 0x81, 0xC0, 0x03, 0x00, 0x06, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x38, 0x00, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC0,
  0x03, 0x83, 0x00, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x70,
  0x00, 0x60, 0x00, 0xC1, 0xC0, 0x03, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x18, 0x00, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x01, 0x83, 0x80,
  0x03, 0x00, 0x06, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x30, 0x00, 0x70, 0x00,
  0xE0, 0xC0, 0x01, 0x80, 0x03, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x01, 0xC1, 0x80, 0x03, 0x00, 0x06,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x00, 0x60, 0xE0, 0x01,
  0xC0, 0x03, 0x83, 0x80, 0x07, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x40, 0x01, 0x87, 0xF8, 0x01, 0x8F, 0xFC, 0x03, 0x9C,
  0x0E, 0x03, 0x30, 0x06, 0x03, 0x60, 0x07, 0x03, 0xC0, 0x07, 0x03, 0xC0,
  0x07, 0x07, 0x80, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x06, 0x07, 0x00,
  0x06, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0C, 0x00,
  0x0C, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x18, 0x00,
  0x1C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x38, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x70, 0x00,
  0x70, 0x70, 0x00, 0x70, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0xE0, 0x00,
  0x60, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xC0, 0x00, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xC0, 0xE0, 0x0E, 0x00, 0xE0, 0x38, 0x01,
  0xC0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x0C, 0x00, 0x06,
  0x38, 0x00, 0x0C, 0x60, 0x00, 0x19, 0xC0, 0x00, 0x33, 0x80, 0x00, 0x66,
  0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xC0,
  0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00,
  0x03, 0x38, 0x00, 0x06, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x31, 0xC0, 0x00,
  0xE3, 0x80, 0x01, 0x83, 0x00, 0x07, 0x06, 0x00, 0x1C, 0x0E, 0x00, 0x38,
  0x1C, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x7F, 0x00, 0x03, 0x1F, 0xF8, 0x00, 0x73,
  0x81, 0xC0, 0x06, 0x70, 0x0E, 0x00, 0x6E, 0x00, 0xE0, 0x06, 0xC0, 0x06,
  0x00, 0x78, 0x00, 0x70, 0x0F, 0x80, 0x07, 0x00, 0xF0, 0x00, 0x70, 0x0E,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x60, 0x38, 0x00, 0x06, 0x03, 0x80, 0x00, 0xE0, 0x30, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x18, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x0F, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x60, 0x0F, 0x00, 0x0E, 0x00, 0xD0, 0x01, 0xC0,
  0x0D, 0x80, 0x38, 0x01, 0xDC, 0x07, 0x00, 0x1C, 0xFF, 0xE0, 0x01, 0x87,
  0xFC, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0F,
  0xF0, 0xC0, 0x1F, 0xFC, 0x60, 0x1E, 0x07, 0x30, 0x1C, 0x01, 0xB8, 0x1C,
  0x00, 0xD8, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x06,
  0x00, 0x07, 0x87, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xE1,
  0xC0, 0x00, 0x70, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x70, 0x00, 0x0C,
  0x38, 0x00, 0x0E, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01,
  0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00,
  0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x0E, 0x00,
  0x1F, 0x03, 0x00, 0x1F, 0x01, 0x80, 0x0D, 0x80, 0xE0, 0x0C, 0xC0, 0x38,
  0x1C, 0xE0, 0x1F, 0xFC, 0x60, 0x03, 0xFC, 0x30, 0x00, 0x70, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x87, 0xF0, 0x18,
  0xFE, 0x03, 0x1C, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0x80, 0x60, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x10, 0x01, 0xC0, 0xC0, 0x1E, 0x07,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x1F, 0xFC,
  0xFF, 0xF0, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x03, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x06, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x38, 0x00, 0x38,
  0x38, 0x00, 0x38, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30,
  0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x60, 0x00, 0x60, 0x60, 0x00, 0xE0,
  0x60, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xC0,
  0xE0, 0x03, 0xC0, 0xE0, 0x06, 0xC0, 0xE0, 0x0C, 0xC0, 0x70, 0x1C, 0xC0,
  0x7F, 0xF9, 0x80, 0x3F, 0xE1, 0x80, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x7C,
  0x00, 0x06, 0xC0, 0x00, 0xEC, 0x00, 0x0C, 0xC0, 0x01, 0xCC, 0x00, 0x18,
  0xC0, 0x03, 0x8C, 0x00, 0x30, 0xC0, 0x07, 0x0C, 0x00, 0x70, 0xC0, 0x06,
  0x0C, 0x00, 0xE0, 0xC0, 0x0C, 0x0C, 0x01, 0xC0, 0xE0, 0x18, 0x0E, 0x03,
  0x80, 0xE0, 0x30, 0x0E, 0x07, 0x00, 0xE0, 0x60, 0x0E, 0x0E, 0x00, 0x60,
  0xC0, 0x06, 0x1C, 0x00, 0x61, 0x80, 0x06, 0x38, 0x00, 0x63, 0x00, 0x06,
  0x70, 0x00, 0x66, 0x00, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x01,
  0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x01, 0xB0, 0x00, 0xF0, 0x01, 0xD8, 0x00,
  0x78, 0x00, 0xCC, 0x00, 0x7C, 0x00, 0x66, 0x00, 0x36, 0x00, 0x73, 0x00,
  0x1B, 0x00, 0x31, 0x80, 0x19, 0x80, 0x38, 0xC0, 0x0C, 0xC0, 0x18, 0x60,
  0x0C, 0x60, 0x0C, 0x30, 0x06, 0x30, 0x0C, 0x18, 0x07, 0x18, 0x06, 0x0C,
  0x03, 0x0C, 0x07, 0x06, 0x03, 0x86, 0x03, 0x03, 0x01, 0x83, 0x03, 0x81,
  0x80, 0xC1, 0x81, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0xE0,
  0x30, 0x70, 0x30, 0x60, 0x18, 0x30, 0x18, 0x70, 0x0C, 0x38, 0x0C, 0x30,
  0x06, 0x18, 0x06, 0x18, 0x03, 0x0C, 0x03, 0x18, 0x01, 0x8C, 0x01, 0x8C,
  0x00, 0xC6, 0x00, 0xCE, 0x00, 0x67, 0x00, 0x66, 0x00, 0x33, 0x00, 0x33,
  0x00, 0x1B, 0x80, 0x1B, 0x00, 0x0D, 0x80, 0x0D, 0x80, 0x06, 0xC0, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x0C,
  0x00, 0x38, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x70,
  0x00, 0x60, 0x0C, 0x00, 0x0C, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x38,
  0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x06, 0x0C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0C,
  0x03, 0x00, 0x03, 0x80, 0x60, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x70, 0x1C, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06,
  0x38, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0x7F, 0xF8, 0x01, 0xE0, 0x3E, 0x07,
  0x80, 0x0F, 0xFE, 0x80, 0x03, 0xFC,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 13, 46, 14, 1, -46 },
  { 76, 14, 17, 19, 6, -46 },
  { 106, 29, 46, 29, 1, -46 },
  { 273, 26, 53, 26, 1, -49 },
  { 446, 32, 47, 39, 4, -46 },
  { 634, 27, 47, 28, 0, -46 },
  { 793, 6, 17, 10, 6, -46 },
  { 806, 18, 56, 16, 2, -46 },
  { 932, 18, 56, 16, -4, -46 },
  { 1058, 19, 21, 25, 8, -49 },
  { 1108, 24, 29, 29, 3, -37 },
  { 1195, 9, 14, 11, -3, -6 },
  { 1211, 14, 3, 18, 2, -19 },
  { 1217, 4, 5, 12, 1, -5 },
  { 1220, 27, 46, 20, -3, -46 },
  { 1376, 24, 47, 26, 2, -46 },
  { 1517, 13, 46, 26, 8, -46 },
  { 1592, 27, 46, 26, -1, -46 },
  { 1748, 27, 47, 26, -1, -46 },
  { 1907, 27, 46, 26, -1, -46 },
  { 2063, 26, 47, 26, 0, -46 },
  { 2216, 25, 47, 26, 2, -46 },
  { 2363, 24, 46, 26, 4, -46 },
  { 2501, 27, 47, 26, 0, -46 },
  { 2660, 25, 47, 26, 1, -46 },
  { 2807, 10, 34, 12, 1, -34 },
  { 2850, 14, 42, 12, -3, -34 },
  { 2924, 24, 28, 29, 3, -37 },
  { 3008, 24, 15, 29, 3, -30 },
  { 3053, 24, 28, 29, 3, -37 },
  { 3137, 19, 46, 19, 2, -46 },
  { 3247, 36, 52, 40, 2, -46 },
  { 3481, 26, 46, 26, -4, -46 },
  { 3631, 28, 46, 29, 1, -46 },
  { 3792, 28, 47, 27, 3, -46 },
  { 3957, 29, 46, 32, 1, -46 },
  { 4124, 27, 46, 26, 1, -46 },
  { 4280, 27, 46, 24, 1, -46 },
  { 4436, 31, 47, 34, 3, -46 },
  { 4619, 33, 46, 33, 1, -46 },
  { 4809, 21, 46, 14, -3, -46 },
  { 4930, 23, 57, 12, -10, -46 },
  { 5094, 30, 46, 27, 1, -46 },
  { 5267, 17, 46, 23, 1, -46 },
  { 5365, 42, 46, 42, 1, -46 },
  { 5607, 34, 46, 34, 1, -46 },
  { 5803, 30, 47, 34, 3, -46 },
  { 5980, 27, 46, 27, 1, -46 },
  { 6136, 30, 57, 34, 3, -46 },
  { 6350, 27, 46, 27, 1, -46 },
  { 6506, 28, 47, 25, -1, -46 },
  { 6671, 23, 46, 23, 5, -46 },
  { 6804, 31, 47, 33, 3, -46 },
  { 6987, 25, 46, 26, 6, -46 },
  { 7131, 42, 46, 43, 6, -46 },
  { 7373, 32, 46, 24, -4, -46 },
  { 7557, 24, 46, 23, 5, -46 },
  { 7695, 30, 46, 24, -2, -46 },
  { 7868, 23, 56, 18, -1, -46 },
  { 8029, 9, 46, 21, 7, -46 },
  { 8081, 23, 56, 18, -4, -46 },
  { 8242, 25, 24, 28, 2, -46 },
  { 8317, 19, 2, 19, -5, 6 },
  { 8322, 7, 10, 14, 9, -49 },
  { 8331, 25, 36, 28, 2, -35 },
  { 8444, 25, 50, 28, 1, -49 },
  { 8601, 21, 36, 21, 2, -35 },
  { 8696, 28, 50, 28, 2, -49 },
  { 8871, 21, 36, 25, 2, -35 },
  { 8966, 30, 64, 14, -8, -49 },
  { 9206, 27, 50, 28, 0, -35 },
  { 9375, 24, 49, 27, 1, -49 },
  { 9522, 12, 46, 11, 1, -46 },
  { 9591, 22, 61, 12, -9, -46 },
  { 9759, 24, 49, 23, 1, -49 },
  { 9906, 13, 49, 11, 1, -49 },
  { 9986, 38, 35, 41, 1, -35 },
  { 10153, 24, 35, 27, 1, -35 },
  { 10258, 23, 35, 27, 2, -34 },
  { 10359, 28, 49, 28, -2, -34 },
  { 10531, 25, 50, 28, 2, -35 },
  { 10688, 20, 34, 18, 1, -34 },
  { 10773, 21, 36, 21, 0, -35 },
  { 10868, 14, 43, 15, 2, -42 },
  { 10944, 24, 35, 27, 2, -34 },
  { 11049, 20, 34, 21, 4, -34 },
  { 11134, 33, 34, 34, 4, -34 },
  { 11275, 27, 34, 22, -3, -34 },
  { 11390, 32, 50, 22, -7, -34 },
  { 11590, 23, 34, 19, -2, -34 },
  { 11688, 22, 56, 20, 2, -46 },
  { 11842, 2, 64, 26, 12, -49 },
  { 11858, 22, 56, 20, -4, -46 },
  { 12012, 24, 6, 29, 3, -26 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic64pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC64PT7B_H_
