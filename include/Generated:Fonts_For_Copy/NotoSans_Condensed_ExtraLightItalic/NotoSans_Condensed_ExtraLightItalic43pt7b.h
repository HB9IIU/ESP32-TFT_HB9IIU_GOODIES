#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC43PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x04, 0x0C,
  0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0xC0, 0x30, 0xCC, 0x23, 0x18,
  0x86, 0x21, 0x98, 0x46, 0x11, 0x04, 0x43, 0x10, 0x8C, 0x20, 0x00, 0x20,
  0xC0, 0x0C, 0x18, 0x01, 0x82, 0x00, 0x20, 0x40, 0x0C, 0x18, 0x01, 0x82,
  0x00, 0x20, 0x40, 0x04, 0x18, 0x01, 0x83, 0x03, 0xFF, 0xFC, 0xFF, 0xFF,
  0x81, 0x83, 0x00, 0x20, 0x40, 0x04, 0x08, 0x01, 0x83, 0x00, 0x30, 0x40,
  0x04, 0x08, 0x01, 0x83, 0x00, 0x30, 0x60, 0x04, 0x08, 0x0F, 0xFF, 0xF0,
  0x30, 0x60, 0x04, 0x08, 0x00, 0x81, 0x00, 0x30, 0x60, 0x06, 0x08, 0x00,
  0x81, 0x00, 0x30, 0x60, 0x06, 0x08, 0x00, 0x81, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x7F, 0x00,
  0x77, 0xF0, 0x31, 0x04, 0x18, 0x40, 0x04, 0x10, 0x03, 0x0C, 0x00, 0xC2,
  0x00, 0x30, 0x80, 0x0C, 0x20, 0x01, 0x08, 0x00, 0x66, 0x00, 0x0D, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x03, 0x60, 0x00, 0x8C, 0x00,
  0x23, 0x00, 0x08, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0x41, 0x00, 0x10,
  0x40, 0x04, 0x30, 0x83, 0x18, 0x3C, 0xBC, 0x03, 0xFC, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x07, 0xC0, 0x18,
  0x33, 0x00, 0x41, 0x86, 0x03, 0x06, 0x18, 0x08, 0x30, 0x60, 0x60, 0xC1,
  0x83, 0x02, 0x06, 0x08, 0x18, 0x18, 0x60, 0x60, 0x61, 0x01, 0x81, 0x0C,
  0x04, 0x04, 0x20, 0x10, 0x31, 0x80, 0x40, 0xCC, 0x33, 0x02, 0x23, 0xFC,
  0x19, 0x98, 0xD0, 0x44, 0x41, 0x43, 0x33, 0x05, 0x98, 0x88, 0x13, 0xC6,
  0x60, 0x40, 0x31, 0x01, 0x00, 0x84, 0x0C, 0x06, 0x30, 0x30, 0x10, 0xC0,
  0xC0, 0xC3, 0x02, 0x02, 0x0C, 0x08, 0x18, 0x20, 0x60, 0xC0, 0x81, 0x02,
  0x02, 0x0C, 0x18, 0x0C, 0x20, 0x40, 0x31, 0x83, 0x00, 0x7C, 0x00, 0x00,
  0x40, 0x00, 0x7C, 0x00, 0x39, 0x80, 0x18, 0x30, 0x06, 0x0C, 0x03, 0x03,
  0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x08, 0x03, 0x06, 0x00, 0xC1, 0x00,
  0x30, 0xC0, 0x04, 0x60, 0x01, 0xB0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x06, 0xC0, 0x03, 0x18, 0x11, 0x86, 0x0C, 0xC0, 0x82, 0x60, 0x31,
  0x98, 0x0C, 0x64, 0x01, 0xB3, 0x00, 0x6C, 0xC0, 0x0E, 0x30, 0x03, 0x0C,
  0x00, 0xC3, 0x00, 0x78, 0x60, 0x36, 0x1C, 0x38, 0x83, 0xF8, 0x30, 0x33,
  0x32, 0x26, 0x64, 0x44, 0xC0, 0x00, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00,
  0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x06, 0x0C, 0x30, 0x39, 0x00, 0x68, 0xE0, 0xFC,
  0x06, 0x00, 0x48, 0x0C, 0x60, 0xC1, 0x04, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x0C, 0x31, 0x86, 0x10, 0xC2, 0x18, 0x42, 0x00, 0xFF, 0xC0,
  0xFC, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x7C, 0x01, 0xEE, 0x03, 0x83, 0x03, 0x03, 0x06, 0x03, 0x04, 0x01, 0x0C,
  0x01, 0x08, 0x01, 0x18, 0x01, 0x18, 0x01, 0x10, 0x01, 0x30, 0x03, 0x30,
  0x03, 0x20, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x02, 0x60, 0x06, 0x40,
  0x06, 0x40, 0x06, 0x40, 0x04, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x08, 0xC0,
  0x18, 0x40, 0x10, 0x40, 0x30, 0x60, 0x60, 0x60, 0x60, 0x31, 0xC0, 0x1F,
  0x80, 0x01, 0x81, 0xC1, 0xE3, 0xB3, 0x97, 0x09, 0x0C, 0x06, 0x03, 0x01,
  0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x01,
  0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80,
  0x00, 0x7E, 0x00, 0x79, 0xE0, 0x30, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0xFE,
  0x00, 0xF3, 0xC0, 0x60, 0x18, 0x10, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x80, 0x30, 0x30, 0x38, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xB0, 0x00, 0xD0, 0x00, 0xC8, 0x00, 0x4C, 0x00,
  0x66, 0x00, 0x63, 0x00, 0x21, 0x00, 0x30, 0x80, 0x30, 0xC0, 0x10, 0x60,
  0x18, 0x30, 0x18, 0x10, 0x08, 0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x0C, 0x02,
  0x04, 0x01, 0x06, 0x01, 0x86, 0x00, 0xC3, 0xFF, 0xFD, 0xFF, 0xFE, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x07, 0xFC, 0x00, 0x83, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x80, 0x30, 0x30, 0x38, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0xF1, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x63, 0xC0, 0x6F, 0xF0, 0x58, 0x18, 0xF0, 0x08, 0xE0, 0x0C, 0xC0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x0C, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x08,
  0x80, 0x18, 0x80, 0x18, 0x80, 0x30, 0xC0, 0x30, 0xC0, 0x60, 0x61, 0xC0,
  0x3F, 0x80, 0x1F, 0xFF, 0x9F, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x71,
  0xC0, 0x30, 0x18, 0x08, 0x02, 0x06, 0x00, 0xC1, 0x00, 0x30, 0x40, 0x0C,
  0x10, 0x03, 0x04, 0x00, 0x81, 0x80, 0x60, 0x60, 0x10, 0x08, 0x0C, 0x03,
  0x0E, 0x00, 0x66, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x30, 0x03, 0x06,
  0x01, 0x80, 0xC0, 0xC0, 0x10, 0x60, 0x06, 0x10, 0x01, 0x8C, 0x00, 0x63,
  0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x41, 0x80, 0x30, 0x60,
  0x18, 0x0E, 0x0C, 0x01, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0xF7, 0x00, 0xC0,
  0xC0, 0xC0, 0x30, 0x60, 0x18, 0x60, 0x0C, 0x30, 0x02, 0x10, 0x01, 0x18,
  0x00, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x1C,
  0x60, 0x0C, 0x30, 0x0E, 0x0C, 0x0D, 0x07, 0x1D, 0x80, 0xF8, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x04, 0x1C, 0x03, 0xFC, 0x00,
  0x06, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x1C, 0x38, 0x00, 0x01, 0x80, 0xC0,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x81, 0x80, 0xC0, 0x40, 0x60,
  0x30, 0x30, 0x10, 0x08, 0x08, 0x00, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xE0, 0xF3, 0x84, 0x06, 0x00,
  0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x1C, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x18, 0x00, 0x04, 0x08, 0x00, 0x03, 0x0C, 0x00,
  0x01, 0x84, 0x03, 0xE0, 0xC6, 0x07, 0x18, 0x62, 0x06, 0x08, 0x33, 0x02,
  0x0C, 0x19, 0x83, 0x06, 0x0C, 0x83, 0x02, 0x04, 0xC1, 0x01, 0x02, 0x60,
  0x81, 0x81, 0x30, 0xC0, 0xC1, 0x90, 0x60, 0x40, 0x88, 0x20, 0x20, 0x44,
  0x10, 0x30, 0x62, 0x08, 0x18, 0x23, 0x04, 0x14, 0x31, 0x82, 0x0A, 0x10,
  0xC1, 0x99, 0x30, 0x20, 0x78, 0xF0, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x02, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x16, 0x00, 0x0D, 0x80, 0x03,
  0x60, 0x00, 0x98, 0x00, 0x66, 0x00, 0x11, 0x80, 0x0C, 0x60, 0x02, 0x18,
  0x01, 0x86, 0x00, 0x41, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x06, 0x06, 0x01,
  0x80, 0x80, 0xC0, 0x20, 0x3F, 0xF8, 0x08, 0x02, 0x06, 0x00, 0x81, 0x00,
  0x20, 0xC0, 0x08, 0x30, 0x02, 0x18, 0x00, 0x86, 0x00, 0x23, 0x00, 0x0C,
  0xC0, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x3C, 0x00, 0x0C, 0x03, 0xFC, 0x00,
  0xFF, 0xC0, 0x20, 0x18, 0x08, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x60,
  0x04, 0x10, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x08, 0x20, 0x06,
  0x08, 0x03, 0x06, 0x03, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x10, 0x0C, 0x04,
  0x01, 0x83, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x08, 0x00, 0xC2, 0x00,
  0x31, 0x80, 0x0C, 0x60, 0x02, 0x18, 0x01, 0x84, 0x00, 0x43, 0x00, 0x30,
  0xC0, 0x38, 0x3F, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0x3C,
  0x07, 0x00, 0x81, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x30, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x7F, 0xE0, 0x08, 0x0E, 0x03, 0x00, 0xE0, 0x60, 0x0C, 0x0C, 0x00, 0xC1,
  0x80, 0x18, 0x20, 0x03, 0x0C, 0x00, 0x21, 0x80, 0x04, 0x30, 0x00, 0x84,
  0x00, 0x10, 0x80, 0x02, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x10,
  0x00, 0x62, 0x00, 0x08, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x40,
  0x03, 0x18, 0x00, 0x63, 0x00, 0x18, 0x60, 0x03, 0x08, 0x00, 0xC1, 0x00,
  0x30, 0x60, 0x0C, 0x0C, 0x07, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1F, 0xFC, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xC7,
  0xC0, 0x70, 0x06, 0x07, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x04, 0xC0, 0x1F, 0xC6, 0x00, 0x02, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C,
  0x00, 0x0C, 0x60, 0x00, 0x43, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01,
  0x82, 0x00, 0x08, 0x18, 0x00, 0x40, 0xC0, 0x06, 0x03, 0x00, 0x30, 0x0E,
  0x07, 0x80, 0x3F, 0xF8, 0x00, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x20, 0x20,
  0x00, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01,
  0x01, 0x00, 0x04, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x02,
  0x00, 0x08, 0x08, 0x00, 0x20, 0x60, 0x01, 0x81, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x10, 0x00, 0x40, 0x40, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30,
  0x30, 0x00, 0x80, 0x80, 0x02, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60,
  0x01, 0x81, 0x00, 0x04, 0x04, 0x00, 0x10, 0x30, 0x00, 0xC0, 0xC0, 0x03,
  0x03, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x00, 0x01, 0xFC, 0x03, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x0F,
  0xF0, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x1F,
  0x80, 0x08, 0x00, 0x00, 0x03, 0x00, 0x30, 0x30, 0x06, 0x02, 0x00, 0xC0,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x06, 0x06, 0x00, 0x40, 0xC0,
  0x0C, 0x18, 0x00, 0xC3, 0x00, 0x0C, 0x70, 0x00, 0x86, 0x00, 0x08, 0xC0,
  0x01, 0x98, 0x00, 0x1B, 0x80, 0x01, 0xE8, 0x00, 0x14, 0xC0, 0x01, 0x8C,
  0x00, 0x30, 0x40, 0x03, 0x06, 0x00, 0x30, 0x60, 0x02, 0x06, 0x00, 0x60,
  0x30, 0x06, 0x03, 0x00, 0x60, 0x30, 0x04, 0x01, 0x00, 0x40, 0x18, 0x0C,
  0x01, 0x80, 0xC0, 0x08, 0x0C, 0x00, 0xC0, 0x80, 0x0C, 0x00, 0x03, 0x00,
  0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80,
  0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60,
  0x0C, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0A, 0x07, 0x80, 0x01, 0xE0, 0x78,
  0x00, 0x16, 0x04, 0x80, 0x03, 0x60, 0x48, 0x00, 0x24, 0x0C, 0x80, 0x06,
  0x40, 0xC8, 0x00, 0x4C, 0x0C, 0x80, 0x0C, 0xC0, 0x88, 0x00, 0x8C, 0x08,
  0xC0, 0x18, 0x81, 0x8C, 0x01, 0x08, 0x18, 0xC0, 0x31, 0x81, 0x8C, 0x02,
  0x18, 0x10, 0xC0, 0x61, 0x81, 0x0C, 0x04, 0x10, 0x30, 0x40, 0xC3, 0x03,
  0x04, 0x08, 0x30, 0x20, 0x41, 0x83, 0x02, 0x04, 0x10, 0x20, 0x60, 0x43,
  0x02, 0x06, 0x04, 0x20, 0x60, 0x60, 0x66, 0x06, 0x04, 0x06, 0x40, 0x60,
  0x40, 0x6C, 0x04, 0x0C, 0x06, 0x80, 0x40, 0xC0, 0x78, 0x0C, 0x0C, 0x07,
  0x00, 0xC0, 0x80, 0x30, 0x0C, 0x00, 0x03, 0x00, 0x04, 0x0C, 0x00, 0x10,
  0x38, 0x00, 0xC1, 0xE0, 0x03, 0x07, 0x80, 0x0C, 0x1A, 0x00, 0x20, 0x4C,
  0x01, 0x81, 0x30, 0x06, 0x0C, 0xC0, 0x18, 0x31, 0x00, 0x40, 0xC6, 0x01,
  0x02, 0x18, 0x0C, 0x08, 0x60, 0x30, 0x60, 0x80, 0xC1, 0x83, 0x02, 0x06,
  0x0C, 0x08, 0x10, 0x30, 0x60, 0x40, 0x41, 0x83, 0x01, 0x86, 0x0C, 0x06,
  0x10, 0x30, 0x18, 0x40, 0x80, 0x23, 0x06, 0x00, 0xCC, 0x18, 0x03, 0x30,
  0x60, 0x0C, 0x81, 0x00, 0x16, 0x04, 0x00, 0x78, 0x30, 0x01, 0xE0, 0xC0,
  0x07, 0x03, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x00, 0x00, 0x3F, 0x00, 0x0F,
  0x78, 0x01, 0x80, 0xC0, 0x30, 0x06, 0x06, 0x00, 0x60, 0xC0, 0x03, 0x0C,
  0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x32,
  0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x24, 0x00, 0x02,
  0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x04, 0xC0, 0x00,
  0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x0C, 0x00,
  0x30, 0x40, 0x06, 0x06, 0x00, 0xE0, 0x30, 0x1C, 0x03, 0x83, 0x80, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x20, 0x30, 0x18, 0x06, 0x06,
  0x01, 0x81, 0x80, 0x20, 0x60, 0x0C, 0x10, 0x03, 0x0C, 0x00, 0xC3, 0x00,
  0x20, 0xC0, 0x18, 0x20, 0x06, 0x08, 0x01, 0x06, 0x00, 0xC1, 0x80, 0x60,
  0x60, 0x30, 0x10, 0xF8, 0x07, 0xF8, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x0F, 0x78, 0x01, 0x80, 0xC0, 0x30, 0x06, 0x06, 0x00,
  0x60, 0xC0, 0x03, 0x0C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x33, 0x00,
  0x03, 0x30, 0x00, 0x32, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60,
  0x00, 0x24, 0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C,
  0x00, 0x04, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x8C, 0x00, 0x18,
  0xC0, 0x01, 0x0C, 0x00, 0x30, 0x40, 0x06, 0x06, 0x00, 0xE0, 0x30, 0x1C,
  0x03, 0x83, 0x80, 0x1F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x03,
  0xF0, 0x00, 0xFF, 0x80, 0x20, 0x30, 0x18, 0x06, 0x06, 0x01, 0x81, 0x80,
  0x20, 0x60, 0x0C, 0x10, 0x03, 0x0C, 0x00, 0x83, 0x00, 0x20, 0xC0, 0x18,
  0x20, 0x06, 0x08, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x60, 0x60, 0x70, 0x1F,
  0xF0, 0x04, 0x10, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x20, 0x08, 0x08,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x04, 0x01, 0x83,
  0x00, 0x60, 0xC0, 0x18, 0x30, 0x02, 0x08, 0x00, 0xC0, 0x00, 0x3F, 0x80,
  0x1E, 0x7C, 0x06, 0x01, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x08, 0x01, 0x81, 0xC0, 0xE0, 0x1F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x18, 0x20, 0x00, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x04,
  0x00, 0x18, 0x20, 0x00, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03,
  0x04, 0x00, 0x10, 0x20, 0x00, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0,
  0x03, 0x04, 0x00, 0x10, 0x20, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x60,
  0xC0, 0x02, 0x04, 0x00, 0x10, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00,
  0x40, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x01, 0x80, 0x18, 0x06,
  0x01, 0x80, 0x18, 0x38, 0x00, 0x7F, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x66, 0x00, 0x33, 0x00, 0x31, 0x80,
  0x18, 0xC0, 0x08, 0x60, 0x0C, 0x30, 0x04, 0x18, 0x06, 0x0C, 0x02, 0x06,
  0x03, 0x03, 0x01, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x20, 0xC0, 0x10, 0x60,
  0x08, 0x20, 0x04, 0x30, 0x02, 0x10, 0x01, 0x18, 0x00, 0x88, 0x00, 0x4C,
  0x00, 0x24, 0x00, 0x16, 0x00, 0x0B, 0x00, 0x05, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x0E, 0x00,
  0x2C, 0x00, 0xA0, 0x06, 0xC0, 0x0A, 0x00, 0x4C, 0x01, 0xA0, 0x0C, 0xC0,
  0x16, 0x00, 0xCC, 0x03, 0x60, 0x18, 0xC0, 0x36, 0x01, 0x8C, 0x02, 0x60,
  0x10, 0xC0, 0x66, 0x03, 0x0C, 0x04, 0x60, 0x30, 0xC0, 0xC6, 0x06, 0x0C,
  0x08, 0x60, 0x60, 0xC1, 0x86, 0x04, 0x0C, 0x18, 0x60, 0xC0, 0xC1, 0x06,
  0x08, 0x0C, 0x30, 0x61, 0x80, 0xC2, 0x06, 0x18, 0x0C, 0x60, 0x63, 0x00,
  0xC6, 0x06, 0x30, 0x0C, 0x40, 0x62, 0x00, 0xCC, 0x06, 0x60, 0x0C, 0x80,
  0x64, 0x00, 0xD8, 0x06, 0xC0, 0x0D, 0x00, 0x6C, 0x00, 0xF0, 0x06, 0x80,
  0x0F, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xC0,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x20, 0x0C, 0x01, 0x80,
  0x10, 0x0C, 0x00, 0x40, 0x20, 0x01, 0x81, 0x80, 0x06, 0x0C, 0x00, 0x18,
  0x30, 0x00, 0x21, 0x80, 0x00, 0x84, 0x00, 0x03, 0x30, 0x00, 0x0D, 0x80,
  0x00, 0x34, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xA0, 0x00, 0x04, 0x80, 0x00, 0x33, 0x00, 0x01, 0x8C,
  0x00, 0x04, 0x30, 0x00, 0x30, 0x40, 0x01, 0x81, 0x00, 0x04, 0x06, 0x00,
  0x30, 0x18, 0x01, 0x80, 0x60, 0x06, 0x00, 0x80, 0x30, 0x02, 0x01, 0x80,
  0x0C, 0x0E, 0x00, 0x30, 0x00, 0x80, 0x07, 0x80, 0x0B, 0x00, 0x36, 0x00,
  0x4C, 0x01, 0x88, 0x06, 0x10, 0x0C, 0x20, 0x30, 0x60, 0x40, 0xC1, 0x81,
  0x82, 0x03, 0x0C, 0x02, 0x30, 0x04, 0x60, 0x09, 0x80, 0x1A, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0xC0, 0x81, 0x02, 0x04, 0x0C, 0x18, 0x30, 0x20, 0x40, 0x81,
  0x83, 0x06, 0x04, 0x08, 0x10, 0x20, 0x60, 0xC1, 0x81, 0x02, 0x04, 0x0C,
  0x18, 0x30, 0x60, 0x40, 0x81, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x3C, 0x00, 0x12, 0x00, 0x19, 0x80, 0x08, 0xC0, 0x0C,
  0x20, 0x0C, 0x18, 0x06, 0x0C, 0x06, 0x03, 0x02, 0x01, 0x83, 0x00, 0x41,
  0x00, 0x31, 0x80, 0x19, 0x80, 0x04, 0xC0, 0x03, 0xC0, 0x00, 0x80, 0xFF,
  0xF8, 0xC2, 0x18, 0x43, 0x08, 0x20, 0x01, 0xF8, 0x81, 0xCE, 0xC1, 0x81,
  0x61, 0x80, 0xE0, 0x80, 0x30, 0xC0, 0x18, 0x40, 0x0C, 0x60, 0x06, 0x30,
  0x02, 0x30, 0x01, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x62, 0x00, 0x21,
  0x00, 0x30, 0x80, 0x18, 0xC0, 0x0C, 0x20, 0x0E, 0x10, 0x06, 0x0C, 0x05,
  0x06, 0x05, 0x81, 0x86, 0xC0, 0x7C, 0x40, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x7C, 0x0D, 0xCE, 0x0B, 0x03, 0x0A, 0x03, 0x1C,
  0x01, 0x1C, 0x01, 0x18, 0x01, 0x18, 0x01, 0x10, 0x01, 0x30, 0x01, 0x30,
  0x03, 0x30, 0x03, 0x20, 0x03, 0x20, 0x02, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x04, 0x60, 0x0C, 0xE0, 0x08, 0xE0, 0x18, 0xB0, 0x30, 0x98, 0x60, 0x8F,
  0xC0, 0x01, 0xF8, 0x3C, 0xC3, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x38,
  0x40, 0xFE, 0x00, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x03, 0xE2, 0x01, 0xCE, 0xC0, 0x60, 0x58, 0x18, 0x07,
  0x02, 0x00, 0xC0, 0xC0, 0x18, 0x10, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C,
  0x30, 0x01, 0x06, 0x00, 0x20, 0xC0, 0x0C, 0x18, 0x01, 0x82, 0x00, 0x30,
  0x40, 0x0C, 0x08, 0x01, 0x83, 0x00, 0x30, 0x20, 0x0E, 0x04, 0x03, 0x80,
  0xC0, 0x50, 0x18, 0x1A, 0x01, 0x86, 0xC0, 0x1F, 0x18, 0x00, 0x01, 0xF0,
  0x1C, 0xE0, 0xC0, 0x86, 0x03, 0x10, 0x0C, 0xC0, 0x26, 0x01, 0x98, 0x06,
  0x40, 0x33, 0x01, 0x8C, 0x3C, 0x3F, 0xC0, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0xC3,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x40, 0x73,
  0x90, 0x30, 0x2C, 0x18, 0x07, 0x04, 0x01, 0x83, 0x00, 0x60, 0x80, 0x18,
  0x60, 0x06, 0x18, 0x01, 0x8C, 0x00, 0x43, 0x00, 0x30, 0xC0, 0x0C, 0x30,
  0x03, 0x08, 0x00, 0xC2, 0x00, 0x60, 0x80, 0x18, 0x60, 0x0E, 0x08, 0x03,
  0x82, 0x01, 0xC0, 0xC0, 0x50, 0x30, 0x3C, 0x06, 0x1B, 0x01, 0xFC, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x08, 0x08, 0x06, 0x03, 0x07, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x7C, 0x0D, 0xCE, 0x0B,
  0x02, 0x0E, 0x03, 0x1C, 0x03, 0x1C, 0x03, 0x18, 0x02, 0x18, 0x02, 0x10,
  0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x04, 0x20, 0x04, 0x20, 0x0C, 0x60,
  0x0C, 0x60, 0x0C, 0x60, 0x08, 0x40, 0x18, 0x40, 0x18, 0xC0, 0x18, 0xC0,
  0x10, 0x80, 0x10, 0x80, 0x30, 0x03, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30,
  0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0x80, 0x80,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x0E, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x03, 0x0C, 0x06, 0x08, 0x0C, 0x08, 0x18, 0x18, 0x30, 0x18,
  0x60, 0x18, 0x40, 0x10, 0xC0, 0x11, 0x80, 0x33, 0x00, 0x37, 0x00, 0x3D,
  0x00, 0x39, 0x80, 0x31, 0x80, 0x60, 0x80, 0x60, 0xC0, 0x40, 0xC0, 0x40,
  0xC0, 0xC0, 0x40, 0xC0, 0x60, 0xC0, 0x60, 0x80, 0x60, 0x80, 0x20, 0x03,
  0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x08,
  0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60,
  0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x0C, 0xF8, 0x3E, 0x04,
  0xC6, 0x31, 0x82, 0xC1, 0xA0, 0x61, 0xC0, 0xF0, 0x31, 0xC0, 0x70, 0x18,
  0xC0, 0x30, 0x0C, 0x60, 0x18, 0x06, 0x30, 0x0C, 0x03, 0x10, 0x04, 0x01,
  0x18, 0x02, 0x00, 0x8C, 0x03, 0x00, 0xC6, 0x01, 0x80, 0x62, 0x00, 0xC0,
  0x31, 0x00, 0x40, 0x11, 0x80, 0x60, 0x08, 0xC0, 0x30, 0x0C, 0x60, 0x18,
  0x06, 0x20, 0x08, 0x03, 0x30, 0x04, 0x01, 0x18, 0x06, 0x01, 0x8C, 0x03,
  0x00, 0xC4, 0x01, 0x80, 0x62, 0x00, 0x80, 0x20, 0x0C, 0x7C, 0x09, 0xCE,
  0x0B, 0x02, 0x0E, 0x03, 0x1C, 0x03, 0x1C, 0x03, 0x18, 0x02, 0x18, 0x02,
  0x10, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x04, 0x20, 0x04, 0x20, 0x0C,
  0x60, 0x0C, 0x60, 0x0C, 0x60, 0x08, 0x40, 0x18, 0xC0, 0x18, 0xC0, 0x18,
  0xC0, 0x10, 0x80, 0x10, 0x80, 0x30, 0x00, 0xF8, 0x03, 0x9C, 0x06, 0x06,
  0x0C, 0x02, 0x08, 0x03, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03,
  0x60, 0x03, 0x60, 0x03, 0x60, 0x02, 0x60, 0x02, 0x40, 0x06, 0x40, 0x06,
  0xC0, 0x04, 0xC0, 0x0C, 0x40, 0x0C, 0x40, 0x18, 0x60, 0x18, 0x60, 0x30,
  0x30, 0xE0, 0x1F, 0xC0, 0x01, 0x8F, 0x80, 0x27, 0x38, 0x05, 0x81, 0x80,
  0xA0, 0x30, 0x3C, 0x02, 0x07, 0x00, 0x40, 0xC0, 0x08, 0x18, 0x01, 0x03,
  0x00, 0x20, 0xC0, 0x04, 0x18, 0x01, 0x83, 0x00, 0x30, 0x40, 0x06, 0x08,
  0x00, 0x83, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0x81, 0x80, 0x30, 0x30,
  0x04, 0x0E, 0x01, 0x81, 0xE0, 0x60, 0x26, 0x18, 0x04, 0x7E, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x81, 0xCE, 0x41, 0x81, 0xE1, 0x80, 0x70, 0x80, 0x30, 0xC0, 0x18,
  0x40, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x30, 0x01, 0x18, 0x00, 0x8C, 0x00,
  0xC4, 0x00, 0x62, 0x00, 0x31, 0x00, 0x30, 0x80, 0x18, 0xC0, 0x0C, 0x20,
  0x0E, 0x10, 0x0E, 0x0C, 0x05, 0x06, 0x07, 0x81, 0x86, 0xC0, 0x7C, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x0C, 0xF8,
  0x4E, 0x42, 0xC0, 0x14, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x00,
  0x03, 0xF8, 0x38, 0xF0, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xC3, 0x07, 0x0F, 0xF0, 0x00, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x0F,
  0xF7, 0xFC, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x01, 0xF0, 0x0C, 0x01, 0x86, 0x00, 0x82, 0x00, 0xC1, 0x00,
  0x61, 0x80, 0x30, 0xC0, 0x10, 0x60, 0x08, 0x20, 0x0C, 0x30, 0x06, 0x18,
  0x03, 0x0C, 0x01, 0x04, 0x00, 0x82, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x30,
  0xC0, 0x10, 0x40, 0x18, 0x20, 0x0C, 0x30, 0x0E, 0x18, 0x07, 0x04, 0x05,
  0x03, 0x0C, 0x80, 0xFC, 0xC0, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0x90, 0x06,
  0x40, 0x31, 0x00, 0xC4, 0x06, 0x10, 0x18, 0x40, 0x41, 0x03, 0x04, 0x08,
  0x10, 0x60, 0x61, 0x01, 0x8C, 0x06, 0x20, 0x19, 0x80, 0x64, 0x01, 0xB0,
  0x06, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x80, 0x30,
  0x0E, 0x01, 0xC0, 0x28, 0x07, 0x01, 0xA0, 0x1C, 0x04, 0x80, 0xF0, 0x32,
  0x02, 0xC0, 0xC8, 0x1B, 0x02, 0x20, 0x4C, 0x18, 0x83, 0x30, 0x42, 0x08,
  0xC3, 0x08, 0x63, 0x08, 0x21, 0x8C, 0x60, 0x84, 0x31, 0x82, 0x30, 0xC4,
  0x08, 0x83, 0x30, 0x26, 0x0C, 0x80, 0x90, 0x36, 0x02, 0xC0, 0xD8, 0x0B,
  0x03, 0x40, 0x28, 0x0F, 0x00, 0xE0, 0x38, 0x03, 0x00, 0xE0, 0x0C, 0x03,
  0x00, 0x00, 0x06, 0x00, 0xC0, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x01,
  0x06, 0x00, 0x41, 0x00, 0x18, 0xC0, 0x06, 0x60, 0x00, 0x90, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x32, 0x00,
  0x18, 0x80, 0x06, 0x30, 0x03, 0x0C, 0x01, 0x81, 0x00, 0x40, 0x60, 0x30,
  0x18, 0x18, 0x02, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x80, 0x0C,
  0x06, 0x00, 0x30, 0x10, 0x00, 0xC0, 0xC0, 0x01, 0x02, 0x00, 0x04, 0x18,
  0x00, 0x10, 0x40, 0x00, 0x43, 0x00, 0x01, 0x08, 0x00, 0x04, 0x60, 0x00,
  0x11, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x30, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x04, 0x3F, 0xF0, 0x00, 0x00, 0x06, 0x00,
  0x7C, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x03, 0xE0, 0x07, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x01, 0xF0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x78, 0x00, 0xF0, 0x03, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x70, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x3E, 0x01, 0xE7, 0x81,
  0x80, 0xFF, 0x80, 0x3C,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 31, 9, 1, -31 },
  { 32, 10, 11, 12, 4, -31 },
  { 46, 19, 31, 19, 1, -31 },
  { 120, 18, 36, 18, 0, -33 },
  { 201, 22, 32, 26, 2, -31 },
  { 289, 18, 31, 19, 0, -31 },
  { 359, 4, 11, 7, 4, -31 },
  { 365, 12, 38, 11, 1, -31 },
  { 422, 12, 38, 11, -3, -31 },
  { 479, 13, 14, 17, 5, -33 },
  { 502, 16, 20, 20, 2, -25 },
  { 542, 6, 10, 8, -2, -4 },
  { 550, 10, 1, 12, 1, -12 },
  { 552, 2, 3, 8, 1, -3 },
  { 553, 18, 31, 13, -2, -31 },
  { 623, 16, 31, 18, 1, -31 },
  { 685, 9, 31, 18, 5, -31 },
  { 720, 18, 31, 18, -1, -31 },
  { 790, 18, 31, 18, 0, -31 },
  { 860, 17, 31, 18, 0, -31 },
  { 926, 18, 31, 18, 0, -31 },
  { 996, 16, 31, 18, 2, -31 },
  { 1058, 17, 31, 18, 2, -31 },
  { 1124, 18, 31, 18, 0, -31 },
  { 1194, 17, 31, 18, 0, -31 },
  { 1260, 7, 23, 8, 0, -23 },
  { 1281, 9, 29, 8, -2, -23 },
  { 1314, 16, 19, 20, 2, -25 },
  { 1352, 16, 10, 20, 2, -20 },
  { 1372, 16, 19, 20, 2, -25 },
  { 1410, 13, 31, 13, 1, -31 },
  { 1461, 25, 35, 27, 1, -31 },
  { 1571, 18, 31, 17, -3, -31 },
  { 1641, 18, 31, 19, 1, -31 },
  { 1711, 19, 31, 18, 2, -31 },
  { 1785, 19, 31, 21, 1, -31 },
  { 1859, 18, 31, 17, 1, -31 },
  { 1929, 18, 31, 16, 1, -31 },
  { 1999, 21, 31, 23, 2, -31 },
  { 2081, 22, 31, 22, 1, -31 },
  { 2167, 14, 31, 9, -2, -31 },
  { 2222, 15, 39, 8, -6, -31 },
  { 2296, 20, 31, 18, 1, -31 },
  { 2374, 11, 31, 16, 1, -31 },
  { 2417, 28, 31, 29, 1, -31 },
  { 2526, 22, 31, 23, 1, -31 },
  { 2612, 20, 31, 23, 2, -31 },
  { 2690, 18, 31, 18, 1, -31 },
  { 2760, 20, 38, 23, 2, -31 },
  { 2855, 18, 31, 18, 1, -31 },
  { 2925, 19, 31, 17, -1, -31 },
  { 2999, 15, 31, 15, 4, -31 },
  { 3058, 21, 31, 22, 2, -31 },
  { 3140, 17, 31, 18, 4, -31 },
  { 3206, 28, 31, 29, 4, -31 },
  { 3315, 22, 31, 16, -3, -31 },
  { 3401, 15, 31, 15, 4, -31 },
  { 3460, 20, 31, 16, -1, -31 },
  { 3538, 16, 38, 12, -1, -31 },
  { 3614, 7, 31, 14, 4, -31 },
  { 3642, 16, 38, 12, -3, -31 },
  { 3718, 17, 17, 19, 1, -31 },
  { 3755, 13, 1, 13, -3, 4 },
  { 3757, 5, 7, 10, 6, -33 },
  { 3762, 17, 23, 19, 1, -23 },
  { 3811, 16, 33, 19, 1, -33 },
  { 3877, 13, 23, 14, 2, -23 },
  { 3915, 19, 33, 19, 1, -33 },
  { 3994, 14, 23, 17, 2, -23 },
  { 4035, 21, 43, 9, -6, -33 },
  { 4148, 18, 33, 19, 0, -23 },
  { 4223, 16, 33, 18, 1, -33 },
  { 4289, 8, 31, 8, 1, -31 },
  { 4320, 15, 41, 8, -6, -31 },
  { 4397, 16, 33, 15, 1, -33 },
  { 4463, 8, 33, 8, 1, -33 },
  { 4496, 25, 23, 28, 1, -23 },
  { 4568, 16, 23, 18, 1, -23 },
  { 4614, 16, 23, 18, 1, -23 },
  { 4660, 19, 33, 19, -2, -23 },
  { 4739, 17, 33, 19, 1, -23 },
  { 4810, 13, 23, 12, 1, -23 },
  { 4848, 14, 23, 14, 0, -23 },
  { 4889, 10, 28, 10, 1, -28 },
  { 4924, 17, 23, 18, 1, -23 },
  { 4973, 14, 23, 14, 2, -23 },
  { 5014, 22, 23, 23, 3, -23 },
  { 5078, 18, 23, 15, -2, -23 },
  { 5130, 22, 33, 15, -5, -23 },
  { 5221, 15, 23, 13, -1, -23 },
  { 5265, 15, 38, 14, 1, -31 },
  { 5337, 2, 43, 17, 8, -33 },
  { 5348, 15, 38, 14, -3, -31 },
  { 5420, 16, 4, 20, 2, -17 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC43PT7B_H_
