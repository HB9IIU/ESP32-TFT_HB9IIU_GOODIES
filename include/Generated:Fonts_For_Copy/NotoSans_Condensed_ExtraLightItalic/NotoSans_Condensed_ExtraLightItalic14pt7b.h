#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC14PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x94, 0x92, 0x10, 0x6E, 0xD0, 0x14, 0x28, 0x93, 0xD2, 0x85,
  0x3F, 0x28, 0x51, 0x20, 0x08, 0x63, 0x54, 0x50, 0x81, 0x0A, 0x2A, 0xC6,
  0x10, 0x65, 0x4A, 0xA5, 0x4B, 0xFB, 0x4A, 0xA9, 0x53, 0x38, 0x38, 0xA2,
  0x8A, 0x31, 0x49, 0x66, 0x8B, 0xE0, 0x5A, 0x12, 0x24, 0x48, 0x88, 0x88,
  0x84, 0x11, 0x11, 0x11, 0x11, 0x22, 0x48, 0x2C, 0x7A, 0xA0, 0x21, 0x09,
  0xF2, 0x10, 0x58, 0xE0, 0x80, 0x04, 0x10, 0x82, 0x10, 0x42, 0x10, 0x42,
  0x00, 0x18, 0x94, 0x51, 0x46, 0x28, 0xA2, 0x91, 0xC0, 0x75, 0x24, 0xA4,
  0x90, 0x38, 0x10, 0x42, 0x08, 0x42, 0x10, 0x43, 0xC0, 0x38, 0x10, 0x42,
  0x30, 0x20, 0x82, 0x0B, 0xC0, 0x04, 0x21, 0x8A, 0x29, 0x29, 0x3E, 0x10,
  0x40, 0x3C, 0x84, 0x10, 0x70, 0x20, 0x82, 0x0B, 0xC0, 0x1C, 0x84, 0x10,
  0x79, 0x28, 0xA2, 0x89, 0xC0, 0xF8, 0x44, 0x22, 0x11, 0x08, 0x84, 0x00,
  0x39, 0x14, 0x4A, 0x31, 0x48, 0xA2, 0x89, 0xC0, 0x39, 0x14, 0x51, 0x49,
  0xE0, 0x82, 0x13, 0x80, 0x40, 0x08, 0x20, 0x00, 0x12, 0x80, 0x09, 0xB1,
  0x83, 0x04, 0xF8, 0x01, 0xF0, 0x83, 0x06, 0x26, 0x40, 0x70, 0x42, 0x22,
  0x21, 0x08, 0x04, 0x00, 0x1E, 0x21, 0x21, 0x4F, 0x55, 0xA5, 0xA5, 0xAD,
  0x92, 0x40, 0x7C, 0x08, 0x21, 0x45, 0x24, 0xF2, 0x51, 0x46, 0x10, 0x3C,
  0x92, 0x51, 0x79, 0x24, 0x51, 0x8B, 0xC0, 0x3D, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x83, 0xC0, 0x3C, 0x44, 0x8A, 0x14, 0x28, 0x51, 0x22, 0x89, 0xE0,
  0x3C, 0x82, 0x10, 0x79, 0x04, 0x10, 0x83, 0xC0, 0x3C, 0x82, 0x10, 0x41,
  0xE4, 0x10, 0x82, 0x00, 0x3E, 0x82, 0x04, 0x08, 0x13, 0xA1, 0x44, 0x88,
  0xF0, 0x22, 0x44, 0x8A, 0x17, 0xE8, 0x91, 0x22, 0x85, 0x08, 0x18, 0x84,
  0x42, 0x10, 0x84, 0x47, 0x00, 0x08, 0x42, 0x21, 0x08, 0x42, 0x21, 0x09,
  0xC0, 0x22, 0x48, 0xA2, 0x86, 0x0A, 0x14, 0x28, 0x89, 0x10, 0x22, 0x24,
  0x44, 0x44, 0x8F, 0x20, 0x90, 0x48, 0x6A, 0x35, 0x2A, 0x99, 0x55, 0x2A,
  0x99, 0x48, 0x80, 0x21, 0x21, 0x32, 0x52, 0x52, 0x4A, 0x4C, 0x8C, 0x84,
  0x84, 0x39, 0x18, 0x61, 0x86, 0x18, 0x62, 0x8B, 0xC0, 0x38, 0x92, 0x51,
  0x45, 0xE4, 0x10, 0x82, 0x00, 0x39, 0x18, 0x61, 0x86, 0x18, 0x62, 0x8B,
  0x42, 0x04, 0x38, 0x92, 0x51, 0x49, 0xC5, 0x14, 0x8A, 0x20, 0x3D, 0x04,
  0x10, 0x20, 0x40, 0x82, 0x0B, 0xC0, 0xF9, 0x08, 0x84, 0x21, 0x08, 0x84,
  0x00, 0x45, 0x18, 0x61, 0x86, 0x28, 0xA2, 0x8B, 0xC0, 0x86, 0x28, 0xA4,
  0x92, 0x4A, 0x28, 0x41, 0x00, 0x88, 0xC4, 0x66, 0x33, 0x29, 0x95, 0x52,
  0xA9, 0x94, 0xC4, 0x42, 0x00, 0x22, 0x28, 0x50, 0xC1, 0x02, 0x0A, 0x14,
  0x49, 0x10, 0x8C, 0x64, 0xC6, 0x21, 0x08, 0x84, 0x00, 0x3C, 0x20, 0x84,
  0x10, 0x84, 0x10, 0x83, 0xC0, 0x39, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21,
  0x80, 0xA5, 0x55, 0x50, 0x18, 0x42, 0x11, 0x08, 0x42, 0x11, 0x09, 0xC0,
  0x10, 0xA2, 0x92, 0xC4, 0xF0, 0xA4, 0x10, 0xB4, 0x51, 0x8A, 0x28, 0x9C,
  0x20, 0x82, 0x0E, 0x25, 0x14, 0x51, 0x8A, 0x2F, 0x00, 0x19, 0x10, 0x88,
  0x42, 0x0E, 0x02, 0x04, 0x10, 0xE2, 0x48, 0x91, 0x44, 0x89, 0x11, 0xC0,
  0x11, 0x52, 0xBA, 0x42, 0x0E, 0x06, 0x10, 0x20, 0x61, 0x02, 0x04, 0x08,
  0x10, 0x40, 0x81, 0x02, 0x18, 0x00, 0x18, 0x94, 0x51, 0x8A, 0x28, 0x9C,
  0x08, 0x4F, 0x00, 0x21, 0x08, 0x72, 0xA5, 0x29, 0x8C, 0x62, 0x20, 0x24,
  0x94, 0x90, 0x08, 0x00, 0x21, 0x08, 0x42, 0x21, 0x08, 0x4C, 0x00, 0x21,
  0x08, 0x44, 0xA9, 0x8C, 0x94, 0xA4, 0x24, 0x94, 0x92, 0x92, 0x00, 0x1B,
  0x12, 0x52, 0x29, 0x24, 0x94, 0x4A, 0x25, 0x22, 0x19, 0x52, 0x94, 0xC6,
  0x31, 0x11, 0x52, 0x98, 0xC6, 0x2E, 0x18, 0x94, 0x51, 0x46, 0x28, 0xBC,
  0x82, 0x08, 0x00, 0x18, 0x94, 0x51, 0x8A, 0x28, 0x9E, 0x08, 0x41, 0x00,
  0x19, 0x10, 0x84, 0x42, 0x10, 0x3A, 0x10, 0x82, 0x08, 0x5C, 0x27, 0x44,
  0x44, 0x88, 0xC0, 0x45, 0x14, 0x92, 0x8A, 0x27, 0x00, 0x99, 0xAA, 0xC8,
  0x80, 0x93, 0x6A, 0xD6, 0xAD, 0x93, 0x24, 0x00, 0x24, 0xA1, 0x04, 0x31,
  0x2C, 0x80, 0x12, 0x24, 0x50, 0xA1, 0x83, 0x04, 0x08, 0x21, 0xC0, 0x78,
  0x88, 0x84, 0x43, 0x80, 0x18, 0x88, 0x42, 0x13, 0x08, 0x42, 0x10, 0xC0,
  0xFF, 0xFC, 0x10, 0x42, 0x21, 0x08, 0x62, 0x21, 0x09, 0x80, 0xCD, 0x80,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 10, 3, 0, -10 },
  { 5, 3, 4, 4, 1, -10 },
  { 7, 7, 10, 6, 0, -10 },
  { 16, 6, 12, 6, 0, -11 },
  { 25, 7, 10, 9, 1, -10 },
  { 34, 6, 10, 6, 0, -10 },
  { 42, 2, 4, 2, 1, -10 },
  { 43, 4, 12, 3, 0, -10 },
  { 49, 4, 12, 3, -1, -10 },
  { 55, 4, 5, 5, 2, -11 },
  { 58, 5, 6, 6, 1, -8 },
  { 62, 2, 3, 2, -1, -1 },
  { 63, 3, 1, 4, 0, -4 },
  { 64, 1, 1, 3, 0, -1 },
  { 65, 6, 10, 4, -1, -10 },
  { 73, 6, 10, 6, 0, -10 },
  { 81, 3, 10, 6, 2, -10 },
  { 85, 6, 10, 6, 0, -10 },
  { 93, 6, 10, 6, 0, -10 },
  { 101, 6, 10, 6, 0, -10 },
  { 109, 6, 10, 6, 0, -10 },
  { 117, 6, 10, 6, 0, -10 },
  { 125, 5, 10, 6, 1, -10 },
  { 132, 6, 10, 6, 0, -10 },
  { 140, 6, 10, 6, 0, -10 },
  { 148, 2, 7, 3, 0, -7 },
  { 150, 3, 9, 3, -1, -7 },
  { 154, 5, 6, 6, 1, -8 },
  { 158, 5, 4, 6, 1, -7 },
  { 161, 5, 6, 6, 1, -8 },
  { 165, 5, 10, 4, 0, -10 },
  { 172, 8, 11, 9, 0, -10 },
  { 183, 6, 10, 6, -1, -10 },
  { 191, 6, 10, 6, 0, -10 },
  { 199, 6, 10, 6, 1, -10 },
  { 207, 7, 10, 7, 0, -10 },
  { 216, 6, 10, 6, 0, -10 },
  { 224, 6, 10, 5, 0, -10 },
  { 232, 7, 10, 7, 1, -10 },
  { 241, 7, 10, 7, 0, -10 },
  { 250, 5, 10, 3, -1, -10 },
  { 257, 5, 12, 3, -2, -10 },
  { 265, 7, 10, 6, 0, -10 },
  { 274, 4, 10, 5, 0, -10 },
  { 279, 9, 10, 9, 0, -10 },
  { 291, 8, 10, 7, 0, -10 },
  { 301, 6, 10, 7, 1, -10 },
  { 309, 6, 10, 6, 0, -10 },
  { 317, 6, 12, 7, 1, -10 },
  { 326, 6, 10, 6, 0, -10 },
  { 334, 6, 10, 6, 0, -10 },
  { 342, 5, 10, 5, 1, -10 },
  { 349, 6, 10, 7, 1, -10 },
  { 357, 6, 10, 6, 1, -10 },
  { 365, 9, 10, 9, 1, -10 },
  { 377, 7, 10, 5, -1, -10 },
  { 386, 5, 10, 5, 1, -10 },
  { 393, 6, 10, 5, 0, -10 },
  { 401, 5, 12, 4, 0, -10 },
  { 409, 2, 10, 5, 1, -10 },
  { 412, 5, 12, 4, -1, -10 },
  { 420, 6, 5, 6, 0, -10 },
  { 424, 4, 1, 4, -1, 1 },
  { 425, 2, 3, 3, 2, -11 },
  { 426, 6, 8, 6, 0, -8 },
  { 432, 6, 11, 6, 0, -11 },
  { 441, 5, 8, 5, 0, -8 },
  { 446, 7, 11, 6, 0, -11 },
  { 456, 5, 8, 5, 0, -8 },
  { 461, 7, 14, 3, -2, -11 },
  { 474, 6, 11, 6, 0, -8 },
  { 483, 5, 11, 6, 0, -11 },
  { 490, 3, 10, 3, 0, -10 },
  { 494, 5, 13, 3, -2, -10 },
  { 503, 5, 11, 5, 0, -11 },
  { 510, 3, 11, 2, 0, -11 },
  { 515, 9, 8, 9, 0, -8 },
  { 524, 5, 8, 6, 0, -8 },
  { 529, 5, 8, 6, 0, -8 },
  { 534, 6, 11, 6, 0, -8 },
  { 543, 6, 11, 6, 0, -8 },
  { 552, 5, 8, 4, 0, -8 },
  { 557, 5, 8, 5, 0, -8 },
  { 562, 4, 9, 3, 0, -9 },
  { 567, 6, 7, 6, 0, -7 },
  { 573, 4, 7, 5, 1, -7 },
  { 577, 7, 7, 7, 1, -7 },
  { 584, 6, 7, 5, -1, -7 },
  { 590, 7, 10, 5, -2, -7 },
  { 599, 5, 7, 4, 0, -7 },
  { 604, 5, 12, 4, 0, -10 },
  { 612, 1, 14, 6, 2, -11 },
  { 614, 5, 12, 4, -1, -10 },
  { 622, 5, 2, 6, 1, -6 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC14PT7B_H_
