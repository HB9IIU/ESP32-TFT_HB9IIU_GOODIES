#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC66PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x00,
  0x18, 0x1C, 0xE0, 0x73, 0x81, 0x8E, 0x06, 0x30, 0x38, 0xC0, 0xE3, 0x03,
  0x1C, 0x0C, 0x60, 0x31, 0x81, 0xC6, 0x06, 0x18, 0x18, 0xC0, 0x63, 0x01,
  0x8C, 0x04, 0x30, 0x30, 0x80, 0xC0, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x70, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x06, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x06, 0x01, 0x80, 0x00, 0x38, 0x06, 0x00,
  0x00, 0xC0, 0x38, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0E, 0x01, 0x80, 0x0F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x60, 0x1C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0xF8, 0xC1, 0xC0, 0x38, 0x30, 0x10,
  0x1C, 0x0C, 0x00, 0x0E, 0x02, 0x00, 0x03, 0x81, 0x80, 0x00, 0xC0, 0x60,
  0x00, 0x30, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x03, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x0E, 0x60, 0x00, 0x03, 0xD8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0x87, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x18, 0x38, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x70,
  0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x60, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x06, 0x06, 0x02, 0x01,
  0x87, 0x80, 0xF0, 0x67, 0xC0, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0x00, 0xF7, 0x80, 0x03, 0x00,
  0xE0, 0xC0, 0x03, 0x80, 0xE0, 0x60, 0x01, 0x80, 0x60, 0x38, 0x01, 0xC0,
  0x70, 0x1C, 0x00, 0xC0, 0x30, 0x0E, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x18, 0x03, 0x80, 0x60, 0x0C, 0x01, 0xC0, 0x70, 0x0E, 0x00, 0xC0, 0x30,
  0x06, 0x00, 0x60, 0x38, 0x03, 0x00, 0x30, 0x18, 0x01, 0x80, 0x18, 0x18,
  0x01, 0xC0, 0x1C, 0x1C, 0x00, 0xE0, 0x0E, 0x0C, 0x00, 0x60, 0x06, 0x0E,
  0x00, 0x30, 0x03, 0x06, 0x00, 0x18, 0x03, 0x87, 0x03, 0x8C, 0x01, 0xC3,
  0x0F, 0xF6, 0x00, 0xC3, 0x0F, 0x3B, 0x00, 0xE3, 0x8E, 0x0F, 0x80, 0x61,
  0x86, 0x03, 0xC0, 0x71, 0xC7, 0x01, 0xF0, 0x30, 0xC3, 0x00, 0xF8, 0x38,
  0xE3, 0x80, 0x6E, 0x78, 0x61, 0x80, 0x33, 0xF8, 0x61, 0xC0, 0x18, 0x60,
  0x70, 0xE0, 0x0C, 0x00, 0x30, 0x60, 0x06, 0x00, 0x38, 0x30, 0x03, 0x00,
  0x18, 0x38, 0x03, 0x80, 0x1C, 0x1C, 0x01, 0xC0, 0x0C, 0x0C, 0x00, 0xC0,
  0x0C, 0x06, 0x00, 0x60, 0x0E, 0x03, 0x00, 0x30, 0x06, 0x01, 0x80, 0x38,
  0x07, 0x01, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x38, 0x06, 0x01, 0xC0, 0x1C, 0x07, 0x01, 0xC0, 0x0E, 0x03,
  0x00, 0xC0, 0x03, 0x03, 0x80, 0xE0, 0x01, 0xC3, 0x80, 0x60, 0x00, 0xF7,
  0x80, 0x70, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x1C, 0x07, 0x00, 0x01, 0x80, 0x30, 0x00, 0x38, 0x03, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x07, 0x00, 0x30, 0x00, 0x70, 0x07,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x70, 0x06, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x70, 0x0C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x03, 0x07,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x1E, 0x70, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x78, 0x30, 0x07,
  0x0F, 0x03, 0x80, 0x60, 0xE0, 0x18, 0x06, 0x1C, 0x01, 0xC0, 0xE3, 0x80,
  0x1C, 0x0C, 0x38, 0x00, 0xC1, 0xC7, 0x00, 0x0E, 0x18, 0x70, 0x00, 0x63,
  0x86, 0x00, 0x07, 0x30, 0x60, 0x00, 0x77, 0x0E, 0x00, 0x03, 0x60, 0xE0,
  0x00, 0x3E, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x03,
  0xC0, 0x60, 0x00, 0x6C, 0x07, 0x00, 0x0E, 0xE0, 0x70, 0x01, 0xC6, 0x03,
  0xC0, 0x78, 0x70, 0x1F, 0xFE, 0x07, 0x00, 0xFF, 0xC0, 0x38, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x63, 0x8E, 0x30, 0xC3, 0x1C, 0x61, 0x86, 0x18, 0xC3,
  0x0C, 0x30, 0x80, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x0C, 0x02, 0x00, 0xE0, 0x60, 0x07, 0x86, 0x00,
  0x1E, 0x60, 0x10, 0x76, 0x3F, 0x01, 0xFF, 0xF0, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x33, 0x00, 0x0E, 0x30, 0x01, 0xC1, 0x80, 0x38, 0x18, 0x07, 0x00,
  0xC0, 0x60, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x03, 0x81,
  0xC0, 0xE0, 0xE0, 0x70, 0x30, 0x38, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03,
  0x03, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0x81, 0xC0, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x0C, 0x03, 0x80, 0x06, 0x01, 0x80, 0x03, 0x01,
  0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x38,
  0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x18, 0x00, 0x06, 0x1C, 0x00, 0x03,
  0x0E, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x71, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x0C, 0x70, 0x00,
  0x06, 0x38, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x8C, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0,
  0x00, 0x18, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x06, 0x0E,
  0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0,
  0xE0, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x03, 0x00, 0xF0, 0x01, 0xC0, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xF0, 0x0F, 0x80, 0x76,
  0x07, 0x98, 0x3C, 0xE1, 0xC3, 0x9E, 0x0C, 0xF0, 0x31, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x3E, 0x01, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x40, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xC0, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x04, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x80, 0x00, 0xE0, 0x0E,
  0x00, 0x3C, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x1C, 0x18, 0x00, 0x01, 0x83, 0x80, 0x00, 0x30, 0x30, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x07, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x70, 0x06, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x0C,
  0x00, 0x18, 0x01, 0xC0, 0x01, 0x80, 0x38, 0x00, 0x38, 0x03, 0x00, 0x03,
  0x80, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0x03, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x40, 0x00, 0xE0, 0x0E, 0x00, 0x78, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x7E,
  0x00, 0x18, 0x7F, 0xE0, 0x06, 0x7C, 0x7C, 0x03, 0xB8, 0x07, 0x80, 0xDC,
  0x00, 0xE0, 0x36, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x00, 0xC1,
  0xE0, 0x00, 0x30, 0x70, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x06, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x38, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x0E, 0x0E,
  0x00, 0x03, 0x81, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x70, 0x18, 0x00, 0x18,
  0x07, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x07, 0x01,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0,
  0x38, 0x00, 0x38, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x38, 0x00,
  0x0C, 0x07, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x30, 0x1C, 0x00, 0x0E, 0x03,
  0x80, 0x01, 0xC0, 0x70, 0x00, 0x30, 0x06, 0x00, 0x0E, 0x00, 0xC0, 0x03,
  0x80, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x3C, 0x00, 0x38, 0x0F, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x39, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x03, 0xC0,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x38, 0x06, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x60, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x18, 0x30, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x0C, 0x38,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0x3C,
  0x03, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0x01, 0xC0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x18, 0x07, 0x00, 0x0E, 0x07,
  0x00, 0x07, 0x03, 0x80, 0x01, 0x83, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0x30, 0x00,
  0x1C, 0x18, 0x00, 0x1E, 0x0E, 0x00, 0x1B, 0x03, 0x80, 0x1F, 0x81, 0xE0,
  0x1D, 0x80, 0x7C, 0xFC, 0xC0, 0x1F, 0xF8, 0x60, 0x03, 0xE0, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x04, 0x03, 0xC0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC0, 0x60,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x38, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x3F, 0x00, 0x60, 0x60, 0x03,
  0xFF, 0x01, 0xC3, 0x80, 0x1E, 0x1C, 0x07, 0x0C, 0x00, 0xE0, 0x70, 0x1C,
  0x30, 0x07, 0x01, 0x80, 0x61, 0xC0, 0x38, 0x06, 0x01, 0x86, 0x00, 0xC0,
  0x18, 0x06, 0x18, 0x06, 0x00, 0xE0, 0x18, 0xE0, 0x38, 0x03, 0x00, 0x63,
  0x00, 0xC0, 0x0C, 0x01, 0x8C, 0x03, 0x00, 0x30, 0x0E, 0x30, 0x1C, 0x01,
  0xC0, 0x31, 0xC0, 0x60, 0x06, 0x00, 0xC6, 0x01, 0x80, 0x18, 0x03, 0x18,
  0x0E, 0x00, 0xE0, 0x1C, 0x60, 0x38, 0x03, 0x80, 0x61, 0x80, 0xC0, 0x0C,
  0x01, 0x86, 0x03, 0x00, 0x70, 0x0E, 0x38, 0x0C, 0x01, 0xC0, 0x30, 0xE0,
  0x30, 0x07, 0x00, 0xC3, 0x80, 0xC0, 0x3C, 0x06, 0x0C, 0x03, 0x00, 0xB0,
  0x38, 0x30, 0x0E, 0x06, 0xC0, 0xC0, 0xC0, 0x38, 0x33, 0x06, 0x03, 0x80,
  0x7B, 0x87, 0xF0, 0x0E, 0x00, 0xFC, 0x1F, 0x80, 0x38, 0x00, 0xC0, 0x08,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x10, 0x00,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0E,
  0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0C, 0x18, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x60, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x01,
  0x80, 0x00, 0xE0, 0x30, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0xE0, 0x18, 0x00, 0x18, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x70,
  0x0E, 0x00, 0x0E, 0x01, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x18, 0x0C, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x30, 0xE0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x18, 0xE0, 0x00, 0x03, 0x38, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x1C, 0x03, 0xF0, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0F,
  0x00, 0x30, 0x00, 0x38, 0x01, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x60, 0x1C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x38, 0x06, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0xE0, 0x06, 0x00, 0x0E, 0x00, 0x30, 0x01, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xE0, 0x7F, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x38, 0x06, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x06, 0x03, 0x80, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x1C, 0x06, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1E, 0x03, 0x80,
  0x01, 0xE0, 0x1C, 0x00, 0x1E, 0x00, 0xC0, 0x01, 0xE0, 0x06, 0x01, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0x00, 0x60,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x10, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0x70,
  0x00, 0xF0, 0x01, 0x80, 0x01, 0xC0, 0x06, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x18, 0x03, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x03, 0x80, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0x30, 0x38, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xE0, 0x07, 0x00, 0x0F, 0x00,
  0x18, 0x00, 0xF8, 0x00, 0x60, 0x7F, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x0F,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x3F, 0xF8, 0x60, 0x00, 0x3F, 0xF0, 0x60, 0x00, 0x7F, 0xF0, 0x60, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x01, 0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00,
  0x70, 0x03, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0C,
  0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x1C, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x38,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x70, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x06, 0x00,
  0x00, 0x38, 0x01, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x70, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x03, 0x00, 0x78, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x03, 0x83, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x18, 0x70, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x01, 0xDF, 0x80, 0x00, 0x03, 0xB7, 0x00, 0x00, 0x06, 0xC6, 0x00, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x01, 0x80, 0x70, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x30, 0x03, 0x80, 0x00, 0x60,
  0x03, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x70, 0x01, 0x80, 0x00, 0xE0, 0x03, 0x00, 0x01,
  0xC0, 0x06, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x06, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0xD8, 0x00, 0x00, 0x0D, 0x80, 0x1B, 0x00, 0x00,
  0x03, 0xB0, 0x07, 0x60, 0x00, 0x00, 0x6E, 0x00, 0xEC, 0x00, 0x00, 0x1D,
  0xC0, 0x19, 0x80, 0x00, 0x03, 0x30, 0x03, 0x30, 0x00, 0x00, 0xE6, 0x00,
  0x67, 0x00, 0x00, 0x19, 0xC0, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x03, 0x9C,
  0x00, 0x00, 0xC7, 0x00, 0x63, 0x80, 0x00, 0x38, 0xC0, 0x0C, 0x30, 0x00,
  0x06, 0x18, 0x03, 0x86, 0x00, 0x01, 0xC7, 0x00, 0x70, 0xC0, 0x00, 0x30,
  0xE0, 0x0E, 0x18, 0x00, 0x0E, 0x1C, 0x01, 0x83, 0x00, 0x01, 0x83, 0x00,
  0x30, 0x60, 0x00, 0x70, 0x60, 0x0E, 0x0C, 0x00, 0x0C, 0x1C, 0x01, 0xC1,
  0xC0, 0x03, 0x83, 0x80, 0x30, 0x38, 0x00, 0x60, 0x60, 0x06, 0x07, 0x00,
  0x1C, 0x0C, 0x00, 0xC0, 0xE0, 0x03, 0x01, 0x80, 0x38, 0x0C, 0x00, 0xE0,
  0x70, 0x07, 0x01, 0x80, 0x38, 0x0E, 0x00, 0xC0, 0x30, 0x07, 0x01, 0x80,
  0x18, 0x06, 0x01, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x00, 0xE0,
  0x18, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60,
  0x70, 0x06, 0x00, 0x60, 0x0E, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC3, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x60, 0x07, 0x00, 0x60, 0x07, 0x1C, 0x00, 0xC0,
  0x0C, 0x00, 0x63, 0x00, 0x18, 0x01, 0x80, 0x0C, 0xE0, 0x03, 0x00, 0x70,
  0x01, 0x98, 0x00, 0xE0, 0x0E, 0x00, 0x37, 0x00, 0x1C, 0x01, 0x80, 0x06,
  0xC0, 0x03, 0x00, 0x30, 0x00, 0xF8, 0x00, 0x60, 0x06, 0x00, 0x1E, 0x00,
  0x1C, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xE0,
  0x00, 0x03, 0x00, 0x3E, 0x00, 0x00, 0x60, 0x06, 0xC0, 0x00, 0x1C, 0x00,
  0xD8, 0x00, 0x03, 0x80, 0x1B, 0x00, 0x00, 0x70, 0x07, 0x70, 0x00, 0x0C,
  0x00, 0xE6, 0x00, 0x01, 0x80, 0x18, 0xC0, 0x00, 0x70, 0x03, 0x18, 0x00,
  0x0E, 0x00, 0x63, 0x80, 0x01, 0x80, 0x1C, 0x30, 0x00, 0x30, 0x03, 0x86,
  0x00, 0x06, 0x00, 0x60, 0xE0, 0x01, 0xC0, 0x0C, 0x1C, 0x00, 0x38, 0x03,
  0x81, 0x80, 0x06, 0x00, 0x70, 0x30, 0x00, 0xC0, 0x0E, 0x07, 0x00, 0x38,
  0x01, 0x80, 0xE0, 0x07, 0x00, 0x30, 0x0C, 0x00, 0xE0, 0x0E, 0x01, 0x80,
  0x18, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x06, 0x00,
  0x60, 0x1C, 0x00, 0xC0, 0x0C, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x60, 0x07,
  0x00, 0x38, 0x0C, 0x00, 0xC0, 0x03, 0x03, 0x80, 0x18, 0x00, 0x60, 0x70,
  0x03, 0x00, 0x0E, 0x0C, 0x00, 0xE0, 0x01, 0xC1, 0x80, 0x1C, 0x00, 0x18,
  0x30, 0x03, 0x00, 0x03, 0x0E, 0x00, 0x60, 0x00, 0x71, 0xC0, 0x1C, 0x00,
  0x0E, 0x30, 0x03, 0x80, 0x00, 0xC6, 0x00, 0x70, 0x00, 0x19, 0xC0, 0x0C,
  0x00, 0x03, 0xB8, 0x01, 0x80, 0x00, 0x77, 0x00, 0x70, 0x00, 0x06, 0xC0,
  0x0E, 0x00, 0x00, 0xD8, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x30, 0x00, 0x03,
  0xE0, 0x06, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x06, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x30, 0x38, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x18, 0xE0, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x06, 0x38,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x78, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x03, 0xE0, 0x3E,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x70, 0x1F, 0x80,
  0x07, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0xE0, 0x0E, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x60, 0x0E, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x60, 0x1C,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0xE0, 0x38, 0x00, 0x0C, 0x03, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x18, 0x03,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x03,
  0xC0, 0x06, 0x01, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xF0,
  0x07, 0x80, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x18, 0x0E, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x01, 0x80, 0x70, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x78, 0x01, 0xC0, 0x01, 0xE0,
  0x01, 0xC0, 0x07, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xC0, 0x7E, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x38, 0x07,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x60, 0x1C, 0x00, 0x0C, 0x03, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x30, 0x1C, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0x60,
  0x00, 0x38, 0x0C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x38,
  0x0E, 0x00, 0x07, 0x01, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x70, 0x0E, 0x00,
  0x1E, 0x01, 0xC0, 0x07, 0x80, 0x38, 0x07, 0xE0, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xC0, 0x18,
  0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x1C,
  0x01, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x01, 0x80,
  0x03, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xC0,
  0x30, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x7C, 0x00, 0xE0, 0x03, 0x80, 0x01, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x08, 0x00, 0x0F, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x18,
  0x07, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x38,
  0x06, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x01, 0x80,
  0x70, 0x00, 0x01, 0x80, 0x70, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x03, 0x80, 0x60, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0xF0, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0x38, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0C, 0x38, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00,
  0x1C, 0x0E, 0x00, 0x07, 0x01, 0x80, 0x03, 0x80, 0x60, 0x00, 0xE0, 0x18,
  0x00, 0x30, 0x06, 0x00, 0x1C, 0x01, 0x80, 0x06, 0x00, 0x60, 0x03, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x01, 0x80, 0x18, 0x00, 0x60, 0x0E,
  0x00, 0x18, 0x03, 0x80, 0x06, 0x01, 0xC0, 0x01, 0x80, 0x70, 0x00, 0x60,
  0x18, 0x00, 0x18, 0x0E, 0x00, 0x06, 0x03, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x70, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x71, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xEE, 0x00,
  0x01, 0xE0, 0x00, 0x19, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x38, 0x00, 0x0D,
  0x80, 0x00, 0xE7, 0x00, 0x01, 0xB0, 0x00, 0x18, 0xE0, 0x00, 0x66, 0x00,
  0x07, 0x1C, 0x00, 0x0C, 0xC0, 0x00, 0xC3, 0x80, 0x03, 0x98, 0x00, 0x38,
  0x70, 0x00, 0x63, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x60, 0x00, 0xC1, 0xC0,
  0x03, 0x0C, 0x00, 0x38, 0x38, 0x00, 0x61, 0x80, 0x06, 0x07, 0x00, 0x1C,
  0x30, 0x01, 0xC0, 0xE0, 0x03, 0x06, 0x00, 0x30, 0x1C, 0x00, 0xE0, 0xC0,
  0x0E, 0x03, 0x80, 0x18, 0x18, 0x01, 0xC0, 0x70, 0x03, 0x03, 0x00, 0x30,
  0x0E, 0x00, 0xE0, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0x38,
  0x07, 0x01, 0x80, 0x70, 0x07, 0x00, 0xC0, 0x30, 0x0E, 0x00, 0xE0, 0x38,
  0x06, 0x01, 0x80, 0x1C, 0x06, 0x00, 0xC0, 0x70, 0x03, 0x80, 0xC0, 0x18,
  0x0C, 0x00, 0x70, 0x38, 0x03, 0x03, 0x80, 0x0E, 0x06, 0x00, 0x60, 0x60,
  0x01, 0xC1, 0xC0, 0x0C, 0x1C, 0x00, 0x38, 0x30, 0x01, 0x83, 0x80, 0x07,
  0x06, 0x00, 0x30, 0x60, 0x00, 0xE1, 0xC0, 0x06, 0x1C, 0x00, 0x1C, 0x30,
  0x00, 0xC3, 0x00, 0x03, 0x8E, 0x00, 0x18, 0xE0, 0x00, 0x71, 0x80, 0x03,
  0x1C, 0x00, 0x0E, 0x70, 0x00, 0x63, 0x00, 0x01, 0xCC, 0x00, 0x0C, 0xE0,
  0x00, 0x39, 0x80, 0x01, 0x98, 0x00, 0x07, 0x70, 0x00, 0x37, 0x00, 0x00,
  0xEC, 0x00, 0x06, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xD8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x06, 0x00, 0x01, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0xE0, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x00, 0x60, 0x38, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x06, 0x1C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x38,
  0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x30, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x77, 0x00, 0x00, 0xCE, 0x00, 0x03, 0x8C, 0x00, 0x0E, 0x18, 0x00, 0x1C,
  0x30, 0x00, 0x70, 0x70, 0x00, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x06, 0x03,
  0x80, 0x1C, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x03, 0x80, 0x1C,
  0x06, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x30, 0x00, 0x60, 0xE0, 0x00, 0xC3,
  0x80, 0x01, 0x87, 0x00, 0x03, 0x1C, 0x00, 0x07, 0x30, 0x00, 0x0E, 0xE0,
  0x00, 0x0D, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xC0, 0x60, 0x30, 0x1C,
  0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x1C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x0C,
  0x06, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x07, 0x30, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x70, 0x70, 0x00, 0x18, 0x0C,
  0x00, 0x0E, 0x03, 0x00, 0x03, 0x00, 0xE0, 0x01, 0xC0, 0x18, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0xC0, 0x1C, 0x00, 0x30, 0x06, 0x00, 0x0E, 0x03,
  0x80, 0x01, 0x80, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0xE0, 0x00,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xC1, 0x83, 0x83, 0x07,
  0x06, 0x06, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x07, 0xF8, 0x30, 0x07,
  0xFF, 0x1C, 0x03, 0xC0, 0xE6, 0x01, 0xE0, 0x19, 0x80, 0xF0, 0x03, 0x60,
  0x38, 0x00, 0xF8, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01,
  0xC0, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x18, 0x00, 0x06, 0x0E, 0x00,
  0x01, 0x83, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C,
  0x00, 0x03, 0x07, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x70, 0x60, 0x00, 0x1C,
  0x18, 0x00, 0x07, 0x0E, 0x00, 0x01, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00,
  0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0,
  0x00, 0xF0, 0x18, 0x00, 0x6C, 0x06, 0x00, 0x1F, 0x01, 0xC0, 0x0D, 0x80,
  0x70, 0x06, 0x60, 0x0E, 0x03, 0x18, 0x01, 0xFF, 0x86, 0x00, 0x3F, 0xC3,
  0x80, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x02, 0x00, 0x07, 0x0F, 0xF0, 0x01, 0x8F, 0xFE,
  0x00, 0x67, 0x03, 0xC0, 0x3B, 0x80, 0x70, 0x0E, 0xC0, 0x0E, 0x03, 0x60,
  0x03, 0x80, 0xF0, 0x00, 0x60, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x07,
  0x80, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x18, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0x83, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00,
  0x06, 0x0C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x0C, 0x18, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x60,
  0xE0, 0x00, 0x38, 0x38, 0x00, 0x0C, 0x0E, 0x00, 0x07, 0x07, 0x80, 0x01,
  0x81, 0xE0, 0x00, 0xE0, 0x68, 0x00, 0x70, 0x1B, 0x00, 0x1C, 0x06, 0xC0,
  0x0E, 0x03, 0x1C, 0x0F, 0x00, 0xC7, 0xFF, 0x80, 0x30, 0x7F, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x01,
  0xE0, 0x10, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x10, 0x07, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x04, 0x03, 0x00,
  0x03, 0xFC, 0x18, 0x00, 0x7F, 0xF1, 0xC0, 0x07, 0x81, 0xCE, 0x00, 0x78,
  0x03, 0x60, 0x07, 0x80, 0x1B, 0x00, 0x38, 0x00, 0x58, 0x03, 0x80, 0x03,
  0xC0, 0x18, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x38, 0x06, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x60, 0x18, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x3C, 0x00, 0xC0, 0x03, 0xE0, 0x06, 0x00, 0x1B, 0x00,
  0x38, 0x01, 0xB8, 0x01, 0xC0, 0x1D, 0x80, 0x07, 0x01, 0xCC, 0x00, 0x1F,
  0xFC, 0x60, 0x00, 0x7F, 0x83, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0x3C, 0x0E, 0x01, 0xE0, 0x1C,
  0x0E, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x38,
  0x00, 0x71, 0xC0, 0x01, 0x87, 0x00, 0x0E, 0x18, 0x00, 0x30, 0xE0, 0x01,
  0xC3, 0x00, 0x0E, 0x0C, 0x00, 0xF0, 0x70, 0x0F, 0x81, 0xFF, 0xF8, 0x07,
  0xFF, 0x00, 0x1F, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x80, 0x70, 0x06, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xCF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0x83, 0x00,
  0x1F, 0xFC, 0x30, 0x03, 0xC0, 0xE3, 0x00, 0x78, 0x03, 0x60, 0x0F, 0x00,
  0x36, 0x00, 0xE0, 0x01, 0x60, 0x1C, 0x00, 0x1E, 0x01, 0x80, 0x01, 0xE0,
  0x38, 0x00, 0x1C, 0x03, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x06, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x38,
  0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x30, 0x18, 0x00, 0x07, 0x01, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xE0, 0x38,
  0x00, 0x1E, 0x03, 0x80, 0x03, 0xE0, 0x38, 0x00, 0x3C, 0x01, 0x80, 0x07,
  0xC0, 0x18, 0x00, 0x6C, 0x01, 0xC0, 0x0D, 0xC0, 0x1C, 0x01, 0xD8, 0x00,
  0xE0, 0x79, 0x80, 0x07, 0xFF, 0x18, 0x00, 0x3F, 0xC3, 0x80, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x08, 0x00, 0x38, 0x00, 0xC0, 0x0F, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x01, 0x80, 0x03, 0x87, 0xF8, 0x01, 0x8F, 0xFE, 0x00,
  0xCE, 0x07, 0x80, 0x6E, 0x01, 0xC0, 0x7C, 0x00, 0x60, 0x36, 0x00, 0x38,
  0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x0C, 0x0F, 0x00, 0x06, 0x07, 0x00, 0x03,
  0x03, 0x80, 0x01, 0x81, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0x60, 0x70, 0x00, 0x30, 0x30, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x0C, 0x00,
  0x0E, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x03, 0x03, 0x00, 0x03, 0x81, 0x80,
  0x01, 0xC1, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x30, 0x30,
  0x00, 0x38, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xC0,
  0xE0, 0x00, 0x60, 0x60, 0x00, 0x70, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x0C, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x0F, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x07, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x07, 0x00, 0x18, 0x07, 0x00, 0x0C,
  0x03, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x03, 0x80, 0x03, 0x03, 0x80, 0x01,
  0x83, 0x80, 0x00, 0xC3, 0x80, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00,
  0x31, 0xE0, 0x00, 0x19, 0xF0, 0x00, 0x0D, 0xDC, 0x00, 0x0F, 0xCE, 0x00,
  0x07, 0xC3, 0x00, 0x03, 0xC1, 0x80, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x70,
  0x00, 0xE0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x07, 0x00, 0x18, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x38, 0x03, 0x00,
  0x1C, 0x01, 0x80, 0x06, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x01, 0xC0, 0x60,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x01, 0x80, 0x03, 0x0F, 0xF0, 0x1F, 0xF0, 0x06,
  0x3F, 0xF0, 0x7F, 0xF0, 0x0C, 0xE0, 0xF1, 0xC0, 0xE0, 0x3B, 0x00, 0xE6,
  0x00, 0xE0, 0x6C, 0x00, 0xD8, 0x01, 0xC0, 0xD0, 0x01, 0xB0, 0x01, 0x81,
  0xE0, 0x03, 0xC0, 0x03, 0x03, 0x80, 0x07, 0x00, 0x06, 0x0F, 0x00, 0x0E,
  0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x30, 0x00, 0x70,
  0x70, 0x00, 0xE0, 0x00, 0xC0, 0xC0, 0x01, 0xC0, 0x01, 0x83, 0x80, 0x03,
  0x00, 0x07, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x30, 0x00, 0x70, 0x00, 0x60, 0xE0, 0x00,
  0xC0, 0x01, 0xC1, 0xC0, 0x01, 0x80, 0x03, 0x83, 0x00, 0x07, 0x00, 0x06,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x38, 0x00,
  0x30, 0x00, 0x70, 0x70, 0x00, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0xC0, 0x01,
  0x81, 0x80, 0x03, 0x80, 0x03, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x00, 0x30, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x60, 0x00, 0xE0, 0x00, 0xC1, 0xC0, 0x01, 0x80, 0x03, 0x83, 0x80,
  0x03, 0x00, 0x07, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0xC1, 0xFE, 0x00, 0x63, 0xFF, 0x80, 0x33, 0x81, 0xE0, 0x3B, 0x80,
  0x70, 0x1B, 0x80, 0x18, 0x0D, 0x80, 0x0E, 0x07, 0x80, 0x07, 0x03, 0x80,
  0x03, 0x03, 0xC0, 0x01, 0x81, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0x70,
  0x00, 0x70, 0x30, 0x00, 0x38, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x0C,
  0x00, 0x0E, 0x06, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0x81,
  0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x70, 0x70, 0x00, 0x30,
  0x38, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x07,
  0x07, 0x00, 0x03, 0x03, 0x80, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00,
  0xE0, 0x60, 0x00, 0x70, 0x70, 0x00, 0x30, 0x38, 0x00, 0x18, 0x18, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0xF0, 0x3C, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x06, 0x07,
  0x00, 0x06, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C,
  0x00, 0x07, 0x18, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x30,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x06, 0x70, 0x00, 0x06, 0x60,
  0x00, 0x0E, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0xE0, 0x00, 0x0C, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x30, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x60, 0x70, 0x00, 0xE0, 0x70,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x3C, 0x07, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01, 0x83, 0xFC,
  0x00, 0x0C, 0x7F, 0xF0, 0x00, 0x67, 0x03, 0xC0, 0x03, 0x70, 0x0E, 0x00,
  0x3B, 0x00, 0x38, 0x01, 0xB0, 0x00, 0xC0, 0x0F, 0x80, 0x06, 0x00, 0x78,
  0x00, 0x38, 0x07, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x70, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x38, 0x07, 0x80, 0x03, 0x80, 0x34, 0x00, 0x38, 0x01, 0xB0, 0x01,
  0xC0, 0x0D, 0x80, 0x1C, 0x00, 0xE6, 0x03, 0xC0, 0x07, 0x3F, 0xFC, 0x00,
  0x30, 0x7F, 0x80, 0x01, 0x80, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x07, 0xF8, 0x30, 0x07, 0xFF, 0x0C, 0x03, 0xC0, 0xE3, 0x01,
  0xE0, 0x1D, 0x80, 0xF0, 0x03, 0x60, 0x38, 0x00, 0x58, 0x1C, 0x00, 0x1E,
  0x06, 0x00, 0x07, 0x83, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x70, 0x00,
  0x1C, 0x18, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x18, 0x30, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x18, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00,
  0x07, 0x83, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x18, 0x00, 0x7C, 0x06,
  0x00, 0x1B, 0x01, 0xC0, 0x0D, 0xC0, 0x70, 0x07, 0x70, 0x0E, 0x03, 0x98,
  0x01, 0xFF, 0xC6, 0x00, 0x3F, 0xC3, 0x80, 0x01, 0x80, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x40, 0x18, 0x7F, 0x01, 0x8F, 0xF0, 0x19, 0xC0, 0x03, 0xB8, 0x00,
  0x37, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0x00, 0x7F,
  0xFE, 0x07, 0x80, 0x70, 0x78, 0x00, 0x83, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x80, 0x07, 0x06, 0x00, 0xF0, 0x3F, 0xFF,
  0x00, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x3F, 0xFE,
  0x7F, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x60, 0x00, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01,
  0xC1, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x30, 0x30, 0x00,
  0x38, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x06, 0x06, 0x00,
  0x07, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xC0, 0xE0,
  0x00, 0x60, 0x60, 0x00, 0x70, 0x30, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C,
  0x00, 0x0C, 0x0E, 0x00, 0x06, 0x06, 0x00, 0x07, 0x03, 0x00, 0x03, 0x83,
  0x80, 0x01, 0x81, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0x60, 0x00, 0x70,
  0x30, 0x00, 0x38, 0x18, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1E,
  0x07, 0x00, 0x1B, 0x03, 0x80, 0x1F, 0x80, 0xC0, 0x1D, 0x80, 0x70, 0x1C,
  0xC0, 0x1F, 0xFC, 0x60, 0x07, 0xF8, 0x30, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xB0, 0x00, 0x1D, 0x80, 0x00, 0xCC, 0x00, 0x0E,
  0x60, 0x00, 0x63, 0x00, 0x07, 0x18, 0x00, 0x30, 0xC0, 0x03, 0x86, 0x00,
  0x18, 0x38, 0x01, 0xC1, 0xC0, 0x0C, 0x0E, 0x00, 0xE0, 0x70, 0x06, 0x03,
  0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x07, 0x01, 0x80, 0x18, 0x1C,
  0x00, 0xC0, 0xC0, 0x06, 0x0E, 0x00, 0x30, 0x70, 0x01, 0x87, 0x00, 0x0C,
  0x38, 0x00, 0x63, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x00, 0xCE, 0x00,
  0x06, 0x60, 0x00, 0x37, 0x00, 0x01, 0xB0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xF0,
  0x00, 0x70, 0x00, 0x6C, 0x00, 0x1C, 0x00, 0x3B, 0x00, 0x0F, 0x00, 0x0E,
  0xC0, 0x03, 0xC0, 0x03, 0x30, 0x00, 0xF8, 0x01, 0xCC, 0x00, 0x6E, 0x00,
  0x63, 0x00, 0x1B, 0x80, 0x38, 0xC0, 0x0E, 0xE0, 0x0C, 0x30, 0x03, 0x38,
  0x03, 0x0C, 0x01, 0xCE, 0x01, 0xC3, 0x00, 0x63, 0x80, 0x60, 0xC0, 0x38,
  0xE0, 0x38, 0x30, 0x0C, 0x38, 0x0C, 0x0C, 0x03, 0x06, 0x03, 0x03, 0x01,
  0xC1, 0x81, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x38, 0x18, 0x38, 0x0C,
  0x0C, 0x06, 0x0C, 0x03, 0x07, 0x01, 0x87, 0x00, 0xE1, 0x80, 0x61, 0x80,
  0x38, 0x60, 0x18, 0x60, 0x0E, 0x30, 0x06, 0x38, 0x03, 0x8C, 0x01, 0x8C,
  0x00, 0xE7, 0x00, 0x67, 0x00, 0x39, 0x80, 0x19, 0x80, 0x0E, 0xE0, 0x06,
  0x60, 0x03, 0xB0, 0x01, 0xB8, 0x00, 0xCC, 0x00, 0x6C, 0x00, 0x36, 0x00,
  0x1F, 0x00, 0x0D, 0x80, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x70, 0x06, 0x00, 0x0E, 0x00, 0x60, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x30, 0x03, 0x80, 0x03, 0x00, 0x70, 0x00, 0x38, 0x06,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x18, 0x1C, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x1C, 0x30, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x70,
  0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x06, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x07, 0x00, 0x38, 0x00, 0x30, 0x07, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x06, 0x00, 0x03, 0x80,
  0x03, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x70, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x06,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x8F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0xBF, 0xFC, 0x00, 0x7C, 0x0F, 0x80, 0xF8, 0x01, 0xFF,
  0xE8, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xC0,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 14, 47, 14, 1, -47 },
  { 84, 14, 17, 19, 7, -47 },
  { 114, 30, 47, 30, 1, -47 },
  { 291, 26, 54, 27, 1, -50 },
  { 467, 33, 49, 40, 4, -48 },
  { 670, 28, 49, 29, 0, -48 },
  { 842, 6, 17, 11, 7, -47 },
  { 855, 18, 57, 16, 2, -47 },
  { 984, 19, 57, 16, -5, -47 },
  { 1120, 20, 21, 26, 8, -50 },
  { 1173, 25, 31, 30, 3, -39 },
  { 1270, 9, 15, 12, -3, -7 },
  { 1287, 14, 2, 18, 2, -19 },
  { 1291, 4, 5, 12, 1, -5 },
  { 1294, 28, 47, 20, -3, -47 },
  { 1459, 25, 49, 27, 2, -48 },
  { 1613, 14, 47, 27, 8, -47 },
  { 1696, 27, 48, 27, -1, -48 },
  { 1858, 28, 49, 27, -1, -48 },
  { 2030, 28, 48, 27, -1, -48 },
  { 2198, 27, 48, 27, 0, -47 },
  { 2360, 26, 49, 27, 2, -48 },
  { 2520, 25, 47, 27, 4, -47 },
  { 2667, 27, 49, 27, 0, -48 },
  { 2833, 25, 49, 27, 1, -48 },
  { 2987, 10, 35, 12, 1, -35 },
  { 3031, 14, 43, 12, -3, -35 },
  { 3107, 25, 29, 30, 3, -38 },
  { 3198, 25, 16, 30, 3, -31 },
  { 3248, 25, 29, 30, 3, -38 },
  { 3339, 20, 48, 20, 2, -48 },
  { 3459, 38, 53, 41, 2, -47 },
  { 3711, 27, 47, 27, -4, -47 },
  { 3870, 29, 47, 30, 1, -47 },
  { 4041, 29, 49, 28, 3, -48 },
  { 4219, 30, 47, 33, 1, -47 },
  { 4396, 28, 47, 26, 1, -47 },
  { 4561, 28, 47, 24, 1, -47 },
  { 4726, 32, 49, 35, 3, -48 },
  { 4922, 34, 47, 34, 1, -47 },
  { 5122, 21, 47, 14, -3, -47 },
  { 5246, 24, 59, 12, -10, -47 },
  { 5423, 31, 47, 27, 1, -47 },
  { 5606, 18, 47, 24, 1, -47 },
  { 5712, 43, 47, 44, 1, -47 },
  { 5965, 35, 47, 35, 1, -47 },
  { 6171, 31, 49, 35, 3, -48 },
  { 6361, 28, 47, 28, 1, -47 },
  { 6526, 31, 59, 35, 3, -48 },
  { 6755, 27, 47, 28, 1, -47 },
  { 6914, 29, 49, 26, -1, -48 },
  { 7092, 23, 47, 24, 6, -47 },
  { 7228, 32, 48, 34, 3, -47 },
  { 7420, 26, 47, 27, 6, -47 },
  { 7573, 43, 47, 45, 6, -47 },
  { 7826, 33, 47, 24, -4, -47 },
  { 8020, 23, 47, 24, 6, -47 },
  { 8156, 30, 47, 25, -2, -47 },
  { 8333, 24, 57, 19, -1, -47 },
  { 8504, 9, 47, 21, 7, -47 },
  { 8557, 24, 57, 19, -4, -47 },
  { 8728, 26, 25, 29, 2, -47 },
  { 8810, 20, 2, 20, -5, 6 },
  { 8815, 7, 10, 15, 10, -50 },
  { 8824, 26, 37, 29, 2, -36 },
  { 8945, 26, 51, 29, 1, -50 },
  { 9111, 21, 37, 22, 2, -36 },
  { 9209, 29, 51, 29, 2, -50 },
  { 9394, 22, 37, 25, 2, -36 },
  { 9496, 32, 66, 14, -9, -50 },
  { 9760, 28, 52, 29, 0, -36 },
  { 9942, 25, 50, 28, 1, -50 },
  { 10099, 13, 47, 12, 1, -47 },
  { 10176, 23, 63, 12, -9, -47 },
  { 10358, 25, 50, 23, 1, -50 },
  { 10515, 13, 50, 12, 1, -50 },
  { 10597, 39, 36, 43, 1, -36 },
  { 10773, 25, 36, 28, 1, -36 },
  { 10886, 24, 37, 28, 2, -36 },
  { 10997, 29, 51, 29, -2, -36 },
  { 11182, 26, 52, 29, 2, -36 },
  { 11351, 20, 36, 19, 1, -36 },
  { 11441, 21, 37, 21, 0, -36 },
  { 11539, 15, 44, 15, 2, -43 },
  { 11622, 25, 36, 28, 2, -35 },
  { 11735, 21, 35, 21, 4, -35 },
  { 11827, 34, 35, 35, 4, -35 },
  { 11976, 28, 35, 23, -3, -35 },
  { 12099, 33, 51, 22, -7, -35 },
  { 12310, 23, 35, 20, -2, -35 },
  { 12411, 23, 57, 21, 2, -47 },
  { 12575, 2, 66, 27, 13, -50 },
  { 12592, 23, 57, 21, -4, -47 },
  { 12756, 25, 6, 30, 3, -26 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic66pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC66PT7B_H_
