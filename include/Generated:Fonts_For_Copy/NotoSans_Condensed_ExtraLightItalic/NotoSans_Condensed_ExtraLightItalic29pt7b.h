#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC29PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x31, 0x08, 0x42, 0x31, 0x08, 0x42, 0x21, 0x08, 0x00,
  0x01, 0x08, 0x00, 0x45, 0x14, 0x52, 0x8A, 0x28, 0xA2, 0x01, 0x08, 0x04,
  0x40, 0x11, 0x00, 0x84, 0x02, 0x10, 0x08, 0x83, 0xFF, 0xC1, 0x08, 0x04,
  0x40, 0x21, 0x00, 0x84, 0x02, 0x20, 0x08, 0x83, 0xFF, 0xC1, 0x08, 0x04,
  0x40, 0x21, 0x00, 0x84, 0x02, 0x20, 0x10, 0x80, 0x42, 0x00, 0x00, 0x80,
  0x08, 0x01, 0x80, 0xEF, 0x09, 0x01, 0x10, 0x11, 0x01, 0x10, 0x12, 0x01,
  0xA0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x48, 0x04, 0x40, 0x44, 0x04, 0x40,
  0x44, 0x08, 0x8C, 0xB0, 0x3C, 0x00, 0x80, 0x10, 0x01, 0x00, 0x1C, 0x08,
  0x90, 0x24, 0x21, 0x10, 0x84, 0x82, 0x22, 0x19, 0x88, 0x44, 0x21, 0x20,
  0x84, 0x9A, 0x24, 0x98, 0x94, 0x64, 0x91, 0x66, 0x84, 0x12, 0x10, 0x88,
  0x42, 0x21, 0x11, 0x04, 0x44, 0x22, 0x10, 0x98, 0x24, 0x40, 0xF0, 0x03,
  0xC0, 0x64, 0x04, 0x20, 0x82, 0x08, 0x60, 0x84, 0x08, 0xC0, 0x88, 0x05,
  0x00, 0x60, 0x0E, 0x01, 0x20, 0x22, 0x14, 0x11, 0x41, 0x28, 0x1A, 0x80,
  0xC8, 0x0C, 0x81, 0xC4, 0x34, 0x7E, 0x60, 0x69, 0x25, 0x24, 0x01, 0x02,
  0x04, 0x08, 0x08, 0x10, 0x30, 0x20, 0x60, 0x40, 0x40, 0xC0, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20,
  0x04, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x03, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x30, 0x20,
  0x40, 0x80, 0x04, 0x02, 0x11, 0x1D, 0x01, 0xF8, 0xC0, 0xD0, 0x88, 0x42,
  0x00, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x32, 0x24, 0x48, 0x80, 0xFC,
  0xC0, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x00, 0x07, 0x81, 0x88,
  0x61, 0x08, 0x13, 0x02, 0x40, 0x48, 0x0A, 0x03, 0x40, 0x48, 0x09, 0x01,
  0x40, 0x28, 0x05, 0x01, 0x20, 0x24, 0x04, 0x81, 0x10, 0x22, 0x08, 0x23,
  0x07, 0xC0, 0x0C, 0x62, 0xB2, 0x88, 0x61, 0x04, 0x10, 0x42, 0x08, 0x20,
  0x82, 0x10, 0x41, 0x04, 0x30, 0x80, 0x03, 0xE0, 0x31, 0x80, 0x04, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x0F, 0xFC, 0x00, 0x07, 0xC1, 0x82, 0x10, 0x30, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x18, 0x0F, 0x00, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x88, 0x30, 0xFE,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0A, 0x01, 0x20, 0x12, 0x02, 0x40,
  0x44, 0x0C, 0x40, 0x84, 0x10, 0xC3, 0x08, 0x20, 0x84, 0x08, 0x80, 0x8F,
  0xFE, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x07, 0xF0, 0xC0,
  0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0xF8,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08,
  0x01, 0x88, 0x30, 0xFE, 0x00, 0x01, 0xE0, 0xC0, 0x30, 0x0C, 0x01, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x46, 0x0B, 0x31, 0x82, 0x60, 0x6C, 0x05, 0x00,
  0xA0, 0x34, 0x04, 0x80, 0x90, 0x12, 0x04, 0x21, 0x03, 0xC0, 0x7F, 0xE0,
  0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0,
  0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00,
  0x60, 0x08, 0x00, 0x03, 0xC0, 0xC2, 0x08, 0x11, 0x01, 0x10, 0x11, 0x01,
  0x10, 0x20, 0x82, 0x08, 0xC0, 0x58, 0x07, 0x01, 0x98, 0x20, 0x84, 0x04,
  0x40, 0x48, 0x04, 0x80, 0x48, 0x04, 0xC0, 0xC4, 0x18, 0x3F, 0x00, 0x03,
  0xC0, 0xC6, 0x08, 0x21, 0x02, 0x10, 0x32, 0x03, 0x20, 0x32, 0x02, 0x20,
  0x22, 0x02, 0x20, 0x61, 0x0A, 0x0F, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x10, 0x03, 0x00, 0x60, 0xFC, 0x00, 0x18, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x63, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x82, 0x10, 0x42, 0x08, 0x00, 0x00, 0x20, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x02, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x06, 0x03,
  0x00, 0xC0, 0x60, 0x30, 0x08, 0x00, 0x1E, 0x10, 0x80, 0x60, 0x10, 0x18,
  0x08, 0x04, 0x04, 0x06, 0x06, 0x06, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x78, 0x03, 0x8C, 0x06, 0x02,
  0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0xF1, 0x21, 0x11, 0x42, 0x11,
  0x46, 0x11, 0x44, 0x21, 0x84, 0x21, 0x88, 0x21, 0x88, 0x62, 0x88, 0x42,
  0x88, 0xC4, 0x8C, 0xAC, 0x87, 0x30, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x38, 0xC0, 0x03, 0x00, 0x00, 0x20, 0x06, 0x00, 0x60, 0x0A,
  0x00, 0xA0, 0x12, 0x01, 0x20, 0x32, 0x02, 0x20, 0x62, 0x04, 0x20, 0x43,
  0x0F, 0xF0, 0x81, 0x10, 0x11, 0x01, 0x20, 0x12, 0x01, 0x60, 0x14, 0x01,
  0xC0, 0x10, 0x07, 0xC0, 0x21, 0x82, 0x06, 0x10, 0x10, 0x80, 0x84, 0x04,
  0x20, 0x62, 0x02, 0x10, 0x30, 0x86, 0x07, 0xE0, 0x60, 0xC2, 0x02, 0x10,
  0x10, 0x80, 0x84, 0x04, 0x60, 0x22, 0x03, 0x10, 0x10, 0x83, 0x0F, 0xE0,
  0x00, 0x01, 0xF0, 0x18, 0x41, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0xF8, 0x00,
  0x07, 0x80, 0x11, 0xC0, 0x81, 0x82, 0x02, 0x08, 0x08, 0x20, 0x30, 0x80,
  0x44, 0x01, 0x10, 0x0C, 0x40, 0x31, 0x00, 0x8C, 0x02, 0x20, 0x08, 0x80,
  0x62, 0x01, 0x08, 0x0C, 0x60, 0x21, 0x01, 0x84, 0x0C, 0x10, 0xE0, 0xFE,
  0x00, 0x07, 0xF8, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x07, 0xF0, 0x60, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x81, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x7F, 0x82, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x01,
  0xF8, 0x06, 0x0C, 0x10, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x07, 0xCC, 0x01, 0x98,
  0x02, 0x30, 0x04, 0x60, 0x08, 0x40, 0x10, 0x80, 0x41, 0x80, 0x81, 0x81,
  0x01, 0xFE, 0x00, 0x04, 0x02, 0x08, 0x04, 0x20, 0x08, 0x40, 0x10, 0x80,
  0x41, 0x00, 0x82, 0x01, 0x08, 0x02, 0x10, 0x0C, 0x20, 0x10, 0x7F, 0xE1,
  0x80, 0x42, 0x00, 0x84, 0x03, 0x08, 0x04, 0x10, 0x08, 0x40, 0x10, 0x80,
  0x21, 0x00, 0x82, 0x01, 0x0C, 0x02, 0x00, 0x0F, 0x81, 0x00, 0x80, 0xC0,
  0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x18, 0x08, 0x04, 0x0F, 0x80, 0x00, 0x40, 0x10, 0x0C, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x10, 0x3C, 0x00, 0x04, 0x04, 0x10, 0x20, 0x81, 0x02, 0x0C, 0x08,
  0x60, 0x23, 0x00, 0x88, 0x04, 0x40, 0x12, 0x00, 0x58, 0x01, 0xE0, 0x0E,
  0x80, 0x33, 0x00, 0x84, 0x02, 0x10, 0x08, 0x40, 0x60, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x10, 0xC0, 0x40, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x40, 0xFF, 0x04, 0x00, 0x30, 0x60, 0x06, 0x0A, 0x00, 0x60, 0xA0, 0x0A,
  0x0A, 0x00, 0xA0, 0xA0, 0x14, 0x0A, 0x01, 0x41, 0x20, 0x24, 0x12, 0x02,
  0x41, 0x20, 0x4C, 0x12, 0x04, 0x83, 0x20, 0x88, 0x22, 0x08, 0x82, 0x31,
  0x08, 0x21, 0x11, 0x82, 0x12, 0x10, 0x41, 0x21, 0x04, 0x14, 0x10, 0x41,
  0x41, 0x04, 0x18, 0x20, 0xC1, 0x82, 0x00, 0x04, 0x01, 0x04, 0x03, 0x0A,
  0x02, 0x0A, 0x02, 0x0A, 0x02, 0x0A, 0x02, 0x09, 0x04, 0x11, 0x04, 0x11,
  0x04, 0x11, 0x04, 0x10, 0x84, 0x30, 0x88, 0x20, 0x88, 0x20, 0x88, 0x20,
  0x48, 0x20, 0x58, 0x60, 0x50, 0x40, 0x50, 0x40, 0x30, 0x40, 0x30, 0xC0,
  0x30, 0x01, 0xE0, 0x18, 0x60, 0xC0, 0x86, 0x02, 0x10, 0x0C, 0xC0, 0x12,
  0x00, 0x48, 0x01, 0x40, 0x0D, 0x00, 0x34, 0x00, 0x90, 0x02, 0x40, 0x0B,
  0x00, 0x6C, 0x01, 0x30, 0x04, 0xC0, 0x31, 0x00, 0x84, 0x04, 0x08, 0x20,
  0x3F, 0x00, 0x07, 0x80, 0x23, 0x02, 0x04, 0x10, 0x20, 0x81, 0x84, 0x0C,
  0x20, 0x42, 0x02, 0x10, 0x10, 0x81, 0x04, 0x10, 0x7F, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00,
  0x00, 0x01, 0xE0, 0x18, 0x60, 0xC0, 0x86, 0x02, 0x10, 0x0C, 0xC0, 0x12,
  0x00, 0x48, 0x01, 0x40, 0x0D, 0x00, 0x34, 0x00, 0x90, 0x02, 0x40, 0x0B,
  0x00, 0x6C, 0x01, 0x30, 0x04, 0xC0, 0x21, 0x00, 0x84, 0x04, 0x18, 0x20,
  0x3F, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x07,
  0x80, 0x23, 0x02, 0x04, 0x10, 0x20, 0x81, 0x84, 0x08, 0x20, 0x42, 0x02,
  0x10, 0x30, 0x81, 0x04, 0x30, 0x7E, 0x02, 0x10, 0x10, 0x80, 0x84, 0x04,
  0x30, 0x60, 0x82, 0x04, 0x10, 0x20, 0x81, 0x8C, 0x04, 0x00, 0x03, 0xE0,
  0xC1, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0xC0,
  0x08, 0x00, 0x88, 0x30, 0xFE, 0x00, 0x7F, 0xF0, 0x80, 0x10, 0x06, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x08,
  0x04, 0x60, 0x11, 0x00, 0x44, 0x03, 0x10, 0x08, 0x40, 0x22, 0x00, 0x88,
  0x02, 0x20, 0x10, 0x80, 0x42, 0x01, 0x10, 0x04, 0x40, 0x31, 0x00, 0x84,
  0x02, 0x30, 0x08, 0xC0, 0x63, 0x01, 0x04, 0x0C, 0x18, 0x60, 0x3F, 0x00,
  0x80, 0x30, 0x0E, 0x01, 0x40, 0x28, 0x09, 0x01, 0x20, 0x44, 0x08, 0x82,
  0x10, 0x42, 0x18, 0x42, 0x08, 0xC1, 0x10, 0x22, 0x04, 0x80, 0x90, 0x14,
  0x02, 0x80, 0x60, 0x0C, 0x00, 0x80, 0x40, 0x70, 0x18, 0x0A, 0x03, 0x01,
  0x40, 0xA0, 0x48, 0x14, 0x09, 0x02, 0x83, 0x20, 0x90, 0x44, 0x12, 0x08,
  0x84, 0x42, 0x10, 0x88, 0x42, 0x31, 0x10, 0x44, 0x22, 0x08, 0x84, 0xC1,
  0x20, 0x90, 0x24, 0x12, 0x05, 0x02, 0x80, 0xA0, 0x50, 0x14, 0x0E, 0x03,
  0x01, 0x80, 0x60, 0x30, 0x08, 0x04, 0x00, 0x06, 0x02, 0x04, 0x08, 0x08,
  0x20, 0x10, 0x40, 0x21, 0x00, 0x46, 0x00, 0x48, 0x00, 0xA0, 0x01, 0x40,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x28, 0x00, 0x90, 0x03, 0x20, 0x04,
  0x20, 0x10, 0x40, 0x20, 0x80, 0x81, 0x02, 0x02, 0x0C, 0x06, 0x00, 0xC0,
  0x28, 0x09, 0x03, 0x20, 0x44, 0x18, 0x82, 0x18, 0x81, 0x10, 0x24, 0x05,
  0x80, 0xA0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x07, 0xFC, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0xFF, 0xC0, 0x07, 0xC1, 0x00, 0xC0, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x3E, 0x00, 0x88, 0x88, 0x44, 0x44, 0x44, 0x62, 0x22, 0x22, 0x21, 0x11,
  0x10, 0x07, 0xE0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x1F,
  0x00, 0x02, 0x00, 0xE0, 0x14, 0x04, 0x80, 0x88, 0x21, 0x04, 0x21, 0x02,
  0x60, 0x48, 0x06, 0x00, 0x80, 0xFF, 0xC9, 0x10, 0x02, 0x01, 0xB4, 0x42,
  0x90, 0x32, 0x04, 0x80, 0x90, 0x12, 0x02, 0x80, 0xD0, 0x12, 0x02, 0x40,
  0x48, 0x19, 0x05, 0x10, 0xC3, 0xE8, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x09, 0x81, 0x26, 0x14, 0x21, 0x83, 0x10, 0x11, 0x01,
  0x30, 0x12, 0x03, 0x20, 0x22, 0x02, 0x20, 0x26, 0x04, 0x60, 0x46, 0x08,
  0x61, 0x89, 0xF0, 0x03, 0x06, 0x44, 0x04, 0x02, 0x02, 0x01, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x01, 0x00, 0xFC, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x08, 0x81, 0xB4, 0x10, 0x61,
  0x03, 0x08, 0x18, 0x80, 0x84, 0x04, 0x20, 0x22, 0x01, 0x10, 0x18, 0x80,
  0x84, 0x04, 0x20, 0x61, 0x05, 0x04, 0x70, 0x3E, 0x80, 0x02, 0x03, 0x61,
  0x08, 0x83, 0x20, 0x90, 0x24, 0x13, 0x18, 0xF8, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x04, 0x10, 0xF8, 0x00, 0x3C, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0xF8, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x6D, 0x08,
  0x31, 0x03, 0x10, 0x32, 0x02, 0x20, 0x26, 0x02, 0x40, 0x24, 0x06, 0x40,
  0x44, 0x0C, 0x40, 0xC4, 0x14, 0x23, 0x83, 0xE8, 0x00, 0x80, 0x08, 0x01,
  0x80, 0x10, 0x03, 0x08, 0x60, 0x78, 0x00, 0x04, 0x00, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x20, 0xB3, 0x14, 0x23, 0x04, 0x40, 0x88, 0x13,
  0x02, 0x40, 0xC8, 0x11, 0x02, 0x20, 0x48, 0x09, 0x02, 0x20, 0x44, 0x09,
  0x81, 0x00, 0x04, 0x30, 0x00, 0x00, 0x01, 0x84, 0x10, 0x41, 0x08, 0x20,
  0x82, 0x08, 0x41, 0x04, 0x10, 0xC0, 0x00, 0x40, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x01, 0x03, 0x80, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0xC3, 0x10, 0xC2, 0x10, 0x44, 0x09, 0x02, 0x40, 0x58,
  0x0D, 0x01, 0x90, 0x22, 0x08, 0x41, 0x0C, 0x20, 0x84, 0x11, 0x82, 0x00,
  0x04, 0x10, 0xC2, 0x08, 0x20, 0x86, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08,
  0x21, 0x04, 0x10, 0x43, 0x00, 0x09, 0x83, 0x05, 0xB3, 0x61, 0x83, 0x0C,
  0x60, 0x81, 0x10, 0x20, 0xC4, 0x18, 0x23, 0x04, 0x08, 0x81, 0x02, 0x20,
  0x40, 0x88, 0x10, 0x42, 0x08, 0x11, 0x02, 0x04, 0x40, 0x81, 0x10, 0x20,
  0x44, 0x18, 0x23, 0x04, 0x08, 0x08, 0x82, 0xCC, 0x50, 0x8C, 0x11, 0x02,
  0x20, 0x4C, 0x09, 0x03, 0x20, 0x44, 0x09, 0x81, 0x20, 0x24, 0x08, 0x81,
  0x10, 0x26, 0x04, 0x03, 0x03, 0x61, 0x04, 0x81, 0x20, 0x50, 0x14, 0x07,
  0x01, 0x80, 0x60, 0x18, 0x0E, 0x02, 0x80, 0xA0, 0x44, 0x21, 0xF0, 0x04,
  0xC0, 0x49, 0x82, 0x84, 0x18, 0x30, 0x80, 0x84, 0x04, 0x60, 0x22, 0x03,
  0x10, 0x10, 0x80, 0x84, 0x04, 0x60, 0x43, 0x02, 0x18, 0x20, 0xC3, 0x0D,
  0xF0, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x00, 0x02, 0x01, 0xB4, 0x41, 0x90, 0x32, 0x06, 0x80, 0x90, 0x12, 0x02,
  0x80, 0x50, 0x1A, 0x02, 0x40, 0x48, 0x19, 0x05, 0x30, 0xC3, 0xE8, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x00, 0x8B, 0xC5,
  0x03, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x80, 0x06, 0x0C, 0xC8, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x80, 0x40, 0x20, 0x12, 0x19, 0xF8, 0x10, 0x41, 0x04,
  0x7C, 0x82, 0x08, 0x61, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x0F, 0x00,
  0x30, 0x24, 0x08, 0x81, 0x10, 0x26, 0x04, 0x80, 0x90, 0x22, 0x04, 0x40,
  0x98, 0x12, 0x06, 0x40, 0x88, 0x31, 0x0A, 0x1E, 0x40, 0x81, 0xC0, 0xA0,
  0xD0, 0x48, 0x64, 0x22, 0x31, 0x10, 0x88, 0x48, 0x24, 0x14, 0x0A, 0x06,
  0x03, 0x00, 0x83, 0x07, 0x06, 0x0A, 0x0C, 0x24, 0x28, 0x48, 0x50, 0x91,
  0x22, 0x22, 0x44, 0x48, 0x90, 0x91, 0x21, 0x62, 0x42, 0x85, 0x05, 0x0A,
  0x0C, 0x18, 0x18, 0x30, 0x20, 0x40, 0x00, 0x18, 0x30, 0x86, 0x08, 0x40,
  0x88, 0x05, 0x80, 0x50, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xA0, 0x13, 0x02,
  0x10, 0x21, 0x04, 0x10, 0x80, 0x80, 0x04, 0x04, 0x10, 0x20, 0x40, 0x81,
  0x04, 0x04, 0x10, 0x10, 0xC0, 0x42, 0x01, 0x18, 0x02, 0x40, 0x0B, 0x00,
  0x28, 0x00, 0xA0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x03, 0x80, 0x00, 0x0F, 0xC0, 0x30,
  0x08, 0x04, 0x03, 0x00, 0x80, 0x40, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80,
  0x60, 0x10, 0x0F, 0xE0, 0x00, 0xC0, 0xC0, 0x60, 0x10, 0x04, 0x03, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0xE0, 0x38, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x70, 0x02,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0xE0, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0xC0, 0x70, 0x20,
  0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x70,
  0x20, 0x00, 0x10, 0x0D, 0x86, 0x0F, 0x80,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 21, 6, 1, -21 },
  { 15, 6, 8, 8, 3, -21 },
  { 21, 14, 21, 13, 0, -21 },
  { 58, 12, 24, 12, 0, -22 },
  { 94, 14, 21, 18, 2, -21 },
  { 131, 12, 21, 13, 0, -21 },
  { 163, 3, 8, 5, 3, -21 },
  { 166, 8, 26, 7, 1, -21 },
  { 192, 8, 26, 7, -2, -21 },
  { 218, 9, 9, 11, 3, -22 },
  { 229, 11, 13, 13, 1, -17 },
  { 247, 4, 7, 5, -1, -3 },
  { 251, 6, 1, 8, 1, -8 },
  { 252, 1, 2, 5, 1, -2 },
  { 253, 12, 21, 9, -1, -21 },
  { 285, 11, 21, 12, 1, -21 },
  { 314, 6, 21, 12, 4, -21 },
  { 330, 13, 21, 12, -1, -21 },
  { 365, 12, 21, 12, 0, -21 },
  { 397, 12, 21, 12, 0, -21 },
  { 429, 12, 21, 12, 0, -21 },
  { 461, 11, 21, 12, 1, -21 },
  { 490, 11, 21, 12, 2, -21 },
  { 519, 12, 21, 12, 0, -21 },
  { 551, 12, 21, 12, 0, -21 },
  { 583, 5, 15, 5, 0, -15 },
  { 593, 6, 19, 5, -1, -15 },
  { 608, 11, 13, 13, 1, -17 },
  { 626, 11, 7, 13, 1, -14 },
  { 636, 11, 13, 13, 1, -17 },
  { 654, 9, 21, 9, 1, -21 },
  { 678, 16, 24, 18, 1, -21 },
  { 726, 12, 21, 12, -2, -21 },
  { 758, 13, 21, 13, 0, -21 },
  { 793, 13, 21, 12, 1, -21 },
  { 828, 14, 21, 14, 0, -21 },
  { 865, 13, 21, 12, 0, -21 },
  { 900, 13, 21, 11, 0, -21 },
  { 935, 15, 21, 15, 1, -21 },
  { 975, 15, 21, 15, 0, -21 },
  { 1015, 9, 21, 6, -1, -21 },
  { 1039, 10, 26, 5, -4, -21 },
  { 1072, 14, 21, 12, 0, -21 },
  { 1109, 8, 21, 11, 0, -21 },
  { 1130, 20, 21, 19, 0, -21 },
  { 1183, 16, 21, 15, 0, -21 },
  { 1225, 14, 21, 15, 1, -21 },
  { 1262, 13, 21, 12, 0, -21 },
  { 1297, 14, 26, 15, 1, -21 },
  { 1343, 13, 21, 12, 0, -21 },
  { 1378, 12, 21, 11, 0, -21 },
  { 1410, 11, 21, 10, 2, -21 },
  { 1439, 14, 21, 15, 1, -21 },
  { 1476, 11, 21, 12, 3, -21 },
  { 1505, 19, 21, 20, 3, -21 },
  { 1555, 15, 21, 11, -2, -21 },
  { 1595, 11, 21, 10, 2, -21 },
  { 1624, 14, 21, 11, -1, -21 },
  { 1661, 10, 26, 8, 0, -21 },
  { 1694, 4, 21, 9, 3, -21 },
  { 1705, 11, 26, 8, -2, -21 },
  { 1741, 11, 11, 13, 1, -21 },
  { 1757, 8, 1, 9, -2, 3 },
  { 1758, 3, 4, 6, 4, -22 },
  { 1760, 11, 16, 13, 1, -16 },
  { 1782, 12, 22, 13, 0, -22 },
  { 1815, 9, 16, 10, 1, -16 },
  { 1833, 13, 22, 13, 1, -22 },
  { 1869, 10, 16, 11, 1, -16 },
  { 1889, 14, 29, 6, -4, -22 },
  { 1940, 12, 23, 13, 0, -16 },
  { 1975, 11, 22, 12, 0, -22 },
  { 2006, 6, 21, 5, 0, -21 },
  { 2022, 10, 28, 5, -4, -21 },
  { 2057, 11, 22, 10, 0, -22 },
  { 2088, 6, 22, 5, 0, -22 },
  { 2105, 18, 16, 19, 0, -16 },
  { 2141, 11, 16, 12, 0, -16 },
  { 2163, 10, 16, 12, 1, -16 },
  { 2183, 13, 23, 13, -1, -16 },
  { 2221, 11, 23, 13, 1, -16 },
  { 2253, 9, 16, 8, 0, -16 },
  { 2271, 9, 16, 9, 0, -16 },
  { 2289, 6, 19, 7, 1, -19 },
  { 2304, 11, 15, 12, 1, -15 },
  { 2325, 9, 15, 9, 2, -15 },
  { 2342, 15, 15, 15, 2, -15 },
  { 2371, 12, 15, 10, -1, -15 },
  { 2394, 14, 22, 10, -3, -15 },
  { 2433, 10, 15, 9, -1, -15 },
  { 2452, 10, 26, 9, 1, -21 },
  { 2485, 1, 29, 12, 6, -22 },
  { 2489, 10, 26, 9, -2, -21 },
  { 2522, 11, 3, 13, 1, -12 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC29PT7B_H_
