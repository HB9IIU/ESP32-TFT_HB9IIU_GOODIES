#ifndef _NOTOSANS_CONDENSED_EXTRALIGHTITALIC7PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHTITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLightItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLightItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x5A, 0x80, 0xC0, 0x6D, 0x7C, 0x79, 0x2C, 0xDE, 0xF7, 0x70, 0x69,
  0x5E, 0xC0, 0x6A, 0xA0, 0xFC, 0xE0, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x29,
  0x48, 0x76, 0xDC, 0xF8, 0x64, 0xAC, 0xE5, 0x1C, 0x2A, 0xF4, 0x71, 0x9C,
  0x73, 0xDC, 0x65, 0x28, 0x75, 0x5E, 0x77, 0x9C, 0x90, 0x98, 0x71, 0x80,
  0xE0, 0xC7, 0x00, 0x56, 0x80, 0x7B, 0xFF, 0x86, 0x5F, 0xC0, 0x77, 0x5E,
  0x72, 0x4C, 0x76, 0xDE, 0x73, 0x4C, 0x71, 0x48, 0x78, 0xAA, 0xE0, 0x59,
  0xFA, 0xA0, 0x5A, 0x80, 0x55, 0x70, 0x75, 0x6A, 0x6A, 0xC0, 0x4A, 0xB5,
  0xED, 0x00, 0x5D, 0xDA, 0xA0, 0x79, 0x99, 0xE0, 0x77, 0xC8, 0x79, 0x99,
  0xA4, 0x76, 0xEA, 0xF1, 0x1C, 0xEA, 0x80, 0x59, 0x9A, 0xE0, 0xFA, 0x80,
  0xDD, 0xDE, 0xC0, 0x69, 0x6C, 0xEA, 0x80, 0x65, 0x4C, 0x6A, 0xA0, 0xF8,
  0x55, 0xA0, 0x56, 0x80, 0xE0, 0x80, 0x76, 0xE0, 0x4E, 0xDE, 0x6B, 0x2E,
  0xDC, 0x57, 0x60, 0x2D, 0x24, 0xA0, 0x76, 0xE5, 0x00, 0x4E, 0xDA, 0xF8,
  0x55, 0x58, 0x55, 0x6C, 0xF8, 0x5B, 0xBD, 0x76, 0xD0, 0x56, 0xE0, 0x76,
  0xF9, 0x00, 0x76, 0xE4, 0x80, 0x6A, 0xE7, 0x7A, 0x80, 0xB6, 0xE0, 0xBB,
  0x40, 0xBD, 0xAA, 0xAA, 0x60, 0x55, 0x24, 0x48, 0x5B, 0x69, 0x49, 0x00,
  0xFE, 0x55, 0xA0, 0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraLightItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 5, 1, 0, -5 },
  { 3, 1, 2, 2, 1, -5 },
  { 4, 3, 5, 3, 0, -5 },
  { 6, 3, 5, 3, 0, -5 },
  { 8, 4, 5, 4, 0, -5 },
  { 11, 3, 5, 3, 0, -5 },
  { 13, 1, 2, 1, 1, -5 },
  { 14, 2, 6, 2, 0, -5 },
  { 16, 1, 6, 2, 0, -5 },
  { 17, 2, 2, 3, 1, -5 },
  { 18, 3, 3, 3, 0, -4 },
  { 20, 1, 2, 1, 0, -1 },
  { 21, 2, 1, 2, 0, -2 },
  { 22, 1, 1, 1, 0, -1 },
  { 23, 3, 5, 2, 0, -5 },
  { 25, 3, 5, 3, 0, -5 },
  { 27, 1, 5, 3, 1, -5 },
  { 28, 3, 5, 3, 0, -5 },
  { 30, 3, 5, 3, 0, -5 },
  { 32, 3, 5, 3, 0, -5 },
  { 34, 3, 5, 3, 0, -5 },
  { 36, 3, 5, 3, 0, -5 },
  { 38, 3, 5, 3, 0, -5 },
  { 40, 3, 5, 3, 0, -5 },
  { 42, 3, 5, 3, 0, -5 },
  { 44, 1, 4, 1, 0, -4 },
  { 45, 1, 5, 1, 0, -4 },
  { 46, 3, 3, 3, 0, -4 },
  { 48, 3, 1, 3, 0, -3 },
  { 49, 3, 3, 3, 0, -4 },
  { 51, 2, 5, 2, 0, -5 },
  { 53, 4, 6, 4, 0, -5 },
  { 56, 2, 5, 3, 0, -5 },
  { 58, 3, 5, 3, 0, -5 },
  { 60, 3, 5, 3, 0, -5 },
  { 62, 3, 5, 3, 0, -5 },
  { 64, 3, 5, 3, 0, -5 },
  { 66, 3, 5, 3, 0, -5 },
  { 68, 4, 5, 4, 0, -5 },
  { 71, 4, 5, 4, 0, -5 },
  { 74, 2, 5, 2, 0, -5 },
  { 76, 2, 6, 1, -1, -5 },
  { 78, 3, 5, 3, 0, -5 },
  { 80, 2, 5, 3, 0, -5 },
  { 82, 5, 5, 5, 0, -5 },
  { 86, 4, 5, 4, 0, -5 },
  { 89, 4, 5, 4, 0, -5 },
  { 92, 3, 5, 3, 0, -5 },
  { 94, 4, 6, 4, 0, -5 },
  { 97, 3, 5, 3, 0, -5 },
  { 99, 3, 5, 3, 0, -5 },
  { 101, 2, 5, 3, 1, -5 },
  { 103, 4, 5, 4, 0, -5 },
  { 106, 2, 5, 3, 1, -5 },
  { 108, 4, 5, 5, 1, -5 },
  { 111, 3, 5, 3, 0, -5 },
  { 113, 2, 5, 3, 1, -5 },
  { 115, 3, 5, 3, 0, -5 },
  { 117, 2, 6, 2, 0, -5 },
  { 119, 1, 5, 2, 1, -5 },
  { 120, 2, 6, 2, 0, -5 },
  { 122, 3, 3, 3, 0, -5 },
  { 124, 3, 1, 2, -1, 0 },
  { 125, 1, 1, 2, 1, -5 },
  { 126, 3, 4, 3, 0, -4 },
  { 128, 3, 5, 3, 0, -5 },
  { 130, 2, 4, 2, 0, -4 },
  { 131, 3, 5, 3, 0, -5 },
  { 133, 3, 4, 3, 0, -4 },
  { 135, 3, 7, 2, -1, -5 },
  { 138, 3, 6, 3, 0, -4 },
  { 141, 3, 5, 3, 0, -5 },
  { 143, 1, 5, 1, 0, -5 },
  { 144, 2, 7, 1, -1, -5 },
  { 146, 3, 5, 2, 0, -5 },
  { 148, 1, 5, 1, 0, -5 },
  { 149, 4, 4, 5, 0, -4 },
  { 151, 3, 4, 3, 0, -4 },
  { 153, 3, 4, 3, 0, -4 },
  { 155, 3, 6, 3, 0, -4 },
  { 158, 3, 6, 3, 0, -4 },
  { 161, 2, 4, 2, 0, -4 },
  { 162, 2, 4, 2, 0, -4 },
  { 163, 2, 5, 2, 0, -5 },
  { 165, 3, 4, 3, 0, -4 },
  { 167, 3, 4, 2, 0, -4 },
  { 169, 4, 4, 4, 0, -4 },
  { 171, 3, 4, 2, 0, -4 },
  { 173, 4, 6, 2, -1, -4 },
  { 176, 2, 4, 2, 0, -4 },
  { 177, 3, 6, 2, 0, -5 },
  { 180, 1, 7, 3, 1, -5 },
  { 181, 2, 6, 2, 0, -5 },
  { 183, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Condensed_ExtraLightItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLightItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLightItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHTITALIC7PT7B_H_
