#ifndef _IBMPLEXMONO_ITALIC65PT7B_H_
#define _IBMPLEXMONO_ITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x07,
  0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x1F,
  0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C,
  0x07, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0x80, 0xF9, 0xF0,
  0x1F, 0x3E, 0x03, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x3E,
  0x01, 0xE0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0x80, 0xFF,
  0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x00,
  0xF0, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xF8, 0xF3, 0xFE, 0x00, 0x7F, 0x07, 0x83, 0xF8, 0x07, 0xF0, 0x3C, 0x0F,
  0xE0, 0x3F, 0x01, 0xE0, 0x3E, 0x03, 0xF0, 0x0F, 0x00, 0xE0, 0x1F, 0x80,
  0x70, 0x02, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x00, 0x7E, 0x03, 0x80, 0x00, 0x03, 0xF8, 0x3C, 0x00, 0x00, 0x0F,
  0xE1, 0xE0, 0x00, 0x00, 0x7F, 0xCF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x03, 0xCF, 0xF8, 0x00, 0x00, 0x1E, 0x1F, 0xE0, 0x00, 0x00, 0xE0,
  0x3F, 0x00, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x07, 0xE0, 0x00,
  0x03, 0xC0, 0x3F, 0x00, 0x00, 0x1E, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x0F,
  0xC0, 0x00, 0x07, 0x00, 0x7E, 0x02, 0x00, 0x78, 0x03, 0xE0, 0x30, 0x03,
  0xC0, 0x1F, 0x03, 0xC0, 0x1E, 0x01, 0xF8, 0x3F, 0x00, 0xF0, 0x1F, 0x83,
  0xFC, 0x07, 0x81, 0xFC, 0x07, 0xF8, 0x38, 0x1F, 0xC0, 0x1F, 0xF3, 0xC7,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0xFF,
  0xC0, 0x00, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x78,
  0x00, 0x3C, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x78, 0x03, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x1E,
  0x00, 0x0F, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x00,
  0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x01,
  0xE0, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78,
  0x01, 0xF0, 0x7C, 0x00, 0x03, 0xC0, 0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0x78, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xE0, 0xF8,
  0x3E, 0x00, 0x00, 0x0F, 0xFF, 0x83, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xF8, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0xF8, 0x00,
  0x00, 0x78, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x1E, 0x00, 0x00,
  0x7C, 0x1E, 0x00, 0x78, 0x00, 0x03, 0xC1, 0xF0, 0x03, 0xC0, 0x00, 0x3E,
  0x0F, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x78, 0x00, 0xF0, 0x00, 0x3E, 0x07,
  0xC0, 0x0F, 0x80, 0x01, 0xE0, 0x3E, 0x00, 0x7C, 0x00, 0x1F, 0x01, 0xF0,
  0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x3C, 0x00,
  0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3C,
  0x00, 0x01, 0xFF, 0xC0, 0x02, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x0F,
  0x81, 0xF8, 0x00, 0x03, 0xFF, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xE3, 0xFE, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0x3E, 0x00, 0x07,
  0xE0, 0x0E, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0xF0, 0x00, 0x7F, 0x03, 0xEF,
  0xC0, 0x03, 0x7E, 0x0F, 0x9F, 0x00, 0x1C, 0xF8, 0x7C, 0x7E, 0x00, 0xF3,
  0xF3, 0xF1, 0xFE, 0x07, 0x8F, 0xCF, 0x83, 0xFF, 0xFE, 0x1F, 0xFE, 0x07,
  0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xFC, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x18, 0x00, 0x78, 0x00, 0xCF, 0x80, 0x7C, 0x03, 0xEF, 0xF8,
  0x3E, 0x0F, 0xF7, 0xFF, 0x9F, 0x7F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFA, 0x1F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x03, 0xF0, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFE, 0x07,
  0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x1F, 0x8F, 0xF7, 0xFD,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFD, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xF8,
  0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x03, 0xEF, 0xC0, 0x3E, 0x03, 0xF7,
  0xE0, 0x7F, 0x81, 0xFB, 0xF0, 0x3F, 0xC0, 0xFD, 0xF0, 0x1F, 0xE0, 0x7E,
  0xF8, 0x1F, 0xF0, 0x3E, 0xFC, 0x0F, 0xF0, 0x1F, 0x7E, 0x03, 0xF8, 0x1F,
  0xBF, 0x01, 0xF8, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00,
  0xFC, 0xF8, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFD, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7F, 0x8F, 0x80, 0x01, 0xFE,
  0x1F, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x7F, 0x00,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xE0, 0x07, 0xC0, 0x00, 0x80, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0x00, 0x00,
  0x3F, 0x00, 0x40, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x18, 0x00, 0x03, 0xF0, 0x04, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x10,
  0x00, 0x00, 0xFC, 0x1E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x1F,
  0x9F, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x3F, 0x80, 0x00, 0x7C, 0x7F, 0xFC, 0x00,
  0x1F, 0x3F, 0xFF, 0x80, 0x07, 0x9F, 0xFF, 0xF0, 0x01, 0xEF, 0xFF, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x20, 0x00, 0x03, 0xF0,
  0x3C, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x83, 0xFC, 0x00, 0x3E, 0x1F, 0xFE, 0x00, 0xFC, 0xFF, 0xFF,
  0x01, 0xF3, 0xFF, 0xFF, 0x07, 0xEF, 0xFF, 0xFF, 0x0F, 0xBE, 0x01, 0xFE,
  0x3F, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFC, 0xFE, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7F, 0x1F, 0x80,
  0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x3F, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xF8, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x0F, 0xC7, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0x3F, 0x3E, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x03, 0xF3, 0xE0,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF8,
  0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0x3F,
  0xC1, 0xFE, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0xEF, 0x9F, 0xF0, 0x1F, 0x7E, 0x3F, 0xFF, 0xF9, 0xF0,
  0xFF, 0xFF, 0xCF, 0xC0, 0xFF, 0xFE, 0x3E, 0x01, 0xFF, 0xF1, 0xF8, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xF8, 0x1F,
  0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x88,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x02, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0x03, 0xFE, 0x1F, 0xC0, 0x0F, 0xE3, 0xF0, 0x00, 0x7F, 0x7E,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF3, 0x80, 0x00,
  0x1F, 0x08, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x01,
  0xF8, 0x78, 0x7C, 0x03, 0xFE, 0x3C, 0x3C, 0x03, 0xFF, 0x9E, 0x3E, 0x03,
  0xFF, 0xEF, 0x1F, 0x03, 0xF8, 0x3F, 0x8F, 0x81, 0xF0, 0x0F, 0xC7, 0xC1,
  0xF0, 0x07, 0xE7, 0xC0, 0xF8, 0x01, 0xE3, 0xE0, 0xFC, 0x00, 0xF1, 0xF0,
  0x7C, 0x00, 0x78, 0xF8, 0x3E, 0x00, 0x7C, 0x7C, 0x1F, 0x00, 0x3E, 0x3C,
  0x1F, 0x80, 0x1F, 0x3E, 0x0F, 0x80, 0x0F, 0x1F, 0x07, 0xC0, 0x07, 0x8F,
  0x83, 0xE0, 0x03, 0xC7, 0xC1, 0xF0, 0x03, 0xE3, 0xE0, 0xF8, 0x01, 0xF1,
  0xF0, 0x7C, 0x00, 0xF8, 0xF0, 0x3E, 0x00, 0xF8, 0x78, 0x1F, 0x00, 0x7C,
  0x3C, 0x0F, 0x80, 0x5E, 0x1E, 0x07, 0xE0, 0x7F, 0x0F, 0x01, 0xF8, 0xEF,
  0x87, 0x80, 0xFF, 0xF7, 0xC3, 0xC0, 0x3F, 0xF3, 0xC1, 0xE0, 0x0F, 0xF1,
  0xE0, 0xF8, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x01, 0xF0, 0xFC, 0x00,
  0x00, 0x3F, 0x1F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3E,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x03, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x07,
  0xE1, 0xF0, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x07,
  0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x01, 0x80, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x20, 0x3F, 0x00, 0x00, 0x3C, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xE0, 0x0F, 0x80, 0x03,
  0xF8, 0x07, 0xC0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x07, 0xE1, 0xF0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7E, 0x1F,
  0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7F,
  0x07, 0xC0, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0x7F, 0x01, 0xF0, 0x00, 0x7F,
  0x81, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x03,
  0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x01, 0x80, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xFC, 0x7C, 0x00, 0xFF,
  0xFE, 0x3E, 0x00, 0x7F, 0xFF, 0x3F, 0x00, 0x3F, 0xFF, 0x1F, 0x80, 0x1F,
  0xFF, 0x8F, 0xC0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x03, 0xE3, 0xF0, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0xF8, 0x7E, 0x00,
  0x00, 0x7C, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x1D, 0xF0, 0x1F, 0xF0, 0x3E, 0xF8, 0x07,
  0xFF, 0xFE, 0x7C, 0x01, 0xFF, 0xFE, 0x3E, 0x00, 0x7F, 0xFE, 0x3E, 0x00,
  0x1F, 0xFE, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x18, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0x00, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0xC0, 0x00, 0x03,
  0xE0, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x3F, 0x80, 0x00, 0x00,
  0xF8, 0xFF, 0x00, 0x00, 0x01, 0xF3, 0xFF, 0x00, 0x00, 0x03, 0xEF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x7E, 0x00, 0x00, 0x1F, 0xFC, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0xFC, 0x00, 0x00, 0x7F, 0xC1, 0xF8, 0x00, 0x00, 0xFF, 0x01,
  0xF0, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x1F,
  0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x7F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3D, 0xF0, 0x1F, 0x78,
  0x03, 0xEF, 0x81, 0xF3, 0xC0, 0x3E, 0x7C, 0x0F, 0x9F, 0x01, 0xF3, 0xC0,
  0x7C, 0xF8, 0x1F, 0x3E, 0x03, 0xE3, 0xC0, 0xF1, 0xF0, 0x1F, 0x1E, 0x0F,
  0x8F, 0x80, 0xF8, 0xF8, 0xF8, 0x7C, 0x0F, 0x87, 0xC7, 0xC3, 0xE0, 0x7C,
  0x1E, 0x7C, 0x1E, 0x03, 0xE0, 0xF3, 0xC1, 0xF0, 0x1F, 0x07, 0xFE, 0x0F,
  0x80, 0xF8, 0x3F, 0xE0, 0x7C, 0x07, 0xC0, 0xFF, 0x03, 0xE0, 0x7C, 0x07,
  0xF0, 0x1F, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80,
  0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x01, 0xC0,
  0x1F, 0x03, 0xE0, 0x0C, 0x00, 0xF8, 0x1F, 0x00, 0x20, 0x0F, 0x80, 0xF8,
  0x02, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xE0, 0x3F, 0xC0, 0x00, 0x7C, 0x07, 0xF8, 0x00, 0x0F, 0x80, 0xFF,
  0x80, 0x01, 0xF0, 0x3F, 0xF0, 0x00, 0x3E, 0x07, 0xFE, 0x00, 0x07, 0xC0,
  0xFB, 0xC0, 0x01, 0xF0, 0x1F, 0x7C, 0x00, 0x3E, 0x03, 0xEF, 0x80, 0x07,
  0xC0, 0x7D, 0xF0, 0x00, 0xF8, 0x1F, 0x3E, 0x00, 0x1F, 0x03, 0xE3, 0xC0,
  0x03, 0xE0, 0x7C, 0x7C, 0x00, 0xF8, 0x0F, 0x8F, 0x80, 0x1F, 0x01, 0xF1,
  0xF0, 0x03, 0xE0, 0x7C, 0x1E, 0x00, 0x7C, 0x0F, 0x83, 0xE0, 0x0F, 0x81,
  0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x0F, 0x80, 0x7C, 0x07, 0xC1, 0xF0, 0x0F,
  0x80, 0xF8, 0x1E, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0xF0, 0x3E, 0x03, 0xE0,
  0x1F, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x03,
  0xE0, 0x0F, 0x83, 0xE0, 0x7C, 0x00, 0xF0, 0x7C, 0x0F, 0x80, 0x1F, 0x1F,
  0x01, 0xF0, 0x03, 0xE3, 0xE0, 0x3E, 0x00, 0x7C, 0x7C, 0x0F, 0x80, 0x07,
  0x8F, 0x81, 0xF0, 0x00, 0xF9, 0xF0, 0x3E, 0x00, 0x1F, 0x3E, 0x07, 0xC0,
  0x03, 0xEF, 0x80, 0xF8, 0x00, 0x7D, 0xF0, 0x1F, 0x00, 0x07, 0xBE, 0x07,
  0xC0, 0x00, 0xFF, 0xC0, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0x00, 0x03, 0xFE,
  0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x7C, 0x00, 0x07, 0xF8, 0x0F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x7E, 0xF8, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x01, 0xF9, 0xF0, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7E, 0x3E, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x3F,
  0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0xFC,
  0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x01, 0xF8, 0x1F,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF0,
  0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3E, 0x7E,
  0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x10, 0x00, 0x0F, 0xC0, 0x1C, 0x00, 0x03, 0xF0, 0x1F, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x7F, 0x80,
  0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0x80,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x1C, 0x07,
  0xE0, 0x00, 0x01, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x01, 0x00, 0x00, 0x01, 0xF0, 0x30, 0x00, 0x00, 0x3F,
  0x07, 0x80, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE1, 0xF8, 0x00,
  0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x3F, 0x0F,
  0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x01, 0xF8,
  0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x3F, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0,
  0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x01, 0xE1, 0xF8, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0x00, 0x1F, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0xFC, 0x01, 0xE0, 0x78, 0x07, 0xF0,
  0x0F, 0x81, 0xE0, 0x1F, 0xC0, 0x3E, 0x07, 0x80, 0x7F, 0x00, 0xF8, 0x3E,
  0x03, 0xFC, 0x03, 0xC0, 0xF8, 0x0F, 0xF0, 0x1F, 0x03, 0xE0, 0x3F, 0xC0,
  0x7C, 0x0F, 0x81, 0xE7, 0x81, 0xF0, 0x3E, 0x07, 0x9E, 0x07, 0x80, 0xF8,
  0x3E, 0x78, 0x3E, 0x03, 0xE0, 0xF1, 0xE0, 0xF8, 0x0F, 0x03, 0xC7, 0x83,
  0xE0, 0x3C, 0x1F, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x78, 0x7C, 0x03, 0xC3,
  0xE1, 0xE1, 0xF0, 0x0F, 0x0F, 0x07, 0x87, 0xC0, 0x7C, 0x3C, 0x1E, 0x1E,
  0x01, 0xF1, 0xF0, 0x78, 0xF8, 0x07, 0xC7, 0x81, 0xE3, 0xE0, 0x1F, 0x1E,
  0x07, 0x8F, 0x80, 0x7C, 0xF8, 0x1E, 0x3C, 0x01, 0xF3, 0xC0, 0x78, 0xF0,
  0x07, 0x9F, 0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x07, 0x9F, 0x00, 0x79, 0xE0,
  0x1E, 0x78, 0x01, 0xEF, 0x80, 0x79, 0xE0, 0x07, 0xBC, 0x01, 0xEF, 0x80,
  0x3E, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00,
  0x0F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x3F,
  0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x01,
  0xF1, 0xF8, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x8F,
  0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0xF9, 0xF8,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0x8C,
  0x00, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x08, 0x38, 0xF8, 0x7C, 0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x1E, 0x0F, 0x0F,
  0x04, 0x00, 0x1F, 0xE0, 0x3E, 0x00, 0xFF, 0xF0, 0x7C, 0x07, 0xFF, 0xF0,
  0xF8, 0x1F, 0xFF, 0xF3, 0xE0, 0x7F, 0xFF, 0xF7, 0xC1, 0xFF, 0x01, 0xEF,
  0x83, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFC,
  0x7E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x7E,
  0x00, 0x00, 0x78, 0xFC, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x6F, 0x87, 0xE0, 0x01,
  0xFE, 0x07, 0xE0, 0x07, 0x7C, 0x0F, 0xF0, 0x3C, 0xFF, 0xDF, 0xFF, 0xF9,
  0xFF, 0x9F, 0xFF, 0xE1, 0xFE, 0x1F, 0xFF, 0x83, 0xFC, 0x1F, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x3F, 0x80, 0x03, 0xE0, 0xFF, 0xF0, 0x03, 0xE1, 0xFF,
  0xF8, 0x03, 0xE3, 0xFF, 0xFC, 0x07, 0xE7, 0xFF, 0xFE, 0x07, 0xCF, 0x81,
  0xFE, 0x07, 0xDE, 0x00, 0x7E, 0x07, 0xD8, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00,
  0x7E, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x7D, 0x80, 0x07, 0xF0, 0x7D, 0xE0, 0x1F,
  0xE0, 0x7C, 0xFF, 0xFF, 0xE0, 0x7C, 0xFF, 0xFF, 0xC0, 0x7C, 0x7F, 0xFF,
  0x00, 0x7C, 0x1F, 0xFE, 0x00, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xF8,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x1F, 0x00, 0x00, 0x3C,
  0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x01, 0xF0, 0x01, 0xFF, 0xE0, 0xF8,
  0x00, 0xFF, 0xFE, 0x3E, 0x00, 0xFF, 0xFF, 0xCF, 0x80, 0x7F, 0xFF, 0xF3,
  0xE0, 0x1F, 0xE0, 0x3E, 0xF8, 0x0F, 0xE0, 0x01, 0xBE, 0x07, 0xF0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F,
  0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00,
  0x7F, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x06, 0xF8, 0x07, 0xE0, 0x07, 0xBE, 0x01, 0xFE, 0x07, 0xCF, 0x80, 0x7F,
  0xFF, 0xE7, 0xE0, 0x0F, 0xFF, 0xF1, 0xF0, 0x01, 0xFF, 0xF8, 0x7C, 0x00,
  0x3F, 0xFC, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xE0,
  0x00, 0x0F, 0x9F, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF9, 0xF0, 0x00,
  0x1F, 0xCF, 0xC0, 0x03, 0xFE, 0x3F, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x30, 0xF8, 0x00, 0x00, 0xE3, 0xF0, 0x00, 0x07, 0xCF, 0xC0,
  0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0xC0, 0xFF, 0x01,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xC0, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x00,
  0x00, 0x03, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x83, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x8F, 0x80, 0x00, 0x00, 0x03, 0xF9,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xC0,
  0x07, 0xFF, 0x83, 0xE0, 0x03, 0xFF, 0xF8, 0xF8, 0x03, 0xFF, 0xFE, 0x3E,
  0x01, 0xFF, 0xFF, 0xCF, 0x80, 0x7F, 0x80, 0xFB, 0xE0, 0x3F, 0x80, 0x06,
  0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07,
  0xF0, 0x3E, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0x6F, 0x80, 0x7E, 0x00, 0x7B, 0xE0, 0x1F, 0xE0, 0x7C, 0xF8, 0x07, 0xFF,
  0xFE, 0x3E, 0x00, 0xFF, 0xFF, 0x9F, 0x80, 0x1F, 0xFF, 0xC7, 0xC0, 0x03,
  0xFF, 0xC1, 0xF0, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x40, 0x00, 0x1F, 0x00, 0x30, 0x00, 0x0F,
  0xC0, 0x1F, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x07, 0xF0, 0x01, 0xF8, 0x7F, 0xF0, 0x07, 0xC3, 0xFF, 0xE0, 0x1F,
  0x1F, 0xFF, 0xC0, 0x7C, 0xFF, 0xFF, 0x81, 0xF3, 0xC0, 0xFE, 0x0F, 0xDC,
  0x01, 0xF8, 0x3F, 0x60, 0x03, 0xF0, 0xFB, 0x00, 0x0F, 0xC3, 0xE8, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x0C, 0x00, 0x7C,
  0x00, 0x70, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x1F, 0x00,
  0xFE, 0x00, 0x7C, 0x07, 0xF0, 0x03, 0xE0, 0x7F, 0x80, 0x0F, 0x83, 0xFC,
  0x00, 0x3E, 0x1F, 0xC0, 0x00, 0xF8, 0xFE, 0x00, 0x03, 0xE7, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x10, 0x00, 0xF8, 0x00, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xFC, 0x03, 0xE0, 0x03, 0xF8, 0x1F, 0x00, 0x07, 0xF0, 0x7C,
  0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x1F, 0xC7, 0xC0, 0x00, 0x3F, 0x9F, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0x83, 0xFF,
  0x80, 0x07, 0xC3, 0xFF, 0xF0, 0x03, 0xE3, 0xFF, 0xF8, 0x01, 0xF3, 0xFF,
  0xFE, 0x00, 0xFB, 0xE0, 0x7F, 0x00, 0xFD, 0xC0, 0x1F, 0xC0, 0x7D, 0xC0,
  0x07, 0xE0, 0x3E, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0xF8, 0x0F, 0xC0,
  0x00, 0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x7C,
  0x00, 0x7F, 0x00, 0x3E, 0x01, 0xFE, 0x00, 0x3F, 0x07, 0xFC, 0x00, 0x1F,
  0x1F, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x41, 0xF0, 0x7E, 0x00, 0x31, 0xF8, 0x1F, 0x00, 0x3C,
  0xF8, 0x0F, 0xC0, 0x3F, 0x7C, 0x03, 0xE0, 0x3F, 0x3E, 0x01, 0xF8, 0x7F,
  0x1F, 0x00, 0x7C, 0x7F, 0x0F, 0x80, 0x3F, 0x7F, 0x0F, 0xC0, 0x1F, 0xFF,
  0x07, 0xC0, 0x07, 0xFF, 0x03, 0xE0, 0x03, 0xFF, 0x01, 0xF0, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x30, 0x0F, 0x80, 0x0F, 0x01, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0xFE, 0x0F,
  0x80, 0x3F, 0x81, 0xF0, 0x1F, 0xE0, 0x3E, 0x07, 0xF8, 0x07, 0xC1, 0xFC,
  0x00, 0xF8, 0x7F, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xC7, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x1F, 0x80, 0x7C, 0x7F, 0x03,
  0xFC, 0x07, 0xCF, 0xF8, 0x7F, 0xE0, 0x7D, 0xFF, 0xCF, 0xFE, 0x07, 0xBF,
  0xFD, 0xFF, 0xF0, 0xFB, 0x8F, 0xDC, 0x3F, 0x0F, 0xE0, 0x7F, 0x81, 0xF0,
  0xFC, 0x07, 0xF0, 0x1F, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xE0,
  0x1F, 0x0F, 0x80, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC0, 0x1E, 0x1F, 0x00,
  0x7C, 0x01, 0xE1, 0xF0, 0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x78, 0x03, 0xE1,
  0xF0, 0x07, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x80,
  0x3C, 0x3E, 0x00, 0xF8, 0x03, 0xC3, 0xE0, 0x0F, 0x80, 0x7C, 0x3E, 0x00,
  0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xF0, 0x07, 0xC7,
  0xC0, 0x1F, 0x00, 0x78, 0x7C, 0x01, 0xF0, 0x07, 0x87, 0xC0, 0x1F, 0x00,
  0xF8, 0x7C, 0x01, 0xE0, 0x0F, 0x87, 0xC0, 0x3E, 0x00, 0xF8, 0x78, 0x03,
  0xE0, 0x0F, 0x87, 0x80, 0x3E, 0x00, 0xF0, 0xF8, 0x03, 0xE0, 0x1F, 0x0F,
  0x80, 0x3E, 0x01, 0xF0, 0xF8, 0x03, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x07, 0xFF, 0x00, 0x7C, 0x3F, 0xFE,
  0x01, 0xF1, 0xFF, 0xFC, 0x07, 0xCF, 0xFF, 0xF8, 0x3F, 0x3C, 0x0F, 0xE0,
  0xFD, 0xC0, 0x1F, 0x83, 0xF6, 0x00, 0x3F, 0x0F, 0xB0, 0x00, 0xFC, 0x3E,
  0x80, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x1F, 0x80,
  0x00, 0xFC, 0x7E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x01, 0xFC, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xF8,
  0xFC, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0xBE, 0x00,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x01,
  0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xF8, 0x0F, 0xE0, 0x00, 0x3E, 0x0F, 0xFF, 0x00, 0x0F, 0x87,
  0xFF, 0xE0, 0x07, 0xE3, 0xFF, 0xFC, 0x01, 0xF1, 0xFF, 0xFF, 0x80, 0x7C,
  0xF8, 0x1F, 0xE0, 0x1F, 0x78, 0x01, 0xF8, 0x07, 0xD8, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x01, 0xF0, 0x3F, 0x80, 0x00, 0x7C,
  0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF8,
  0x1F, 0x60, 0x01, 0xFC, 0x07, 0xDF, 0x01, 0xFE, 0x01, 0xF3, 0xFF, 0xFF,
  0x80, 0x7C, 0xFF, 0xFF, 0xC0, 0x1F, 0x1F, 0xFF, 0xC0, 0x0F, 0xC1, 0xFF,
  0xE0, 0x03, 0xE0, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x7F, 0xF8, 0x3E, 0x00, 0xFF, 0xFE, 0x3E, 0x03, 0xFF, 0xFF,
  0x3E, 0x07, 0xFF, 0xFF, 0x3E, 0x07, 0xF8, 0x0F, 0xBE, 0x0F, 0xE0, 0x01,
  0xBE, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00,
  0xF8, 0xFC, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07,
  0xF0, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1B,
  0xE0, 0x7E, 0x00, 0x7B, 0xE0, 0x7F, 0x81, 0xF3, 0xE0, 0x7F, 0xFF, 0xE7,
  0xE0, 0x3F, 0xFF, 0xC7, 0xC0, 0x1F, 0xFF, 0x87, 0xC0, 0x0F, 0xFF, 0x07,
  0xC0, 0x03, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0xFE, 0x03, 0xFE, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xE0, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x3E, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xF0, 0x00, 0x3C, 0x07, 0xE0, 0x00,
  0x18, 0x07, 0xC0, 0x00, 0x10, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x10, 0x00, 0x00,
  0xF8, 0x18, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0xFF, 0x00, 0x03,
  0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x04, 0x01, 0xF0, 0x00,
  0x60, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xF0,
  0x3E, 0x01, 0xFE, 0x01, 0xF0, 0x3F, 0xE0, 0x0F, 0x83, 0xFC, 0x00, 0x7C,
  0x7F, 0xC0, 0x03, 0xE7, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C,
  0x7E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x5F, 0x0F, 0xC0, 0x03, 0x7C, 0x1F, 0x00, 0x1D, 0xF0, 0x7E, 0x00, 0xEF,
  0xC1, 0xFE, 0x0F, 0x3E, 0x07, 0xFF, 0xFC, 0xF8, 0x0F, 0xFF, 0xE3, 0xE0,
  0x1F, 0xFF, 0x0F, 0x80, 0x3F, 0xF8, 0x3E, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x18, 0xFF, 0xF0, 0x01, 0xF9, 0xFF, 0xE0, 0x01, 0xF3,
  0xFF, 0xC0, 0x03, 0xEF, 0xFF, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0xF8, 0x1F, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xF0, 0x07, 0x80, 0x0F,
  0xE0, 0x1F, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0xFE, 0x00, 0x7C, 0x03, 0xFC,
  0x00, 0xF8, 0x1F, 0xF0, 0x01, 0xF1, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x03, 0x03, 0xC0, 0x1F, 0x03,
  0xE0, 0xF0, 0x07, 0xC0, 0xF8, 0x7C, 0x01, 0xE0, 0x1E, 0x1F, 0x00, 0x78,
  0x07, 0x87, 0xC0, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x80, 0x7C, 0x78, 0x03,
  0xE0, 0x1F, 0x1E, 0x00, 0xF8, 0x07, 0xCF, 0x80, 0x3C, 0x01, 0xF3, 0xE0,
  0x0F, 0x00, 0x7C, 0xF8, 0x07, 0xC0, 0x1F, 0x3E, 0x01, 0xF0, 0x07, 0xCF,
  0x00, 0x7C, 0x01, 0xF3, 0xC0, 0x1F, 0x00, 0x7C, 0xF0, 0x07, 0x80, 0x1F,
  0x7C, 0x01, 0xE0, 0x07, 0x9F, 0x00, 0xF8, 0x01, 0xE7, 0xC0, 0x3E, 0x00,
  0xF9, 0xE0, 0x0F, 0x80, 0x3E, 0x78, 0x03, 0xE0, 0x0F, 0x9E, 0x00, 0xF0,
  0x03, 0xCF, 0x80, 0x3C, 0x01, 0xF3, 0xE0, 0x1F, 0x00, 0x7C, 0xF8, 0x07,
  0xC0, 0x3F, 0x3E, 0x01, 0xF0, 0x0F, 0x8F, 0x80, 0xFC, 0x07, 0xE3, 0xE0,
  0x3F, 0x01, 0xF0, 0xF8, 0x1F, 0xC0, 0xFC, 0x3F, 0x1E, 0xF8, 0x7E, 0x0F,
  0xFF, 0xBF, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0xC0,
  0x0F, 0xF0, 0x3F, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0,
  0x03, 0xFF, 0x83, 0xFF, 0xE0, 0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0x7F, 0x9F,
  0x1F, 0x1F, 0x81, 0xFE, 0x3E, 0x78, 0x1F, 0x07, 0xF0, 0x3C, 0xE0, 0x1E,
  0x1F, 0x80, 0x7B, 0xC0, 0x3E, 0x1E, 0x00, 0xF7, 0x00, 0x7C, 0x30, 0x01,
  0xEE, 0x00, 0xF8, 0x00, 0x03, 0xD8, 0x01, 0xE0, 0x00, 0x07, 0xF0, 0x03,
  0xC0, 0x00, 0x0F, 0xC0, 0x08, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x7F, 0x00,
  0x00, 0x3C, 0x00, 0xDE, 0x00, 0x20, 0xF8, 0x03, 0xBC, 0x00, 0xE1, 0xF0,
  0x07, 0x78, 0x07, 0xC3, 0xE0, 0x1E, 0xF0, 0x1F, 0xC7, 0xC0, 0x39, 0xE0,
  0x7E, 0x07, 0xC0, 0xF3, 0xE3, 0xF8, 0x0F, 0x87, 0xC7, 0xCF, 0xE0, 0x1F,
  0xFF, 0x8F, 0xFF, 0x80, 0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xF0, 0x1F,
  0x00, 0x03, 0xF0, 0x0F, 0x80, 0x03, 0xF8, 0x07, 0xC0, 0x03, 0x7C, 0x03,
  0xF0, 0x03, 0xBE, 0x01, 0xF8, 0x03, 0x9F, 0x00, 0xFF, 0x07, 0xDF, 0x80,
  0x3F, 0xFF, 0xCF, 0x80, 0x1F, 0xFF, 0xC7, 0xC0, 0x07, 0xFF, 0xC3, 0xE0,
  0x01, 0xFF, 0xC1, 0xF0, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x40, 0x00, 0x1F, 0x80, 0x30, 0x00, 0x1F,
  0xC0, 0x3E, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0x80, 0x7F,
  0xFE, 0x07, 0xC0, 0x7F, 0xFF, 0xC3, 0xE0, 0x7F, 0xFF, 0xF9, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x3F, 0x03, 0xFF, 0xFC, 0x3E, 0x00, 0x3F, 0xFE, 0x1F,
  0x00, 0x07, 0xFC, 0x0F, 0x00, 0x00, 0xFC, 0x07, 0x80, 0x00, 0xFC, 0x03,
  0xC0, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x01, 0x80, 0x03, 0xF0, 0x03,
  0xC0, 0x03, 0xF0, 0x01, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x03, 0xF0, 0x00,
  0x7C, 0x07, 0xE0, 0x00, 0x1E, 0x07, 0xF0, 0x00, 0x0F, 0x87, 0xFF, 0x80,
  0x07, 0xC7, 0xFF, 0xFE, 0x03, 0xE3, 0xEF, 0xFF, 0xF9, 0xF1, 0xF0, 0xFF,
  0xFF, 0xF8, 0xF8, 0x1F, 0xFF, 0xFC, 0xFC, 0x01, 0xFF, 0xFC, 0x7E, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x3F, 0xF0, 0x00,
  0x7C, 0x1F, 0xFE, 0x00, 0x1E, 0x0F, 0xFF, 0xC0, 0x0F, 0x87, 0xE3, 0xF0,
  0x03, 0xC1, 0xF0, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC0, 0x7C, 0x3E, 0x01,
  0xF0, 0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x87, 0xC0, 0x0F, 0xFF, 0xC1, 0xE0,
  0x01, 0xFF, 0xE0, 0xF8, 0x00, 0x3F, 0xF0, 0x3C, 0x00, 0x07, 0xF8, 0x03,
  0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_Italic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 15, 46, 39, 12, -45 },
  { 88, 19, 18, 39, 14, -48 },
  { 131, 39, 45, 39, 1, -45 },
  { 351, 37, 61, 39, 1, -53 },
  { 634, 45, 47, 39, -2, -46 },
  { 899, 38, 47, 39, 0, -46 },
  { 1123, 8, 18, 39, 19, -48 },
  { 1141, 25, 58, 39, 13, -49 },
  { 1323, 24, 58, 39, 3, -49 },
  { 1497, 33, 32, 39, 4, -36 },
  { 1629, 32, 33, 39, 4, -36 },
  { 1761, 15, 18, 39, 9, -9 },
  { 1795, 20, 5, 39, 10, -22 },
  { 1808, 10, 9, 39, 12, -8 },
  { 1820, 37, 58, 39, 2, -49 },
  { 2089, 33, 47, 39, 4, -46 },
  { 2283, 31, 45, 39, 3, -45 },
  { 2458, 34, 46, 39, 2, -46 },
  { 2654, 34, 47, 39, 2, -46 },
  { 2854, 35, 45, 39, 1, -45 },
  { 3051, 34, 46, 39, 3, -45 },
  { 3247, 31, 46, 39, 4, -45 },
  { 3426, 32, 45, 39, 7, -45 },
  { 3606, 34, 47, 39, 3, -46 },
  { 3806, 30, 46, 39, 6, -46 },
  { 3979, 15, 35, 39, 12, -34 },
  { 4045, 18, 43, 39, 9, -34 },
  { 4142, 31, 37, 39, 6, -38 },
  { 4286, 34, 18, 39, 3, -29 },
  { 4363, 31, 37, 39, 3, -38 },
  { 4507, 28, 47, 39, 8, -46 },
  { 4672, 33, 53, 39, 4, -46 },
  { 4891, 35, 45, 39, -1, -45 },
  { 5088, 33, 45, 39, 3, -45 },
  { 5274, 33, 47, 39, 5, -46 },
  { 5468, 33, 45, 39, 4, -45 },
  { 5654, 35, 45, 39, 3, -45 },
  { 5851, 36, 45, 39, 3, -45 },
  { 6054, 33, 47, 39, 4, -46 },
  { 6248, 35, 45, 39, 3, -45 },
  { 6445, 35, 45, 39, 3, -45 },
  { 6642, 32, 46, 39, 4, -45 },
  { 6826, 39, 45, 39, 3, -45 },
  { 7046, 28, 45, 39, 5, -45 },
  { 7204, 37, 45, 39, 2, -45 },
  { 7413, 35, 45, 39, 3, -45 },
  { 7610, 33, 47, 39, 4, -46 },
  { 7804, 35, 45, 39, 3, -45 },
  { 8001, 33, 58, 39, 4, -46 },
  { 8241, 35, 45, 39, 3, -45 },
  { 8438, 36, 47, 39, 2, -46 },
  { 8650, 36, 45, 39, 6, -45 },
  { 8853, 33, 46, 39, 5, -45 },
  { 9043, 34, 45, 39, 7, -45 },
  { 9235, 38, 45, 39, 3, -45 },
  { 9449, 43, 45, 39, -1, -45 },
  { 9691, 37, 45, 39, 6, -45 },
  { 9900, 40, 45, 39, 0, -45 },
  { 10125, 28, 58, 39, 10, -49 },
  { 10328, 17, 58, 39, 12, -49 },
  { 10452, 27, 58, 39, 1, -49 },
  { 10648, 33, 26, 39, 4, -45 },
  { 10756, 32, 5, 39, 0, 6 },
  { 10776, 8, 13, 39, 15, -51 },
  { 10789, 31, 35, 39, 4, -34 },
  { 10925, 32, 49, 39, 3, -48 },
  { 11121, 29, 35, 39, 5, -34 },
  { 11248, 34, 49, 39, 4, -48 },
  { 11457, 30, 35, 39, 5, -34 },
  { 11589, 43, 62, 39, -1, -48 },
  { 11923, 34, 48, 39, 2, -34 },
  { 12127, 30, 48, 39, 4, -48 },
  { 12307, 30, 51, 39, 5, -50 },
  { 12499, 30, 64, 39, 4, -50 },
  { 12739, 33, 49, 39, 4, -48 },
  { 12942, 27, 49, 39, 7, -48 },
  { 13108, 36, 34, 39, 1, -34 },
  { 13261, 30, 34, 39, 4, -34 },
  { 13389, 31, 35, 39, 4, -34 },
  { 13525, 34, 47, 39, 1, -34 },
  { 13725, 32, 47, 39, 4, -34 },
  { 13913, 31, 34, 39, 7, -34 },
  { 14045, 32, 35, 39, 3, -34 },
  { 14185, 29, 46, 39, 5, -45 },
  { 14352, 30, 35, 39, 5, -34 },
  { 14484, 31, 35, 39, 4, -34 },
  { 14620, 34, 35, 39, 3, -34 },
  { 14769, 39, 35, 39, 0, -34 },
  { 14940, 33, 48, 39, 2, -34 },
  { 15138, 33, 35, 39, 3, -34 },
  { 15283, 31, 58, 39, 7, -49 },
  { 15508, 14, 58, 39, 13, -49 },
  { 15610, 30, 58, 39, 3, -49 },
  { 15828, 34, 15, 39, 3, -27 },
};

const GFXfont IBMPlexMono_Italic65pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic65pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic65pt7bGlyphs,
  0x20, 0x7E, 85
};

#endif // _IBMPLEXMONO_ITALIC65PT7B_H_
