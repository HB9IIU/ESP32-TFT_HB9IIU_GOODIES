#ifndef _IBMPLEXMONO_ITALIC21PT7B_H_
#define _IBMPLEXMONO_ITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x8C, 0x63, 0x18, 0x84, 0x20, 0x00, 0x0E, 0x73, 0x80, 0x66,
  0xC9, 0x92, 0x64, 0xD9, 0x80, 0x03, 0x30, 0x11, 0x00, 0x98, 0x0C, 0xC0,
  0x44, 0x1E, 0x7C, 0x33, 0x01, 0x10, 0x09, 0x87, 0xCF, 0x84, 0x40, 0x26,
  0x03, 0x30, 0x11, 0x01, 0x98, 0x00, 0x01, 0x80, 0x18, 0x07, 0xE1, 0x93,
  0x31, 0x13, 0x10, 0x33, 0x03, 0x30, 0x1E, 0x00, 0x78, 0x02, 0xE0, 0x26,
  0x06, 0x60, 0x66, 0x44, 0x6E, 0x4C, 0x3F, 0x00, 0x40, 0x0C, 0x00, 0x0F,
  0x06, 0x32, 0x18, 0x46, 0x21, 0x8C, 0x83, 0x13, 0x02, 0x6C, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x1B, 0x30, 0x24, 0x20, 0x88, 0xC3, 0x11, 0x84,
  0x22, 0x30, 0x38, 0x00, 0x07, 0x80, 0x8C, 0x18, 0x41, 0x84, 0x18, 0x41,
  0x8C, 0x0C, 0x83, 0xF0, 0x46, 0x0C, 0x60, 0xC3, 0x0C, 0x31, 0xC3, 0xB4,
  0x5A, 0x38, 0xC0, 0x6D, 0x2D, 0x80, 0x03, 0x04, 0x08, 0x10, 0x30, 0x20,
  0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x60, 0x30,
  0x18, 0x18, 0x0C, 0x06, 0x02, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02,
  0x02, 0x06, 0x04, 0x0C, 0x08, 0x10, 0x20, 0xC0, 0x06, 0x00, 0xC0, 0x18,
  0x22, 0x1F, 0xFE, 0x3E, 0x03, 0x80, 0xD0, 0x33, 0x0C, 0x20, 0x06, 0x00,
  0xC0, 0x18, 0x02, 0x07, 0xFF, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x3B,
  0x98, 0xCC, 0x60, 0xFE, 0xFF, 0x80, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x60,
  0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80,
  0x20, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x00, 0x0F, 0x83, 0x18,
  0xC1, 0x90, 0x36, 0x06, 0xC0, 0xD1, 0x9E, 0x73, 0xC0, 0x78, 0x0B, 0x03,
  0x60, 0x64, 0x18, 0xC6, 0x0F, 0x80, 0x07, 0x03, 0xC3, 0x31, 0x8C, 0x43,
  0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x0F,
  0xFC, 0x1F, 0x86, 0x19, 0x81, 0x10, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x3F, 0xF0, 0x07, 0xC1,
  0x86, 0x10, 0x20, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0xF0, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x06, 0x40, 0xCE, 0x18, 0x3F, 0x00, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x36, 0x06, 0x40, 0xC4, 0x0C, 0xC1, 0x8C, 0x30, 0xC6, 0x0C,
  0x60, 0xCF, 0xFF, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1F, 0xE2, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x40, 0x0B, 0xC3, 0x8E, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x64, 0x09, 0xC3, 0x0F, 0x80, 0x03, 0xC1, 0x80, 0xC0, 0x60, 0x30, 0x0C,
  0x06, 0xF9, 0xC3, 0x60, 0xF0, 0x3C, 0x0F, 0x03, 0x40, 0x98, 0x63, 0xE0,
  0x7F, 0xE8, 0x1B, 0x03, 0x60, 0xC0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C,
  0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x00, 0x0F, 0x83, 0x18,
  0xC1, 0x90, 0x32, 0x06, 0x40, 0x8C, 0x20, 0x78, 0x70, 0xD8, 0x1B, 0x03,
  0x60, 0x6C, 0x0D, 0xC3, 0x0F, 0x80, 0x1F, 0x18, 0x64, 0x0B, 0x03, 0xC0,
  0xF0, 0x3C, 0x1F, 0x0E, 0x3D, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x0F,
  0x00, 0x33, 0xCC, 0x00, 0x00, 0x00, 0xE7, 0x38, 0x18, 0xF1, 0x80, 0x00,
  0x00, 0x00, 0x39, 0xC6, 0x18, 0xC3, 0x00, 0x00, 0x40, 0x70, 0x70, 0x70,
  0x70, 0x38, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x30, 0x04, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x20, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x30, 0x1C, 0x0E, 0x0E, 0x0E, 0x0E, 0x02, 0x00, 0x3E, 0x71, 0xB0, 0x50,
  0x30, 0x18, 0x18, 0x1C, 0x7C, 0x38, 0x18, 0x0C, 0x00, 0x07, 0x03, 0x81,
  0x80, 0x0F, 0x83, 0x18, 0xC1, 0x90, 0x36, 0x3E, 0xC8, 0xD3, 0x12, 0x42,
  0xC8, 0x59, 0x0B, 0x23, 0x64, 0x6C, 0xFD, 0x80, 0x10, 0x03, 0x00, 0x3F,
  0x00, 0x01, 0x80, 0x70, 0x0A, 0x03, 0x60, 0x4C, 0x19, 0x82, 0x30, 0xC6,
  0x10, 0x47, 0xF8, 0x81, 0x30, 0x36, 0x06, 0x80, 0xF0, 0x18, 0x3F, 0x86,
  0x18, 0xC1, 0x98, 0x32, 0x06, 0x41, 0x98, 0x33, 0xF8, 0x60, 0xCC, 0x19,
  0x03, 0x20, 0x6C, 0x0D, 0x83, 0x3F, 0xC0, 0x0F, 0x8C, 0x32, 0x0D, 0x80,
  0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x02, 0xC1, 0x90,
  0xC3, 0xE0, 0x1F, 0x86, 0x18, 0xC1, 0x18, 0x33, 0x06, 0x40, 0xC8, 0x1B,
  0x03, 0x60, 0x6C, 0x09, 0x83, 0x30, 0x64, 0x19, 0x86, 0x3F, 0x80, 0x3F,
  0xE6, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0xFE, 0x60, 0x0C,
  0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x3F, 0xE0, 0x3F, 0xF3, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x07, 0xFC, 0x60, 0x06, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0xC3, 0x1C, 0xC1, 0x90,
  0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC7, 0xD8, 0x1B, 0x03, 0x20, 0x66,
  0x1C, 0xC5, 0x0F, 0x60, 0x30, 0x26, 0x0C, 0xC1, 0x90, 0x32, 0x06, 0xC0,
  0xD8, 0x13, 0xFE, 0x60, 0xC8, 0x19, 0x03, 0x60, 0x6C, 0x09, 0x83, 0x30,
  0x60, 0x3F, 0xE0, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20,
  0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x3F, 0xE0, 0x1F, 0xE0,
  0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xCC, 0x10, 0xC6, 0x0F, 0x80, 0x30, 0x39, 0x83, 0x0C, 0x30,
  0x63, 0x02, 0x30, 0x33, 0x01, 0xB0, 0x0F, 0xC0, 0x76, 0x03, 0x18, 0x10,
  0xC1, 0x83, 0x0C, 0x18, 0x60, 0x43, 0x03, 0x00, 0x30, 0x18, 0x08, 0x04,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0xFE, 0x30, 0x73, 0x06, 0x38, 0xE7, 0x9A, 0x69, 0x66, 0xB6, 0x4E, 0x64,
  0xE4, 0x44, 0x4C, 0x84, 0xC0, 0xCC, 0x0C, 0xC0, 0xC8, 0x08, 0x80, 0x80,
  0x38, 0x27, 0x04, 0xA1, 0x96, 0x32, 0xC6, 0xD8, 0xD9, 0x13, 0x22, 0x46,
  0xC8, 0xD9, 0x0B, 0x61, 0x6C, 0x29, 0x87, 0x30, 0xE0, 0x0F, 0x83, 0x18,
  0xC1, 0x90, 0x36, 0x06, 0xC0, 0xD8, 0x1E, 0x03, 0xC0, 0x78, 0x0B, 0x03,
  0x60, 0x64, 0x18, 0xC6, 0x0F, 0x80, 0x3F, 0xC6, 0x0C, 0xC1, 0x98, 0x32,
  0x06, 0x40, 0xD8, 0x33, 0xFC, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x30, 0x00, 0x0F, 0x83, 0x18, 0xC1, 0x90, 0x36, 0x06, 0xC0, 0xD8,
  0x1E, 0x03, 0xC0, 0x78, 0x0B, 0x03, 0x60, 0x64, 0x18, 0xC6, 0x0F, 0x80,
  0x60, 0x04, 0x40, 0xD0, 0x0C, 0x00, 0x3F, 0xC6, 0x0C, 0xC1, 0x98, 0x32,
  0x06, 0x40, 0xD8, 0x33, 0xFC, 0x66, 0x0C, 0x41, 0x0C, 0x21, 0x8C, 0x19,
  0x83, 0x30, 0x70, 0x0F, 0xC6, 0x0C, 0x81, 0x30, 0x06, 0x00, 0xC0, 0x0E,
  0x00, 0xF8, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x68, 0x0D, 0x83, 0x1F, 0x80,
  0xFF, 0xF0, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x00, 0x60,
  0x58, 0x36, 0x0D, 0x03, 0xC0, 0xF0, 0x3C, 0x0B, 0x02, 0xC1, 0xA0, 0x68,
  0x1A, 0x04, 0x83, 0x30, 0x87, 0xC0, 0xC0, 0x78, 0x0D, 0x03, 0x20, 0x64,
  0x08, 0xC3, 0x18, 0x43, 0x18, 0x63, 0x04, 0xC0, 0x98, 0x16, 0x02, 0xC0,
  0x70, 0x0E, 0x00, 0x60, 0x16, 0x03, 0x60, 0x34, 0x03, 0x46, 0x24, 0x62,
  0x4E, 0x64, 0xA6, 0x5A, 0x4D, 0x24, 0xD2, 0xCF, 0x2C, 0xE3, 0x8E, 0x38,
  0xE3, 0x80, 0x30, 0x1C, 0x60, 0xC0, 0x83, 0x03, 0x18, 0x0C, 0xC0, 0x1E,
  0x00, 0x70, 0x00, 0xC0, 0x07, 0x00, 0x36, 0x01, 0x98, 0x0C, 0x30, 0x30,
  0xC1, 0x81, 0x0C, 0x06, 0x00, 0xC0, 0x74, 0x06, 0x60, 0xC6, 0x18, 0x33,
  0x03, 0x30, 0x16, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x00, 0x10, 0x00, 0x1F, 0xF8, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x03, 0xFF, 0x80, 0x1F, 0x8C, 0x04, 0x02, 0x01, 0x00, 0x80,
  0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40,
  0x20, 0x3F, 0x00, 0x84, 0x30, 0x84, 0x21, 0x8C, 0x21, 0x08, 0x61, 0x08,
  0x43, 0x18, 0x42, 0x1F, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06,
  0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x3F,
  0x00, 0x03, 0x00, 0xE0, 0x36, 0x0C, 0x41, 0x0C, 0x61, 0x98, 0x12, 0x03,
  0xC0, 0x40, 0xFF, 0xC0, 0xF5, 0x1E, 0x4C, 0x76, 0x0D, 0x03, 0xC0, 0xF0,
  0x2C, 0x0B, 0x06, 0xC1, 0x98, 0xE3, 0xDC, 0x10, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x09, 0xE2, 0x8D, 0xC1, 0x60, 0x58, 0x16, 0x05, 0x03, 0x40, 0xD0,
  0x2E, 0x1B, 0x78, 0x1F, 0x30, 0xD0, 0x58, 0x0C, 0x04, 0x02, 0x01, 0x02,
  0x81, 0xE3, 0x8F, 0x00, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x3C,
  0x8C, 0x53, 0x06, 0x40, 0xD8, 0x1B, 0x03, 0x60, 0x4C, 0x19, 0x83, 0x18,
  0xE1, 0xEC, 0x1F, 0x10, 0xD0, 0x78, 0x38, 0x77, 0xE2, 0x01, 0x02, 0xC1,
  0xE1, 0x9F, 0x00, 0x00, 0xF8, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x0F,
  0xFC, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0xC4, 0x03, 0x20, 0x0F, 0x00, 0x30, 0x00,
  0x1E, 0x4C, 0x56, 0x0D, 0x03, 0x40, 0xF0, 0x3C, 0x0B, 0x06, 0xC2, 0x98,
  0xE3, 0xD8, 0x04, 0x01, 0x20, 0x87, 0xC0, 0x10, 0x04, 0x03, 0x00, 0xC0,
  0x30, 0x0D, 0xE2, 0x8C, 0xC3, 0x60, 0xD8, 0x36, 0x0D, 0x82, 0x40, 0x90,
  0x6C, 0x1B, 0x06, 0x0E, 0x06, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x20, 0x30,
  0x18, 0x0C, 0x06, 0x02, 0x13, 0x19, 0x98, 0xD0, 0x70, 0x00, 0xC0, 0x70,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x22, 0x08, 0x46, 0x09, 0x81, 0x60, 0x30, 0x10, 0x02,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x6F, 0x0A, 0x31, 0x86, 0x60, 0xCC, 0x31,
  0x8C, 0x36, 0x04, 0xC4, 0x88, 0xF1, 0xA6, 0x18, 0xFC, 0x06, 0x03, 0x01,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x13, 0x11, 0xB0,
  0xB0, 0x70, 0x3E, 0x63, 0x3B, 0x23, 0x36, 0x23, 0x62, 0x36, 0x22, 0x46,
  0x24, 0x62, 0x46, 0x6C, 0x46, 0xC4, 0x60, 0x37, 0x8A, 0x33, 0x0D, 0x83,
  0x60, 0xD8, 0x36, 0x09, 0x02, 0x41, 0xB0, 0x6C, 0x18, 0x0F, 0x0C, 0x26,
  0x0D, 0x81, 0x40, 0x70, 0x3C, 0x0F, 0x03, 0x41, 0x98, 0x43, 0xE0, 0x1B,
  0xC2, 0x8C, 0x60, 0x98, 0x13, 0x02, 0x60, 0x48, 0x19, 0x03, 0x60, 0x4E,
  0x19, 0xBC, 0x30, 0x04, 0x00, 0x80, 0x30, 0x00, 0x1E, 0x4C, 0x56, 0x0D,
  0x03, 0xC0, 0xF0, 0x3C, 0x0B, 0x06, 0xC1, 0x98, 0xE3, 0xD8, 0x06, 0x01,
  0x00, 0x40, 0x30, 0xF9, 0xC7, 0x81, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x02, 0x00, 0x1F, 0x8C, 0x32, 0x01, 0x80, 0x30, 0x07,
  0xC0, 0x18, 0x02, 0x80, 0xB8, 0x63, 0xE0, 0x08, 0x04, 0x06, 0x03, 0x0F,
  0xF8, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x32, 0x33, 0x60, 0xE0,
  0x60, 0xA0, 0x50, 0x78, 0x3C, 0x1E, 0x0F, 0x05, 0x06, 0x83, 0x67, 0x9C,
  0xC0, 0xF8, 0xC4, 0x33, 0x04, 0xC1, 0x30, 0x4C, 0x33, 0x0C, 0x86, 0x21,
  0x09, 0x83, 0xC0, 0x62, 0x68, 0xCD, 0x19, 0xA2, 0x34, 0x47, 0x88, 0xF1,
  0x1E, 0x62, 0x94, 0xDA, 0x93, 0x9C, 0x00, 0x1C, 0x73, 0x69, 0x47, 0x10,
  0x31, 0x06, 0x00, 0x60, 0x06, 0x0C, 0x60, 0xCA, 0x2C, 0xAF, 0x73, 0x80,
  0x30, 0x48, 0x12, 0x0D, 0x83, 0x60, 0xD8, 0x26, 0x09, 0x06, 0x61, 0x98,
  0xE3, 0xD8, 0x04, 0x03, 0x21, 0x8F, 0xC0, 0x1E, 0x64, 0x79, 0x82, 0x21,
  0x80, 0x60, 0x18, 0x06, 0x21, 0x86, 0x60, 0xDF, 0x8B, 0x1E, 0x00, 0x07,
  0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x04, 0x3E, 0x00,
  0xC0, 0x10, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x03, 0xE0, 0x18,
  0xC4, 0x21, 0x18, 0xC6, 0x21, 0x08, 0xC6, 0x31, 0x08, 0x46, 0x30, 0x1F,
  0x00, 0x40, 0x10, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x0C, 0x00, 0xF0,
  0xC0, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x0F, 0x80, 0x38,
  0x69, 0x8B, 0x1B, 0x41, 0xC0,
};

const GFXglyph IBMPlexMono_Italic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 15, 13, 4, -15 },
  { 11, 7, 6, 13, 4, -16 },
  { 17, 13, 15, 13, 0, -15 },
  { 42, 12, 19, 13, 0, -17 },
  { 71, 15, 15, 13, -1, -15 },
  { 100, 12, 15, 13, 0, -15 },
  { 123, 3, 6, 13, 6, -16 },
  { 126, 8, 19, 13, 4, -16 },
  { 145, 8, 19, 13, 1, -16 },
  { 164, 11, 10, 13, 1, -12 },
  { 178, 11, 9, 13, 1, -11 },
  { 191, 5, 6, 13, 3, -3 },
  { 195, 7, 1, 13, 3, -7 },
  { 196, 3, 3, 13, 4, -3 },
  { 198, 11, 19, 13, 1, -16 },
  { 225, 11, 15, 13, 1, -15 },
  { 246, 10, 15, 13, 1, -15 },
  { 265, 11, 15, 13, 1, -15 },
  { 286, 12, 15, 13, 0, -15 },
  { 309, 12, 15, 13, 0, -15 },
  { 332, 11, 15, 13, 1, -15 },
  { 353, 10, 15, 13, 1, -15 },
  { 372, 11, 15, 13, 2, -15 },
  { 393, 11, 15, 13, 1, -15 },
  { 414, 10, 15, 13, 2, -15 },
  { 433, 5, 11, 13, 4, -11 },
  { 440, 6, 14, 13, 3, -11 },
  { 451, 10, 12, 13, 2, -12 },
  { 466, 11, 5, 13, 1, -9 },
  { 473, 10, 12, 13, 1, -12 },
  { 488, 9, 15, 13, 3, -15 },
  { 505, 11, 17, 13, 1, -15 },
  { 529, 11, 15, 13, 0, -15 },
  { 550, 11, 15, 13, 1, -15 },
  { 571, 10, 15, 13, 2, -15 },
  { 590, 11, 15, 13, 1, -15 },
  { 611, 11, 15, 13, 1, -15 },
  { 632, 12, 15, 13, 1, -15 },
  { 655, 11, 15, 13, 1, -15 },
  { 676, 11, 15, 13, 1, -15 },
  { 697, 11, 15, 13, 1, -15 },
  { 718, 11, 15, 13, 1, -15 },
  { 739, 13, 15, 13, 1, -15 },
  { 764, 9, 15, 13, 2, -15 },
  { 781, 12, 15, 13, 1, -15 },
  { 804, 11, 15, 13, 1, -15 },
  { 825, 11, 15, 13, 1, -15 },
  { 846, 11, 15, 13, 1, -15 },
  { 867, 11, 19, 13, 1, -15 },
  { 894, 11, 15, 13, 1, -15 },
  { 915, 11, 15, 13, 1, -15 },
  { 936, 12, 15, 13, 2, -15 },
  { 959, 10, 15, 13, 2, -15 },
  { 978, 11, 15, 13, 2, -15 },
  { 999, 12, 15, 13, 1, -15 },
  { 1022, 14, 15, 13, 0, -15 },
  { 1049, 12, 15, 13, 2, -15 },
  { 1072, 13, 15, 13, 0, -15 },
  { 1097, 9, 19, 13, 3, -16 },
  { 1119, 5, 19, 13, 4, -16 },
  { 1131, 9, 19, 13, 0, -16 },
  { 1153, 11, 9, 13, 1, -15 },
  { 1166, 10, 1, 13, 0, 2 },
  { 1168, 2, 4, 13, 5, -16 },
  { 1169, 10, 11, 13, 1, -11 },
  { 1183, 10, 16, 13, 1, -16 },
  { 1203, 9, 11, 13, 2, -11 },
  { 1216, 11, 16, 13, 1, -16 },
  { 1238, 9, 11, 13, 2, -11 },
  { 1251, 13, 20, 13, 0, -16 },
  { 1284, 10, 15, 13, 1, -11 },
  { 1303, 10, 16, 13, 1, -16 },
  { 1323, 9, 16, 13, 2, -16 },
  { 1341, 10, 20, 13, 1, -16 },
  { 1366, 11, 16, 13, 1, -16 },
  { 1388, 9, 16, 13, 2, -16 },
  { 1406, 12, 11, 13, 0, -11 },
  { 1423, 10, 11, 13, 1, -11 },
  { 1437, 10, 11, 13, 1, -11 },
  { 1451, 11, 15, 13, 0, -11 },
  { 1472, 10, 15, 13, 1, -11 },
  { 1491, 10, 11, 13, 2, -11 },
  { 1505, 10, 11, 13, 1, -11 },
  { 1519, 9, 15, 13, 2, -15 },
  { 1536, 9, 11, 13, 2, -11 },
  { 1549, 10, 11, 13, 1, -11 },
  { 1563, 11, 11, 13, 1, -11 },
  { 1579, 12, 11, 13, 0, -11 },
  { 1596, 10, 15, 13, 1, -11 },
  { 1615, 11, 11, 13, 1, -11 },
  { 1631, 10, 19, 13, 2, -16 },
  { 1655, 5, 19, 13, 4, -16 },
  { 1667, 10, 19, 13, 1, -16 },
  { 1691, 11, 4, 13, 1, -8 },
};

const GFXfont IBMPlexMono_Italic21pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic21pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic21pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _IBMPLEXMONO_ITALIC21PT7B_H_
