#ifndef _IBMPLEXMONO_ITALIC18PT7B_H_
#define _IBMPLEXMONO_ITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x84, 0x63, 0x10, 0x84, 0x20, 0x00, 0xCE, 0x00, 0x4E, 0xF7,
  0x29, 0x00, 0x06, 0x40, 0x98, 0x12, 0x06, 0x43, 0x9E, 0x92, 0x06, 0x40,
  0x98, 0xF3, 0xC6, 0x40, 0x98, 0x12, 0x06, 0x40, 0x03, 0x00, 0x40, 0x3E,
  0x09, 0x63, 0x26, 0x44, 0x0D, 0x01, 0xE0, 0x0F, 0x00, 0xB0, 0x13, 0x02,
  0x64, 0xC9, 0xD3, 0x0F, 0x80, 0x40, 0x08, 0x00, 0x1C, 0x32, 0x46, 0x66,
  0x44, 0x48, 0x45, 0x83, 0x80, 0x00, 0x00, 0x38, 0x1E, 0x42, 0x44, 0x64,
  0x44, 0x4C, 0x83, 0x80, 0x0F, 0x03, 0x30, 0x42, 0x08, 0x41, 0x18, 0x32,
  0x0B, 0x82, 0x60, 0xC4, 0x18, 0xC3, 0x19, 0xE5, 0xE7, 0x98, 0x69, 0x2C,
  0x0C, 0x63, 0x08, 0x41, 0x08, 0x20, 0x82, 0x08, 0x20, 0x81, 0x04, 0x0C,
  0x30, 0x20, 0xC1, 0x04, 0x10, 0x41, 0x04, 0x10, 0xC2, 0x18, 0x42, 0x30,
  0x04, 0x06, 0x02, 0x1D, 0x33, 0xE0, 0xE0, 0xD0, 0xCC, 0x42, 0x00, 0x04,
  0x06, 0x03, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x30, 0x18, 0x00, 0x39, 0x98,
  0xCC, 0x00, 0xF8, 0x7C, 0x00, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x03, 0x00, 0x40, 0x18,
  0x06, 0x00, 0x0F, 0x18, 0xC8, 0x2C, 0x14, 0x0E, 0x67, 0x33, 0x83, 0xC1,
  0xE0, 0xB0, 0xC8, 0xC3, 0xC0, 0x0E, 0x1E, 0x26, 0x44, 0x04, 0x04, 0x0C,
  0x0C, 0x0C, 0x08, 0x08, 0x08, 0xFF, 0x1E, 0x18, 0x98, 0x60, 0x30, 0x18,
  0x08, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x0F, 0xF0, 0x0F, 0x86, 0x32,
  0x0C, 0x03, 0x00, 0xC0, 0x60, 0xE0, 0x06, 0x00, 0x80, 0x24, 0x1B, 0x8C,
  0x3E, 0x00, 0x01, 0xC0, 0xE0, 0x28, 0x12, 0x09, 0x86, 0x63, 0x11, 0x84,
  0x41, 0x3F, 0xF0, 0x30, 0x0C, 0x03, 0x00, 0x3F, 0x90, 0x08, 0x04, 0x06,
  0x03, 0xF1, 0x8C, 0x02, 0x01, 0x80, 0xA0, 0xD8, 0x47, 0xC0, 0x07, 0x06,
  0x06, 0x06, 0x02, 0x02, 0xF1, 0x8D, 0x83, 0xC1, 0xE0, 0xB0, 0x48, 0x43,
  0xC0, 0xFF, 0xC0, 0xE0, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x30, 0x18, 0x18,
  0x08, 0x0C, 0x0C, 0x00, 0x1F, 0x18, 0xD8, 0x2C, 0x16, 0x19, 0x08, 0x78,
  0xC6, 0xC1, 0xC0, 0xE0, 0x58, 0x67, 0xC0, 0x3E, 0x63, 0xC1, 0x81, 0x83,
  0x83, 0xC7, 0x7A, 0x06, 0x0C, 0x18, 0x30, 0xE0, 0x33, 0x00, 0x00, 0x06,
  0xE0, 0x18, 0xC0, 0x00, 0x00, 0x07, 0x33, 0x19, 0x80, 0x01, 0x07, 0x1C,
  0x70, 0xC0, 0xC0, 0x60, 0x18, 0x0C, 0x02, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x40, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x18, 0x38, 0x70, 0xE0, 0x40,
  0x00, 0x3E, 0x63, 0xC3, 0x03, 0x03, 0x03, 0x0E, 0x18, 0x30, 0x30, 0x00,
  0x70, 0x70, 0x1F, 0x18, 0xC8, 0x28, 0x14, 0xEA, 0x4F, 0x67, 0xA3, 0x91,
  0x48, 0xA7, 0xD0, 0x0C, 0x02, 0x00, 0xF8, 0x03, 0x01, 0xC0, 0x50, 0x34,
  0x09, 0x06, 0x41, 0x18, 0xC6, 0x3F, 0x98, 0x24, 0x09, 0x02, 0xC0, 0xC0,
  0x3F, 0x10, 0xC8, 0x6C, 0x36, 0x1B, 0x09, 0xF8, 0x82, 0x41, 0xE0, 0xF0,
  0x58, 0x6F, 0xE0, 0x0F, 0x08, 0xC8, 0x2C, 0x06, 0x02, 0x01, 0x01, 0x80,
  0xC0, 0x60, 0x10, 0x6C, 0x63, 0xE0, 0x3E, 0x10, 0x88, 0x64, 0x16, 0x0B,
  0x05, 0x86, 0x83, 0x41, 0xA0, 0xB0, 0xD8, 0xCF, 0xC0, 0x3F, 0xC8, 0x02,
  0x01, 0x80, 0x60, 0x18, 0x07, 0xF9, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00,
  0xFF, 0x00, 0x3F, 0xC8, 0x02, 0x01, 0x80, 0x60, 0x18, 0x07, 0xF1, 0x00,
  0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x00, 0x0F, 0x18, 0xC8, 0x2C, 0x04,
  0x02, 0x03, 0x01, 0x8F, 0xC9, 0x60, 0xB0, 0xC8, 0xA3, 0xB0, 0x20, 0xC8,
  0x26, 0x09, 0x82, 0x61, 0x90, 0x67, 0xF9, 0x04, 0xC1, 0x30, 0x4C, 0x32,
  0x0C, 0x83, 0x00, 0x3F, 0xC1, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80,
  0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0xFF, 0x00, 0x1F, 0x80, 0xC0, 0x60,
  0x20, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x30, 0x98, 0xC7, 0xC0, 0x20,
  0xE4, 0x31, 0x8C, 0x33, 0x06, 0xC0, 0xB0, 0x17, 0x03, 0x20, 0x46, 0x18,
  0xC3, 0x08, 0x41, 0x88, 0x18, 0x30, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60,
  0x60, 0x60, 0x40, 0x40, 0x40, 0xFF, 0x30, 0x67, 0x1C, 0xA3, 0x14, 0xA2,
  0x94, 0x5C, 0x89, 0xB3, 0x26, 0x64, 0xC8, 0x11, 0x02, 0x20, 0x4C, 0x18,
  0x30, 0xCC, 0x27, 0x09, 0xE2, 0x48, 0x92, 0x64, 0x99, 0x34, 0xCD, 0x31,
  0x48, 0x52, 0x1C, 0x87, 0x00, 0x0F, 0x18, 0xC8, 0x2C, 0x14, 0x0E, 0x07,
  0x07, 0x83, 0xC1, 0xE0, 0xB0, 0xC8, 0xC3, 0xC0, 0x3F, 0x08, 0x22, 0x09,
  0x83, 0x60, 0x98, 0x67, 0xF1, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80,
  0x00, 0x0F, 0x18, 0xC8, 0x2C, 0x14, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0,
  0xB0, 0xC8, 0xC3, 0xC0, 0xC8, 0x36, 0x0C, 0x3F, 0x08, 0x22, 0x09, 0x83,
  0x60, 0x98, 0x67, 0xF1, 0x30, 0x44, 0x31, 0x8C, 0x23, 0x08, 0x83, 0x00,
  0x0F, 0x82, 0x18, 0xC1, 0x90, 0x03, 0x00, 0x70, 0x03, 0xC0, 0x0C, 0x00,
  0xC0, 0x19, 0x02, 0x70, 0xC3, 0xE0, 0xFF, 0xC2, 0x00, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x00, 0x20,
  0xC8, 0x26, 0x09, 0x82, 0x61, 0x90, 0x64, 0x19, 0x04, 0xC1, 0x30, 0x4C,
  0x31, 0x08, 0x3C, 0x00, 0x80, 0xE0, 0xF0, 0x58, 0x64, 0x22, 0x11, 0x18,
  0x88, 0x4C, 0x34, 0x1E, 0x0E, 0x03, 0x00, 0x40, 0x50, 0x14, 0x05, 0x33,
  0x4C, 0xB7, 0x2D, 0x4B, 0x56, 0xB5, 0x29, 0x4A, 0x53, 0x9C, 0xC7, 0x00,
  0x30, 0x71, 0x04, 0x18, 0xC0, 0x98, 0x0F, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x1B, 0x03, 0x30, 0x21, 0x06, 0x18, 0xC0, 0xC0, 0x80, 0xF0, 0x64, 0x31,
  0x98, 0x64, 0x0B, 0x03, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20,
  0x00, 0x3F, 0xE0, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x20, 0x0F, 0xF8, 0x3F, 0x30, 0x20, 0x20, 0x20,
  0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x80, 0xF8, 0xC2,
  0x10, 0x84, 0x10, 0x84, 0x21, 0x84, 0x21, 0x08, 0x21, 0x1F, 0x03, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08,
  0xF8, 0x06, 0x05, 0x06, 0xC6, 0x22, 0x13, 0x0F, 0x02, 0xFF, 0x80, 0xD4,
  0x3D, 0xB1, 0x90, 0x58, 0x2C, 0x14, 0x1A, 0x0D, 0x8C, 0x7B, 0x80, 0x30,
  0x10, 0x08, 0x04, 0x06, 0xF3, 0x89, 0x86, 0x83, 0x41, 0xA0, 0xB0, 0x58,
  0x6B, 0xC0, 0x1E, 0x21, 0x40, 0x40, 0xC0, 0xC0, 0xC1, 0x42, 0x3C, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x3D, 0x98, 0xE4, 0x13, 0x04, 0xC1, 0x20, 0xC8,
  0x33, 0x1C, 0x7A, 0x00, 0x1F, 0x10, 0x90, 0x68, 0x6F, 0xC6, 0x03, 0x04,
  0x84, 0x3C, 0x00, 0x01, 0xF0, 0x30, 0x02, 0x00, 0x20, 0x3F, 0xE0, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x08, 0xC0,
  0x48, 0x06, 0x80, 0x38, 0x00, 0x3D, 0xB1, 0xD0, 0x58, 0x2C, 0x14, 0x1B,
  0x0D, 0x8E, 0x7A, 0x01, 0x00, 0x90, 0x8F, 0x80, 0x30, 0x20, 0x20, 0x20,
  0x2E, 0x71, 0x61, 0x41, 0x41, 0x43, 0xC3, 0xC3, 0xC2, 0x0C, 0x06, 0x00,
  0x00, 0x07, 0x84, 0x40, 0x20, 0x30, 0x18, 0x08, 0xC4, 0xC2, 0xC1, 0x80,
  0x03, 0x03, 0x00, 0x00, 0x3F, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04,
  0x04, 0xC4, 0x4C, 0x2C, 0x18, 0x30, 0x10, 0x08, 0x04, 0x02, 0xF3, 0x89,
  0x84, 0x86, 0x46, 0x2C, 0x32, 0x39, 0xAC, 0x60, 0xF8, 0x30, 0x40, 0x81,
  0x06, 0x0C, 0x10, 0x20, 0x45, 0x93, 0x47, 0x00, 0x2D, 0xCD, 0x96, 0x45,
  0x11, 0x44, 0x51, 0x34, 0xCB, 0x32, 0xC8, 0x80, 0x2E, 0x71, 0x61, 0x41,
  0x41, 0x43, 0xC3, 0xC3, 0xC2, 0x1E, 0x10, 0x90, 0x78, 0x3C, 0x1E, 0x0B,
  0x0C, 0x84, 0x3C, 0x00, 0x37, 0x8E, 0x23, 0x0C, 0x83, 0x20, 0xC8, 0x26,
  0x09, 0x86, 0x5E, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x00, 0x3D, 0xB1, 0xD0,
  0x58, 0x2C, 0x14, 0x1A, 0x0D, 0x8E, 0x7A, 0x01, 0x00, 0x80, 0x40, 0x60,
  0xF7, 0x9C, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x00, 0x1F,
  0x30, 0xD8, 0x0C, 0x03, 0xE0, 0x18, 0x05, 0x86, 0x7C, 0x00, 0x08, 0x04,
  0x02, 0x03, 0x07, 0xFC, 0x80, 0x40, 0x20, 0x30, 0x18, 0x8C, 0xC5, 0x83,
  0x80, 0x61, 0xB0, 0xD8, 0x48, 0x24, 0x12, 0x1B, 0x0C, 0x9C, 0x7A, 0x00,
  0xF1, 0x18, 0xC8, 0x64, 0x32, 0x13, 0x09, 0x88, 0xD8, 0x78, 0x00, 0x44,
  0xA6, 0x52, 0x39, 0x18, 0x8C, 0x46, 0x65, 0x52, 0xEE, 0x00, 0x19, 0xCC,
  0xCD, 0x19, 0x82, 0x00, 0x40, 0x18, 0x33, 0x16, 0xAC, 0x67, 0x00, 0x30,
  0xCC, 0x33, 0x08, 0x82, 0x20, 0x88, 0x62, 0x18, 0x9E, 0x3D, 0x00, 0x40,
  0x31, 0x08, 0xFC, 0x00, 0x3C, 0xA1, 0xD0, 0xC0, 0x80, 0x81, 0x89, 0x85,
  0xF2, 0x8F, 0x00, 0x0F, 0x18, 0x18, 0x18, 0x08, 0x08, 0x0C, 0xF0, 0x18,
  0x08, 0x10, 0x30, 0x20, 0x60, 0x60, 0x7C, 0x32, 0x22, 0x26, 0x44, 0x44,
  0x4C, 0x88, 0x88, 0x3E, 0x02, 0x06, 0x04, 0x08, 0x18, 0x18, 0x07, 0x18,
  0x10, 0x10, 0x18, 0x08, 0x08, 0x18, 0xF0, 0x30, 0xA4, 0x62, 0x50, 0xC0,
};

const GFXglyph IBMPlexMono_Italic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 13, 11, 3, -13 },
  { 10, 5, 5, 11, 4, -13 },
  { 14, 11, 13, 11, 0, -13 },
  { 32, 11, 17, 11, 0, -15 },
  { 56, 12, 13, 11, 0, -13 },
  { 76, 11, 13, 11, 0, -13 },
  { 94, 3, 5, 11, 5, -13 },
  { 96, 6, 16, 11, 4, -14 },
  { 108, 6, 16, 11, 1, -14 },
  { 120, 9, 9, 11, 1, -10 },
  { 131, 9, 9, 11, 1, -10 },
  { 142, 5, 5, 11, 2, -2 },
  { 146, 5, 1, 11, 3, -6 },
  { 147, 3, 2, 11, 3, -2 },
  { 148, 11, 16, 11, 0, -14 },
  { 170, 9, 13, 11, 1, -13 },
  { 185, 8, 13, 11, 1, -13 },
  { 198, 9, 13, 11, 1, -13 },
  { 213, 10, 13, 11, 0, -13 },
  { 230, 10, 13, 11, 0, -13 },
  { 247, 9, 13, 11, 1, -13 },
  { 262, 9, 13, 11, 1, -13 },
  { 277, 9, 13, 11, 2, -13 },
  { 292, 9, 13, 11, 1, -13 },
  { 307, 8, 13, 11, 2, -13 },
  { 320, 4, 9, 11, 3, -9 },
  { 325, 5, 12, 11, 2, -9 },
  { 333, 8, 10, 11, 2, -11 },
  { 343, 9, 5, 11, 1, -8 },
  { 349, 9, 10, 11, 1, -11 },
  { 361, 8, 13, 11, 2, -13 },
  { 374, 9, 15, 11, 1, -13 },
  { 391, 10, 13, 11, 0, -13 },
  { 408, 9, 13, 11, 1, -13 },
  { 423, 9, 13, 11, 1, -13 },
  { 438, 9, 13, 11, 1, -13 },
  { 453, 10, 13, 11, 1, -13 },
  { 470, 10, 13, 11, 1, -13 },
  { 487, 9, 13, 11, 1, -13 },
  { 502, 10, 13, 11, 1, -13 },
  { 519, 10, 13, 11, 1, -13 },
  { 536, 9, 13, 11, 1, -13 },
  { 551, 11, 13, 11, 1, -13 },
  { 569, 8, 13, 11, 1, -13 },
  { 582, 11, 13, 11, 0, -13 },
  { 600, 10, 13, 11, 1, -13 },
  { 617, 9, 13, 11, 1, -13 },
  { 632, 10, 13, 11, 1, -13 },
  { 649, 9, 16, 11, 1, -13 },
  { 667, 10, 13, 11, 1, -13 },
  { 684, 11, 13, 11, 0, -13 },
  { 702, 10, 13, 11, 2, -13 },
  { 719, 10, 13, 11, 1, -13 },
  { 736, 9, 13, 11, 2, -13 },
  { 751, 10, 13, 11, 1, -13 },
  { 768, 12, 13, 11, 0, -13 },
  { 788, 10, 13, 11, 2, -13 },
  { 805, 11, 13, 11, 0, -13 },
  { 823, 8, 16, 11, 3, -14 },
  { 839, 5, 16, 11, 3, -14 },
  { 849, 8, 16, 11, 0, -14 },
  { 865, 9, 7, 11, 1, -13 },
  { 873, 9, 1, 11, 0, 2 },
  { 875, 2, 3, 11, 4, -14 },
  { 876, 9, 9, 11, 1, -9 },
  { 887, 9, 13, 11, 1, -13 },
  { 902, 8, 9, 11, 1, -9 },
  { 911, 10, 13, 11, 1, -13 },
  { 928, 9, 9, 11, 1, -9 },
  { 939, 12, 17, 11, 0, -13 },
  { 965, 9, 13, 11, 1, -9 },
  { 980, 8, 13, 11, 1, -13 },
  { 993, 9, 13, 11, 1, -13 },
  { 1008, 8, 17, 11, 1, -13 },
  { 1025, 9, 13, 11, 1, -13 },
  { 1040, 7, 13, 11, 2, -13 },
  { 1052, 10, 9, 11, 0, -9 },
  { 1064, 8, 9, 11, 1, -9 },
  { 1073, 9, 9, 11, 1, -9 },
  { 1084, 10, 13, 11, 0, -9 },
  { 1101, 9, 13, 11, 1, -9 },
  { 1116, 9, 9, 11, 2, -9 },
  { 1127, 9, 9, 11, 1, -9 },
  { 1138, 9, 13, 11, 1, -13 },
  { 1153, 9, 9, 11, 1, -9 },
  { 1164, 9, 9, 11, 1, -9 },
  { 1175, 9, 9, 11, 1, -9 },
  { 1186, 11, 9, 11, 0, -9 },
  { 1199, 10, 13, 11, 0, -9 },
  { 1216, 9, 9, 11, 1, -9 },
  { 1227, 8, 16, 11, 2, -14 },
  { 1243, 4, 16, 11, 4, -14 },
  { 1251, 8, 16, 11, 1, -14 },
  { 1267, 9, 4, 11, 1, -7 },
};

const GFXfont IBMPlexMono_Italic18pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic18pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic18pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _IBMPLEXMONO_ITALIC18PT7B_H_
