#ifndef _IBMPLEXMONO_ITALIC9PT7B_H_
#define _IBMPLEXMONO_ITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0x20, 0xF8, 0x29, 0xB3, 0x14, 0xDA, 0x80, 0x11, 0xDA, 0xC3,
  0xD5, 0xC8, 0x66, 0xA7, 0x16, 0xAA, 0x60, 0x32, 0x95, 0x49, 0xFC, 0xC0,
  0x2A, 0x49, 0x26, 0x22, 0x11, 0x12, 0x2C, 0x25, 0x5C, 0xA0, 0x44, 0xF4,
  0x40, 0x60, 0xE0, 0x80, 0x08, 0x44, 0x42, 0x21, 0x10, 0x79, 0x9D, 0x9E,
  0x33, 0x94, 0x42, 0x7C, 0x3A, 0x42, 0x64, 0x7C, 0x3A, 0x4C, 0x19, 0x38,
  0x19, 0x55, 0x2F, 0x88, 0x3A, 0x1C, 0x98, 0xB8, 0x34, 0xE9, 0x9E, 0xF9,
  0x22, 0x48, 0x3A, 0x4D, 0x98, 0xB8, 0x79, 0x9F, 0x2C, 0xC0, 0x80, 0x60,
  0x05, 0x00, 0x16, 0x84, 0x20, 0x78, 0x3E, 0x41, 0x82, 0x6C, 0x00, 0x79,
  0x16, 0x04, 0x79, 0xFD, 0xF8, 0xE0, 0x11, 0x94, 0xA7, 0xC4, 0x7A, 0x5C,
  0x98, 0xF8, 0x79, 0x88, 0x9E, 0x7A, 0x52, 0x98, 0xF8, 0x7A, 0x1E, 0x88,
  0x78, 0x7A, 0x1E, 0x88, 0x40, 0x79, 0x8B, 0x9E, 0x4A, 0x5F, 0x18, 0xC8,
  0x78, 0x88, 0x42, 0x78, 0x71, 0x12, 0xAE, 0x4D, 0x46, 0x14, 0x92, 0x20,
  0x88, 0x88, 0x8F, 0x4B, 0xDF, 0x58, 0xC8, 0x6B, 0x5B, 0x59, 0xC8, 0x79,
  0x99, 0x9E, 0x7A, 0x52, 0xF8, 0x40, 0x79, 0x99, 0x9E, 0x52, 0x7A, 0x52,
  0xF9, 0x4C, 0x3A, 0x58, 0x38, 0xB8, 0xF9, 0x10, 0x84, 0x20, 0x99, 0x99,
  0xAE, 0x9C, 0xA5, 0x4A, 0x20, 0x46, 0x2B, 0xAE, 0xDB, 0x40, 0x4C, 0xA3,
  0x0C, 0x52, 0x20, 0x8C, 0x98, 0x84, 0x20, 0x78, 0x44, 0x44, 0x7C, 0x34,
  0x44, 0x48, 0x8E, 0xAA, 0xA5, 0x71, 0x12, 0x22, 0x2E, 0x26, 0x99, 0xF0,
  0xC0, 0x7A, 0x65, 0x26, 0x80, 0x42, 0x1E, 0x94, 0xC7, 0xC0, 0x69, 0x8B,
  0xE0, 0x08, 0x5E, 0x98, 0xC9, 0xC0, 0x69, 0xEA, 0xF0, 0x1C, 0x47, 0x88,
  0x20, 0x8A, 0x28, 0x40, 0x7A, 0x63, 0x27, 0x0B, 0x80, 0x88, 0xAD, 0x9A,
  0xA0, 0x20, 0xC4, 0x47, 0x60, 0x10, 0x62, 0x22, 0xAC, 0x40, 0x88, 0xE9,
  0xED, 0xA0, 0xC4, 0x44, 0x6B, 0x40, 0xFF, 0x6B, 0x5A, 0x80, 0xAD, 0x9A,
  0xA0, 0x69, 0x99, 0xE0, 0x7A, 0x53, 0x1F, 0x42, 0x00, 0x7A, 0x63, 0x27,
  0x08, 0x40, 0xD6, 0x44, 0x80, 0x3A, 0x1C, 0x2F, 0x00, 0x4F, 0x48, 0xBC,
  0x99, 0x9E, 0xE0, 0x99, 0x9A, 0xC0, 0x6D, 0x6B, 0x5F, 0x00, 0x7D, 0x49,
  0x5D, 0x00, 0x4A, 0x54, 0xE7, 0x0B, 0x80, 0x7A, 0x4C, 0x9B, 0x80, 0x34,
  0x2C, 0x44, 0x86, 0x5A, 0xAA, 0x30, 0x88, 0x36, 0x10, 0x9C, 0x6C, 0x80,
};

const GFXglyph IBMPlexMono_Italic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 6, 5, 2, -6 },
  { 3, 3, 2, 5, 2, -7 },
  { 4, 6, 6, 5, 0, -6 },
  { 9, 5, 8, 5, 0, -7 },
  { 14, 6, 6, 5, 0, -6 },
  { 19, 5, 6, 5, 0, -6 },
  { 23, 1, 2, 5, 3, -7 },
  { 24, 3, 8, 5, 2, -7 },
  { 27, 4, 8, 5, 0, -7 },
  { 31, 5, 4, 5, 0, -5 },
  { 34, 4, 5, 5, 1, -5 },
  { 37, 2, 2, 5, 1, -1 },
  { 38, 3, 1, 5, 1, -3 },
  { 39, 1, 1, 5, 2, -1 },
  { 40, 5, 8, 5, 0, -7 },
  { 45, 4, 6, 5, 1, -6 },
  { 48, 5, 6, 5, 0, -6 },
  { 52, 5, 6, 5, 0, -6 },
  { 56, 5, 6, 5, 0, -6 },
  { 60, 5, 6, 5, 0, -6 },
  { 64, 5, 6, 5, 0, -6 },
  { 68, 4, 6, 5, 1, -6 },
  { 71, 4, 6, 5, 1, -6 },
  { 74, 5, 6, 5, 0, -6 },
  { 78, 4, 6, 5, 1, -6 },
  { 81, 2, 5, 5, 2, -5 },
  { 83, 3, 6, 5, 1, -5 },
  { 86, 4, 5, 5, 1, -5 },
  { 89, 5, 3, 5, 0, -4 },
  { 91, 5, 5, 5, 0, -5 },
  { 95, 4, 6, 5, 1, -6 },
  { 98, 4, 7, 5, 1, -6 },
  { 102, 5, 6, 5, 0, -6 },
  { 106, 5, 6, 5, 0, -6 },
  { 110, 4, 6, 5, 1, -6 },
  { 113, 5, 6, 5, 0, -6 },
  { 117, 5, 6, 5, 0, -6 },
  { 121, 5, 6, 5, 0, -6 },
  { 125, 4, 6, 5, 1, -6 },
  { 128, 5, 6, 5, 0, -6 },
  { 132, 5, 6, 5, 0, -6 },
  { 136, 4, 6, 5, 1, -6 },
  { 139, 6, 6, 5, 0, -6 },
  { 144, 4, 6, 5, 1, -6 },
  { 147, 5, 6, 5, 0, -6 },
  { 151, 5, 6, 5, 0, -6 },
  { 155, 4, 6, 5, 1, -6 },
  { 158, 5, 6, 5, 0, -6 },
  { 162, 4, 8, 5, 1, -6 },
  { 166, 5, 6, 5, 0, -6 },
  { 170, 5, 6, 5, 0, -6 },
  { 174, 5, 6, 5, 1, -6 },
  { 178, 4, 6, 5, 1, -6 },
  { 181, 5, 6, 5, 1, -6 },
  { 185, 6, 6, 5, 0, -6 },
  { 190, 6, 6, 5, 0, -6 },
  { 195, 5, 6, 5, 1, -6 },
  { 199, 5, 6, 5, 0, -6 },
  { 203, 4, 8, 5, 1, -7 },
  { 207, 2, 8, 5, 2, -7 },
  { 209, 4, 8, 5, 0, -7 },
  { 213, 4, 4, 5, 1, -6 },
  { 215, 4, 1, 5, 0, 1 },
  { 216, 1, 2, 5, 2, -8 },
  { 217, 5, 5, 5, 0, -5 },
  { 221, 5, 7, 5, 0, -7 },
  { 226, 4, 5, 5, 1, -5 },
  { 229, 5, 7, 5, 0, -7 },
  { 234, 4, 5, 5, 1, -5 },
  { 237, 6, 9, 5, 0, -7 },
  { 244, 5, 7, 5, 0, -5 },
  { 249, 4, 7, 5, 1, -7 },
  { 253, 4, 7, 5, 1, -7 },
  { 257, 4, 9, 5, 1, -7 },
  { 262, 4, 7, 5, 1, -7 },
  { 266, 4, 7, 5, 1, -7 },
  { 270, 5, 5, 5, 0, -5 },
  { 274, 4, 5, 5, 1, -5 },
  { 277, 4, 5, 5, 1, -5 },
  { 280, 5, 7, 5, 0, -5 },
  { 285, 5, 7, 5, 0, -5 },
  { 290, 4, 5, 5, 1, -5 },
  { 293, 5, 5, 5, 0, -5 },
  { 297, 4, 6, 5, 1, -6 },
  { 300, 4, 5, 5, 1, -5 },
  { 303, 4, 5, 5, 1, -5 },
  { 306, 5, 5, 5, 0, -5 },
  { 310, 5, 5, 5, 0, -5 },
  { 314, 5, 7, 5, 0, -5 },
  { 319, 5, 5, 5, 0, -5 },
  { 323, 4, 8, 5, 1, -7 },
  { 327, 2, 8, 5, 2, -7 },
  { 329, 5, 8, 5, 0, -7 },
  { 334, 5, 2, 5, 0, -4 },
};

const GFXfont IBMPlexMono_Italic9pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic9pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _IBMPLEXMONO_ITALIC9PT7B_H_
