#ifndef _IBMPLEXMONO_ITALIC23PT7B_H_
#define _IBMPLEXMONO_ITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x61, 0x86, 0x18, 0x41, 0x04, 0x10, 0x80, 0x00, 0x01, 0xCF,
  0x18, 0x66, 0x8B, 0x16, 0x6C, 0xD9, 0x80, 0x01, 0x98, 0x0C, 0x40, 0x33,
  0x00, 0xC8, 0x3E, 0x3C, 0xF9, 0xF0, 0x46, 0x03, 0x10, 0x0C, 0xC0, 0x23,
  0x0F, 0x8F, 0xBE, 0x7C, 0x11, 0x80, 0x46, 0x03, 0x30, 0x08, 0xC0, 0x01,
  0x80, 0x10, 0x0F, 0xC1, 0xFE, 0x39, 0x77, 0x31, 0x62, 0x07, 0x20, 0x3A,
  0x01, 0xF8, 0x07, 0xC0, 0x6E, 0x04, 0x60, 0x46, 0xC4, 0x6E, 0xCE, 0x7F,
  0xC3, 0xF0, 0x08, 0x00, 0x80, 0x07, 0x03, 0x1F, 0x86, 0x18, 0x84, 0x10,
  0x8C, 0x30, 0x98, 0x31, 0x90, 0x1F, 0x30, 0x0E, 0x00, 0x00, 0x78, 0x06,
  0xFC, 0x0C, 0x8C, 0x09, 0x84, 0x19, 0x8C, 0x31, 0x8C, 0x61, 0xF8, 0xC0,
  0xF0, 0x07, 0xC0, 0x3F, 0x80, 0xC6, 0x06, 0x08, 0x18, 0x20, 0x21, 0x80,
  0xC6, 0x0F, 0xF0, 0x77, 0x03, 0x18, 0x0C, 0x30, 0x30, 0x62, 0xC1, 0x9F,
  0x0B, 0x67, 0xEF, 0x0F, 0x18, 0x6B, 0x6D, 0x80, 0x03, 0x0C, 0x08, 0x10,
  0x30, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0xC0, 0xC0,
  0x40, 0x60, 0x20, 0x18, 0x1C, 0x03, 0x00, 0x80, 0x60, 0x30, 0x08, 0x04,
  0x02, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x0C,
  0x0C, 0x1C, 0x00, 0x03, 0x00, 0x30, 0x02, 0x08, 0x21, 0xF6, 0x73, 0xFC,
  0x06, 0x00, 0xF0, 0x1B, 0x03, 0x18, 0x60, 0x80, 0x06, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0xC1, 0xFF, 0xFF, 0xF0, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C,
  0x00, 0x39, 0x8C, 0xC6, 0x60, 0xFF, 0xF8, 0x7F, 0x60, 0x00, 0x18, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x00, 0x07, 0xC0, 0xFE, 0x18, 0x73, 0x03,
  0x30, 0x36, 0x03, 0x67, 0x36, 0x73, 0x66, 0x3C, 0x03, 0xC0, 0x6C, 0x06,
  0x60, 0xC6, 0x1C, 0x7F, 0x81, 0xE0, 0x03, 0x81, 0xF0, 0x76, 0x1C, 0xC7,
  0x10, 0x46, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x3F, 0xFF, 0xFF, 0x07, 0xC1, 0xFE, 0x38, 0x63, 0x03, 0x60, 0x30,
  0x06, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x30, 0x06,
  0x00, 0xFF, 0xEF, 0xFC, 0x07, 0xC1, 0xFE, 0x38, 0x71, 0x03, 0x00, 0x60,
  0x0E, 0x0F, 0x80, 0xF8, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x80, 0xCE,
  0x1C, 0x7F, 0x83, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x03, 0x60, 0x32,
  0x03, 0x30, 0x31, 0x81, 0x0C, 0x10, 0x61, 0x83, 0x18, 0x10, 0xFF, 0xFF,
  0xFF, 0x80, 0x60, 0x03, 0x00, 0x18, 0x1F, 0xF1, 0xFF, 0x18, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x37, 0x82, 0xFC, 0x30, 0xE4, 0x06, 0x00, 0x60, 0x06,
  0x40, 0x6E, 0x1C, 0x7F, 0x81, 0xF0, 0x01, 0xE0, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x6F, 0x0B, 0xF3, 0x87, 0x60, 0x6C, 0x0F, 0x01, 0xE0, 0x34, 0x06,
  0xC3, 0x9F, 0xE0, 0xF8, 0x7F, 0xF7, 0xFF, 0x40, 0x64, 0x04, 0xC0, 0xC0,
  0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x07, 0xC1, 0xFE, 0x38, 0x73, 0x03, 0x30, 0x33,
  0x03, 0x30, 0x61, 0xFC, 0x1F, 0xC7, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6E,
  0x0E, 0x7F, 0xC3, 0xF0, 0x0F, 0x87, 0xF9, 0xC3, 0xB0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x06, 0xE1, 0xCF, 0xD8, 0xF6, 0x01, 0x80, 0x70, 0x1C, 0x06,
  0x03, 0x80, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x03, 0xBC, 0xC0, 0x1C, 0x71,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x0C, 0x61, 0x8C, 0x00, 0x00, 0x20,
  0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x30, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x08, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xEF,
  0xFE, 0x20, 0x07, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x18, 0x0F,
  0x07, 0x83, 0xC0, 0xE0, 0x70, 0x08, 0x00, 0x1F, 0x0F, 0xE6, 0x1F, 0x03,
  0x40, 0xC0, 0x20, 0x18, 0x3C, 0x1C, 0x04, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x07, 0x01, 0xC0, 0x07, 0xC1, 0xFE, 0x18, 0x73, 0x03, 0x30, 0x36, 0x3B,
  0x67, 0xF6, 0x62, 0x4C, 0x24, 0xC2, 0xCC, 0x6C, 0xC6, 0xCF, 0xEC, 0x74,
  0xC0, 0x04, 0x00, 0x60, 0x03, 0xF8, 0x1F, 0x00, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x34, 0x06, 0x60, 0x66, 0x0C, 0x60, 0xC6, 0x18, 0x61, 0x86, 0x3F,
  0xE3, 0xFF, 0x70, 0x36, 0x03, 0x60, 0x3C, 0x03, 0x1F, 0xC3, 0xFE, 0x30,
  0x73, 0x03, 0x30, 0x33, 0x02, 0x30, 0x67, 0xFC, 0x7F, 0xC6, 0x06, 0x60,
  0x66, 0x06, 0x40, 0x6C, 0x0E, 0xFF, 0xCF, 0xF0, 0x0F, 0x83, 0xF8, 0xE1,
  0xB8, 0x36, 0x04, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x6C, 0x0D, 0xC3, 0x1F, 0xC1, 0xF0, 0x1F, 0x81, 0xFE, 0x10, 0x63, 0x03,
  0x30, 0x33, 0x03, 0x30, 0x33, 0x03, 0x20, 0x36, 0x03, 0x60, 0x66, 0x06,
  0x60, 0xE6, 0x1C, 0x7F, 0x8F, 0xE0, 0x1F, 0xF8, 0xFF, 0x8C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xFC, 0x7F, 0xE3, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x03, 0xFF, 0x1F, 0xF8, 0x1F, 0xF8, 0xFF, 0xCC,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xFC, 0x7F, 0xE3, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x0F, 0x83,
  0xF8, 0xE3, 0xB0, 0x36, 0x05, 0x80, 0x30, 0x06, 0x00, 0xC7, 0xD8, 0xFA,
  0x03, 0x60, 0x6C, 0x1D, 0x85, 0x3F, 0xA1, 0xEC, 0x10, 0x19, 0x81, 0x8C,
  0x0C, 0x60, 0x63, 0x03, 0x18, 0x19, 0x80, 0xCF, 0xFC, 0x7F, 0xE3, 0x03,
  0x18, 0x18, 0xC0, 0xCC, 0x06, 0x60, 0x63, 0x03, 0x18, 0x18, 0x1F, 0xF9,
  0xFF, 0x80, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x03, 0xFF, 0x1F, 0xF8,
  0x0F, 0xF0, 0xFE, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0xC1, 0xC6, 0x18, 0x7F, 0x81, 0xE0,
  0x18, 0x1C, 0xC0, 0xC3, 0x06, 0x0C, 0x30, 0x31, 0x80, 0xCC, 0x02, 0x60,
  0x1B, 0x80, 0x7B, 0x01, 0xCC, 0x06, 0x18, 0x18, 0x60, 0x40, 0xC3, 0x03,
  0x0C, 0x0E, 0x30, 0x18, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFE,
  0x38, 0x39, 0xC1, 0xCE, 0x1C, 0x51, 0xA2, 0xCF, 0x36, 0xD9, 0x94, 0xCC,
  0xE6, 0x66, 0x22, 0x31, 0x11, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x33, 0x01,
  0x10, 0x18, 0x18, 0x19, 0xE0, 0x8F, 0x0C, 0x78, 0x63, 0x43, 0x13, 0x19,
  0x98, 0xCC, 0xC4, 0x62, 0x63, 0x13, 0x18, 0xD8, 0x86, 0xCC, 0x36, 0x60,
  0xA3, 0x07, 0x18, 0x38, 0x07, 0xC0, 0xFE, 0x18, 0x73, 0x03, 0x30, 0x36,
  0x03, 0x60, 0x36, 0x03, 0x60, 0x3C, 0x03, 0xC0, 0x6C, 0x06, 0x60, 0xC6,
  0x1C, 0x7F, 0x81, 0xE0, 0x1F, 0xE1, 0xFF, 0x30, 0x33, 0x03, 0x30, 0x33,
  0x03, 0x30, 0x32, 0x07, 0x7F, 0xE7, 0xFC, 0x60, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x07, 0xC0, 0xFE, 0x18, 0x73, 0x03, 0x30, 0x36,
  0x03, 0x60, 0x36, 0x03, 0x60, 0x3C, 0x03, 0xC0, 0x6C, 0x06, 0x60, 0xE6,
  0x1C, 0x7F, 0x83, 0xF0, 0x06, 0x20, 0x77, 0x03, 0xC0, 0x18, 0x1F, 0xE1,
  0xFF, 0x30, 0x33, 0x03, 0x30, 0x33, 0x03, 0x30, 0x32, 0x07, 0x7F, 0xE7,
  0xF8, 0x63, 0x06, 0x30, 0x61, 0x8C, 0x18, 0xC0, 0xCC, 0x0E, 0x0F, 0xC1,
  0xFE, 0x38, 0x73, 0x01, 0x60, 0x07, 0x00, 0x38, 0x01, 0xF8, 0x07, 0xC0,
  0x06, 0x00, 0x60, 0x06, 0xC0, 0x6E, 0x0E, 0x7F, 0xC3, 0xF0, 0xFF, 0xFF,
  0xFF, 0xC1, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x60, 0x36, 0x06, 0x60, 0x66, 0x06, 0x60, 0x64, 0x06, 0xC0, 0x6C, 0x0C,
  0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC1, 0x8C, 0x38, 0xFF, 0x07, 0xE0,
  0xC0, 0x3A, 0x01, 0x98, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x61, 0x83, 0x0C,
  0x30, 0x21, 0x81, 0x98, 0x0C, 0xC0, 0x6C, 0x03, 0x60, 0x1A, 0x00, 0xF0,
  0x03, 0x00, 0x60, 0x0D, 0x80, 0x26, 0x01, 0x98, 0x06, 0x63, 0x19, 0x9C,
  0x46, 0x53, 0x13, 0x4C, 0x4D, 0x31, 0x24, 0x85, 0x96, 0x34, 0x58, 0xD1,
  0x63, 0xC5, 0x0E, 0x1C, 0x38, 0x70, 0x18, 0x0E, 0x30, 0x38, 0x30, 0x60,
  0x61, 0x80, 0x66, 0x00, 0xD8, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x33, 0x00, 0xC6, 0x03, 0x86, 0x06, 0x0C, 0x18, 0x0C, 0x60, 0x18,
  0xC0, 0x3B, 0x01, 0x98, 0x18, 0xC1, 0xC3, 0x0C, 0x18, 0xC0, 0x6C, 0x03,
  0x60, 0x1E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0F, 0xFF, 0x3F, 0xFC, 0x1F, 0x8F, 0xC4, 0x02, 0x03, 0x01,
  0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80,
  0xC0, 0x60, 0x3F, 0x1F, 0x80, 0xC1, 0x04, 0x10, 0x61, 0x82, 0x08, 0x30,
  0xC1, 0x04, 0x10, 0x61, 0x82, 0x08, 0x30, 0xC1, 0x0F, 0xC7, 0xF0, 0x0C,
  0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x8F, 0xE3, 0xF8, 0x03, 0x80, 0x38,
  0x06, 0xC0, 0xCC, 0x18, 0x41, 0x86, 0x30, 0x26, 0x03, 0xC0, 0x30, 0xFF,
  0xFF, 0xFC, 0xCD, 0x90, 0x0F, 0x27, 0xFC, 0xC3, 0xB0, 0x36, 0x07, 0x80,
  0xB0, 0x16, 0x06, 0xC0, 0xCC, 0x79, 0xFB, 0x9E, 0x70, 0x18, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x30, 0x03, 0x3C, 0x37, 0xE3, 0x86, 0x30, 0x26, 0x03,
  0x60, 0x26, 0x06, 0x60, 0x66, 0x06, 0x60, 0xCD, 0xF8, 0xCF, 0x00, 0x1F,
  0x0F, 0xE7, 0x0F, 0x82, 0xC0, 0x30, 0x0C, 0x03, 0x02, 0xC1, 0xF8, 0xE7,
  0xF0, 0xF0, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0xF3, 0x3F,
  0xA3, 0x0E, 0x60, 0x66, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xCC, 0x0C, 0x61,
  0xC7, 0xEC, 0x3C, 0xC0, 0x0F, 0x8F, 0xF7, 0x0F, 0x03, 0xC1, 0xFF, 0xEF,
  0xC3, 0x00, 0xC0, 0xF0, 0x67, 0xF0, 0xF8, 0x00, 0x7E, 0x01, 0xFC, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x86, 0x01, 0x8C, 0x03, 0x98, 0x03, 0xB0, 0x03, 0xC0, 0x03, 0x80,
  0x00, 0x0F, 0x33, 0xFA, 0x30, 0xE6, 0x06, 0x60, 0x64, 0x06, 0xC0, 0x6C,
  0x0C, 0xC0, 0xC6, 0x1C, 0x7E, 0xC3, 0xCC, 0x00, 0xC0, 0x18, 0xC3, 0x8F,
  0xF0, 0x7E, 0x00, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x67, 0x8D,
  0xF9, 0xC3, 0x30, 0x66, 0x0D, 0x81, 0xB0, 0x36, 0x04, 0xC1, 0x98, 0x32,
  0x06, 0xC0, 0xC0, 0x06, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC3,
  0xF0, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x86, 0x31, 0x9C, 0x5C, 0x3E,
  0x07, 0x00, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08,
  0x03, 0x08, 0x63, 0x8C, 0x39, 0x83, 0xB0, 0x3C, 0x03, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x3C, 0x37, 0xE3, 0x86, 0x30, 0x63,
  0x06, 0x61, 0xC6, 0xF0, 0x64, 0x26, 0x63, 0x66, 0x74, 0x3C, 0xC1, 0x80,
  0x7E, 0x1F, 0x08, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06,
  0x01, 0x80, 0x42, 0x11, 0xCC, 0xE3, 0x70, 0xF8, 0x38, 0x00, 0x36, 0x31,
  0xFB, 0xCC, 0xE6, 0x62, 0x32, 0x31, 0xB1, 0x8D, 0x8C, 0x4C, 0x62, 0x62,
  0x32, 0x11, 0x91, 0x8D, 0x8C, 0x60, 0x33, 0xC6, 0xFC, 0xE1, 0x98, 0x33,
  0x06, 0xC0, 0xD8, 0x1B, 0x02, 0x60, 0xCC, 0x19, 0x03, 0x60, 0x60, 0x0F,
  0x83, 0xF8, 0xC1, 0xB0, 0x36, 0x02, 0xC0, 0xF0, 0x1E, 0x03, 0x40, 0xEC,
  0x38, 0xFE, 0x0F, 0x80, 0x19, 0xE0, 0xDF, 0x87, 0x0C, 0x30, 0x23, 0x01,
  0x98, 0x08, 0xC0, 0xC6, 0x06, 0x30, 0x31, 0x83, 0x1B, 0xF0, 0xCF, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x00, 0x0F, 0x33, 0xFA, 0x30,
  0xE6, 0x06, 0x60, 0x6C, 0x06, 0xC0, 0x6C, 0x0C, 0xC0, 0xC6, 0x1C, 0x7E,
  0xC3, 0xCC, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x7C, 0xF7,
  0xDE, 0x8E, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x0F, 0x83, 0xFC, 0xC1, 0x90, 0x03, 0x00, 0x7F,
  0x03, 0xF0, 0x06, 0x00, 0x5C, 0x19, 0xFF, 0x1F, 0x80, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0xFF, 0xFF, 0xF1, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC3,
  0x33, 0xCD, 0xC3, 0xE0, 0xE0, 0x60, 0x58, 0x36, 0x0D, 0x03, 0xC0, 0xF0,
  0x3C, 0x0B, 0x06, 0xC3, 0xB1, 0x6F, 0xD9, 0xE6, 0xF0, 0xFC, 0x33, 0x04,
  0x81, 0x20, 0xC8, 0x36, 0x0D, 0x86, 0x63, 0x99, 0xC7, 0xE1, 0xE0, 0x63,
  0x36, 0x33, 0x62, 0x34, 0x23, 0x46, 0x34, 0x63, 0xC6, 0x3C, 0x63, 0xC4,
  0x6C, 0xE6, 0xF7, 0xC7, 0x38, 0x0E, 0x38, 0x79, 0xE3, 0xAC, 0xD8, 0xA3,
  0x03, 0x0C, 0x0C, 0x00, 0x30, 0x31, 0xC0, 0xC7, 0x1B, 0x3D, 0xCF, 0xBE,
  0x1C, 0x70, 0x30, 0x26, 0x0C, 0xC1, 0x90, 0x32, 0x06, 0xC0, 0xD8, 0x13,
  0x06, 0x61, 0xCC, 0x79, 0xFB, 0x1E, 0x60, 0x18, 0x03, 0x30, 0xE7, 0xF8,
  0x7C, 0x00, 0x1F, 0x33, 0xFF, 0x61, 0xF6, 0x0C, 0x01, 0x80, 0x30, 0x0C,
  0x01, 0x84, 0x30, 0x6F, 0xE6, 0xDF, 0xEC, 0x3C, 0x07, 0xC3, 0xF0, 0xC0,
  0x20, 0x08, 0x03, 0x00, 0x40, 0x18, 0x0C, 0x3E, 0x0F, 0x80, 0x30, 0x0C,
  0x02, 0x01, 0x00, 0x80, 0x20, 0x18, 0x07, 0xE0, 0xF8, 0x18, 0x84, 0x63,
  0x18, 0x84, 0x23, 0x18, 0xC4, 0x21, 0x18, 0xC6, 0x21, 0x00, 0x1F, 0x83,
  0xF0, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x00, 0xFC,
  0x1F, 0x86, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x06, 0x00, 0x83, 0xF0,
  0x7E, 0x00, 0x3C, 0x37, 0xC3, 0x66, 0x6C, 0x3E, 0xC1, 0xC0,
};

const GFXglyph IBMPlexMono_Italic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 16, 14, 4, -16 },
  { 13, 7, 6, 14, 5, -17 },
  { 19, 14, 16, 14, 0, -16 },
  { 47, 12, 20, 14, 1, -18 },
  { 77, 16, 16, 14, -1, -16 },
  { 109, 14, 16, 14, 0, -16 },
  { 137, 3, 6, 14, 7, -17 },
  { 140, 8, 20, 14, 5, -17 },
  { 160, 9, 20, 14, 1, -17 },
  { 183, 12, 11, 14, 1, -13 },
  { 200, 11, 12, 14, 2, -13 },
  { 217, 5, 6, 14, 3, -3 },
  { 221, 7, 2, 14, 4, -8 },
  { 223, 4, 3, 14, 4, -3 },
  { 225, 13, 20, 14, 1, -17 },
  { 258, 12, 16, 14, 1, -16 },
  { 282, 11, 16, 14, 1, -16 },
  { 304, 12, 16, 14, 1, -16 },
  { 328, 12, 16, 14, 1, -16 },
  { 352, 13, 16, 14, 0, -16 },
  { 378, 12, 16, 14, 1, -16 },
  { 402, 11, 16, 14, 1, -16 },
  { 424, 12, 16, 14, 2, -16 },
  { 448, 12, 16, 14, 1, -16 },
  { 472, 11, 16, 14, 2, -16 },
  { 494, 5, 12, 14, 4, -12 },
  { 502, 6, 15, 14, 3, -12 },
  { 514, 11, 13, 14, 2, -14 },
  { 532, 12, 6, 14, 1, -10 },
  { 541, 11, 13, 14, 1, -14 },
  { 559, 10, 16, 14, 3, -16 },
  { 579, 12, 19, 14, 1, -16 },
  { 608, 12, 16, 14, 0, -16 },
  { 632, 12, 16, 14, 1, -16 },
  { 656, 11, 16, 14, 2, -16 },
  { 678, 12, 16, 14, 1, -16 },
  { 702, 13, 16, 14, 1, -16 },
  { 728, 13, 16, 14, 1, -16 },
  { 754, 11, 16, 14, 2, -16 },
  { 776, 13, 16, 14, 1, -16 },
  { 802, 13, 16, 14, 1, -16 },
  { 828, 12, 16, 14, 1, -16 },
  { 852, 14, 16, 14, 1, -16 },
  { 880, 10, 16, 14, 2, -16 },
  { 900, 13, 16, 14, 1, -16 },
  { 926, 13, 16, 14, 1, -16 },
  { 952, 12, 16, 14, 1, -16 },
  { 976, 12, 16, 14, 1, -16 },
  { 1000, 12, 20, 14, 1, -16 },
  { 1030, 12, 16, 14, 1, -16 },
  { 1054, 12, 16, 14, 1, -16 },
  { 1078, 13, 16, 14, 2, -16 },
  { 1104, 12, 16, 14, 2, -16 },
  { 1128, 13, 16, 14, 2, -16 },
  { 1154, 14, 16, 14, 1, -16 },
  { 1182, 15, 16, 14, 0, -16 },
  { 1212, 13, 16, 14, 2, -16 },
  { 1238, 14, 16, 14, 0, -16 },
  { 1266, 9, 20, 14, 4, -17 },
  { 1289, 6, 20, 14, 4, -17 },
  { 1304, 10, 20, 14, 0, -17 },
  { 1329, 12, 9, 14, 1, -16 },
  { 1343, 11, 2, 14, 0, 2 },
  { 1346, 3, 4, 14, 5, -17 },
  { 1348, 11, 12, 14, 1, -12 },
  { 1365, 12, 17, 14, 1, -17 },
  { 1391, 10, 12, 14, 2, -12 },
  { 1406, 12, 17, 14, 1, -17 },
  { 1432, 10, 12, 14, 2, -12 },
  { 1447, 15, 22, 14, 0, -17 },
  { 1489, 12, 17, 14, 1, -12 },
  { 1515, 11, 17, 14, 1, -17 },
  { 1539, 10, 18, 14, 2, -18 },
  { 1562, 11, 23, 14, 1, -18 },
  { 1594, 12, 17, 14, 1, -17 },
  { 1620, 10, 17, 14, 2, -17 },
  { 1642, 13, 12, 14, 0, -12 },
  { 1662, 11, 12, 14, 1, -12 },
  { 1679, 11, 12, 14, 1, -12 },
  { 1696, 13, 17, 14, 0, -12 },
  { 1724, 12, 17, 14, 1, -12 },
  { 1750, 12, 12, 14, 2, -12 },
  { 1768, 11, 12, 14, 1, -12 },
  { 1785, 10, 16, 14, 2, -16 },
  { 1805, 10, 12, 14, 2, -12 },
  { 1820, 10, 12, 14, 2, -12 },
  { 1835, 12, 12, 14, 1, -12 },
  { 1853, 14, 12, 14, 0, -12 },
  { 1874, 11, 17, 14, 1, -12 },
  { 1898, 12, 12, 14, 1, -12 },
  { 1916, 10, 20, 14, 3, -17 },
  { 1941, 5, 20, 14, 5, -17 },
  { 1954, 11, 20, 14, 1, -17 },
  { 1982, 12, 5, 14, 1, -10 },
};

const GFXfont IBMPlexMono_Italic23pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic23pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _IBMPLEXMONO_ITALIC23PT7B_H_
