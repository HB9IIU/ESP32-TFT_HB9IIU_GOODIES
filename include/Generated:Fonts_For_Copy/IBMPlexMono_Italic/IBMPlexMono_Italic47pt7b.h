#ifndef _IBMPLEXMONO_ITALIC47PT7B_H_
#define _IBMPLEXMONO_ITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E,
  0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0x78, 0x00, 0x3C,
  0x3C, 0xE0, 0xF3, 0x83, 0x9E, 0x0E, 0x78, 0x79, 0xE1, 0xE7, 0x07, 0x9C,
  0x1E, 0x70, 0x73, 0xC1, 0xCF, 0x0F, 0x3C, 0x3C, 0xE0, 0xF0, 0x00, 0x07,
  0x83, 0x80, 0x00, 0x70, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x70,
  0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0E, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xC0, 0x1F, 0xF8, 0x3F,
  0xF1, 0xFF, 0x83, 0xFF, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0x07, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x0F,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1C, 0x1E, 0x00, 0xFF, 0xC1, 0xFF, 0x8F,
  0xFC, 0x1F, 0xF8, 0xFF, 0x83, 0xFF, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83,
  0x80, 0x00, 0x70, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x70, 0x00,
  0x0E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xF3, 0x9F,
  0x80, 0xF8, 0x70, 0xF8, 0x1E, 0x0E, 0x0F, 0x87, 0x81, 0xC0, 0xC0, 0xF0,
  0x38, 0x00, 0x1E, 0x06, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x78, 0x38, 0x00,
  0x0F, 0x07, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x1F, 0x1C, 0x00, 0x03, 0xFB,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0E, 0x3E, 0x00, 0x01, 0x83, 0xE0, 0x00, 0x30,
  0x3C, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x38, 0x1E, 0x00,
  0x07, 0x03, 0xC1, 0x00, 0xE0, 0x78, 0x70, 0x18, 0x1E, 0x1F, 0x07, 0x07,
  0xC1, 0xF0, 0xE1, 0xF0, 0x1F, 0x9C, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x0F, 0x00, 0xFF, 0x00, 0x1E, 0x03, 0xFF, 0x80, 0x1C, 0x03,
  0xC3, 0xC0, 0x38, 0x07, 0x81, 0xC0, 0x78, 0x07, 0x01, 0xC0, 0x70, 0x0F,
  0x01, 0xC0, 0xE0, 0x0E, 0x01, 0xC1, 0xE0, 0x0E, 0x01, 0xC1, 0xC0, 0x0E,
  0x01, 0xC3, 0x80, 0x0E, 0x03, 0xC7, 0x80, 0x0E, 0x03, 0x8F, 0x00, 0x0F,
  0x0F, 0x8E, 0x00, 0x07, 0xFF, 0x1C, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x78, 0xFF, 0xE0, 0x00, 0x71, 0xE0, 0xE0, 0x00,
  0xE1, 0xC0, 0xE0, 0x01, 0xE3, 0xC0, 0x70, 0x03, 0xC3, 0x80, 0x70, 0x03,
  0x83, 0x80, 0x70, 0x07, 0x83, 0x80, 0xF0, 0x0F, 0x07, 0x80, 0xF0, 0x0E,
  0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x3C, 0x03, 0x81, 0xC0, 0x38,
  0x03, 0xC3, 0xC0, 0x70, 0x03, 0xFF, 0x80, 0xF0, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x01, 0xE0,
  0x01, 0xE0, 0x0E, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x1E,
  0x00, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xE0, 0x1C,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0F, 0x8F, 0x00, 0x07,
  0xFF, 0xE0, 0x01, 0xF3, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x78, 0x1E, 0x00, 0x07, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x06, 0xF0, 0x03,
  0xC0, 0xFF, 0x00, 0x7E, 0x1E, 0xF0, 0x06, 0xE1, 0xC7, 0x80, 0xCF, 0x3C,
  0x7C, 0x1C, 0xF3, 0x83, 0xFF, 0x87, 0xF8, 0x1F, 0xF0, 0x3F, 0x00, 0x7C,
  0x01, 0xE0, 0x3C, 0xE3, 0x8E, 0x79, 0xE7, 0x9C, 0x71, 0xCF, 0x3C, 0xF0,
  0x00, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x20, 0x1E, 0x01, 0xF8,
  0x3C, 0x1F, 0xFE, 0x73, 0xFD, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xCE,
  0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x3C,
  0x0F, 0x00, 0x78, 0x04, 0x00, 0x40, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xC1, 0xF0,
  0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xE0, 0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3C, 0xFF, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xF8, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x1E, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C,
  0x00, 0x0F, 0x38, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78,
  0x3C, 0x0F, 0x78, 0x7E, 0x0F, 0xF0, 0x7E, 0x1E, 0xF0, 0x7E, 0x1E, 0xF0,
  0x7C, 0x1E, 0xF0, 0x7C, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x70, 0xF0, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x03, 0xE0, 0x3E,
  0x0F, 0xC0, 0x3F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3E, 0xF0, 0x01, 0xF3,
  0xC0, 0x0F, 0x8F, 0x00, 0x7C, 0x3C, 0x03, 0xE0, 0xF0, 0x1F, 0x07, 0x80,
  0x78, 0x1E, 0x00, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x7E, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x3C, 0x00,
  0x78, 0x3E, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x02, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x3E, 0x07, 0xE0, 0x3E, 0x00, 0xF0, 0x3C, 0x00, 0x7C, 0x04, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x06, 0x00, 0x07, 0x8F, 0x80, 0x07, 0x83, 0xE0, 0x07, 0xC1,
  0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x07, 0x00,
  0x07, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0x80, 0xF0,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E,
  0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC1, 0xE0, 0x01,
  0xC1, 0xE0, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0xFC, 0x00, 0x39, 0xFF, 0xC0, 0x1D, 0xFF, 0xF0, 0x1F,
  0xC0, 0xFC, 0x0F, 0x80, 0x3E, 0x03, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x06, 0x00, 0x0F,
  0x87, 0x80, 0x07, 0x87, 0xE0, 0x07, 0x81, 0xFC, 0x0F, 0x80, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0xFE, 0x03, 0xCF,
  0xFE, 0x0F, 0x7F, 0xFC, 0x7B, 0x81, 0xF9, 0xF8, 0x01, 0xE7, 0xC0, 0x07,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xBC, 0x00,
  0x1E, 0x70, 0x00, 0xF1, 0xE0, 0x07, 0x83, 0xE0, 0x7C, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0x80, 0x01, 0xF7, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0xBC,
  0x00, 0x1E, 0x78, 0x00, 0x78, 0xE0, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x7E, 0x07, 0xE0, 0x7C, 0x00, 0xF0, 0x3C, 0x00, 0x7C,
  0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x00, 0x03,
  0xC3, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x3C, 0x01,
  0xE0, 0x1F, 0x03, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x01, 0xE3, 0xC0,
  0x00, 0xF1, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78,
  0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x07, 0x8F, 0x80, 0x07, 0xC3,
  0xC0, 0x07, 0xC1, 0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF,
  0x03, 0xE0, 0x7E, 0x1F, 0x00, 0x78, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xDE,
  0x00, 0x0F, 0x78, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F,
  0x7C, 0x01, 0xF9, 0xF8, 0x1D, 0xE3, 0xFF, 0xEF, 0x07, 0xFF, 0x3C, 0x07,
  0xF1, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0x83, 0xF1, 0xFC, 0x7F, 0x1F, 0xC3, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x7E, 0x3F, 0x8F, 0xE3, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x3F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xC3, 0xF0, 0x7E, 0x7C, 0x01,
  0xE7, 0x80, 0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x20, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0x03, 0xE0, 0x78,
  0x01, 0xC1, 0xE0, 0x03, 0xC3, 0x80, 0x03, 0x8F, 0x00, 0x07, 0x1C, 0x00,
  0x0E, 0x78, 0x0F, 0x1C, 0xE0, 0x7F, 0x39, 0xC1, 0xFF, 0x77, 0x87, 0xC2,
  0xEF, 0x0F, 0x03, 0xDC, 0x3C, 0x07, 0xB8, 0x78, 0x0F, 0x70, 0xE0, 0x1D,
  0xE1, 0xC0, 0x3B, 0xC7, 0x80, 0x77, 0x8F, 0x00, 0xEE, 0x1E, 0x03, 0xDC,
  0x3C, 0x07, 0xB8, 0x78, 0x0E, 0x70, 0xF0, 0x3C, 0xE1, 0xE0, 0x79, 0xC3,
  0xC1, 0x73, 0x83, 0xEF, 0xE7, 0x07, 0xFB, 0xCE, 0x07, 0xE7, 0x1C, 0x02,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3C, 0xE0, 0x00,
  0x1C, 0x70, 0x00, 0x1E, 0x38, 0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x0F, 0x00,
  0x07, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0x81, 0xE0, 0x03, 0xC0, 0x70,
  0x01, 0xE0, 0x38, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80,
  0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0,
  0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x0F,
  0x07, 0x00, 0x0F, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F,
  0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1E,
  0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x1C, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x1E,
  0x78, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78,
  0x78, 0x01, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x03, 0xE0,
  0x78, 0x03, 0xE1, 0xE0, 0x03, 0xC7, 0xC0, 0x07, 0x8F, 0x00, 0x06, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x41,
  0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0x87, 0x80, 0x1F, 0x0F,
  0x80, 0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F,
  0x00, 0xF8, 0x0F, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E,
  0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0,
  0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x0F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xF0, 0x7C, 0x07, 0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x0F,
  0x00, 0x0F, 0x1E, 0x00, 0x0C, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x0F, 0xFC, 0xF0,
  0x0F, 0xFC, 0xF0, 0x1F, 0xFC, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x38, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0x7C, 0x03, 0x70, 0x3E,
  0x0E, 0xF0, 0x1F, 0xFE, 0xF0, 0x0F, 0xF8, 0xF0, 0x07, 0xF0, 0x00, 0x07,
  0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x1E, 0x00, 0x1E,
  0x07, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xE0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x0F, 0x03, 0x80,
  0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07,
  0x80, 0x03, 0x81, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0x78, 0x3C, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC1, 0xC0, 0x07, 0x87, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1F, 0x00,
  0xF0, 0x1F, 0x07, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xC0,
  0x78, 0x00, 0xF8, 0x07, 0x80, 0x1F, 0x00, 0x70, 0x03, 0xE0, 0x0F, 0x00,
  0x7C, 0x00, 0xF0, 0x0F, 0x80, 0x0F, 0x01, 0xF0, 0x00, 0xF0, 0x3E, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0xE0, 0xF8, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xE3,
  0xE0, 0x00, 0x1E, 0x7E, 0x00, 0x01, 0xEF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFE, 0xF0, 0x00, 0x3F, 0xCF, 0x00, 0x03, 0xF8, 0x78, 0x00, 0x3F,
  0x07, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0x80, 0x3E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x78, 0x00, 0xF0, 0x07,
  0x80, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x07, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xDC, 0x07, 0x70, 0x7B, 0x81, 0xEE, 0x0F,
  0x70, 0x39, 0xC1, 0xEF, 0x0F, 0x78, 0x38, 0xE1, 0xCF, 0x07, 0x1C, 0x71,
  0xE0, 0xE3, 0x9E, 0x38, 0x3C, 0x7B, 0x87, 0x07, 0x87, 0xF1, 0xE0, 0xF0,
  0xFC, 0x3C, 0x1C, 0x1F, 0x07, 0x83, 0x83, 0xE0, 0xF0, 0x70, 0x38, 0x1C,
  0x1E, 0x07, 0x03, 0x83, 0xC0, 0xC0, 0xF0, 0x78, 0x18, 0x1E, 0x0E, 0x02,
  0x03, 0xC1, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x3C, 0x1C, 0x00, 0x07, 0x07, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0xE0, 0x03, 0xC1, 0xF8, 0x00, 0xF0, 0x7E, 0x00, 0x38, 0x1F, 0xC0,
  0x0E, 0x07, 0xF0, 0x07, 0x83, 0xDC, 0x01, 0xE0, 0xF7, 0x00, 0x78, 0x3D,
  0xE0, 0x1E, 0x0E, 0x78, 0x07, 0x03, 0x8E, 0x01, 0xC0, 0xE3, 0x80, 0xF0,
  0x78, 0xE0, 0x3C, 0x1E, 0x3C, 0x0F, 0x07, 0x8F, 0x03, 0xC1, 0xC1, 0xC0,
  0xE0, 0x70, 0x70, 0x38, 0x1C, 0x1E, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC0,
  0xE1, 0xE0, 0xF0, 0x38, 0x78, 0x38, 0x0E, 0x1C, 0x0E, 0x03, 0xC7, 0x03,
  0x80, 0xF3, 0xC1, 0xE0, 0x1C, 0xF0, 0x78, 0x07, 0x3C, 0x1E, 0x01, 0xEF,
  0x07, 0x00, 0x7B, 0x81, 0xC0, 0x0E, 0xE0, 0x70, 0x03, 0xF8, 0x3C, 0x00,
  0xFE, 0x0F, 0x00, 0x3F, 0x83, 0xC0, 0x0F, 0xE0, 0xE0, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x0E,
  0x1E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F,
  0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0,
  0x78, 0x01, 0xE0, 0x78, 0x03, 0xE0, 0x3E, 0x0F, 0xC0, 0x3F, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0xF0, 0x03, 0xE0, 0x78, 0x00, 0x78, 0x3C, 0x00,
  0x3C, 0x1C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80,
  0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03,
  0xE0, 0x7C, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x1E,
  0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF8,
  0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0x78,
  0x01, 0xE0, 0x78, 0x03, 0xE0, 0x3E, 0x0F, 0xC0, 0x3F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x08, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xF0, 0x03, 0xE0, 0x78, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07,
  0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0x81, 0xE0, 0x03, 0xC0,
  0xF0, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07,
  0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC1, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x07, 0xC1, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x18, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC2, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x78, 0xF8,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x03, 0xF0, 0x1F, 0x80, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xC1, 0xE0, 0x01, 0xE1,
  0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E,
  0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03,
  0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0x78, 0x00,
  0x78, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00,
  0x07, 0x87, 0x80, 0x03, 0x83, 0xC0, 0x03, 0xC1, 0xC0, 0x01, 0xE0, 0xE0,
  0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x0E,
  0x00, 0x1E, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x1F, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xCE, 0x00, 0x03, 0xC7, 0x00,
  0x01, 0xE3, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x78,
  0x00, 0x78, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x03,
  0x80, 0x1E, 0x01, 0xC0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x3C, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x07, 0x01, 0xC0, 0x03, 0x81, 0xE0,
  0x01, 0xC0, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x78,
  0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x0F, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xE1,
  0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1C, 0x3C, 0x00,
  0x03, 0xC3, 0xC0, 0xF0, 0x3C, 0x38, 0x1F, 0x03, 0x83, 0x81, 0xF0, 0x38,
  0x38, 0x3F, 0x07, 0x83, 0x83, 0xB0, 0x78, 0x38, 0x3B, 0x07, 0x03, 0x87,
  0x38, 0x70, 0x38, 0x73, 0x87, 0x07, 0x87, 0x38, 0xF0, 0x78, 0xE3, 0x8E,
  0x07, 0x8E, 0x38, 0xE0, 0x79, 0xE3, 0x8E, 0x07, 0x1C, 0x39, 0xE0, 0x71,
  0xC3, 0x9C, 0x07, 0x38, 0x39, 0xC0, 0x73, 0x83, 0x9C, 0x07, 0x78, 0x3B,
  0xC0, 0x77, 0x03, 0xBC, 0x07, 0x70, 0x3B, 0x80, 0x7F, 0x03, 0xB8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0,
  0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x0F, 0x8F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x0F, 0x80,
  0x01, 0xE0, 0x3E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x03, 0xEF, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x83,
  0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x1C, 0x07, 0x80, 0x03,
  0xC1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x07, 0x9F, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x0E, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x18, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x60, 0x07, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3D, 0xC0, 0x00,
  0x79, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0xF0, 0xE0, 0x01, 0xE0, 0xF0, 0x01,
  0xC0, 0x70, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x38, 0x0F,
  0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x0E, 0xF0, 0x00, 0x0F, 0x20, 0x00, 0x04, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x23, 0xCF, 0x1C, 0x78, 0xE3, 0x87, 0x18,
  0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x70, 0x7F, 0xFB, 0xC3, 0xE0, 0x6F, 0x1E,
  0x00, 0xFC, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00,
  0x79, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x73,
  0xC0, 0x01, 0xCF, 0x00, 0x0F, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0xF3, 0x80,
  0x07, 0xCE, 0x00, 0x1E, 0x3C, 0x00, 0xF8, 0xF0, 0x03, 0xE3, 0xE0, 0x17,
  0x87, 0xC1, 0xDF, 0xDF, 0xFE, 0x3F, 0x3F, 0xF0, 0x7C, 0x3F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x07, 0xE0, 0x0F, 0x1F, 0xF8,
  0x0F, 0x3F, 0xFC, 0x0F, 0x70, 0x7C, 0x0F, 0xC0, 0x3E, 0x0E, 0x80, 0x1E,
  0x0F, 0x80, 0x0E, 0x1F, 0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F,
  0x1E, 0x00, 0x0F, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x3C,
  0x38, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x7C, 0x00, 0x78, 0x7E, 0x00, 0xF0,
  0x7F, 0x03, 0xF0, 0x73, 0xFF, 0xE0, 0x71, 0xFF, 0x80, 0x80, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xF8, 0x1F, 0x1E, 0x00,
  0xF3, 0xC0, 0x07, 0x3C, 0x00, 0x47, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x04, 0xE0, 0x00, 0xFF,
  0x00, 0x1E, 0xF0, 0x03, 0xE7, 0x80, 0x7C, 0x7C, 0x0F, 0x83, 0xFF, 0xF0,
  0x1F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x3F, 0x07, 0x80, 0x7F, 0xE3, 0xC0, 0x7F, 0xF9, 0xC0, 0x7C, 0x0E,
  0xE0, 0x78, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x1E, 0x1E, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x87, 0x80,
  0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0x70,
  0x00, 0x38, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x1F, 0x07,
  0x80, 0x0F, 0x83, 0xC0, 0x0F, 0x81, 0xF0, 0x0D, 0xC0, 0x7C, 0x1D, 0xE0,
  0x3F, 0xFC, 0xF0, 0x0F, 0xFC, 0x78, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xF0, 0x3E, 0x0F, 0x00, 0x3C,
  0x78, 0x00, 0xF1, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x38, 0x00, 0x3D, 0xE0,
  0x01, 0xE7, 0x80, 0x1F, 0x9E, 0x0F, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x0F, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x87,
  0x00, 0x03, 0x1E, 0x00, 0x1E, 0x78, 0x00, 0xF0, 0xF0, 0x07, 0x83, 0xE0,
  0x7C, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x80, 0x3C,
  0x00, 0x03, 0x80, 0x78, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x0F, 0x81, 0xC0,
  0x00, 0x0F, 0x87, 0x80, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x0F, 0x9E, 0x00,
  0x00, 0x0F, 0xB8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xE3, 0xC0,
  0x7F, 0xF9, 0xC0, 0x7C, 0x0E, 0xE0, 0x78, 0x01, 0xF0, 0x78, 0x00, 0xF8,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x0E, 0x00, 0x07,
  0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0x70, 0x70, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x1E, 0x00,
  0x3E, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x1F, 0x83, 0xE0, 0x1B, 0x80, 0xF8,
  0x39, 0xC0, 0x3F, 0xF9, 0xE0, 0x1F, 0xF8, 0xF0, 0x03, 0xF8, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x01,
  0x00, 0x0F, 0x00, 0xC0, 0x0F, 0x80, 0xF8, 0x1F, 0x80, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC3, 0xF0,
  0x1C, 0x7F, 0xC1, 0xE7, 0xFF, 0x0F, 0x30, 0x7C, 0x7B, 0x01, 0xE3, 0xF0,
  0x0F, 0x1F, 0x00, 0x38, 0xF0, 0x01, 0xCF, 0x80, 0x0E, 0x78, 0x00, 0xF3,
  0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x00, 0x0F, 0x78, 0x00,
  0x73, 0xC0, 0x03, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x38,
  0x00, 0x7B, 0xC0, 0x03, 0x9E, 0x00, 0x1C, 0xF0, 0x01, 0xE7, 0x80, 0x0F,
  0x3C, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x01, 0x80,
  0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x1E, 0x01, 0xC1, 0xE0, 0x1E, 0x1E,
  0x00, 0xF1, 0xE0, 0x07, 0xBE, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x02,
  0x00, 0xE0, 0x3C, 0x03, 0x80, 0xF8, 0x1E, 0x01, 0xE0, 0x78, 0x03, 0xC1,
  0xE0, 0x07, 0x87, 0x80, 0x0F, 0x1C, 0x00, 0x1E, 0x70, 0x00, 0x3F, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x0F, 0xC0, 0x0E, 0x3F, 0xF0, 0x1E, 0x7F, 0xF0, 0x1E, 0xE0, 0xF8,
  0x1E, 0xC0, 0x78, 0x1F, 0x80, 0x78, 0x1F, 0x00, 0x38, 0x1E, 0x00, 0x38,
  0x3E, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x3C, 0x01, 0xE0,
  0x3C, 0x07, 0xC0, 0x38, 0x1F, 0x00, 0x78, 0xFC, 0x00, 0x79, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0x78, 0x78, 0x04, 0x78, 0x78, 0x0E, 0x70, 0x38, 0x1F,
  0xF0, 0x3C, 0x3C, 0xF0, 0x3C, 0x78, 0xF0, 0x1E, 0xF0, 0xF0, 0x1F, 0xE0,
  0xF0, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x06, 0x0F,
  0x01, 0xF0, 0xF0, 0x3E, 0x0F, 0x07, 0x80, 0xE0, 0xF0, 0x1E, 0x1E, 0x01,
  0xE3, 0xC0, 0x1E, 0x78, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x1F, 0x03, 0x9F, 0x8F, 0xE1, 0xEF, 0xE7, 0xF8, 0x7E, 0x3F,
  0x8F, 0x1D, 0x0F, 0x83, 0xC7, 0x83, 0xE0, 0xF1, 0xC0, 0xF0, 0x3C, 0xF0,
  0x3C, 0x0E, 0x3C, 0x0F, 0x03, 0x8F, 0x03, 0x80, 0xE3, 0x80, 0xE0, 0x38,
  0xE0, 0x38, 0x1E, 0x38, 0x1E, 0x07, 0x9E, 0x07, 0x81, 0xC7, 0x81, 0xE0,
  0x71, 0xE0, 0x70, 0x1C, 0x70, 0x1C, 0x07, 0x1C, 0x07, 0x03, 0xC7, 0x03,
  0xC0, 0xF3, 0xC0, 0xF0, 0x38, 0xF0, 0x3C, 0x0E, 0x3C, 0x0E, 0x03, 0x8E,
  0x03, 0x80, 0xE3, 0x80, 0xE0, 0x78, 0xE0, 0x78, 0x1E, 0x00, 0x00, 0x0F,
  0xC0, 0x71, 0xFF, 0x03, 0x9F, 0xFC, 0x3C, 0xC1, 0xF1, 0xEC, 0x07, 0x8F,
  0xC0, 0x3C, 0x7C, 0x00, 0xE3, 0xC0, 0x07, 0x1E, 0x00, 0x39, 0xE0, 0x03,
  0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9C, 0x00, 0x3C, 0xE0,
  0x01, 0xCF, 0x00, 0x0E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3C,
  0xE0, 0x01, 0xE7, 0x00, 0x0E, 0x78, 0x00, 0x73, 0xC0, 0x07, 0x9E, 0x00,
  0x3C, 0xF0, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE,
  0x03, 0xF0, 0x7C, 0x1F, 0x00, 0x78, 0x78, 0x00, 0xE3, 0xC0, 0x03, 0xCF,
  0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0x9C, 0x00, 0x3C, 0x78,
  0x01, 0xE1, 0xE0, 0x0F, 0x83, 0xE0, 0x7C, 0x07, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xC7, 0xFE, 0x01, 0xE7,
  0xFF, 0x80, 0xF7, 0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x3A, 0x00, 0x78, 0x1F,
  0x00, 0x1C, 0x1F, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3,
  0xC0, 0x01, 0xE1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0E, 0x00, 0x0F,
  0x07, 0x00, 0x07, 0x87, 0x80, 0x07, 0x83, 0xE0, 0x03, 0xC1, 0xF8, 0x03,
  0xC0, 0xFE, 0x07, 0xE0, 0x73, 0xFF, 0xE0, 0x78, 0xFF, 0xC0, 0x3C, 0x1F,
  0x80, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFE, 0x3C, 0x1F, 0xFE, 0x70,
  0x7C, 0x0E, 0xE1, 0xE0, 0x07, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x0F, 0x3C,
  0x00, 0x1E, 0x78, 0x00, 0x38, 0xE0, 0x00, 0x73, 0xC0, 0x01, 0xE7, 0x80,
  0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1C, 0x70, 0x00,
  0x38, 0xE0, 0x00, 0xF1, 0xC0, 0x01, 0xE3, 0x80, 0x07, 0xC7, 0x80, 0x0F,
  0x8F, 0x00, 0x2E, 0x1F, 0x00, 0xDC, 0x1F, 0x07, 0x78, 0x3F, 0xFC, 0xF0,
  0x3F, 0xF1, 0xE0, 0x1F, 0x83, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xC7, 0xFB, 0xFF,
  0x9F, 0xF0, 0x0E, 0x70, 0x00, 0x1D, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x3E,
  0x03, 0xF0, 0xF8, 0x01, 0xC1, 0xE0, 0x01, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE1, 0x00, 0x01, 0xC7,
  0x00, 0x07, 0x9F, 0x00, 0x1E, 0x1F, 0x80, 0xFC, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x20, 0x78,
  0x07, 0x83, 0xC0, 0x7E, 0x1E, 0x0F, 0xC0, 0xF0, 0xF8, 0x07, 0x8F, 0x80,
  0x3D, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x3C, 0xF0, 0x00, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00,
  0x78, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x1E, 0x00, 0x1C, 0x78, 0x00, 0xF1,
  0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1C, 0x00, 0x3C, 0x70, 0x00, 0xE3, 0xC0,
  0x03, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F,
  0x8F, 0x00, 0x5C, 0x3C, 0x01, 0x70, 0xF8, 0x0B, 0xC1, 0xF0, 0xEF, 0x07,
  0xFF, 0x3C, 0x0F, 0xF8, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x19, 0xFE,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00,
  0x70, 0x78, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x3C, 0x00, 0xF0,
  0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x38, 0x01, 0xE0, 0xE0,
  0x07, 0x83, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0x81, 0xE0, 0x3E,
  0x07, 0x81, 0xF0, 0x1C, 0x1F, 0x80, 0x71, 0xFC, 0x01, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0x07, 0x03, 0x0E, 0x03, 0x87, 0x87,
  0x03, 0xC1, 0xC7, 0x81, 0xC0, 0xE3, 0xC0, 0xE0, 0x79, 0xC0, 0x70, 0x3C,
  0xE0, 0x38, 0x1E, 0x70, 0x3C, 0x0F, 0x38, 0x1E, 0x07, 0xBC, 0x0E, 0x03,
  0xDE, 0x07, 0x01, 0xCE, 0x03, 0x80, 0xE7, 0x01, 0xC0, 0x73, 0x81, 0xE0,
  0x39, 0xC0, 0xF0, 0x3D, 0xE0, 0x70, 0x1C, 0xF0, 0x38, 0x0E, 0x70, 0x3C,
  0x0F, 0x38, 0x1E, 0x07, 0x1E, 0x1F, 0x07, 0x8F, 0x1B, 0xC7, 0x87, 0xFC,
  0xFF, 0x81, 0xFC, 0x7F, 0x80, 0x7C, 0x1F, 0x00, 0x00, 0x78, 0x07, 0xC0,
  0x1F, 0xC1, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x7C, 0xE7, 0x8F, 0x1F, 0x0E,
  0x60, 0xF3, 0xE0, 0xEE, 0x0F, 0x18, 0x0E, 0xC0, 0xF1, 0x00, 0xEC, 0x0F,
  0x00, 0x0E, 0x80, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x07, 0x01, 0xF0, 0x00, 0xF0,
  0x17, 0x00, 0x8F, 0x03, 0x70, 0x38, 0xF0, 0x77, 0x07, 0xCF, 0x06, 0x71,
  0xF0, 0x78, 0xE7, 0xBE, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0x83, 0xF8, 0x01,
  0xF0, 0x1E, 0x00, 0x03, 0x80, 0x07, 0x83, 0xC0, 0x03, 0x81, 0xE0, 0x03,
  0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x38, 0x00, 0x78, 0x1C, 0x00,
  0x38, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0,
  0x07, 0x81, 0xC0, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0xF0, 0x00, 0xE0, 0x78,
  0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x07,
  0x80, 0x2E, 0x03, 0xE0, 0x2F, 0x00, 0xF8, 0x77, 0x80, 0x7F, 0xF3, 0xC0,
  0x1F, 0xF1, 0xE0, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x02, 0x00, 0x1E, 0x01, 0x80, 0x1E,
  0x01, 0xF0, 0x3F, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFE, 0x0F, 0x0F, 0xFF, 0x8F, 0x0F,
  0x07, 0xEF, 0x1E, 0x01, 0xFE, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x1C,
  0x00, 0xF0, 0x1C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x08, 0x01,
  0xE0, 0x38, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x3C, 0x1F, 0x00, 0x1C, 0x3F,
  0x00, 0x1C, 0x7F, 0xF0, 0x1E, 0x7F, 0xFF, 0x9E, 0x71, 0xFF, 0xFC, 0x70,
  0x3F, 0xFC, 0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x03, 0x07, 0xF8,
  0x03, 0xC7, 0xFE, 0x01, 0xC3, 0xCF, 0x01, 0xE3, 0xC3, 0xC0, 0xE1, 0xC0,
  0xF0, 0xF1, 0xC0, 0x3C, 0xF0, 0xE0, 0x1F, 0xF0, 0xF0, 0x07, 0xF8, 0x30,
  0x01, 0xF0, 0x00,
};

const GFXglyph IBMPlexMono_Italic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 11, 33, 28, 9, -33 },
  { 47, 14, 13, 28, 10, -35 },
  { 70, 28, 33, 28, 1, -33 },
  { 186, 27, 44, 28, 1, -38 },
  { 335, 32, 34, 28, -1, -33 },
  { 471, 28, 34, 28, 0, -33 },
  { 590, 6, 13, 28, 14, -35 },
  { 600, 17, 42, 28, 10, -36 },
  { 690, 17, 42, 28, 2, -36 },
  { 780, 23, 23, 28, 3, -26 },
  { 847, 23, 23, 28, 3, -26 },
  { 914, 10, 13, 28, 7, -6 },
  { 931, 14, 3, 28, 7, -16 },
  { 937, 7, 6, 28, 9, -6 },
  { 943, 27, 42, 28, 1, -36 },
  { 1085, 24, 34, 28, 3, -33 },
  { 1187, 22, 33, 28, 2, -33 },
  { 1278, 25, 33, 28, 1, -33 },
  { 1382, 25, 34, 28, 1, -33 },
  { 1489, 25, 33, 28, 1, -33 },
  { 1593, 25, 34, 28, 2, -33 },
  { 1700, 22, 34, 28, 3, -33 },
  { 1794, 23, 33, 28, 5, -33 },
  { 1889, 25, 34, 28, 2, -33 },
  { 1996, 22, 33, 28, 4, -33 },
  { 2087, 10, 25, 28, 9, -25 },
  { 2119, 12, 32, 28, 7, -25 },
  { 2167, 23, 27, 28, 4, -28 },
  { 2245, 25, 13, 28, 2, -21 },
  { 2286, 23, 27, 28, 2, -28 },
  { 2364, 20, 33, 28, 6, -33 },
  { 2447, 23, 38, 28, 3, -33 },
  { 2557, 25, 33, 28, 0, -33 },
  { 2661, 24, 33, 28, 2, -33 },
  { 2760, 23, 34, 28, 4, -33 },
  { 2858, 24, 33, 28, 3, -33 },
  { 2957, 26, 33, 28, 2, -33 },
  { 3065, 26, 33, 28, 2, -33 },
  { 3173, 24, 34, 28, 3, -33 },
  { 3275, 26, 33, 28, 2, -33 },
  { 3383, 26, 33, 28, 2, -33 },
  { 3491, 23, 34, 28, 3, -33 },
  { 3589, 28, 33, 28, 2, -33 },
  { 3705, 20, 33, 28, 4, -33 },
  { 3788, 27, 33, 28, 1, -33 },
  { 3900, 26, 33, 28, 2, -33 },
  { 4008, 24, 34, 28, 3, -33 },
  { 4110, 25, 33, 28, 2, -33 },
  { 4214, 24, 42, 28, 3, -33 },
  { 4340, 25, 33, 28, 2, -33 },
  { 4444, 26, 34, 28, 1, -33 },
  { 4555, 27, 33, 28, 4, -33 },
  { 4667, 25, 34, 28, 3, -33 },
  { 4774, 25, 33, 28, 5, -33 },
  { 4878, 28, 33, 28, 2, -33 },
  { 4994, 31, 33, 28, -1, -33 },
  { 5122, 27, 33, 28, 4, -33 },
  { 5234, 29, 33, 28, 0, -33 },
  { 5354, 20, 42, 28, 8, -36 },
  { 5459, 12, 42, 28, 9, -36 },
  { 5522, 20, 42, 28, 0, -36 },
  { 5627, 24, 19, 28, 3, -33 },
  { 5684, 23, 3, 28, 0, 5 },
  { 5693, 6, 9, 28, 11, -37 },
  { 5700, 22, 26, 28, 3, -25 },
  { 5772, 24, 36, 28, 2, -35 },
  { 5880, 20, 26, 28, 4, -25 },
  { 5945, 25, 36, 28, 3, -35 },
  { 6058, 22, 26, 28, 3, -25 },
  { 6130, 31, 45, 28, -1, -35 },
  { 6305, 25, 35, 28, 1, -25 },
  { 6415, 21, 35, 28, 3, -35 },
  { 6507, 21, 36, 28, 4, -35 },
  { 6602, 22, 45, 28, 3, -35 },
  { 6726, 24, 36, 28, 3, -35 },
  { 6834, 20, 36, 28, 5, -35 },
  { 6924, 26, 25, 28, 1, -25 },
  { 7006, 21, 25, 28, 3, -25 },
  { 7072, 22, 26, 28, 3, -25 },
  { 7144, 25, 34, 28, 1, -25 },
  { 7251, 23, 34, 28, 3, -25 },
  { 7349, 23, 24, 28, 5, -24 },
  { 7418, 23, 26, 28, 2, -25 },
  { 7493, 21, 34, 28, 4, -33 },
  { 7583, 22, 25, 28, 4, -24 },
  { 7652, 22, 25, 28, 3, -25 },
  { 7721, 25, 24, 28, 2, -24 },
  { 7796, 28, 26, 28, 0, -25 },
  { 7887, 25, 34, 28, 1, -24 },
  { 7994, 24, 25, 28, 2, -25 },
  { 8069, 22, 42, 28, 5, -36 },
  { 8185, 11, 42, 28, 9, -36 },
  { 8243, 22, 42, 28, 2, -36 },
  { 8359, 25, 10, 28, 2, -19 },
};

const GFXfont IBMPlexMono_Italic47pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic47pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic47pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _IBMPLEXMONO_ITALIC47PT7B_H_
