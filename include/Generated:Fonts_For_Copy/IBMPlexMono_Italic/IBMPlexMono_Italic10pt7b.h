#ifndef _IBMPLEXMONO_ITALIC10PT7B_H_
#define _IBMPLEXMONO_ITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x88, 0xB6, 0x80, 0x1C, 0xA6, 0xCC, 0xDD, 0x46, 0x00, 0x10,
  0xE5, 0x54, 0x38, 0xAA, 0x9C, 0x20, 0x67, 0x29, 0xA0, 0x07, 0xCC, 0xA6,
  0x00, 0x39, 0x24, 0x9C, 0xA2, 0x5E, 0x80, 0xE0, 0x34, 0x88, 0x88, 0x88,
  0x40, 0x21, 0x11, 0x11, 0x22, 0xC0, 0x21, 0x3E, 0xCB, 0x00, 0x22, 0xF4,
  0x40, 0x70, 0xE0, 0x80, 0x04, 0x20, 0x84, 0x20, 0x84, 0x10, 0x80, 0x74,
  0x63, 0x59, 0x4B, 0x80, 0x13, 0x94, 0x21, 0x13, 0xE0, 0x39, 0x20, 0xC2,
  0x31, 0x0F, 0x80, 0x39, 0x20, 0xCC, 0x0A, 0x27, 0x00, 0x08, 0x62, 0x92,
  0x8B, 0xF1, 0x00, 0x3D, 0x07, 0x92, 0x0A, 0x27, 0x00, 0x34, 0xF9, 0x99,
  0xE0, 0xFC, 0x84, 0x42, 0x23, 0x00, 0x39, 0x14, 0x8C, 0x4A, 0x27, 0x00,
  0x74, 0x63, 0x2F, 0x13, 0x00, 0x40, 0x80, 0x20, 0x07, 0x00, 0x09, 0xB1,
  0x06, 0x08, 0xF8, 0x3C, 0x41, 0x82, 0x13, 0x60, 0x74, 0x44, 0x64, 0x01,
  0x00, 0x74, 0x6F, 0xAD, 0x7A, 0x1C, 0x11, 0x4A, 0x97, 0xC6, 0x20, 0x39,
  0x14, 0x9C, 0x4A, 0x2F, 0x80, 0x76, 0x61, 0x08, 0x4B, 0x80, 0x74, 0x63,
  0x19, 0x4B, 0x80, 0x3D, 0x04, 0x1E, 0x41, 0x0F, 0x80, 0x3D, 0x04, 0x1E,
  0x41, 0x08, 0x00, 0x74, 0x61, 0x69, 0x4B, 0xC0, 0x45, 0x14, 0x5E, 0x4A,
  0x28, 0x80, 0x3D, 0x41, 0x04, 0x20, 0x8F, 0x80, 0x78, 0x84, 0x21, 0x4B,
  0x80, 0x45, 0x25, 0x1C, 0x51, 0x28, 0x80, 0x44, 0x88, 0x88, 0xF0, 0x65,
  0xB7, 0x56, 0xAA, 0x28, 0x80, 0x65, 0x96, 0x56, 0x5A, 0x69, 0x80, 0x74,
  0x63, 0x19, 0x4B, 0x80, 0x39, 0x14, 0x5E, 0x41, 0x08, 0x00, 0x74, 0x63,
  0x19, 0x4B, 0x86, 0x30, 0x39, 0x14, 0x5E, 0x51, 0x48, 0x80, 0x39, 0x14,
  0x0E, 0x0A, 0x27, 0x00, 0xF9, 0x08, 0x44, 0x21, 0x00, 0x8C, 0x65, 0x29,
  0x4B, 0x80, 0x8C, 0x65, 0x2A, 0x31, 0x00, 0x45, 0x15, 0x6D, 0xBB, 0x6D,
  0x80, 0x44, 0xA3, 0x04, 0x31, 0x28, 0x80, 0x8E, 0x46, 0x18, 0x41, 0x04,
  0x00, 0x7C, 0x20, 0x84, 0x21, 0x0F, 0x80, 0x74, 0x88, 0x88, 0x88, 0xC0,
  0xAA, 0x95, 0x40, 0x35, 0x11, 0x12, 0x22, 0xE0, 0x22, 0xA5, 0x10, 0xF8,
  0xB0, 0x79, 0x99, 0xF0, 0xC8, 0xBD, 0x99, 0xE0, 0x79, 0x89, 0xE0, 0x08,
  0x5D, 0x29, 0x4B, 0xC0, 0x79, 0xE9, 0xE0, 0x0C, 0x47, 0xC4, 0x10, 0x8A,
  0x28, 0x60, 0x3A, 0x63, 0x17, 0xC9, 0xC0, 0x48, 0xBD, 0x99, 0x90, 0x20,
  0xE4, 0x45, 0x60, 0x10, 0x72, 0x22, 0xAA, 0x60, 0x44, 0x2D, 0xAF, 0x66,
  0xC0, 0xE4, 0x44, 0x57, 0x60, 0x6D, 0x5A, 0xAA, 0xA8, 0xBD, 0x99, 0x90,
  0x79, 0x99, 0xE0, 0x5B, 0x52, 0x9B, 0x42, 0x00, 0x79, 0x99, 0xF1, 0x20,
  0xDB, 0x10, 0x84, 0x00, 0x3A, 0x0E, 0x1F, 0x00, 0x44, 0xF4, 0x47, 0x60,
  0x99, 0x99, 0xF0, 0xD9, 0x9B, 0xE0, 0x56, 0x5A, 0x6A, 0x58, 0x2F, 0x52,
  0x2B, 0xD0, 0x4A, 0x52, 0x97, 0xC9, 0xC0, 0xEC, 0x89, 0xAF, 0x00, 0x39,
  0x08, 0x4C, 0x11, 0x08, 0x60, 0x55, 0xAA, 0x80, 0x30, 0x84, 0x41, 0x90,
  0x84, 0xE0, 0x66, 0x60,
};

const GFXglyph IBMPlexMono_Italic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 3, 3, 6, 2, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 6, 9, 6, 0, -8 },
  { 18, 7, 7, 6, 0, -7 },
  { 25, 6, 7, 6, 0, -7 },
  { 31, 1, 3, 6, 3, -7 },
  { 32, 4, 9, 6, 2, -8 },
  { 37, 4, 9, 6, 0, -8 },
  { 42, 5, 5, 6, 1, -5 },
  { 46, 4, 5, 6, 1, -6 },
  { 49, 3, 2, 6, 1, -1 },
  { 50, 3, 1, 6, 2, -4 },
  { 51, 1, 1, 6, 2, -1 },
  { 52, 6, 9, 6, 0, -8 },
  { 59, 5, 7, 6, 1, -7 },
  { 64, 5, 7, 6, 0, -7 },
  { 69, 6, 7, 6, 0, -7 },
  { 75, 6, 7, 6, 0, -7 },
  { 81, 6, 7, 6, 0, -7 },
  { 87, 6, 7, 6, 0, -7 },
  { 93, 4, 7, 6, 1, -7 },
  { 97, 5, 7, 6, 1, -7 },
  { 102, 6, 7, 6, 0, -7 },
  { 108, 5, 7, 6, 1, -7 },
  { 113, 2, 5, 6, 2, -5 },
  { 115, 3, 6, 6, 1, -5 },
  { 118, 5, 6, 6, 1, -6 },
  { 122, 5, 3, 6, 1, -5 },
  { 124, 5, 6, 6, 0, -6 },
  { 128, 5, 7, 6, 1, -7 },
  { 133, 5, 8, 6, 1, -7 },
  { 138, 5, 7, 6, 0, -7 },
  { 143, 6, 7, 6, 0, -7 },
  { 149, 5, 7, 6, 1, -7 },
  { 154, 5, 7, 6, 1, -7 },
  { 159, 6, 7, 6, 0, -7 },
  { 165, 6, 7, 6, 0, -7 },
  { 171, 5, 7, 6, 1, -7 },
  { 176, 6, 7, 6, 0, -7 },
  { 182, 6, 7, 6, 0, -7 },
  { 188, 5, 7, 6, 1, -7 },
  { 193, 6, 7, 6, 0, -7 },
  { 199, 4, 7, 6, 1, -7 },
  { 203, 6, 7, 6, 0, -7 },
  { 209, 6, 7, 6, 0, -7 },
  { 215, 5, 7, 6, 1, -7 },
  { 220, 6, 7, 6, 0, -7 },
  { 226, 5, 9, 6, 1, -7 },
  { 232, 6, 7, 6, 0, -7 },
  { 238, 6, 7, 6, 0, -7 },
  { 244, 5, 7, 6, 1, -7 },
  { 249, 5, 7, 6, 1, -7 },
  { 254, 5, 7, 6, 1, -7 },
  { 259, 6, 7, 6, 0, -7 },
  { 265, 6, 7, 6, 0, -7 },
  { 271, 6, 7, 6, 1, -7 },
  { 277, 6, 7, 6, 0, -7 },
  { 283, 4, 9, 6, 2, -8 },
  { 288, 2, 9, 6, 2, -8 },
  { 291, 4, 9, 6, 0, -8 },
  { 296, 5, 4, 6, 1, -7 },
  { 299, 5, 1, 6, 0, 1 },
  { 300, 2, 2, 6, 2, -8 },
  { 301, 4, 5, 6, 1, -5 },
  { 304, 4, 7, 6, 1, -7 },
  { 308, 4, 5, 6, 1, -5 },
  { 311, 5, 7, 6, 1, -7 },
  { 316, 4, 5, 6, 1, -5 },
  { 319, 6, 9, 6, 0, -7 },
  { 326, 5, 7, 6, 0, -5 },
  { 331, 4, 7, 6, 1, -7 },
  { 335, 4, 7, 6, 1, -7 },
  { 339, 4, 9, 6, 1, -7 },
  { 344, 5, 7, 6, 1, -7 },
  { 349, 4, 7, 6, 1, -7 },
  { 353, 6, 5, 6, 0, -5 },
  { 357, 4, 5, 6, 1, -5 },
  { 360, 4, 5, 6, 1, -5 },
  { 363, 5, 7, 6, 0, -5 },
  { 368, 4, 7, 6, 1, -5 },
  { 372, 5, 5, 6, 1, -5 },
  { 376, 5, 5, 6, 0, -5 },
  { 380, 4, 7, 6, 1, -7 },
  { 384, 4, 5, 6, 1, -5 },
  { 387, 4, 5, 6, 1, -5 },
  { 390, 6, 5, 6, 0, -5 },
  { 394, 6, 5, 6, 0, -5 },
  { 398, 5, 7, 6, 0, -5 },
  { 403, 5, 5, 6, 1, -5 },
  { 407, 5, 9, 6, 1, -8 },
  { 413, 2, 9, 6, 2, -8 },
  { 416, 5, 9, 6, 0, -8 },
  { 422, 6, 2, 6, 0, -4 },
};

const GFXfont IBMPlexMono_Italic10pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic10pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _IBMPLEXMONO_ITALIC10PT7B_H_
