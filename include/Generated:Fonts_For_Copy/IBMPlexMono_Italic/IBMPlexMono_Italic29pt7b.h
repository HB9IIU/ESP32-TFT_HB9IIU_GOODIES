#ifndef _IBMPLEXMONO_ITALIC29PT7B_H_
#define _IBMPLEXMONO_ITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC6, 0x18, 0x61, 0x8E, 0x30, 0xC3, 0x08, 0x20, 0x00,
  0x00, 0xF3, 0xCF, 0x38, 0x73, 0xB1, 0x98, 0xCC, 0x66, 0x33, 0x1B, 0x9D,
  0x8C, 0x00, 0x63, 0x00, 0x30, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x01, 0x86,
  0x00, 0x63, 0x01, 0xF8, 0xFC, 0xFC, 0x3F, 0x03, 0x18, 0x00, 0xC6, 0x00,
  0x61, 0x80, 0x18, 0xC0, 0x7E, 0x3F, 0x3F, 0x0F, 0xC0, 0xC6, 0x00, 0x31,
  0x80, 0x18, 0x60, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xC7, 0x00, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x03, 0xF8, 0x0F, 0xFC, 0x1C, 0xCE, 0x38, 0xC7,
  0x38, 0xC4, 0x30, 0xC0, 0x38, 0xC0, 0x38, 0x80, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xBC, 0x01, 0x0C, 0x01, 0x0C, 0x03, 0x0C, 0x43, 0x0C,
  0xE3, 0x1C, 0xF3, 0x38, 0x7F, 0xF0, 0x1F, 0xC0, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0xC0, 0x30, 0xFE, 0x06, 0x0C, 0x60, 0xC1, 0x83, 0x1C,
  0x18, 0x31, 0x81, 0x87, 0x30, 0x18, 0x67, 0x01, 0x8E, 0x60, 0x1F, 0xCC,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x33, 0xF8, 0x03, 0x31, 0x80, 0x66,
  0x08, 0x0C, 0x61, 0xC1, 0xC6, 0x18, 0x18, 0x61, 0x83, 0x06, 0x38, 0x60,
  0x7F, 0x0E, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xC7, 0x01, 0xC1,
  0x80, 0xE0, 0xC0, 0x70, 0x60, 0x38, 0x30, 0x0C, 0x38, 0x07, 0x18, 0x0F,
  0xF8, 0x0E, 0xF0, 0x0C, 0x30, 0x0E, 0x1C, 0x07, 0x06, 0x03, 0x03, 0x85,
  0x81, 0xC3, 0xE0, 0xB3, 0x30, 0xDB, 0x9F, 0xCF, 0x83, 0xC3, 0x80, 0x6D,
  0xFD, 0xB6, 0x00, 0xE0, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x38,
  0x1C, 0x00, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x83, 0x07, 0xCC,
  0x77, 0xFF, 0xC7, 0xF8, 0x07, 0x00, 0x36, 0x01, 0xDC, 0x0E, 0x30, 0x70,
  0xE1, 0x81, 0x80, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x1E, 0x78, 0xE1, 0xC7, 0x0C, 0x18, 0x60, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x70,
  0x71, 0xC0, 0x63, 0x00, 0xCE, 0x01, 0x98, 0x03, 0xB0, 0x07, 0xE0, 0x0D,
  0xC7, 0x1B, 0x1E, 0x36, 0x38, 0xEC, 0x01, 0xD8, 0x03, 0x30, 0x06, 0x60,
  0x1C, 0xE0, 0x70, 0xE1, 0xC1, 0xFF, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F,
  0xC0, 0x76, 0x03, 0x98, 0x1C, 0x60, 0xE1, 0x81, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x1F, 0xF8,
  0x78, 0x70, 0xE0, 0x73, 0x80, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x03, 0xFF, 0xF7, 0xFF, 0xC0, 0x03, 0xF0,
  0x0F, 0xF8, 0x78, 0x78, 0xC0, 0x70, 0x80, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x1C, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x20, 0x0C, 0xC0, 0x39, 0xE0, 0xE1, 0xFF, 0x80, 0xFC, 0x00,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x76, 0x00, 0xEE, 0x00, 0xCC,
  0x01, 0x8C, 0x03, 0x0C, 0x07, 0x0C, 0x0E, 0x0C, 0x0C, 0x1C, 0x18, 0x18,
  0x30, 0x18, 0x60, 0x18, 0x7F, 0xFF, 0x7F, 0xFF, 0x80, 0x38, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x0F, 0xFF, 0x0F, 0xFE, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x19, 0xF0, 0x1F, 0xF8, 0x3C, 0x3C,
  0x30, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x20, 0x1C,
  0x60, 0x38, 0xF0, 0x78, 0x3F, 0xE0, 0x0F, 0x80, 0x00, 0x78, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0xF8, 0x6F, 0xF1,
  0xE0, 0xEF, 0x01, 0xB8, 0x06, 0xC0, 0x1F, 0x00, 0x6C, 0x01, 0xB0, 0x0E,
  0xE0, 0x31, 0xC3, 0xC7, 0xFC, 0x07, 0xC0, 0x7F, 0xFD, 0xFF, 0xF6, 0x01,
  0xF8, 0x06, 0xC0, 0x3B, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0E, 0x0E,
  0x1C, 0x06, 0x18, 0x07, 0x38, 0x06, 0x18, 0x0E, 0x1C, 0x1C, 0x0F, 0xF0,
  0x0F, 0xF0, 0x38, 0x18, 0x70, 0x0C, 0x60, 0x0C, 0xE0, 0x0E, 0xE0, 0x0C,
  0xE0, 0x0C, 0xE0, 0x1C, 0x70, 0x78, 0x3F, 0xF0, 0x1F, 0xC0, 0x07, 0xC0,
  0xFF, 0x9E, 0x1C, 0xC0, 0x7E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x03, 0xF8, 0x3C, 0xFF, 0x63, 0xE6, 0x00, 0x70, 0x07, 0x00, 0x30,
  0x07, 0x00, 0x70, 0x07, 0x01, 0xF0, 0x00, 0x38, 0xF7, 0xCE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF3, 0xCF, 0x38, 0x0E, 0x0F, 0x1F, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x38, 0x38, 0x70,
  0x60, 0x60, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x3C, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x20, 0x3F, 0xFE, 0x7F,
  0xFD, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x7F, 0xFE,
  0x10, 0x00, 0x60, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x78,
  0x07, 0x80, 0x18, 0x00, 0x80, 0x00, 0x0F, 0x83, 0xFE, 0x70, 0xFE, 0x07,
  0xC0, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0xFC, 0x1F, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x07, 0xE0, 0x3F, 0xE1, 0xC1, 0xCE, 0x03, 0x30, 0x0D, 0xC0, 0x36, 0x1E,
  0xD8, 0xFF, 0x67, 0x1F, 0x98, 0x3C, 0x60, 0xF3, 0x86, 0xCC, 0x1B, 0x30,
  0x6C, 0xE3, 0xB1, 0xF6, 0xC7, 0xB3, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x03, 0x60, 0x06,
  0xC0, 0x19, 0x80, 0x33, 0x00, 0xC6, 0x01, 0x8E, 0x07, 0x1C, 0x0C, 0x18,
  0x38, 0x30, 0x60, 0x61, 0xFF, 0xC3, 0xFF, 0x8E, 0x03, 0x98, 0x07, 0x70,
  0x0E, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x30, 0x0F, 0xF8, 0x3F, 0xF8, 0x70,
  0x38, 0xC0, 0x31, 0x80, 0x63, 0x00, 0xC6, 0x03, 0x9C, 0x06, 0x38, 0x1C,
  0x7F, 0xE0, 0xFF, 0xE1, 0x80, 0xE3, 0x00, 0xCE, 0x01, 0x9C, 0x03, 0x30,
  0x06, 0x60, 0x1C, 0xC0, 0x71, 0xFF, 0xC7, 0xFF, 0x00, 0x01, 0xF0, 0x0F,
  0xF0, 0x38, 0x70, 0xE0, 0x73, 0x80, 0x66, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x06, 0x70, 0x0C, 0x60, 0x38, 0xE0, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x1F,
  0xE0, 0x7F, 0xC1, 0x83, 0x8E, 0x07, 0x38, 0x0C, 0xC0, 0x33, 0x00, 0xCC,
  0x03, 0x30, 0x0D, 0xC0, 0x37, 0x00, 0xD8, 0x07, 0x60, 0x1D, 0x80, 0x66,
  0x01, 0xB8, 0x0E, 0xE0, 0x73, 0x03, 0x8F, 0xFC, 0x3F, 0xC0, 0x0F, 0xFF,
  0x1F, 0xFF, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x30, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x7F, 0xF8,
  0xFF, 0xF8, 0x0F, 0xFF, 0x1F, 0xFF, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3F, 0xFC, 0x3F, 0xFC,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x78, 0x71,
  0xC0, 0x63, 0x00, 0xEE, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x87, 0xF6, 0x0F, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x0E, 0x70, 0x1C,
  0xE0, 0x78, 0xE1, 0xE1, 0xFE, 0xC0, 0xF1, 0x80, 0x1C, 0x03, 0x1C, 0x03,
  0x1C, 0x07, 0x18, 0x07, 0x18, 0x06, 0x18, 0x06, 0x38, 0x06, 0x38, 0x06,
  0x30, 0x0E, 0x3F, 0xFE, 0x3F, 0xFC, 0x30, 0x0C, 0x70, 0x0C, 0x70, 0x0C,
  0x60, 0x1C, 0x60, 0x1C, 0x60, 0x18, 0x60, 0x18, 0xE0, 0x18, 0xE0, 0x38,
  0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x30, 0x18, 0xC0, 0xE3, 0x87, 0x07,
  0xFC, 0x07, 0xC0, 0x0C, 0x03, 0xC7, 0x01, 0xC1, 0xC0, 0xE0, 0x60, 0x70,
  0x18, 0x38, 0x06, 0x1C, 0x01, 0x8E, 0x00, 0xE7, 0x00, 0x3B, 0x80, 0x0D,
  0xF0, 0x03, 0xEC, 0x00, 0xF3, 0x00, 0x78, 0xE0, 0x1C, 0x18, 0x07, 0x07,
  0x01, 0x80, 0xC0, 0x60, 0x38, 0x18, 0x06, 0x0E, 0x01, 0xC3, 0x80, 0x30,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1C, 0x07, 0x8E,
  0x03, 0x87, 0x83, 0xC3, 0xC3, 0xE3, 0xE1, 0xB1, 0xB1, 0xB8, 0xCC, 0xD8,
  0x66, 0xCC, 0x33, 0x66, 0x19, 0xE3, 0x1C, 0x71, 0x8C, 0x31, 0xC6, 0x10,
  0xC3, 0x08, 0x61, 0x80, 0x31, 0xC0, 0x18, 0xE0, 0x0C, 0x60, 0x0E, 0x30,
  0x06, 0x18, 0x03, 0x00, 0x1E, 0x03, 0x1E, 0x03, 0x1F, 0x03, 0x1B, 0x07,
  0x1B, 0x06, 0x1B, 0x06, 0x3B, 0x06, 0x31, 0x86, 0x31, 0x86, 0x31, 0x8E,
  0x31, 0x8C, 0x31, 0xCC, 0x70, 0xCC, 0x60, 0xCC, 0x60, 0xDC, 0x60, 0xDC,
  0x60, 0x78, 0x60, 0x78, 0xE0, 0x78, 0xC0, 0x78, 0x03, 0xF0, 0x1F, 0xF0,
  0x70, 0x71, 0xC0, 0x63, 0x00, 0xCE, 0x01, 0x98, 0x03, 0xB0, 0x07, 0xE0,
  0x0D, 0xC0, 0x1B, 0x80, 0x36, 0x00, 0xEC, 0x01, 0xD8, 0x03, 0x30, 0x06,
  0x60, 0x1C, 0xE0, 0x70, 0xE1, 0xC1, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0xFC,
  0x1F, 0xFE, 0x1C, 0x07, 0x1C, 0x07, 0x18, 0x07, 0x18, 0x07, 0x18, 0x07,
  0x38, 0x06, 0x38, 0x0E, 0x3F, 0xFC, 0x3F, 0xF0, 0x30, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x70, 0x71, 0xC0, 0x63, 0x00, 0xCE,
  0x01, 0x98, 0x03, 0xB0, 0x07, 0xE0, 0x0D, 0xC0, 0x1B, 0x80, 0x36, 0x00,
  0xEC, 0x01, 0xD8, 0x03, 0x30, 0x06, 0x60, 0x1C, 0xE0, 0x70, 0xE1, 0xC1,
  0xFF, 0x00, 0xFC, 0x00, 0x70, 0x80, 0x63, 0x80, 0xEE, 0x00, 0xF8, 0x00,
  0xE0, 0x0F, 0xFC, 0x1F, 0xFE, 0x1C, 0x07, 0x1C, 0x07, 0x18, 0x07, 0x18,
  0x07, 0x18, 0x07, 0x38, 0x06, 0x38, 0x0E, 0x3F, 0xFC, 0x3F, 0xF0, 0x30,
  0xC0, 0x30, 0xC0, 0x70, 0xE0, 0x70, 0x60, 0x60, 0x70, 0x60, 0x30, 0x60,
  0x38, 0x60, 0x38, 0xE0, 0x1C, 0x03, 0xF0, 0x0F, 0xFC, 0x1E, 0x0E, 0x38,
  0x07, 0x38, 0x04, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x40,
  0x0C, 0xE0, 0x1C, 0xF0, 0x38, 0x3F, 0xF0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x06, 0x70, 0x0C, 0xC0, 0x39, 0x80, 0x73, 0x00, 0xC6, 0x01,
  0x9C, 0x03, 0x38, 0x0E, 0x60, 0x1C, 0xC0, 0x39, 0x80, 0x67, 0x00, 0xCE,
  0x01, 0x9C, 0x07, 0x30, 0x0E, 0x70, 0x18, 0xE0, 0x70, 0xE1, 0xC1, 0xFF,
  0x80, 0xFC, 0x00, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x33, 0x00, 0xE6, 0x01,
  0x8C, 0x07, 0x18, 0x0C, 0x30, 0x38, 0x70, 0x60, 0xE0, 0xC0, 0xC3, 0x81,
  0x86, 0x03, 0x1C, 0x06, 0x30, 0x0C, 0xE0, 0x19, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xE0, 0x00, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66,
  0x00, 0x73, 0x00, 0x31, 0x8E, 0x18, 0xC7, 0x0C, 0xE3, 0x8E, 0x63, 0x46,
  0x31, 0xA3, 0x19, 0x91, 0x8C, 0xCC, 0xC6, 0x66, 0xC3, 0x63, 0x61, 0xB1,
  0xB0, 0xD8, 0xD8, 0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x00,
  0x1C, 0x01, 0xE1, 0xC0, 0x30, 0x18, 0x0E, 0x03, 0x03, 0x80, 0x70, 0xE0,
  0x06, 0x38, 0x00, 0xE6, 0x00, 0x0D, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x37, 0x00, 0x0E, 0x60, 0x03, 0x8E, 0x00,
  0xE0, 0xC0, 0x38, 0x1C, 0x06, 0x01, 0x81, 0xC0, 0x38, 0x70, 0x03, 0x00,
  0xC0, 0x07, 0xE0, 0x0E, 0x60, 0x1C, 0x70, 0x18, 0x70, 0x38, 0x30, 0x70,
  0x38, 0x60, 0x18, 0xC0, 0x19, 0xC0, 0x1F, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xE3, 0xFF,
  0xF8, 0x0F, 0xF0, 0xFF, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xFF, 0x0F, 0xF0, 0xC0, 0x40, 0x60, 0x60, 0x60, 0x60, 0x30, 0x30,
  0x30, 0x30, 0x10, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x04,
  0x06, 0x06, 0x06, 0x06, 0x03, 0x03, 0x07, 0xF8, 0x7F, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x7F, 0x87, 0xF8,
  0x00, 0x01, 0xC0, 0x03, 0xC0, 0x0D, 0x80, 0x3B, 0x80, 0xE3, 0x01, 0x86,
  0x06, 0x06, 0x1C, 0x0C, 0x70, 0x1C, 0xC0, 0x1B, 0x00, 0x32, 0x00, 0x50,
  0xFF, 0xFF, 0xFF, 0xF0, 0x5B, 0x36, 0x40, 0x0F, 0x9C, 0x7F, 0x63, 0x87,
  0x9C, 0x0E, 0x60, 0x1B, 0x80, 0xEC, 0x03, 0xB0, 0x0C, 0xC0, 0x33, 0x00,
  0xCC, 0x07, 0x30, 0x3C, 0xE1, 0xF1, 0xFD, 0xF3, 0xC3, 0x80, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x1E, 0x0D, 0xFE,
  0x34, 0x38, 0xE0, 0x77, 0x01, 0xDC, 0x07, 0x60, 0x1D, 0x80, 0x76, 0x01,
  0xB8, 0x06, 0xE0, 0x3B, 0x80, 0xCF, 0x0F, 0x37, 0xF8, 0xCF, 0x80, 0x07,
  0xC0, 0xFF, 0x8E, 0x0E, 0x60, 0x37, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x06, 0x01, 0x38, 0x0E, 0xC0, 0xE7, 0x0E, 0x1F, 0xE0, 0x7C, 0x00,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x83,
  0xE3, 0x0F, 0xEE, 0x38, 0x3C, 0xE0, 0x31, 0x80, 0x67, 0x00, 0xCC, 0x01,
  0x98, 0x07, 0x30, 0x0E, 0x60, 0x18, 0xC0, 0x71, 0x81, 0x63, 0x87, 0xC3,
  0xFB, 0x83, 0xE6, 0x00, 0x03, 0xE0, 0x7F, 0xCF, 0x0E, 0x60, 0x36, 0x01,
  0xB0, 0x1F, 0x83, 0xDF, 0xFC, 0xFF, 0x07, 0x00, 0x38, 0x05, 0xC0, 0x77,
  0x07, 0x1F, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0xF0, 0x7F, 0xFC,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x08, 0x18, 0x01, 0x83, 0x00, 0x38, 0xE0, 0x03,
  0x9C, 0x00, 0x3B, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x07, 0xC6,
  0x1F, 0xDC, 0x70, 0x71, 0xC0, 0x63, 0x00, 0xCE, 0x01, 0x98, 0x03, 0x30,
  0x0E, 0x60, 0x18, 0xC0, 0x31, 0x80, 0xE3, 0x01, 0xC7, 0x0D, 0x87, 0xF7,
  0x07, 0xCC, 0x00, 0x18, 0x00, 0x30, 0x80, 0xE3, 0x83, 0x87, 0xFE, 0x03,
  0xF0, 0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xC7, 0x86, 0x7E, 0x34, 0x39, 0xC0, 0xDC, 0x06, 0xE0, 0x36, 0x01, 0xB0,
  0x1D, 0x80, 0xCC, 0x06, 0xE0, 0x37, 0x01, 0xB0, 0x0D, 0x80, 0xEC, 0x06,
  0x00, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x3F, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xE0, 0x83, 0x87, 0x0C, 0x38, 0x33, 0x80, 0xDC, 0x03, 0xE0,
  0x0F, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x84, 0x18,
  0x70, 0xC1, 0x86, 0x0E, 0x30, 0x3B, 0x80, 0xF8, 0x01, 0x80, 0x1C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x78, 0x19,
  0xF8, 0x34, 0x38, 0x70, 0x31, 0xC0, 0x63, 0x81, 0xC6, 0x07, 0x0C, 0x3C,
  0x1B, 0xC0, 0x33, 0x00, 0xE7, 0x0D, 0xC6, 0x3F, 0x0E, 0xE6, 0x0F, 0x8C,
  0x0E, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18,
  0x21, 0x87, 0x38, 0xE3, 0x9C, 0x33, 0x83, 0xF0, 0x1C, 0x00, 0x1B, 0x8F,
  0x1F, 0xDF, 0x3C, 0xD3, 0x38, 0xE3, 0x30, 0xC3, 0x30, 0xC3, 0x30, 0xC3,
  0x30, 0xC3, 0x70, 0xC3, 0x61, 0x86, 0x61, 0x86, 0x61, 0x86, 0x61, 0x86,
  0x61, 0x86, 0xE3, 0x8E, 0x31, 0xE1, 0x9F, 0x8D, 0x0E, 0x70, 0x37, 0x01,
  0xB8, 0x0D, 0x80, 0x6C, 0x07, 0x60, 0x33, 0x01, 0xB8, 0x0D, 0xC0, 0x6C,
  0x03, 0x60, 0x3B, 0x01, 0x80, 0x07, 0xC0, 0x7F, 0xC3, 0x83, 0x9C, 0x06,
  0x60, 0x1B, 0x80, 0x7E, 0x01, 0xF0, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x03,
  0xB8, 0x1C, 0x70, 0xE1, 0xFF, 0x01, 0xF0, 0x00, 0x18, 0xF0, 0x37, 0xF8,
  0x68, 0x71, 0xE0, 0x73, 0x80, 0xE7, 0x01, 0xCC, 0x03, 0x98, 0x07, 0x30,
  0x0C, 0xE0, 0x19, 0xC0, 0x73, 0x80, 0xC7, 0x87, 0x8D, 0xFE, 0x19, 0xF0,
  0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00,
  0x0F, 0x8C, 0x7F, 0x73, 0x83, 0x9C, 0x06, 0x60, 0x1B, 0x80, 0x6C, 0x01,
  0xB0, 0x0E, 0xC0, 0x33, 0x00, 0xCC, 0x07, 0x30, 0x2C, 0xE1, 0xF1, 0xFD,
  0xC3, 0xE6, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00,
  0xC0, 0xFE, 0x7F, 0xFB, 0xF0, 0xF8, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0xF1, 0xC1, 0xC6, 0x02, 0x38,
  0x00, 0x60, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x60, 0x01, 0x98,
  0x06, 0xF0, 0x38, 0xFF, 0xC1, 0xFC, 0x00, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x3F, 0xFF, 0xFF, 0xE0, 0xC0, 0x0E, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x63, 0x0F, 0x18, 0xF0, 0xDE,
  0x07, 0xE0, 0x3C, 0x00, 0x30, 0x1C, 0xC0, 0x73, 0x01, 0x9C, 0x06, 0x70,
  0x19, 0x80, 0x66, 0x03, 0x98, 0x0E, 0x60, 0x33, 0x80, 0xCE, 0x07, 0x38,
  0x3C, 0x71, 0xF1, 0xFD, 0xC3, 0xE6, 0x00, 0xFC, 0x1B, 0xE0, 0x61, 0x81,
  0xC6, 0x07, 0x18, 0x1C, 0x60, 0x73, 0x81, 0x8C, 0x06, 0x30, 0x38, 0xC0,
  0xC3, 0x07, 0x0C, 0x38, 0x73, 0xC0, 0xFE, 0x03, 0xE0, 0x00, 0x30, 0xC6,
  0x61, 0x8C, 0xC3, 0x19, 0x86, 0x36, 0x18, 0x6C, 0x30, 0xD8, 0x61, 0xB0,
  0xC3, 0x61, 0x86, 0xC7, 0x0F, 0x0C, 0x36, 0x18, 0x6E, 0x59, 0x9F, 0xBF,
  0x1E, 0x78, 0x00, 0x07, 0x0F, 0x07, 0xCF, 0xC7, 0x6C, 0x6E, 0x34, 0x32,
  0x0A, 0x18, 0x06, 0x0C, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x60, 0xE0,
  0x30, 0xF0, 0x98, 0x58, 0xEE, 0x6D, 0xE3, 0xE7, 0xC1, 0xE1, 0xC0, 0x18,
  0x0E, 0x30, 0x1C, 0x60, 0x30, 0xC0, 0x63, 0x80, 0xC6, 0x01, 0x8C, 0x07,
  0x18, 0x0E, 0x30, 0x18, 0x60, 0x31, 0xC0, 0xE1, 0x82, 0xC3, 0x8F, 0x87,
  0xF7, 0x07, 0xCC, 0x00, 0x18, 0x00, 0x71, 0x00, 0xC3, 0x83, 0x87, 0xFE,
  0x03, 0xF0, 0x00, 0x0F, 0xC6, 0x3F, 0xEC, 0xE1, 0xF9, 0x80, 0xE3, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x30, 0x70, 0x31,
  0xC0, 0x67, 0xFC, 0xCC, 0xFF, 0xB8, 0x3E, 0x00, 0x01, 0xFC, 0x0F, 0xF0,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0xFE, 0x03, 0xF8, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x0C, 0x30, 0xC3, 0x18, 0x61, 0x86,
  0x18, 0x63, 0x0C, 0x30, 0xC3, 0x0C, 0x61, 0x86, 0x18, 0x61, 0x8C, 0x30,
  0xC3, 0x00, 0x07, 0xE0, 0x3F, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0xFC, 0x07, 0xF0, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xFF, 0x03, 0xF8, 0x00,
  0x0E, 0x02, 0x3F, 0x07, 0x33, 0x86, 0x61, 0xCC, 0x60, 0xF8, 0xC0, 0x70,
};

const GFXglyph IBMPlexMono_Italic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 6, 20, 17, 6, -20 },
  { 16, 9, 8, 17, 6, -21 },
  { 25, 18, 20, 17, 0, -20 },
  { 70, 16, 26, 17, 1, -23 },
  { 122, 20, 20, 17, -1, -20 },
  { 172, 17, 20, 17, 0, -20 },
  { 215, 3, 8, 17, 9, -21 },
  { 218, 11, 26, 17, 6, -22 },
  { 254, 11, 26, 17, 1, -22 },
  { 290, 14, 14, 17, 2, -16 },
  { 315, 14, 14, 17, 2, -16 },
  { 340, 7, 8, 17, 4, -4 },
  { 347, 8, 2, 17, 5, -10 },
  { 349, 4, 4, 17, 6, -4 },
  { 351, 16, 26, 17, 1, -22 },
  { 403, 15, 20, 17, 2, -20 },
  { 441, 14, 20, 17, 1, -20 },
  { 476, 15, 20, 17, 1, -20 },
  { 514, 15, 20, 17, 1, -20 },
  { 552, 16, 20, 17, 0, -20 },
  { 592, 16, 20, 17, 1, -20 },
  { 632, 14, 20, 17, 2, -20 },
  { 667, 14, 20, 17, 3, -20 },
  { 702, 16, 20, 17, 1, -20 },
  { 742, 13, 20, 17, 3, -20 },
  { 775, 6, 16, 17, 6, -16 },
  { 787, 8, 20, 17, 4, -16 },
  { 807, 14, 17, 17, 3, -17 },
  { 837, 15, 8, 17, 1, -13 },
  { 852, 14, 17, 17, 1, -17 },
  { 882, 12, 20, 17, 4, -20 },
  { 912, 14, 23, 17, 2, -20 },
  { 953, 15, 20, 17, 0, -20 },
  { 991, 15, 20, 17, 1, -20 },
  { 1029, 15, 20, 17, 2, -20 },
  { 1067, 14, 20, 17, 2, -20 },
  { 1102, 16, 20, 17, 1, -20 },
  { 1142, 16, 20, 17, 1, -20 },
  { 1182, 15, 20, 17, 2, -20 },
  { 1220, 16, 20, 17, 1, -20 },
  { 1260, 16, 20, 17, 1, -20 },
  { 1300, 14, 20, 17, 2, -20 },
  { 1335, 18, 20, 17, 1, -20 },
  { 1380, 13, 20, 17, 2, -20 },
  { 1413, 17, 20, 17, 1, -20 },
  { 1456, 16, 20, 17, 1, -20 },
  { 1496, 15, 20, 17, 2, -20 },
  { 1534, 16, 20, 17, 1, -20 },
  { 1574, 15, 25, 17, 2, -20 },
  { 1621, 16, 20, 17, 1, -20 },
  { 1661, 16, 20, 17, 1, -20 },
  { 1701, 16, 20, 17, 3, -20 },
  { 1741, 15, 20, 17, 2, -20 },
  { 1779, 15, 20, 17, 3, -20 },
  { 1817, 17, 20, 17, 1, -20 },
  { 1860, 19, 20, 17, 0, -20 },
  { 1908, 16, 20, 17, 3, -20 },
  { 1948, 18, 20, 17, 0, -20 },
  { 1993, 12, 26, 17, 5, -22 },
  { 2032, 8, 26, 17, 5, -22 },
  { 2058, 13, 26, 17, 0, -22 },
  { 2101, 15, 12, 17, 2, -20 },
  { 2124, 14, 2, 17, 0, 3 },
  { 2128, 3, 6, 17, 7, -23 },
  { 2131, 14, 15, 17, 2, -15 },
  { 2158, 14, 21, 17, 2, -21 },
  { 2195, 13, 15, 17, 2, -15 },
  { 2220, 15, 21, 17, 2, -21 },
  { 2260, 13, 15, 17, 2, -15 },
  { 2285, 19, 27, 17, 0, -21 },
  { 2350, 15, 21, 17, 1, -15 },
  { 2390, 13, 21, 17, 2, -21 },
  { 2425, 14, 21, 17, 2, -21 },
  { 2462, 13, 27, 17, 2, -21 },
  { 2506, 15, 21, 17, 2, -21 },
  { 2546, 12, 21, 17, 3, -21 },
  { 2578, 16, 15, 17, 0, -15 },
  { 2608, 13, 15, 17, 2, -15 },
  { 2633, 14, 15, 17, 2, -15 },
  { 2660, 15, 21, 17, 1, -15 },
  { 2700, 14, 21, 17, 2, -15 },
  { 2737, 14, 15, 17, 3, -15 },
  { 2764, 14, 15, 17, 1, -15 },
  { 2791, 13, 20, 17, 2, -20 },
  { 2824, 14, 15, 17, 2, -15 },
  { 2851, 14, 15, 17, 2, -15 },
  { 2878, 15, 15, 17, 1, -15 },
  { 2907, 17, 15, 17, 0, -15 },
  { 2939, 15, 21, 17, 1, -15 },
  { 2979, 15, 15, 17, 1, -15 },
  { 3008, 14, 26, 17, 3, -22 },
  { 3054, 6, 26, 17, 6, -22 },
  { 3074, 14, 26, 17, 1, -22 },
  { 3120, 16, 6, 17, 1, -12 },
};

const GFXfont IBMPlexMono_Italic29pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic29pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _IBMPLEXMONO_ITALIC29PT7B_H_
