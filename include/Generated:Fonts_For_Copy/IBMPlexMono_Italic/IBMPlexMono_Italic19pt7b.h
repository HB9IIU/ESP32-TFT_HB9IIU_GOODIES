#ifndef _IBMPLEXMONO_ITALIC19PT7B_H_
#define _IBMPLEXMONO_ITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x22, 0x26, 0x44, 0x00, 0xCE, 0xC0, 0x4D, 0x2C, 0xB2, 0xD8,
  0x02, 0x60, 0x64, 0x04, 0xC0, 0x48, 0x3C, 0xF0, 0x98, 0x09, 0x01, 0x90,
  0xF3, 0xC1, 0x20, 0x32, 0x02, 0x60, 0x64, 0x00, 0x01, 0x00, 0x20, 0x3F,
  0x0D, 0x33, 0x24, 0x64, 0x0C, 0x80, 0xD0, 0x0F, 0x00, 0x98, 0x13, 0x02,
  0x24, 0x4D, 0xCB, 0x0F, 0xC0, 0x40, 0x08, 0x00, 0x1C, 0x12, 0x22, 0x62,
  0x64, 0x24, 0x64, 0x83, 0x98, 0x00, 0x01, 0x9C, 0x12, 0x62, 0x62, 0x64,
  0x64, 0x44, 0x83, 0x80, 0x0F, 0x03, 0x10, 0x42, 0x08, 0x41, 0x88, 0x33,
  0x0B, 0x82, 0x60, 0xC6, 0x18, 0xC3, 0x1C, 0xE2, 0xA7, 0x9C, 0xFE, 0x80,
  0x06, 0x10, 0x41, 0x06, 0x08, 0x10, 0x60, 0x81, 0x02, 0x04, 0x08, 0x18,
  0x10, 0x30, 0x30, 0x18, 0x10, 0x10, 0x20, 0x60, 0xC0, 0x83, 0x06, 0x08,
  0x10, 0x60, 0x83, 0x04, 0x10, 0xC0, 0x04, 0x01, 0x00, 0x43, 0x33, 0x7F,
  0x07, 0x01, 0x40, 0x98, 0x63, 0x00, 0x04, 0x02, 0x03, 0x01, 0x8F, 0xF8,
  0x40, 0x20, 0x10, 0x18, 0x00, 0x76, 0x6C, 0xC8, 0xFC, 0xDF, 0x00, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0x80, 0x20, 0x04, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x00, 0x0F,
  0x04, 0x22, 0x0D, 0x83, 0x40, 0xD3, 0x3C, 0xCF, 0x02, 0xC0, 0xB0, 0x6C,
  0x11, 0x0C, 0x3C, 0x00, 0x0E, 0x0D, 0x0D, 0x88, 0xC0, 0x60, 0x20, 0x10,
  0x08, 0x0C, 0x06, 0x03, 0x01, 0x0F, 0xF8, 0x1F, 0x18, 0xD8, 0x20, 0x10,
  0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x0F, 0xF8, 0x0F, 0x86,
  0x31, 0x04, 0x01, 0x00, 0xC0, 0x20, 0xF0, 0x06, 0x00, 0xC0, 0x34, 0x0B,
  0x86, 0x3E, 0x00, 0x00, 0xC0, 0x38, 0x0F, 0x03, 0x40, 0xC8, 0x31, 0x0C,
  0x61, 0x0C, 0x41, 0x9F, 0xFC, 0x04, 0x00, 0x80, 0x30, 0x1F, 0xCC, 0x02,
  0x00, 0x80, 0x20, 0x1B, 0xC7, 0x18, 0x06, 0x01, 0x80, 0x68, 0x1B, 0x0C,
  0x7C, 0x00, 0x03, 0x86, 0x06, 0x06, 0x02, 0x03, 0x79, 0xC7, 0x83, 0xC0,
  0xE0, 0xF0, 0x68, 0x63, 0xC0, 0x7F, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x30,
  0x30, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x0E, 0x00, 0x0F, 0x0C, 0x22, 0x0D,
  0x83, 0x60, 0x88, 0x61, 0xE1, 0x86, 0xC0, 0xA0, 0x28, 0x1B, 0x0C, 0x7E,
  0x00, 0x3E, 0x31, 0xB0, 0x50, 0x38, 0x1C, 0x0B, 0x0C, 0xFE, 0x06, 0x02,
  0x03, 0x06, 0x0E, 0x00, 0x77, 0x60, 0x00, 0x00, 0xCE, 0xC0, 0x39, 0xCC,
  0x00, 0x00, 0x00, 0x73, 0x19, 0x8C, 0x40, 0x00, 0x81, 0xC3, 0x87, 0x0E,
  0x04, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x80, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x20, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x0C, 0x0C, 0x18,
  0x38, 0x70, 0x20, 0x00, 0x3E, 0x31, 0x90, 0x70, 0x30, 0x30, 0x38, 0x70,
  0x20, 0x10, 0x10, 0x0C, 0x0E, 0x07, 0x00, 0x0F, 0x0C, 0x22, 0x0D, 0x83,
  0x47, 0xD2, 0x2D, 0x8B, 0x62, 0xD0, 0xA6, 0x68, 0xFA, 0x00, 0xC0, 0x18,
  0x03, 0xE0, 0x03, 0x01, 0xC0, 0x58, 0x36, 0x09, 0x86, 0x61, 0x88, 0xC2,
  0x3F, 0x88, 0x36, 0x0D, 0x03, 0xC0, 0xC0, 0x3F, 0x08, 0x22, 0x0D, 0x83,
  0x60, 0x98, 0x67, 0xE1, 0x06, 0x41, 0xB0, 0x6C, 0x1B, 0x0C, 0xFE, 0x00,
  0x0F, 0x86, 0x33, 0x0D, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x10,
  0x44, 0x19, 0x8C, 0x3E, 0x00, 0x3F, 0x0C, 0x62, 0x08, 0x83, 0x60, 0xD8,
  0x36, 0x0D, 0x82, 0x40, 0x90, 0x6C, 0x13, 0x0C, 0xFC, 0x00, 0x3F, 0xC8,
  0x02, 0x00, 0x80, 0x60, 0x18, 0x07, 0xF9, 0x00, 0x40, 0x30, 0x0C, 0x03,
  0x00, 0xFF, 0x00, 0x3F, 0xC8, 0x02, 0x00, 0x80, 0x60, 0x18, 0x07, 0xF9,
  0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x0F, 0x84, 0x22, 0x0D,
  0x80, 0x40, 0x10, 0x0C, 0x03, 0x1E, 0xC1, 0xB0, 0x6C, 0x19, 0x8C, 0x3D,
  0x00, 0x30, 0x48, 0x32, 0x0D, 0x83, 0x60, 0x98, 0x27, 0xF9, 0x06, 0x41,
  0xB0, 0x6C, 0x13, 0x04, 0x83, 0x00, 0x3F, 0xC1, 0x80, 0x40, 0x10, 0x04,
  0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0xFF, 0x00, 0x1F,
  0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xCC,
  0x33, 0x18, 0x7C, 0x00, 0x30, 0x64, 0x18, 0x86, 0x31, 0x86, 0x60, 0xD8,
  0x17, 0x03, 0xB0, 0x66, 0x18, 0x43, 0x0C, 0x60, 0x88, 0x18, 0x10, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0F,
  0xF8, 0x18, 0x73, 0x86, 0x38, 0xA3, 0x9E, 0x2D, 0x62, 0x76, 0x26, 0x46,
  0x44, 0x64, 0x46, 0x0C, 0x40, 0xC4, 0x0C, 0xC0, 0x80, 0x30, 0x4E, 0x13,
  0x8D, 0xA3, 0x68, 0x92, 0x24, 0xC9, 0x12, 0x45, 0xB1, 0x6C, 0x72, 0x1C,
  0x83, 0x00, 0x0F, 0x0C, 0x22, 0x0D, 0x83, 0x40, 0xD0, 0x3C, 0x0F, 0x02,
  0xC0, 0xB0, 0x6C, 0x11, 0x0C, 0x3C, 0x00, 0x3F, 0x88, 0x32, 0x0C, 0x83,
  0x60, 0xD8, 0x27, 0xF1, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00,
  0x0F, 0x0C, 0x22, 0x0D, 0x83, 0x40, 0xD0, 0x3C, 0x0F, 0x02, 0xC0, 0xB0,
  0x6C, 0x11, 0x0C, 0x3C, 0x02, 0x20, 0xD8, 0x1C, 0x3F, 0x88, 0x32, 0x0C,
  0x83, 0x60, 0xD8, 0x27, 0xF1, 0x10, 0x46, 0x30, 0x8C, 0x33, 0x0C, 0xC1,
  0x80, 0x0F, 0xC3, 0x0C, 0xC1, 0x18, 0x03, 0x00, 0x30, 0x03, 0xC0, 0x0E,
  0x00, 0xC0, 0x09, 0x03, 0x70, 0xC3, 0xF0, 0xFF, 0xC3, 0x00, 0x80, 0x20,
  0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x00,
  0x20, 0x48, 0x36, 0x0D, 0x83, 0x60, 0x98, 0x24, 0x09, 0x06, 0xC1, 0xB0,
  0x6C, 0x11, 0x0C, 0x3E, 0x00, 0xC0, 0xF0, 0x2C, 0x19, 0x04, 0x43, 0x10,
  0x84, 0x61, 0x98, 0x64, 0x1B, 0x06, 0x80, 0xE0, 0x30, 0x00, 0x40, 0x28,
  0x0D, 0x01, 0x26, 0x24, 0xC4, 0x99, 0xB7, 0xA6, 0xB4, 0xD6, 0x9C, 0xF2,
  0x9C, 0x71, 0x8C, 0x30, 0x30, 0x31, 0x86, 0x18, 0xC0, 0x88, 0x0D, 0x80,
  0x70, 0x06, 0x00, 0xE0, 0x1B, 0x01, 0x10, 0x31, 0x86, 0x08, 0xC0, 0xC0,
  0xC0, 0xF0, 0x64, 0x11, 0x8C, 0x26, 0x0F, 0x01, 0x80, 0x60, 0x10, 0x04,
  0x01, 0x00, 0xC0, 0x30, 0x00, 0x1F, 0xF2, 0x06, 0x00, 0xC0, 0x18, 0x01,
  0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xFF,
  0xC0, 0x1F, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40,
  0x40, 0x40, 0x40, 0xC0, 0xC0, 0xF8, 0xC2, 0x10, 0x86, 0x10, 0x84, 0x30,
  0x84, 0x21, 0x0C, 0x21, 0x08, 0x1F, 0x01, 0x01, 0x03, 0x03, 0x02, 0x02,
  0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0xFC, 0x06, 0x03,
  0xC0, 0x90, 0x44, 0x31, 0x98, 0x24, 0x0E, 0x02, 0xFF, 0x80, 0x59, 0x10,
  0x1E, 0x90, 0xD0, 0x78, 0x3C, 0x1E, 0x0B, 0x05, 0x86, 0xC7, 0x3C, 0xC0,
  0x30, 0x18, 0x08, 0x04, 0x02, 0xF3, 0x8D, 0x82, 0xC1, 0x40, 0xA0, 0x50,
  0x78, 0x2E, 0x36, 0xF0, 0x1F, 0x18, 0xD8, 0x48, 0x04, 0x06, 0x03, 0x00,
  0x83, 0x63, 0x1E, 0x00, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x1E, 0x88, 0xA4,
  0x1B, 0x06, 0xC1, 0xB0, 0x6C, 0x13, 0x0C, 0xC5, 0x1E, 0xC0, 0x1F, 0x18,
  0xD8, 0x28, 0x34, 0x37, 0xE3, 0x00, 0x83, 0x63, 0x1F, 0x00, 0x01, 0xF0,
  0x10, 0x03, 0x00, 0x30, 0x3F, 0xF0, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x8C, 0x04, 0xC0, 0x28, 0x01,
  0x80, 0x1E, 0x91, 0x50, 0x68, 0x3C, 0x1E, 0x0B, 0x05, 0x86, 0x45, 0x3D,
  0x80, 0xC0, 0x48, 0x67, 0xC0, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x71, 0xCD,
  0x86, 0xC3, 0x61, 0xA0, 0xD0, 0x48, 0x2C, 0x16, 0x18, 0x0C, 0x1C, 0x00,
  0x00, 0xF8, 0x18, 0x10, 0x10, 0x30, 0x30, 0x33, 0x26, 0x2C, 0x38, 0x01,
  0x80, 0xC0, 0x00, 0x03, 0xF0, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80,
  0xC0, 0x60, 0x23, 0x10, 0xC8, 0x34, 0x0C, 0x00, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x2F, 0x0C, 0x66, 0x19, 0x86, 0x63, 0x13, 0x05, 0x81, 0x33, 0xC5,
  0xB1, 0x80, 0xF8, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20,
  0x23, 0x66, 0x68, 0x30, 0x2C, 0xC6, 0xED, 0x99, 0xB3, 0x34, 0x44, 0x88,
  0x91, 0x12, 0x22, 0xCC, 0xD9, 0x98, 0x27, 0x1C, 0xD8, 0x6C, 0x36, 0x1A,
  0x0D, 0x04, 0x82, 0xC1, 0x61, 0x80, 0x1E, 0x18, 0xD8, 0x28, 0x1C, 0x0E,
  0x0F, 0x07, 0x82, 0x43, 0x1E, 0x00, 0x17, 0x8E, 0x33, 0x04, 0xC1, 0x20,
  0x48, 0x12, 0x0D, 0x82, 0x71, 0x9B, 0xC4, 0x01, 0x00, 0x40, 0x30, 0x00,
  0x1E, 0x91, 0x50, 0x78, 0x3C, 0x1E, 0x0B, 0x05, 0x86, 0xC5, 0x3D, 0x80,
  0xC0, 0x60, 0x20, 0x10, 0xFB, 0x8E, 0x06, 0x06, 0x03, 0x01, 0x80, 0x80,
  0x40, 0x20, 0x30, 0x00, 0x1F, 0x10, 0xD8, 0x0C, 0x03, 0xC0, 0x38, 0x05,
  0x02, 0xC3, 0x1F, 0x00, 0x0C, 0x04, 0x02, 0x0F, 0xF9, 0x80, 0xC0, 0x40,
  0x20, 0x10, 0x18, 0x4C, 0xC6, 0xC3, 0x80, 0x41, 0xC1, 0xC3, 0xC3, 0x83,
  0x82, 0x82, 0x8E, 0xCE, 0x76, 0xF1, 0x98, 0x4C, 0x24, 0x12, 0x09, 0x0C,
  0x84, 0xC6, 0x66, 0x1C, 0x00, 0x44, 0x91, 0x34, 0x4F, 0x33, 0xCC, 0xF2,
  0x38, 0x8A, 0x22, 0x99, 0x3B, 0x80, 0x1C, 0xEE, 0xA5, 0x18, 0x83, 0x00,
  0x60, 0x08, 0x01, 0x06, 0x62, 0xD6, 0xCE, 0x60, 0x20, 0xB0, 0x58, 0x6C,
  0x34, 0x1A, 0x09, 0x04, 0x8E, 0x67, 0x1D, 0x80, 0xC0, 0x48, 0x67, 0xC0,
  0x3C, 0xD8, 0xE4, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x11, 0x86, 0xF8, 0xB3,
  0xC0, 0x0F, 0x84, 0x02, 0x01, 0x00, 0x80, 0x60, 0x10, 0x18, 0xF0, 0x04,
  0x02, 0x03, 0x03, 0x01, 0x00, 0x80, 0x40, 0x7C, 0x00, 0x13, 0x32, 0x22,
  0x26, 0x64, 0x44, 0x4C, 0xC8, 0x80, 0x1E, 0x11, 0x00, 0x80, 0x40, 0x40,
  0x40, 0x20, 0x30, 0x07, 0x8C, 0x04, 0x02, 0x01, 0x80, 0x40, 0x20, 0x10,
  0xF0, 0x00, 0x30, 0xD2, 0x2C, 0xCA, 0x1C,
};

const GFXglyph IBMPlexMono_Italic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 13, 11, 4, -13 },
  { 8, 6, 5, 11, 4, -14 },
  { 12, 12, 13, 11, 0, -13 },
  { 32, 11, 17, 11, 0, -15 },
  { 56, 12, 13, 11, 0, -13 },
  { 76, 11, 13, 11, 0, -13 },
  { 94, 2, 5, 11, 6, -14 },
  { 96, 7, 17, 11, 4, -14 },
  { 111, 7, 17, 11, 1, -14 },
  { 126, 10, 9, 11, 1, -10 },
  { 138, 9, 9, 11, 1, -10 },
  { 149, 4, 6, 11, 3, -3 },
  { 152, 6, 1, 11, 3, -6 },
  { 153, 3, 3, 11, 4, -3 },
  { 155, 11, 17, 11, 0, -14 },
  { 179, 10, 13, 11, 1, -13 },
  { 196, 9, 13, 11, 1, -13 },
  { 211, 9, 13, 11, 1, -13 },
  { 226, 10, 13, 11, 0, -13 },
  { 243, 11, 13, 11, 0, -13 },
  { 261, 10, 13, 11, 1, -13 },
  { 278, 9, 13, 11, 1, -13 },
  { 293, 9, 13, 11, 2, -13 },
  { 308, 10, 13, 11, 1, -13 },
  { 325, 9, 13, 11, 2, -13 },
  { 340, 4, 11, 11, 4, -11 },
  { 346, 5, 14, 11, 3, -11 },
  { 355, 9, 11, 11, 2, -11 },
  { 368, 10, 5, 11, 1, -8 },
  { 375, 9, 11, 11, 1, -11 },
  { 388, 9, 13, 11, 2, -13 },
  { 403, 10, 15, 11, 1, -13 },
  { 422, 10, 13, 11, 0, -13 },
  { 439, 10, 13, 11, 1, -13 },
  { 456, 10, 13, 11, 1, -13 },
  { 473, 10, 13, 11, 1, -13 },
  { 490, 10, 13, 11, 1, -13 },
  { 507, 10, 13, 11, 1, -13 },
  { 524, 10, 13, 11, 1, -13 },
  { 541, 10, 13, 11, 1, -13 },
  { 558, 10, 13, 11, 1, -13 },
  { 575, 10, 13, 11, 1, -13 },
  { 592, 11, 13, 11, 1, -13 },
  { 610, 9, 13, 11, 1, -13 },
  { 625, 12, 13, 11, 0, -13 },
  { 645, 10, 13, 11, 1, -13 },
  { 662, 10, 13, 11, 1, -13 },
  { 679, 10, 13, 11, 1, -13 },
  { 696, 10, 16, 11, 1, -13 },
  { 716, 10, 13, 11, 1, -13 },
  { 733, 11, 13, 11, 0, -13 },
  { 751, 10, 13, 11, 2, -13 },
  { 768, 10, 13, 11, 1, -13 },
  { 785, 10, 13, 11, 2, -13 },
  { 802, 11, 13, 11, 1, -13 },
  { 820, 12, 13, 11, 0, -13 },
  { 840, 10, 13, 11, 2, -13 },
  { 857, 12, 13, 11, 0, -13 },
  { 877, 8, 17, 11, 3, -14 },
  { 894, 5, 17, 11, 3, -14 },
  { 905, 8, 17, 11, 0, -14 },
  { 922, 10, 8, 11, 1, -13 },
  { 932, 9, 1, 11, 0, 2 },
  { 934, 3, 4, 11, 4, -15 },
  { 936, 9, 10, 11, 1, -10 },
  { 948, 9, 14, 11, 1, -14 },
  { 964, 9, 10, 11, 1, -10 },
  { 976, 10, 14, 11, 1, -14 },
  { 994, 9, 10, 11, 1, -10 },
  { 1006, 12, 18, 11, 0, -14 },
  { 1033, 9, 14, 11, 1, -10 },
  { 1049, 9, 14, 11, 1, -14 },
  { 1065, 8, 14, 11, 2, -14 },
  { 1079, 9, 18, 11, 1, -14 },
  { 1100, 10, 14, 11, 1, -14 },
  { 1118, 8, 14, 11, 2, -14 },
  { 1132, 11, 10, 11, 0, -10 },
  { 1146, 9, 10, 11, 1, -10 },
  { 1158, 9, 10, 11, 1, -10 },
  { 1170, 10, 14, 11, 0, -10 },
  { 1188, 9, 14, 11, 1, -10 },
  { 1204, 9, 10, 11, 2, -10 },
  { 1216, 9, 10, 11, 1, -10 },
  { 1228, 9, 13, 11, 1, -13 },
  { 1243, 8, 10, 11, 2, -10 },
  { 1253, 9, 10, 11, 1, -10 },
  { 1265, 10, 10, 11, 1, -10 },
  { 1278, 11, 10, 11, 0, -10 },
  { 1292, 9, 14, 11, 1, -10 },
  { 1308, 10, 10, 11, 1, -10 },
  { 1321, 9, 17, 11, 2, -14 },
  { 1341, 4, 17, 11, 4, -14 },
  { 1350, 9, 17, 11, 1, -14 },
  { 1370, 10, 4, 11, 1, -8 },
};

const GFXfont IBMPlexMono_Italic19pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic19pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _IBMPLEXMONO_ITALIC19PT7B_H_
