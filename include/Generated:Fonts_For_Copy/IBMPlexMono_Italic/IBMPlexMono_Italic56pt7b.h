#ifndef _IBMPLEXMONO_ITALIC56PT7B_H_
#define _IBMPLEXMONO_ITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07,
  0xC0, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1F, 0x7C,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0xF8,
  0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3E, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xFE, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1F, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x81, 0xE0, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07,
  0xFF, 0x80, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x79,
  0xFC, 0x03, 0xF8, 0x78, 0x7E, 0x03, 0xE0, 0x70, 0x3F, 0x07, 0xE0, 0x70,
  0x1C, 0x07, 0xC0, 0x70, 0x08, 0x07, 0xC0, 0x70, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07, 0xC0, 0xE0,
  0x00, 0x07, 0xC0, 0xE0, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x03, 0xF0, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xC7, 0xF0, 0x00, 0x03, 0xC3, 0xF0, 0x00, 0x03, 0x81,
  0xF8, 0x00, 0x03, 0x80, 0xF8, 0x00, 0x03, 0x80, 0xF8, 0x00, 0x03, 0x80,
  0xF8, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x07, 0x80, 0xF8, 0x10, 0x07, 0x00,
  0xF8, 0x38, 0x07, 0x01, 0xF0, 0x78, 0x07, 0x01, 0xF0, 0xFE, 0x07, 0x03,
  0xE0, 0x7F, 0x0F, 0x0F, 0xE0, 0x3F, 0xCF, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x0F,
  0xFF, 0x00, 0x07, 0x80, 0x7F, 0xFE, 0x00, 0x3C, 0x03, 0xF0, 0xF8, 0x01,
  0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0x7C, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x0F, 0x80, 0x1E, 0x00, 0xF0, 0x3C,
  0x00, 0x70, 0x07, 0x81, 0xE0, 0x01, 0xC0, 0x1E, 0x0F, 0x00, 0x07, 0x00,
  0x78, 0x3C, 0x00, 0x1C, 0x03, 0xE1, 0xE0, 0x00, 0x78, 0x0F, 0x0F, 0x00,
  0x01, 0xF0, 0xFC, 0x3C, 0x00, 0x07, 0xFF, 0xE1, 0xE0, 0x00, 0x0F, 0xFF,
  0x0F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0x87, 0xFF, 0x80, 0x00, 0x3E, 0x1F, 0xFF, 0x00,
  0x00, 0xF0, 0xF8, 0x3C, 0x00, 0x07, 0x87, 0xC0, 0x78, 0x00, 0x3C, 0x1E,
  0x01, 0xE0, 0x00, 0xF0, 0xF0, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x1E, 0x00,
  0x3C, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0xF0,
  0x07, 0x80, 0x3C, 0x03, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x07, 0x80, 0x3C, 0x00, 0xF8, 0x3E, 0x01, 0xE0, 0x01, 0xFF,
  0xF0, 0x07, 0x80, 0x07, 0xFF, 0x80, 0x3C, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x03,
  0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3C,
  0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x3C,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x0F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x19,
  0xF0, 0x00, 0xF8, 0x0F, 0xF8, 0x00, 0xFC, 0x0F, 0x7C, 0x00, 0x7F, 0x07,
  0x9E, 0x00, 0x67, 0x87, 0x8F, 0x80, 0x73, 0xE7, 0xC7, 0xE0, 0x79, 0xF3,
  0xC1, 0xFF, 0xF8, 0x7F, 0xE0, 0x7F, 0xF8, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F,
  0xE0, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0xF3, 0xCF, 0x7D, 0xE7, 0x9E,
  0x79, 0xEF, 0xBC, 0xF3, 0xCF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x78, 0x07, 0x7F, 0x07, 0x83, 0xFF, 0xFE, 0x7B, 0xFF, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1F,
  0x3E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0xF8, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xC0, 0x0C,
  0x00, 0x38, 0x00, 0x80, 0x02, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xE0, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xC0, 0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0,
  0xF8, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xFB,
  0xE0, 0x3C, 0x07, 0xDF, 0x03, 0xF0, 0x3E, 0xF8, 0x3F, 0x81, 0xF7, 0xC1,
  0xFC, 0x0F, 0x3E, 0x0F, 0xE0, 0xF9, 0xE0, 0x7F, 0x07, 0xCF, 0x01, 0xF0,
  0x3E, 0x78, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0xF8, 0x00,
  0x3F, 0x1F, 0x00, 0x1F, 0xC3, 0xC0, 0x07, 0xF0, 0x78, 0x01, 0xFC, 0x0F,
  0x00, 0x7F, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x70, 0x0F, 0x80, 0x08,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xF8, 0x01,
  0xF8, 0x1F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8,
  0x3C, 0x00, 0x07, 0xC0, 0x40, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x07,
  0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x1F, 0x00, 0x40,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x18, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x1E,
  0x00, 0xF8, 0x00, 0x78, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0xFE, 0x00, 0x0F, 0x1F, 0xFC, 0x00, 0x7B, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x02, 0x00, 0x01,
  0xF0, 0x78, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x3F, 0x80, 0x0F, 0xC0,
  0xFF, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x3F, 0x80,
  0x1F, 0x1F, 0xFE, 0x03, 0xE7, 0xFF, 0xE0, 0xFB, 0xFF, 0xFE, 0x1F, 0xF8,
  0x1F, 0xE3, 0xD8, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x9E,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x78,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x7C, 0x78, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0xF8, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xC0, 0x03,
  0xE0, 0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x78,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x00,
  0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x03, 0xE3, 0xF0, 0x00, 0x7C, 0xF8,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xFD, 0xF8, 0x01, 0xFE, 0x7F, 0x01, 0xEF, 0x8F, 0xFF, 0xF3, 0xC1,
  0xFF, 0xF9, 0xF0, 0x3F, 0xFC, 0xF8, 0x03, 0xFC, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xE0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF1, 0xFE, 0x0F, 0xE0, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x20, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x1F, 0xC0, 0xFE, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x10, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x3E,
  0x03, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0xF0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x71, 0xE0, 0x0F, 0x87, 0x1E, 0x03, 0xFC,
  0xF1, 0xE0, 0x7F, 0xEF, 0x3E, 0x0F, 0xFE, 0xF3, 0xC0, 0xF8, 0x3F, 0x3C,
  0x1F, 0x01, 0xF3, 0xC1, 0xE0, 0x1F, 0x3C, 0x3E, 0x01, 0xE7, 0xC3, 0xC0,
  0x1E, 0x78, 0x3C, 0x01, 0xE7, 0x83, 0xC0, 0x1E, 0x78, 0x7C, 0x01, 0xE7,
  0x87, 0xC0, 0x1E, 0x78, 0x78, 0x01, 0xC7, 0x87, 0x80, 0x3C, 0xF0, 0x78,
  0x03, 0xCF, 0x07, 0x80, 0x3C, 0xF0, 0x78, 0x07, 0xCF, 0x07, 0x80, 0xFC,
  0xF0, 0x7C, 0x1B, 0xCF, 0x03, 0xF3, 0xF8, 0xF0, 0x3F, 0xF7, 0x8F, 0x01,
  0xFE, 0x78, 0xF0, 0x0F, 0xC7, 0x8F, 0x00, 0x38, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0xF9, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0xC7, 0x80, 0x00,
  0x0F, 0x0F, 0x80, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xE0,
  0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3E,
  0x0F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x07, 0xBF,
  0x00, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0,
  0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x7C,
  0x1F, 0x00, 0x1F, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3E, 0x3C,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x7C, 0x78, 0x00, 0x0F, 0x8F,
  0x80, 0x01, 0xF8, 0xF8, 0x00, 0x7F, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xC0, 0xFE, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xF8,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x01, 0x01, 0xE0, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xFC,
  0x0F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3C, 0x01, 0xFC, 0x01, 0xE0, 0x03, 0xF0,
  0x0F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F,
  0x0F, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x7C, 0x3E,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x78, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x7C, 0x1E,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00,
  0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x1E, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xE0,
  0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x0C, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x03, 0xFF,
  0xCF, 0x80, 0x7F, 0xFC, 0xF8, 0x07, 0xFF, 0xCF, 0x80, 0x7F, 0xFC, 0xF8,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x0F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00,
  0x6F, 0x07, 0xE0, 0x0F, 0xF0, 0x3F, 0x03, 0xDE, 0x03, 0xFF, 0xF9, 0xE0,
  0x1F, 0xFF, 0x1E, 0x00, 0xFF, 0xE1, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0xF8, 0x1F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF8, 0x1F, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x38, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x07, 0xC0,
  0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x07, 0xE0, 0x1E, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x3C, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x0F,
  0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0x07, 0x80, 0xFC, 0x00, 0x01, 0xE0, 0x7E, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x03,
  0xE7, 0xF0, 0x00, 0x00, 0xF3, 0xFC, 0x00, 0x00, 0x3D, 0xFF, 0x80, 0x00,
  0x1F, 0xFB, 0xE0, 0x00, 0x07, 0xFC, 0x7C, 0x00, 0x01, 0xFE, 0x1F, 0x00,
  0x00, 0x7F, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x03, 0xE0, 0x07,
  0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F,
  0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xFC, 0x07,
  0xB8, 0x03, 0xFE, 0x03, 0xDE, 0x03, 0xDE, 0x03, 0xEF, 0x01, 0xEF, 0x01,
  0xE7, 0x81, 0xE7, 0x80, 0xF1, 0xC1, 0xF3, 0xC0, 0x78, 0xF0, 0xF1, 0xE0,
  0x3C, 0x78, 0xF1, 0xF0, 0x1E, 0x3C, 0x78, 0xF0, 0x1F, 0x1E, 0x78, 0x78,
  0x0F, 0x07, 0xFC, 0x3C, 0x07, 0x83, 0xFC, 0x1E, 0x03, 0xC1, 0xFC, 0x0F,
  0x01, 0xE0, 0xFE, 0x0F, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF8, 0x1F, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xF0, 0x1E, 0x01, 0x80,
  0x78, 0x0F, 0x00, 0x80, 0x7C, 0x07, 0x80, 0x40, 0x3C, 0x07, 0xC0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3E, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x01,
  0xFC, 0x00, 0x1E, 0x07, 0xF8, 0x00, 0x3C, 0x0F, 0xF0, 0x00, 0xF8, 0x1F,
  0xE0, 0x01, 0xF0, 0x3F, 0xC0, 0x03, 0xC0, 0x7B, 0xC0, 0x07, 0x80, 0xF7,
  0x80, 0x0F, 0x03, 0xEF, 0x00, 0x1E, 0x07, 0xDE, 0x00, 0x7C, 0x0F, 0x3E,
  0x00, 0xF8, 0x1E, 0x3C, 0x01, 0xE0, 0x3C, 0x78, 0x03, 0xC0, 0x78, 0xF0,
  0x07, 0x81, 0xF1, 0xE0, 0x0F, 0x03, 0xE1, 0xE0, 0x3E, 0x07, 0x83, 0xC0,
  0x7C, 0x0F, 0x07, 0x80, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0x3C, 0x1F, 0x03,
  0xC0, 0xF8, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x1F, 0x03, 0xC0, 0x78, 0x3E,
  0x07, 0x80, 0xF0, 0x78, 0x0F, 0x01, 0xF0, 0xF0, 0x1E, 0x01, 0xE1, 0xE0,
  0x7C, 0x03, 0xC3, 0xC0, 0xF8, 0x07, 0x8F, 0x81, 0xE0, 0x0F, 0x1F, 0x03,
  0xC0, 0x0F, 0x3C, 0x07, 0x80, 0x1E, 0x78, 0x0F, 0x00, 0x3C, 0xF0, 0x3E,
  0x00, 0x79, 0xE0, 0x7C, 0x00, 0xFF, 0xC0, 0xF0, 0x00, 0xFF, 0x81, 0xE0,
  0x01, 0xFE, 0x03, 0xC0, 0x03, 0xFC, 0x07, 0x80, 0x07, 0xF8, 0x1F, 0x00,
  0x07, 0xF0, 0x3E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xC0,
  0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x3E,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3E, 0x78, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x3E, 0x3C, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1F, 0x0F,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x03, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x7C, 0x1E, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x81, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0xF8, 0x01,
  0xF0, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF0,
  0x7C, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x0F, 0x8F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x0F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E,
  0x3C, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x06, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x03, 0xF8,
  0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x3F,
  0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x1F, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x1E, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF8,
  0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x1C, 0x07, 0xC0, 0x00, 0x08, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x10, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0,
  0xFE, 0x00, 0x03, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3E, 0x1F,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3C, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x3E, 0x07,
  0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0x00, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x80,
  0x07, 0x80, 0x3E, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x01,
  0xE0, 0x1E, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x01, 0xF8,
  0x0F, 0x07, 0x80, 0xFC, 0x07, 0x83, 0xC0, 0xFE, 0x07, 0xC1, 0xE0, 0x7F,
  0x03, 0xC0, 0xF0, 0x3F, 0x81, 0xE0, 0x78, 0x3F, 0xC0, 0xF0, 0x3C, 0x1E,
  0xE0, 0x78, 0x3C, 0x0E, 0x70, 0x78, 0x1E, 0x0F, 0x38, 0x3C, 0x0F, 0x07,
  0x9C, 0x1E, 0x07, 0x87, 0x8E, 0x0F, 0x03, 0xC3, 0xC7, 0x0F, 0x01, 0xE1,
  0xC3, 0x87, 0x80, 0xF1, 0xE1, 0xC3, 0xC0, 0x78, 0xF0, 0xE1, 0xE0, 0x3C,
  0x70, 0x71, 0xE0, 0x1E, 0x78, 0x38, 0xF0, 0x0F, 0x3C, 0x1E, 0x78, 0x0F,
  0x3C, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0xBC, 0x03, 0xCE, 0x03, 0xDE, 0x01,
  0xEF, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0xF7, 0x80, 0x7B, 0x80, 0x7B, 0x80,
  0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x00, 0xFC, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0x7C, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x3F, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0xFC, 0x7C, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x03, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xF7,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0x78, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x78, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x78, 0x0F, 0x80, 0x07,
  0x81, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3E, 0x7C,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x0E, 0x20, 0x00, 0x00, 0x80, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x11, 0xE3, 0xE3, 0xC7, 0x87,
  0x8F, 0x1E, 0x1C, 0x3C, 0x20, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFC, 0x3C,
  0x07, 0xFF, 0xC7, 0x83, 0xFF, 0xFD, 0xF0, 0x7F, 0x03, 0xBE, 0x1F, 0x80,
  0x1F, 0x87, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x7C, 0xF8,
  0x00, 0x0F, 0x9F, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x07,
  0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0xC7, 0xC0,
  0x03, 0xF0, 0x7C, 0x00, 0xDE, 0x0F, 0x80, 0x3B, 0xC1, 0xFC, 0x1E, 0x7F,
  0x9F, 0xFF, 0x8F, 0xF1, 0xFF, 0xE1, 0xFE, 0x1F, 0xF8, 0x0F, 0x80, 0xFC,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0xFE, 0x00, 0x78, 0x7F, 0xF0, 0x0F, 0x1F,
  0xFF, 0x03, 0xE7, 0xFF, 0xF0, 0x7D, 0xE0, 0x7E, 0x0F, 0x70, 0x07, 0xE1,
  0xEC, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF1, 0xF8, 0x00,
  0x1E, 0x3E, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1E,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E,
  0x3F, 0x00, 0x0F, 0x87, 0xF0, 0x03, 0xF0, 0xF7, 0x01, 0xFC, 0x3E, 0xFF,
  0xFF, 0x07, 0xCF, 0xFF, 0xC0, 0xF0, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3E, 0x00,
  0x0E, 0x3E, 0x00, 0x04, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x47, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x7C,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x0F, 0xE0, 0xFE,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0xFF,
  0xE1, 0xF0, 0x07, 0xFF, 0xC7, 0x80, 0x3F, 0xFF, 0x9E, 0x01, 0xFC, 0x0F,
  0x78, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0,
  0x1F, 0x00, 0x1F, 0xC0, 0x7C, 0x01, 0xDF, 0x01, 0xFC, 0x1E, 0x78, 0x03,
  0xFF, 0xF9, 0xE0, 0x07, 0xFF, 0xC7, 0x80, 0x0F, 0xFC, 0x1E, 0x00, 0x0F,
  0xE0, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0x83, 0xF0, 0x03, 0xE1, 0xF0,
  0x00, 0x7C, 0x78, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x7E, 0x78, 0x00, 0x7F, 0x1E, 0x03, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x01, 0x8F, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x3F,
  0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x1F, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x30, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3F, 0x00,
  0xF0, 0x00, 0x00, 0xFC, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0x87, 0xC0, 0x3F, 0xFE,
  0x3C, 0x03, 0xFF, 0xF9, 0xE0, 0x3F, 0x81, 0xEF, 0x03, 0xF0, 0x03, 0xF8,
  0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0x78, 0x7C, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x3E, 0x1E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x78,
  0x7C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x5E, 0x07, 0xC0, 0x06, 0xF0, 0x3F, 0x00, 0x6F, 0x81, 0xFC, 0x0F, 0x7C,
  0x07, 0xFF, 0xF3, 0xC0, 0x1F, 0xFF, 0x1E, 0x00, 0x7F, 0xF0, 0xF0, 0x00,
  0xFE, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x40, 0x00, 0xF8,
  0x07, 0x00, 0x0F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x07, 0xE0, 0x07, 0xC7, 0xFE, 0x01, 0xE3, 0xFF, 0xC0, 0x79, 0xFF, 0xF8,
  0x1E, 0xF0, 0x7E, 0x0F, 0xB0, 0x0F, 0xC3, 0xF8, 0x01, 0xF0, 0xF4, 0x00,
  0x7C, 0x3F, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xF0,
  0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xE1,
  0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xE3, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00,
  0x03, 0xC7, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x1E,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x08, 0x03, 0xE0, 0x0E, 0x01, 0xF0, 0x0F, 0x80, 0xF0, 0x0F, 0xC0,
  0x78, 0x0F, 0xC0, 0x3C, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x1F, 0x1F, 0x80,
  0x0F, 0x1F, 0x80, 0x07, 0x9F, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0xFC, 0x07, 0x80, 0x0F, 0xC0, 0xF0, 0x00, 0xFC, 0x1E,
  0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xDE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x83, 0xF8, 0x00, 0x78, 0x7F, 0xE0,
  0x03, 0xC7, 0xFF, 0x80, 0x1E, 0x7F, 0xFE, 0x00, 0xF7, 0x83, 0xF8, 0x0F,
  0xB0, 0x07, 0xC0, 0x7F, 0x00, 0x3E, 0x03, 0xD0, 0x00, 0xF0, 0x1F, 0x80,
  0x07, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1E,
  0x03, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x3F, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x7E, 0x00, 0x3C, 0x1F, 0xC0, 0x03, 0xE3, 0xF8, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x07, 0x83, 0xC0, 0x04, 0x3C, 0x1F, 0x00,
  0x71, 0xE0, 0x78, 0x07, 0xDF, 0x03, 0xE0, 0x7C, 0xF8, 0x0F, 0x07, 0xC7,
  0x80, 0x7C, 0x7C, 0x3C, 0x01, 0xE7, 0xC1, 0xE0, 0x0F, 0xFC, 0x0F, 0x00,
  0x7F, 0xC0, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x80, 0xF8, 0x01,
  0x81, 0xE0, 0x0F, 0x83, 0xC0, 0x3F, 0x07, 0x80, 0xFC, 0x1F, 0x03, 0xF0,
  0x3E, 0x0F, 0xC0, 0x78, 0x7E, 0x00, 0xF1, 0xF8, 0x01, 0xE7, 0xE0, 0x03,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x81, 0xF0, 0x1F, 0x3F, 0x87, 0xF8, 0x3C, 0xFF, 0x1F, 0xF0, 0x7B,
  0xFF, 0x7F, 0xF0, 0xF6, 0x3E, 0xC3, 0xE1, 0xF0, 0x3F, 0x07, 0xC3, 0xE0,
  0x7C, 0x07, 0x8F, 0x80, 0xF8, 0x0F, 0x1F, 0x01, 0xE0, 0x1E, 0x3C, 0x03,
  0xC0, 0x78, 0x78, 0x07, 0x80, 0xF0, 0xF0, 0x1F, 0x01, 0xE1, 0xE0, 0x3C,
  0x03, 0xC7, 0x80, 0x78, 0x07, 0x8F, 0x00, 0xF0, 0x0F, 0x1E, 0x01, 0xE0,
  0x3C, 0x3C, 0x03, 0xC0, 0x78, 0x78, 0x0F, 0x80, 0xF0, 0xF0, 0x1E, 0x01,
  0xE3, 0xC0, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0x07, 0x8F, 0x00, 0xF0, 0x1E,
  0x1E, 0x01, 0xE0, 0x3C, 0x3C, 0x07, 0xC0, 0x78, 0x78, 0x0F, 0x00, 0xF1,
  0xE0, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0x0F, 0x0F,
  0x00, 0xF0, 0x1E, 0x1E, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x01,
  0xE1, 0xFF, 0x80, 0x78, 0xFF, 0xF0, 0x1E, 0x7F, 0xFE, 0x07, 0xBC, 0x1F,
  0x83, 0xEC, 0x03, 0xF0, 0xFE, 0x00, 0x7C, 0x3D, 0x00, 0x1F, 0x0F, 0xC0,
  0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x1F, 0x1F,
  0x00, 0x07, 0xC7, 0x80, 0x01, 0xF1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E,
  0x1E, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF0, 0x00,
  0x3E, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xF0,
  0x00, 0x3C, 0x7C, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xE1,
  0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xE0, 0x3F, 0x03, 0xE0, 0x07, 0xE1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x1E,
  0x3E, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3D, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xCF, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x03, 0xF0,
  0x3F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0x0F, 0xFE, 0x00, 0x78,
  0xFF, 0xF8, 0x07, 0xCF, 0xFF, 0xE0, 0x3E, 0xF0, 0x3F, 0x01, 0xEE, 0x00,
  0xFC, 0x0F, 0x60, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x78,
  0x3F, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x78,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x01, 0xE1, 0xF0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E,
  0x1E, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xC0, 0xFE, 0x00,
  0x7E, 0x0F, 0xB8, 0x0F, 0xE0, 0x7D, 0xFF, 0xFE, 0x03, 0xE7, 0xFF, 0xE0,
  0x1E, 0x1F, 0xFE, 0x00, 0xF0, 0x3F, 0x80, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xFE, 0x1F, 0x01, 0xFF, 0xF1, 0xE0, 0x3F, 0xFF, 0x9E, 0x07, 0xF0,
  0x3D, 0xE0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0x3E,
  0x3E, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x03, 0xC7, 0xC0,
  0x00, 0x3C, 0x7C, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x7C, 0x78, 0x00, 0x07,
  0x8F, 0x80, 0x00, 0x78, 0xF8, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x78, 0xF8,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x02, 0xF0, 0x7C, 0x00, 0x7F, 0x07,
  0xC0, 0x1D, 0xF0, 0x7F, 0x07, 0x9E, 0x03, 0xFF, 0xF9, 0xE0, 0x1F, 0xFF,
  0x1E, 0x00, 0xFF, 0xE3, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xF8, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x0F, 0x3C,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x7F, 0x01, 0xFE, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x00, 0x60, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE1, 0x80, 0x00, 0x7C, 0x78, 0x00, 0x0F, 0x1F, 0x80,
  0x03, 0xE1, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x03, 0x00, 0xF8, 0x03, 0xE0, 0x3C, 0x01, 0xF8,
  0x0F, 0x01, 0xFC, 0x03, 0xC0, 0xFE, 0x01, 0xF0, 0xFE, 0x00, 0x7C, 0x7F,
  0x00, 0x1F, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xCF,
  0x80, 0x01, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xE0, 0x00, 0x7C,
  0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x0F,
  0x9F, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xE7, 0x80, 0x01, 0xE3, 0xC0, 0x00,
  0xF3, 0xE0, 0x00, 0x79, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x78, 0x00,
  0x1F, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0xC7, 0x80,
  0x07, 0xE3, 0xC0, 0x07, 0xF1, 0xF0, 0x06, 0xF8, 0xF8, 0x07, 0x78, 0x7F,
  0x07, 0x3C, 0x1F, 0xFF, 0x9E, 0x0F, 0xFF, 0x9F, 0x01, 0xFF, 0x0F, 0x80,
  0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xBF, 0xF8, 0x03, 0xEF, 0xFC, 0x00,
  0x7B, 0xFF, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0xC0, 0xF0, 0x00, 0xF0, 0x7C,
  0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x01,
  0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x83, 0xC0,
  0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x07,
  0x80, 0x3F, 0x01, 0xE0, 0x1F, 0x80, 0x78, 0x1F, 0xC0, 0x1E, 0x3F, 0xE0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0xE0, 0x10, 0x3C, 0x07, 0x81, 0xE0, 0xF0, 0x1E,
  0x07, 0x87, 0x80, 0x78, 0x1E, 0x1E, 0x01, 0xE0, 0x78, 0x78, 0x07, 0x80,
  0xF1, 0xE0, 0x1C, 0x03, 0xC7, 0x80, 0xF0, 0x0F, 0x1E, 0x03, 0xC0, 0x3C,
  0xF0, 0x0F, 0x00, 0xF3, 0xC0, 0x3C, 0x03, 0xCF, 0x00, 0xF0, 0x0F, 0x3C,
  0x07, 0x80, 0x3C, 0xF0, 0x1E, 0x01, 0xE3, 0xC0, 0x78, 0x07, 0x8E, 0x01,
  0xE0, 0x1E, 0x78, 0x07, 0x80, 0x79, 0xE0, 0x1E, 0x01, 0xE7, 0x80, 0xF0,
  0x0F, 0x9E, 0x03, 0xC0, 0x3C, 0x78, 0x0F, 0x00, 0xF1, 0xE0, 0x3C, 0x07,
  0xCF, 0x81, 0xF0, 0x1E, 0x3E, 0x07, 0xC0, 0xF8, 0xF8, 0x37, 0x07, 0xC3,
  0xE1, 0xDE, 0x3F, 0x07, 0xFE, 0x7F, 0xF8, 0x1F, 0xF9, 0xFF, 0xC0, 0x3F,
  0xC3, 0xFE, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x1F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xF0,
  0x7F, 0x3C, 0xF8, 0xF8, 0x7F, 0x1E, 0x70, 0x3C, 0x7E, 0x0F, 0x38, 0x1E,
  0x7C, 0x03, 0xB8, 0x0F, 0x0C, 0x01, 0xD8, 0x07, 0x80, 0x00, 0xEC, 0x03,
  0xC0, 0x00, 0x7E, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x7E, 0x00, 0x07, 0xC0, 0x3F,
  0x00, 0x43, 0xE0, 0x3F, 0x80, 0x71, 0xF0, 0x1B, 0xC0, 0x7C, 0xF8, 0x1D,
  0xE0, 0xFC, 0x7C, 0x1E, 0x70, 0xFC, 0x1F, 0x1E, 0x3D, 0xFC, 0x0F, 0xFE,
  0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F,
  0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0, 0xF8,
  0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x7C, 0x1F,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0xF8, 0x1E, 0x00, 0x1F, 0x81, 0xF0, 0x03, 0xF8, 0x1F, 0x00, 0x3F, 0x81,
  0xF0, 0x0E, 0xF8, 0x1F, 0xC1, 0xCF, 0x00, 0xFF, 0xFC, 0xF0, 0x07, 0xFF,
  0x8F, 0x00, 0x3F, 0xF1, 0xF0, 0x01, 0xFC, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x20, 0x00, 0x7C, 0x07, 0x00, 0x0F, 0x80, 0xFC, 0x07, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x0F, 0x07, 0xFF,
  0xE0, 0xF0, 0xFF, 0xFF, 0x9F, 0x0F, 0x83, 0xFF, 0xF1, 0xF0, 0x07, 0xFE,
  0x1E, 0x00, 0x1F, 0xC1, 0xE0, 0x00, 0xF8, 0x1C, 0x00, 0x1F, 0x01, 0xC0,
  0x03, 0xE0, 0x1C, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x03, 0x00, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x07, 0x80, 0x7C, 0x00, 0x78, 0x0F, 0x80, 0x03, 0xC1,
  0xF0, 0x00, 0x3C, 0x3F, 0xE0, 0x03, 0xC7, 0xFF, 0xF0, 0x3C, 0xFB, 0xFF,
  0xF3, 0xCF, 0x87, 0xFF, 0xFC, 0xF8, 0x0F, 0xFF, 0xCF, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x60, 0x3F, 0xC0, 0x03, 0xC3, 0xFF, 0x00, 0x3C, 0x3F,
  0xFC, 0x01, 0xE3, 0xE3, 0xF0, 0x0F, 0x1E, 0x0F, 0x80, 0xF1, 0xE0, 0x3E,
  0x0F, 0x8F, 0x00, 0xF8, 0xF8, 0xF0, 0x03, 0xFF, 0x87, 0x80, 0x1F, 0xF8,
  0x3C, 0x00, 0x7F, 0x80, 0xC0, 0x00, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_Italic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 12, 40, 34, 11, -39 },
  { 61, 16, 15, 34, 12, -41 },
  { 91, 34, 39, 34, 1, -39 },
  { 257, 32, 53, 34, 1, -46 },
  { 469, 38, 41, 34, -1, -40 },
  { 664, 33, 41, 34, 0, -40 },
  { 834, 6, 15, 34, 17, -41 },
  { 846, 20, 51, 34, 12, -43 },
  { 974, 21, 51, 34, 2, -43 },
  { 1108, 28, 28, 34, 3, -31 },
  { 1206, 27, 28, 34, 4, -31 },
  { 1301, 12, 16, 34, 8, -8 },
  { 1325, 17, 4, 34, 9, -19 },
  { 1334, 8, 8, 34, 11, -7 },
  { 1342, 32, 51, 34, 1, -43 },
  { 1546, 29, 41, 34, 3, -40 },
  { 1695, 27, 39, 34, 2, -39 },
  { 1827, 29, 40, 34, 2, -40 },
  { 1972, 30, 41, 34, 1, -40 },
  { 2126, 30, 39, 34, 1, -39 },
  { 2273, 29, 40, 34, 3, -39 },
  { 2418, 27, 40, 34, 3, -39 },
  { 2553, 28, 39, 34, 6, -39 },
  { 2690, 30, 41, 34, 2, -40 },
  { 2844, 26, 40, 34, 5, -40 },
  { 2974, 12, 30, 34, 11, -29 },
  { 3019, 15, 37, 34, 8, -29 },
  { 3089, 27, 32, 34, 5, -33 },
  { 3197, 29, 15, 34, 3, -25 },
  { 3252, 27, 32, 34, 3, -33 },
  { 3360, 24, 41, 34, 7, -40 },
  { 3483, 28, 46, 34, 3, -40 },
  { 3644, 31, 39, 34, -1, -39 },
  { 3796, 28, 39, 34, 3, -39 },
  { 3933, 29, 41, 34, 4, -40 },
  { 4082, 29, 39, 34, 3, -39 },
  { 4224, 30, 39, 34, 3, -39 },
  { 4371, 31, 39, 34, 3, -39 },
  { 4523, 28, 41, 34, 4, -40 },
  { 4667, 31, 39, 34, 2, -39 },
  { 4819, 31, 39, 34, 2, -39 },
  { 4971, 28, 40, 34, 3, -39 },
  { 5111, 34, 39, 34, 2, -39 },
  { 5277, 24, 39, 34, 4, -39 },
  { 5394, 33, 39, 34, 1, -39 },
  { 5555, 31, 39, 34, 2, -39 },
  { 5707, 29, 41, 34, 3, -40 },
  { 5856, 30, 39, 34, 3, -39 },
  { 6003, 29, 50, 34, 3, -40 },
  { 6185, 30, 39, 34, 3, -39 },
  { 6332, 32, 41, 34, 1, -40 },
  { 6496, 31, 39, 34, 5, -39 },
  { 6648, 29, 40, 34, 4, -39 },
  { 6793, 30, 39, 34, 6, -39 },
  { 6940, 33, 39, 34, 3, -39 },
  { 7101, 37, 39, 34, -1, -39 },
  { 7282, 32, 39, 34, 5, -39 },
  { 7438, 34, 39, 34, 0, -39 },
  { 7604, 24, 51, 34, 9, -43 },
  { 7757, 15, 51, 34, 10, -43 },
  { 7853, 23, 51, 34, 1, -43 },
  { 8000, 28, 23, 34, 4, -39 },
  { 8081, 27, 4, 34, 0, 5 },
  { 8095, 7, 11, 34, 13, -44 },
  { 8105, 27, 31, 34, 3, -30 },
  { 8210, 27, 42, 34, 3, -41 },
  { 8352, 25, 31, 34, 4, -30 },
  { 8449, 30, 42, 34, 3, -41 },
  { 8607, 26, 31, 34, 4, -30 },
  { 8708, 37, 53, 34, -1, -41 },
  { 8954, 29, 42, 34, 2, -30 },
  { 9107, 26, 41, 34, 3, -41 },
  { 9241, 25, 44, 34, 5, -43 },
  { 9379, 27, 55, 34, 3, -43 },
  { 9565, 29, 42, 34, 3, -41 },
  { 9718, 23, 42, 34, 6, -41 },
  { 9839, 31, 30, 34, 1, -30 },
  { 9956, 26, 30, 34, 3, -30 },
  { 10054, 26, 31, 34, 4, -30 },
  { 10155, 29, 41, 34, 1, -30 },
  { 10304, 28, 41, 34, 3, -30 },
  { 10448, 27, 29, 34, 6, -29 },
  { 10546, 27, 31, 34, 3, -30 },
  { 10651, 26, 40, 34, 4, -39 },
  { 10781, 25, 30, 34, 5, -29 },
  { 10875, 26, 29, 34, 4, -29 },
  { 10970, 30, 30, 34, 2, -29 },
  { 11083, 33, 31, 34, 0, -30 },
  { 11211, 28, 41, 34, 2, -29 },
  { 11355, 28, 31, 34, 3, -30 },
  { 11464, 26, 51, 34, 6, -43 },
  { 11630, 12, 51, 34, 11, -43 },
  { 11707, 27, 51, 34, 2, -43 },
  { 11880, 29, 12, 34, 3, -23 },
};

const GFXfont IBMPlexMono_Italic56pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic56pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic56pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _IBMPLEXMONO_ITALIC56PT7B_H_
