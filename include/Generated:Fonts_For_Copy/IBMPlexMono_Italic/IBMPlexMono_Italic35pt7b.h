#ifndef _IBMPLEXMONO_ITALIC35PT7B_H_
#define _IBMPLEXMONO_ITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x18,
  0x18, 0x18, 0x10, 0x10, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF8,
  0xF0, 0x38, 0xE6, 0x18, 0xC3, 0x38, 0xE7, 0x1C, 0xE3, 0x9C, 0x73, 0x0C,
  0x61, 0x9C, 0x70, 0x00, 0x18, 0x70, 0x00, 0xE1, 0x80, 0x03, 0x0E, 0x00,
  0x0C, 0x38, 0x00, 0x70, 0xC0, 0x01, 0x87, 0x00, 0x06, 0x1C, 0x00, 0x38,
  0x60, 0x1F, 0xC3, 0xFC, 0x7F, 0x0F, 0xE0, 0x1C, 0x70, 0x00, 0x61, 0xC0,
  0x03, 0x86, 0x00, 0x0E, 0x38, 0x07, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x87,
  0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0x80, 0x03, 0x8E, 0x00, 0x1C, 0x38,
  0x00, 0x70, 0xC0, 0x01, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0x83,
  0xCE, 0xF8, 0xF1, 0x87, 0x1C, 0x30, 0x43, 0x86, 0x00, 0x70, 0xC0, 0x0E,
  0x18, 0x01, 0xC3, 0x00, 0x3C, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x00, 0x0D, 0xF0, 0x03, 0x8E, 0x00, 0x60, 0xE0, 0x0C, 0x1C, 0x01,
  0x83, 0x90, 0x30, 0xE3, 0x06, 0x1C, 0xF1, 0xC7, 0x8F, 0x31, 0xE0, 0xFF,
  0xF0, 0x07, 0xF8, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x01, 0xF0, 0x07, 0x07, 0xF8, 0x0E, 0x06, 0x18, 0x0C, 0x0E, 0x1C,
  0x1C, 0x0C, 0x0C, 0x38, 0x1C, 0x1C, 0x30, 0x1C, 0x1C, 0x60, 0x1C, 0x18,
  0xE0, 0x1C, 0x18, 0xC0, 0x0C, 0x31, 0x80, 0x0F, 0xF3, 0x80, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x01, 0xC7, 0xF0, 0x01, 0x8E, 0x38, 0x03, 0x9C,
  0x18, 0x07, 0x18, 0x18, 0x06, 0x38, 0x38, 0x0E, 0x38, 0x38, 0x1C, 0x38,
  0x38, 0x18, 0x38, 0x30, 0x30, 0x18, 0x70, 0x70, 0x1F, 0xE0, 0xE0, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x0F, 0xF8, 0x00, 0xE1, 0xE0, 0x06, 0x07, 0x00,
  0x70, 0x18, 0x03, 0x80, 0xC0, 0x1C, 0x06, 0x00, 0xE0, 0x70, 0x03, 0x03,
  0x80, 0x1C, 0x18, 0x00, 0xE3, 0x80, 0x1F, 0xF8, 0x03, 0x8E, 0x00, 0x38,
  0x70, 0x01, 0xC1, 0x80, 0x1C, 0x0E, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0,
  0x38, 0x0F, 0x0F, 0xC0, 0x78, 0xEE, 0x06, 0xE6, 0x38, 0x67, 0x70, 0xFF,
  0x1F, 0x03, 0xE0, 0x70, 0x39, 0x8C, 0xE7, 0x39, 0xCC, 0x67, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01, 0x80,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x10, 0x38, 0x2F, 0x8C, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFE, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1D, 0x80, 0x0E, 0x70,
  0x07, 0x0C, 0x03, 0xC3, 0x81, 0xE0, 0x70, 0x30, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x1F, 0x1E, 0x3C, 0x3C,
  0x38, 0x78, 0x70, 0x70, 0xE0, 0xC0, 0x7F, 0xFF, 0xFC, 0x77, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0x70, 0x78, 0x38, 0x0E, 0x1C, 0x01, 0xC6, 0x00, 0x73, 0x80,
  0x1C, 0xC0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x77, 0x0E, 0x1D, 0xC7, 0x87,
  0xE1, 0xE1, 0xF8, 0x78, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0x38,
  0x01, 0xCE, 0x00, 0x71, 0x80, 0x38, 0x70, 0x1C, 0x1E, 0x0E, 0x03, 0xFF,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x77, 0x00, 0xF3, 0x80,
  0xF1, 0xC0, 0xF0, 0xE0, 0xF0, 0xE0, 0x20, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xF8,
  0x78, 0x38, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x78, 0x78, 0x38, 0x07, 0x04, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x79, 0x80, 0x1C, 0xE0, 0x0F, 0x1E,
  0x07, 0x83, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x1C, 0xE0, 0x0E, 0x38, 0x07, 0x0C,
  0x01, 0xC7, 0x00, 0xE1, 0xC0, 0x70, 0x70, 0x38, 0x1C, 0x1C, 0x07, 0x0F,
  0x01, 0x83, 0x80, 0xE1, 0xC0, 0x38, 0xE0, 0x0E, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x7E, 0x03, 0xBF,
  0xE0, 0xF0, 0x7C, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x71, 0x80, 0x38, 0xE0, 0x0E, 0x3E,
  0x0F, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1C, 0xFC, 0x0E, 0xFF, 0x8F, 0xC1, 0xE7, 0x80, 0x73, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xB8, 0x01, 0xDC, 0x00,
  0xE7, 0x00, 0xE3, 0xC1, 0xE0, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0xFF, 0xBF,
  0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xEE, 0x00, 0xE6, 0x00, 0x73, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1E, 0x0F, 0x07, 0x00, 0xF0, 0xE0, 0x0E,
  0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0E, 0x0C, 0x01, 0xC1, 0xE0, 0xE0,
  0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xE0, 0x70, 0x70, 0x07, 0x1C, 0x00, 0x63,
  0x80, 0x0E, 0x70, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x0E, 0x38, 0x01, 0xC7,
  0x00, 0x70, 0xF8, 0x3E, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x07,
  0xFE, 0x07, 0x83, 0x87, 0x00, 0xE7, 0x00, 0x33, 0x80, 0x1B, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xB8, 0x01, 0xDE, 0x01, 0xE7, 0x83,
  0x71, 0xFF, 0x70, 0x7E, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xF8, 0x00,
  0x1E, 0x7C, 0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x7C, 0xF9, 0xF3, 0xC0, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x3C, 0x3C,
  0x1E, 0x0E, 0x0F, 0x07, 0x03, 0x83, 0x81, 0x80, 0x00, 0x00, 0x80, 0x01,
  0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x00, 0x80, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xC0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x10, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xF8, 0xF0,
  0x7B, 0xC0, 0x77, 0x00, 0xFC, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x78, 0x07, 0xE0, 0x3F, 0x80, 0x78, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x0E, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xF0, 0x70, 0x30,
  0x0E, 0x1C, 0x01, 0x86, 0x00, 0x73, 0x80, 0x1C, 0xC1, 0xE7, 0x70, 0xFD,
  0x9C, 0x70, 0xE7, 0x18, 0x39, 0x8E, 0x06, 0x63, 0x83, 0xB8, 0xE0, 0xEE,
  0x30, 0x33, 0x8C, 0x0C, 0xE3, 0x07, 0x38, 0xC1, 0xCC, 0x30, 0xF3, 0x0F,
  0xFC, 0xC1, 0xF6, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xDC, 0x00, 0x77, 0x00, 0x19, 0xC0, 0x0E, 0x70, 0x03,
  0x1C, 0x01, 0xC3, 0x00, 0x70, 0xC0, 0x38, 0x38, 0x0E, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0xE0, 0x38, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0x00, 0x73,
  0x80, 0x1C, 0xE0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0x0F, 0xFC, 0x0F, 0xFF, 0x87, 0x01, 0xE3, 0x80, 0x71, 0xC0, 0x38,
  0xE0, 0x1C, 0x60, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0x8E, 0x03,
  0x87, 0xFF, 0x83, 0xFF, 0xC3, 0x80, 0x79, 0xC0, 0x1C, 0xE0, 0x06, 0x70,
  0x03, 0xB8, 0x03, 0xD8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0xE7, 0x00, 0xF3,
  0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0x83, 0xC1, 0xC3, 0x80,
  0x71, 0xC0, 0x39, 0xC0, 0x08, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x02, 0x38, 0x01, 0xDC, 0x01, 0xC7, 0x01,
  0xC3, 0xC1, 0xE0, 0xFF, 0xE0, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x80,
  0xC0, 0xF0, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0x71, 0xC0, 0x1C, 0x70,
  0x07, 0x18, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03,
  0x8E, 0x00, 0xE3, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x01, 0xC7,
  0x00, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x38, 0x0F, 0x0F, 0xFF, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0,
  0x78, 0x78, 0x38, 0x0F, 0x1C, 0x01, 0xC6, 0x00, 0x43, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x7F,
  0xB8, 0x1F, 0xEE, 0x00, 0x33, 0x80, 0x0C, 0xE0, 0x07, 0x38, 0x01, 0xC6,
  0x00, 0x71, 0xC0, 0x3C, 0x70, 0x1E, 0x0E, 0x0D, 0x83, 0xFE, 0xE0, 0x3E,
  0x38, 0x0E, 0x00, 0x70, 0xE0, 0x06, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E,
  0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0C, 0x1C, 0x01, 0xC1,
  0xC0, 0x1C, 0x1C, 0x01, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0x80, 0x18,
  0x38, 0x03, 0x83, 0x80, 0x38, 0x38, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03,
  0x87, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x0E, 0x00,
  0x70, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x08, 0x07, 0x1C, 0x03, 0x8E, 0x03, 0x83, 0xC3, 0xC0,
  0xFF, 0xC0, 0x3F, 0x80, 0x0E, 0x00, 0x7C, 0x38, 0x03, 0xC0, 0xE0, 0x1E,
  0x03, 0x80, 0xF0, 0x0E, 0x07, 0x80, 0x38, 0x3C, 0x01, 0xC1, 0xE0, 0x07,
  0x0F, 0x00, 0x1C, 0x78, 0x00, 0x73, 0xC0, 0x01, 0xDE, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFC, 0xE0, 0x03, 0xE3, 0x80, 0x0F, 0x07, 0x00,
  0x38, 0x1C, 0x00, 0xE0, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x07, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x38, 0x38, 0x00, 0xF0, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0xF0, 0xF0, 0x0F,
  0x0F, 0x01, 0xF1, 0xF0, 0x3F, 0x1F, 0x83, 0xE1, 0xF8, 0x76, 0x1D, 0x86,
  0xE1, 0x98, 0xEE, 0x19, 0xCC, 0xE3, 0x9D, 0xCE, 0x38, 0xD8, 0xC3, 0x8F,
  0x0C, 0x30, 0xF1, 0xC3, 0x0E, 0x1C, 0x30, 0x61, 0xC7, 0x04, 0x1C, 0x70,
  0x41, 0x87, 0x00, 0x18, 0x60, 0x03, 0x86, 0x00, 0x38, 0xE0, 0x03, 0x8E,
  0x00, 0x38, 0xE0, 0x03, 0x0E, 0x00, 0x70, 0x0F, 0x80, 0x70, 0xF8, 0x06,
  0x0F, 0x80, 0x60, 0xF8, 0x0E, 0x0D, 0xC0, 0xE1, 0xDC, 0x0E, 0x1C, 0xC0,
  0xE1, 0xCC, 0x0C, 0x1C, 0xE0, 0xC1, 0xCE, 0x1C, 0x18, 0xE1, 0xC3, 0x86,
  0x1C, 0x38, 0x61, 0xC3, 0x87, 0x18, 0x38, 0x71, 0x83, 0x03, 0x38, 0x30,
  0x33, 0x87, 0x03, 0xB8, 0x70, 0x3B, 0x87, 0x03, 0xB0, 0x70, 0x1B, 0x06,
  0x01, 0xF0, 0x60, 0x1F, 0x0E, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xC0,
  0x70, 0x78, 0x38, 0x0E, 0x1C, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0,
  0x07, 0x70, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x01, 0xCE,
  0x00, 0x71, 0x80, 0x38, 0x70, 0x1C, 0x1E, 0x0E, 0x03, 0xFF, 0x00, 0x3F,
  0x00, 0x0F, 0xFE, 0x07, 0xFF, 0xE1, 0xC0, 0x3C, 0x70, 0x07, 0x1C, 0x01,
  0xC7, 0x00, 0x71, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xE3,
  0x80, 0x78, 0xFF, 0xFC, 0x3F, 0xFC, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0,
  0x70, 0x78, 0x38, 0x0E, 0x1C, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0,
  0x07, 0x70, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x01, 0xCE,
  0x00, 0x71, 0x80, 0x38, 0x70, 0x1C, 0x1E, 0x0E, 0x03, 0xFF, 0x00, 0x3F,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x40, 0x0E, 0x38, 0x03, 0x98, 0x00, 0x7C,
  0x00, 0x0E, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0xE1, 0xC0, 0x3C, 0x70, 0x07,
  0x1C, 0x01, 0xC7, 0x00, 0x71, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCE,
  0x00, 0xE3, 0x80, 0x78, 0xFF, 0xFC, 0x3F, 0xF8, 0x1C, 0x38, 0x07, 0x07,
  0x01, 0xC1, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x83, 0x80, 0x70,
  0xE0, 0x1C, 0x38, 0x07, 0x8E, 0x00, 0xE3, 0x80, 0x3C, 0x00, 0xFE, 0x00,
  0x7F, 0xF0, 0x3C, 0x0F, 0x87, 0x00, 0x71, 0xC0, 0x04, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x39, 0x00, 0x0E, 0x30, 0x01, 0xCF, 0x00, 0x70, 0xF8,
  0x3E, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x38, 0x01, 0xCE, 0x00, 0x63, 0x80,
  0x38, 0xE0, 0x0E, 0x38, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0C,
  0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38,
  0x01, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x30, 0x03, 0x8C, 0x01,
  0xC3, 0x80, 0x70, 0xE0, 0x38, 0x3C, 0x1E, 0x07, 0xFF, 0x00, 0x7F, 0x00,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x07, 0x18,
  0x01, 0xC6, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x1C, 0x1C, 0x07, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x70, 0x0C, 0x1C, 0x03, 0x06, 0x00, 0xE3, 0x80,
  0x38, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xEE, 0x00, 0x1B, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x30, 0x00, 0x33, 0x00, 0x07, 0x30,
  0x00, 0x77, 0x00, 0x06, 0x70, 0x00, 0x67, 0x00, 0x0E, 0x70, 0xF0, 0xE7,
  0x0F, 0x0C, 0x61, 0xF0, 0xC6, 0x1B, 0x1C, 0x61, 0xB1, 0xC6, 0x33, 0x18,
  0x63, 0x31, 0x86, 0x73, 0x38, 0xE6, 0x33, 0x8E, 0x63, 0x30, 0xEE, 0x33,
  0x0E, 0xC3, 0x70, 0xEC, 0x37, 0x0D, 0xC3, 0x60, 0xD8, 0x36, 0x0F, 0x83,
  0xE0, 0xF0, 0x3E, 0x0F, 0x03, 0xC0, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x1C,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x78, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0xE0,
  0x00, 0xE1, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x77, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xEE, 0x00, 0x01, 0xE7, 0x00, 0x01, 0xC7, 0x00, 0x03, 0x83, 0x80,
  0x07, 0x03, 0x80, 0x0E, 0x03, 0xC0, 0x1E, 0x01, 0xC0, 0x3C, 0x01, 0xC0,
  0x38, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0xE0, 0x00, 0xF7, 0x00, 0x1E, 0x70,
  0x01, 0xC3, 0x80, 0x38, 0x38, 0x07, 0x83, 0x80, 0x70, 0x1C, 0x0E, 0x01,
  0xC1, 0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0x80, 0x0E, 0x70, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x07, 0xFE, 0x0F,
  0xF8, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0xE0, 0x18, 0x06,
  0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60,
  0x18, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x18,
  0x07, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x1F, 0xF0, 0x7F,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x07, 0x70, 0x03, 0x8E,
  0x00, 0xE3, 0x80, 0x70, 0x60, 0x38, 0x1C, 0x1C, 0x07, 0x07, 0x00, 0xE3,
  0x80, 0x39, 0xC0, 0x06, 0x70, 0x01, 0xF8, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x2E, 0x67, 0x33, 0x30, 0x03, 0xE3, 0x87, 0xF9, 0xC7, 0x86,
  0xC7, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0,
  0x07, 0x70, 0x03, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0xF3,
  0x80, 0xB8, 0xE0, 0xD8, 0x3F, 0xCF, 0x8F, 0x87, 0x80, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x7C, 0x0C, 0xFF, 0x0E, 0xC3, 0xC7, 0xC0, 0x73, 0xC0,
  0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x60, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xDC,
  0x00, 0xEE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x33, 0xC0, 0x39, 0xD0, 0x78,
  0xEF, 0xF8, 0x71, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x70, 0x79, 0xC0,
  0x77, 0x00, 0x4E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0xDC, 0x03, 0xF8, 0x0F, 0x3C, 0x3C, 0x3F,
  0xF0, 0x1F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x03, 0xE3, 0x83,
  0xFE, 0xE1, 0xE0, 0xB8, 0xE0, 0x1E, 0x30, 0x07, 0x1C, 0x01, 0xC7, 0x00,
  0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x63, 0x80, 0x38,
  0xE0, 0x0E, 0x38, 0x07, 0x8E, 0x03, 0xE1, 0xC1, 0xB8, 0x3F, 0xCC, 0x07,
  0xC7, 0x00, 0x03, 0xF8, 0x0F, 0xFC, 0x1C, 0x0E, 0x38, 0x07, 0x70, 0x07,
  0x60, 0x0E, 0xE0, 0x1E, 0xE0, 0xFC, 0xFF, 0xF0, 0xFF, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x04, 0xE0, 0x0E, 0xE0, 0x1C, 0x78, 0x78, 0x3F, 0xF0,
  0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x40, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x86,
  0x00, 0x03, 0x8C, 0x00, 0x03, 0xB8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF1, 0xC1, 0xFF, 0x70, 0xF0, 0x5C, 0x70, 0x0F, 0x1C, 0x03,
  0x8E, 0x00, 0xE3, 0x80, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xE7,
  0x00, 0x31, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x03, 0xC7, 0x81, 0xF0, 0xF0,
  0xDC, 0x1F, 0xE6, 0x03, 0xE1, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x10, 0x07, 0x07, 0x07, 0x83, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x7C, 0x1D, 0xFE, 0x1D, 0x0F, 0x3A, 0x07, 0x3C, 0x07,
  0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x30, 0x07, 0x70, 0x07, 0x70, 0x06,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x0E, 0xE0, 0x0E, 0xE0, 0x0C,
  0xE0, 0x1C, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x02, 0x06, 0x07, 0x0E, 0x1E, 0x0E, 0x38, 0x0E, 0x70,
  0x0E, 0xE0, 0x0F, 0xC0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x0F, 0xFC, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x40, 0x70, 0xE0, 0x60,
  0x70, 0x60, 0x38, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x07, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x7C, 0x07, 0x7F, 0x81, 0xB0,
  0xF0, 0xE8, 0x1C, 0x3C, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x38,
  0x30, 0x3C, 0x1C, 0x3C, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x71, 0xC0, 0x9C,
  0x70, 0x76, 0x0E, 0x7B, 0x83, 0xB8, 0xE0, 0x7C, 0x38, 0x0E, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0xC7, 0x07, 0x18, 0x38,
  0xE1, 0xC3, 0x9E, 0x0E, 0xE0, 0x3F, 0x00, 0x78, 0x00, 0x1C, 0xE1, 0xE1,
  0xDF, 0x3F, 0x1E, 0x34, 0x71, 0xC3, 0x87, 0x1C, 0x38, 0x73, 0x83, 0x07,
  0x38, 0x30, 0x73, 0x87, 0x06, 0x38, 0x70, 0x63, 0x07, 0x0E, 0x30, 0x70,
  0xE7, 0x06, 0x0E, 0x70, 0x60, 0xC7, 0x0E, 0x0C, 0x70, 0xE0, 0xC6, 0x0E,
  0x1C, 0x60, 0xE1, 0xCE, 0x0C, 0x1C, 0x1C, 0x7C, 0x1D, 0xFE, 0x19, 0x0F,
  0x3A, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x30, 0x07,
  0x70, 0x07, 0x70, 0x06, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0C, 0xE0, 0x1C, 0x01, 0xF8, 0x03, 0xFE, 0x07, 0x83,
  0x87, 0x80, 0xE3, 0x80, 0x33, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x73, 0x00, 0x71,
  0xC0, 0x78, 0x70, 0x78, 0x1F, 0xF0, 0x07, 0xE0, 0x00, 0x0E, 0x3E, 0x03,
  0x3F, 0xC1, 0xD8, 0x78, 0x7C, 0x07, 0x1E, 0x01, 0xC7, 0x00, 0x71, 0xC0,
  0x1C, 0x60, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0E,
  0x38, 0x03, 0x8E, 0x00, 0xC7, 0x80, 0x71, 0xD0, 0x78, 0x77, 0xFC, 0x1C,
  0x7C, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xE3, 0x87, 0xFD, 0xC7, 0x82,
  0xE7, 0x00, 0xF3, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0,
  0x07, 0x70, 0x03, 0xB8, 0x01, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0xF3,
  0x80, 0xF8, 0xE0, 0xDC, 0x3F, 0xCC, 0x0F, 0x8E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00,
  0xFF, 0x1F, 0xFF, 0x9F, 0x81, 0xD0, 0x00, 0xD0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0x81, 0xE3, 0x00, 0x63,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x62, 0x00, 0x33, 0x80, 0x39, 0xF0,
  0x38, 0x7F, 0xF8, 0x07, 0xF0, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x06, 0x1C, 0x1E, 0x1C, 0x3C, 0x1C, 0xF0,
  0x1D, 0xE0, 0x1F, 0x80, 0x0E, 0x00, 0x38, 0x07, 0x30, 0x07, 0x70, 0x07,
  0x70, 0x06, 0x70, 0x06, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x5C,
  0xF0, 0x98, 0x7F, 0xB8, 0x3E, 0x38, 0x7E, 0x03, 0x7F, 0x03, 0x83, 0x80,
  0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x60, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C,
  0x03, 0x0E, 0x03, 0x87, 0x01, 0xC3, 0x01, 0xC1, 0x80, 0xE1, 0xC0, 0xE0,
  0xE1, 0xE0, 0x73, 0xE0, 0x3F, 0xC0, 0x0F, 0x80, 0x00, 0x18, 0x30, 0xC3,
  0x06, 0x18, 0xE0, 0xC3, 0x9C, 0x38, 0x73, 0x87, 0x0E, 0x60, 0xE1, 0xCC,
  0x18, 0x39, 0x83, 0x07, 0x70, 0x60, 0xEE, 0x1C, 0x19, 0xC3, 0x83, 0x30,
  0x70, 0xE6, 0x0C, 0x1C, 0xC3, 0x83, 0x38, 0x70, 0xE3, 0x17, 0x38, 0x7E,
  0x7E, 0x07, 0x8F, 0x80, 0x03, 0xC1, 0xE0, 0x3F, 0x1F, 0x87, 0x99, 0x8E,
  0x78, 0xD8, 0x77, 0x06, 0x83, 0x80, 0x34, 0x1C, 0x01, 0xE0, 0x80, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x41, 0xE0, 0x0E,
  0x0B, 0x04, 0x70, 0x58, 0x73, 0x86, 0xC7, 0x9C, 0x66, 0x78, 0x7E, 0x3F,
  0x01, 0xE0, 0xE0, 0x00, 0x0E, 0x01, 0xC3, 0x00, 0x70, 0xC0, 0x1C, 0x70,
  0x06, 0x1C, 0x01, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x60, 0x0E, 0x18, 0x03,
  0x8E, 0x00, 0xC3, 0x80, 0x30, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x03, 0xC3,
  0x81, 0x70, 0xF0, 0xD8, 0x1F, 0xE6, 0x01, 0xE3, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1C, 0x10, 0x07, 0x0F, 0x07, 0x81, 0xFF, 0xC0, 0x1F, 0xC0,
  0x00, 0x0F, 0xE1, 0xC7, 0xFE, 0x63, 0x87, 0xF8, 0xC0, 0x3C, 0x30, 0x0E,
  0x0C, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x20, 0x38, 0x18, 0x1C, 0x07, 0x0E, 0x01, 0xC7, 0xE0, 0x33, 0xFF,
  0x8C, 0xE3, 0xFF, 0x38, 0x1F, 0x80, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0xFF, 0x00, 0xFF, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0x06,
  0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x18,
  0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0x30, 0x70, 0x70, 0x60,
  0x60, 0x60, 0x60, 0xE0, 0xE0, 0xC0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0x0F, 0x00, 0xCF, 0xE0, 0x77, 0x18, 0x19, 0x87, 0x0E, 0xE0,
  0xE7, 0x30, 0x1F, 0x8C, 0x03, 0xC0,
};

const GFXglyph IBMPlexMono_Italic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 8, 24, 21, 7, -24 },
  { 25, 11, 10, 21, 7, -26 },
  { 39, 22, 24, 21, 0, -24 },
  { 105, 19, 32, 21, 1, -28 },
  { 181, 24, 24, 21, -1, -24 },
  { 253, 21, 24, 21, 0, -24 },
  { 316, 5, 10, 21, 10, -26 },
  { 323, 13, 32, 21, 7, -27 },
  { 375, 13, 32, 21, 1, -27 },
  { 427, 18, 17, 21, 2, -19 },
  { 466, 17, 16, 21, 2, -19 },
  { 500, 8, 10, 21, 5, -5 },
  { 510, 11, 2, 21, 5, -12 },
  { 513, 5, 5, 21, 7, -5 },
  { 517, 20, 32, 21, 1, -27 },
  { 597, 18, 24, 21, 2, -24 },
  { 651, 17, 24, 21, 1, -24 },
  { 702, 18, 24, 21, 1, -24 },
  { 756, 18, 24, 21, 1, -24 },
  { 810, 18, 24, 21, 1, -24 },
  { 864, 18, 24, 21, 2, -24 },
  { 918, 17, 24, 21, 2, -24 },
  { 969, 17, 24, 21, 4, -24 },
  { 1020, 19, 24, 21, 1, -24 },
  { 1077, 17, 24, 21, 3, -24 },
  { 1128, 7, 19, 21, 7, -19 },
  { 1145, 9, 24, 21, 5, -19 },
  { 1172, 17, 20, 21, 3, -21 },
  { 1215, 18, 9, 21, 2, -15 },
  { 1236, 17, 20, 21, 2, -21 },
  { 1279, 15, 24, 21, 4, -24 },
  { 1324, 18, 28, 21, 2, -24 },
  { 1387, 18, 24, 21, 0, -24 },
  { 1441, 17, 24, 21, 2, -24 },
  { 1492, 17, 24, 21, 3, -24 },
  { 1543, 18, 24, 21, 2, -24 },
  { 1597, 19, 24, 21, 2, -24 },
  { 1654, 19, 24, 21, 2, -24 },
  { 1711, 18, 24, 21, 2, -24 },
  { 1765, 20, 24, 21, 1, -24 },
  { 1825, 20, 24, 21, 1, -24 },
  { 1885, 17, 24, 21, 2, -24 },
  { 1936, 22, 24, 21, 1, -24 },
  { 2002, 15, 24, 21, 3, -24 },
  { 2047, 20, 24, 21, 1, -24 },
  { 2107, 20, 24, 21, 1, -24 },
  { 2167, 18, 24, 21, 2, -24 },
  { 2221, 18, 24, 21, 2, -24 },
  { 2275, 18, 30, 21, 2, -24 },
  { 2343, 18, 24, 21, 2, -24 },
  { 2397, 19, 24, 21, 1, -24 },
  { 2454, 20, 24, 21, 3, -24 },
  { 2514, 18, 24, 21, 3, -24 },
  { 2568, 18, 24, 21, 4, -24 },
  { 2622, 20, 24, 21, 2, -24 },
  { 2682, 24, 24, 21, -1, -24 },
  { 2754, 20, 24, 21, 3, -24 },
  { 2814, 21, 24, 21, 0, -24 },
  { 2877, 15, 32, 21, 6, -27 },
  { 2937, 10, 32, 21, 6, -27 },
  { 2977, 15, 32, 21, 0, -27 },
  { 3037, 18, 14, 21, 2, -24 },
  { 3069, 17, 2, 21, 0, 4 },
  { 3074, 4, 7, 21, 8, -27 },
  { 3078, 17, 18, 21, 2, -18 },
  { 3117, 17, 26, 21, 2, -26 },
  { 3173, 15, 18, 21, 3, -18 },
  { 3207, 18, 26, 21, 2, -26 },
  { 3266, 16, 18, 21, 3, -18 },
  { 3302, 23, 33, 21, -1, -26 },
  { 3397, 18, 25, 21, 1, -18 },
  { 3454, 16, 26, 21, 2, -26 },
  { 3506, 16, 26, 21, 3, -26 },
  { 3558, 16, 33, 21, 2, -26 },
  { 3624, 18, 26, 21, 2, -26 },
  { 3683, 14, 26, 21, 4, -26 },
  { 3729, 20, 18, 21, 0, -18 },
  { 3774, 16, 18, 21, 2, -18 },
  { 3810, 17, 18, 21, 2, -18 },
  { 3849, 18, 25, 21, 1, -18 },
  { 3906, 17, 25, 21, 2, -18 },
  { 3960, 17, 18, 21, 4, -18 },
  { 3999, 17, 18, 21, 2, -18 },
  { 4038, 16, 24, 21, 3, -24 },
  { 4086, 16, 18, 21, 3, -18 },
  { 4122, 17, 18, 21, 2, -18 },
  { 4161, 19, 18, 21, 1, -18 },
  { 4204, 21, 18, 21, 0, -18 },
  { 4252, 18, 25, 21, 1, -18 },
  { 4309, 18, 18, 21, 2, -18 },
  { 4350, 16, 32, 21, 4, -27 },
  { 4414, 8, 32, 21, 7, -27 },
  { 4446, 17, 32, 21, 1, -27 },
  { 4514, 18, 7, 21, 2, -14 },
};

const GFXfont IBMPlexMono_Italic35pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic35pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _IBMPLEXMONO_ITALIC35PT7B_H_
