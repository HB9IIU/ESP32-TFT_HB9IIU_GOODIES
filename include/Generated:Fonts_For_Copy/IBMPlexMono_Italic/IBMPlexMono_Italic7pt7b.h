#ifndef _IBMPLEXMONO_ITALIC7PT7B_H_
#define _IBMPLEXMONO_ITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x58, 0x80, 0xF8, 0x36, 0x7B, 0xC0, 0x27, 0xA6, 0x5A, 0x40, 0xDD,
  0xB1, 0xEF, 0x00, 0x66, 0x6A, 0xF0, 0xC0, 0x72, 0x48, 0x80, 0x64, 0x95,
  0x00, 0x2D, 0x6A, 0x24, 0xF4, 0xE0, 0xC0, 0x80, 0x12, 0x24, 0x88, 0x79,
  0xB9, 0xE0, 0x2E, 0x22, 0xF0, 0x71, 0x24, 0xF0, 0x71, 0x61, 0xE0, 0x16,
  0x6A, 0x70, 0x74, 0x71, 0xE0, 0x34, 0x79, 0xE0, 0xF5, 0x48, 0x79, 0x69,
  0xE0, 0xF6, 0xA8, 0x42, 0x43, 0x80, 0x3A, 0x20, 0x7F, 0x43, 0x2C, 0xE5,
  0x48, 0x7B, 0xDD, 0xA6, 0x26, 0x66, 0x90, 0x79, 0x69, 0xE0, 0x72, 0x4E,
  0x65, 0x99, 0xE0, 0x78, 0x78, 0xE0, 0x78, 0x78, 0x80, 0x78, 0x8B, 0xE0,
  0x59, 0x79, 0xA0, 0x72, 0x24, 0xE0, 0x71, 0x22, 0xE0, 0x5D, 0x19, 0x4B,
  0x00, 0x92, 0x4E, 0x5D, 0xBD, 0x90, 0x5D, 0xDB, 0xA0, 0x79, 0x99, 0xE0,
  0x79, 0x78, 0x80, 0x79, 0x99, 0xA7, 0x79, 0x7A, 0xB0, 0x78, 0x61, 0xE0,
  0xF4, 0x48, 0x80, 0xB6, 0xDC, 0xB7, 0x68, 0x9B, 0xBF, 0xA0, 0x5B, 0x08,
  0xCB, 0x00, 0xBA, 0x48, 0x80, 0x72, 0x24, 0xF0, 0xF2, 0x49, 0x80, 0xA9,
  0x50, 0x64, 0xA5, 0x80, 0x25, 0x90, 0xE0, 0x80, 0x79, 0xAF, 0x4A, 0xD9,
  0xE0, 0x56, 0x70, 0x17, 0x9A, 0xE0, 0x57, 0x70, 0x37, 0x24, 0x4C, 0x79,
  0xA6, 0xE0, 0x46, 0x9A, 0xA0, 0x52, 0x5C, 0x16, 0x22, 0x2E, 0x46, 0x9E,
  0xB0, 0xD2, 0x6E, 0x5F, 0xDD, 0x69, 0xAA, 0x2D, 0x9E, 0xED, 0x9A, 0xC0,
  0x79, 0xAA, 0x60, 0xBA, 0x40, 0x69, 0x6F, 0x9E, 0x4E, 0xB7, 0x60, 0x5D,
  0x5E, 0xBD, 0xDE, 0x5B, 0x4F, 0x59, 0xA6, 0xE0, 0x7A, 0x6F, 0x69, 0x69,
  0x80, 0x5A, 0xA0, 0x62, 0x47, 0x4C, 0x5A,
};

const GFXglyph IBMPlexMono_Italic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 3, 2, 4, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 7, 4, 0, -6 },
  { 11, 5, 5, 4, 0, -5 },
  { 15, 4, 5, 4, 0, -5 },
  { 18, 1, 2, 4, 2, -5 },
  { 19, 3, 6, 4, 1, -5 },
  { 22, 3, 6, 4, 0, -5 },
  { 25, 4, 4, 4, 0, -4 },
  { 27, 4, 4, 4, 0, -4 },
  { 29, 2, 2, 4, 1, -1 },
  { 30, 2, 1, 4, 1, -3 },
  { 31, 1, 1, 4, 1, -1 },
  { 32, 4, 6, 4, 0, -5 },
  { 35, 4, 5, 4, 0, -5 },
  { 38, 4, 5, 4, 0, -5 },
  { 41, 4, 5, 4, 0, -5 },
  { 44, 4, 5, 4, 0, -5 },
  { 47, 4, 5, 4, 0, -5 },
  { 50, 4, 5, 4, 0, -5 },
  { 53, 4, 5, 4, 0, -5 },
  { 56, 3, 5, 4, 1, -5 },
  { 58, 4, 5, 4, 0, -5 },
  { 61, 3, 5, 4, 1, -5 },
  { 63, 2, 4, 4, 1, -4 },
  { 64, 2, 5, 4, 1, -4 },
  { 66, 3, 4, 4, 1, -4 },
  { 68, 4, 2, 4, 0, -3 },
  { 69, 4, 4, 4, 0, -4 },
  { 71, 3, 5, 4, 1, -5 },
  { 73, 4, 6, 4, 0, -5 },
  { 76, 4, 5, 4, 0, -5 },
  { 79, 4, 5, 4, 0, -5 },
  { 82, 3, 5, 4, 1, -5 },
  { 84, 4, 5, 4, 0, -5 },
  { 87, 4, 5, 4, 0, -5 },
  { 90, 4, 5, 4, 0, -5 },
  { 93, 4, 5, 4, 0, -5 },
  { 96, 4, 5, 4, 0, -5 },
  { 99, 4, 5, 4, 0, -5 },
  { 102, 4, 5, 4, 0, -5 },
  { 105, 5, 5, 4, 0, -5 },
  { 109, 3, 5, 4, 1, -5 },
  { 111, 4, 5, 4, 0, -5 },
  { 114, 4, 5, 4, 0, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 4, 5, 4, 0, -5 },
  { 123, 4, 6, 4, 0, -5 },
  { 126, 4, 5, 4, 0, -5 },
  { 129, 4, 5, 4, 0, -5 },
  { 132, 4, 5, 4, 1, -5 },
  { 135, 3, 5, 4, 1, -5 },
  { 137, 3, 5, 4, 1, -5 },
  { 139, 4, 5, 4, 0, -5 },
  { 142, 5, 5, 4, 0, -5 },
  { 146, 4, 5, 4, 1, -5 },
  { 149, 4, 5, 4, 0, -5 },
  { 152, 3, 6, 4, 1, -5 },
  { 155, 2, 6, 4, 1, -5 },
  { 157, 3, 6, 4, 0, -5 },
  { 160, 4, 3, 4, 0, -5 },
  { 162, 3, 1, 4, 0, 0 },
  { 163, 1, 1, 4, 2, -5 },
  { 164, 4, 4, 4, 0, -4 },
  { 166, 4, 5, 4, 0, -5 },
  { 169, 3, 4, 4, 1, -4 },
  { 171, 4, 5, 4, 0, -5 },
  { 174, 3, 4, 4, 1, -4 },
  { 176, 4, 6, 4, 0, -5 },
  { 179, 4, 5, 4, 0, -4 },
  { 182, 4, 5, 4, 0, -5 },
  { 185, 3, 5, 4, 1, -5 },
  { 187, 4, 6, 4, 0, -5 },
  { 190, 4, 5, 4, 0, -5 },
  { 193, 3, 5, 4, 1, -5 },
  { 195, 4, 4, 4, 0, -4 },
  { 197, 4, 4, 4, 0, -4 },
  { 199, 4, 4, 4, 0, -4 },
  { 201, 4, 5, 4, 0, -4 },
  { 204, 4, 5, 4, 0, -4 },
  { 207, 3, 4, 4, 1, -4 },
  { 209, 4, 4, 4, 0, -4 },
  { 211, 3, 5, 4, 1, -5 },
  { 213, 3, 4, 4, 1, -4 },
  { 215, 4, 4, 4, 0, -4 },
  { 217, 4, 4, 4, 0, -4 },
  { 219, 4, 4, 4, 0, -4 },
  { 221, 4, 5, 4, 0, -4 },
  { 224, 4, 4, 4, 0, -4 },
  { 226, 3, 6, 4, 1, -5 },
  { 229, 2, 6, 4, 1, -5 },
  { 231, 4, 6, 4, 0, -5 },
  { 234, 4, 2, 4, 0, -3 },
};

const GFXfont IBMPlexMono_Italic7pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic7pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _IBMPLEXMONO_ITALIC7PT7B_H_
