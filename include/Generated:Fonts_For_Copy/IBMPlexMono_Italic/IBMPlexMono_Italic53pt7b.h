#ifndef _IBMPLEXMONO_ITALIC53PT7B_H_
#define _IBMPLEXMONO_ITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07,
  0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x00, 0x1E, 0x0F, 0x3C,
  0x0F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x78,
  0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x70, 0x3C, 0xF0,
  0x3C, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1F, 0x07, 0x80, 0x0F,
  0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F,
  0xFC, 0x0F, 0xFE, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF,
  0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0xF0, 0x03,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xF3, 0xDF, 0xE0, 0x3F, 0x0E, 0x0F,
  0x81, 0xF8, 0x38, 0x1F, 0x07, 0xC0, 0xE0, 0x30, 0x1E, 0x03, 0x80, 0x80,
  0xF8, 0x0E, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x81, 0xC0, 0x00, 0x3E,
  0x07, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xF0, 0x70, 0x00, 0x07, 0xF1,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xE3, 0xF0, 0x00, 0x07, 0x07, 0xE0, 0x00, 0x1C, 0x0F, 0x80,
  0x00, 0x70, 0x1E, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x0C, 0x03, 0x80, 0xF8, 0x78, 0x0E,
  0x03, 0xC3, 0xF0, 0x38, 0x1F, 0x07, 0xE0, 0xE1, 0xF8, 0x0F, 0xF3, 0x9F,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x00, 0xFF, 0xE0, 0x01,
  0xE0, 0x1E, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0x38, 0x07,
  0x00, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x78, 0x07, 0x01, 0xE0, 0x07,
  0x00, 0x70, 0x1E, 0x00, 0xF0, 0x07, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x78,
  0x00, 0xF0, 0x0F, 0x07, 0x00, 0x0F, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x0E,
  0x1E, 0x00, 0x07, 0x01, 0xE1, 0xC0, 0x00, 0x78, 0x3C, 0x3C, 0x00, 0x03,
  0xFF, 0x87, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1E, 0x3F, 0xFC, 0x00, 0x03, 0xC7, 0xC3, 0xC0, 0x00,
  0x78, 0x78, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0xF0, 0x0E,
  0x00, 0x1E, 0x1E, 0x00, 0xE0, 0x03, 0xC1, 0xE0, 0x0E, 0x00, 0x38, 0x1E,
  0x01, 0xE0, 0x07, 0x81, 0xE0, 0x1E, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x0E,
  0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x38,
  0x07, 0x80, 0x0F, 0x0F, 0x80, 0x78, 0x00, 0xFF, 0xF0, 0x0F, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0,
  0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x3C, 0x1F,
  0x00, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xF1, 0xFC, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0x80, 0x03,
  0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x9E,
  0x00, 0x1E, 0x03, 0xFE, 0x00, 0x7E, 0x07, 0xFC, 0x00, 0xFC, 0x1E, 0xF8,
  0x03, 0xFC, 0x3C, 0xF8, 0x06, 0x78, 0xF1, 0xF8, 0x3C, 0xFB, 0xE1, 0xFF,
  0xF0, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0x01, 0xFF, 0x81, 0xFC, 0x00, 0xFC,
  0x01, 0xF0, 0x00, 0x3C, 0xF3, 0xCF, 0x79, 0xE7, 0x9E, 0x79, 0xEF, 0x3C,
  0xF3, 0xCF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x60, 0x0F, 0x00, 0x4F, 0x81, 0xE0, 0x7F, 0xFE, 0x3C, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0xF0, 0x00,
  0x07, 0x8F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x03,
  0xC0, 0x07, 0xC0, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1C, 0x00, 0x70, 0x01,
  0x00, 0x0C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x01,
  0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0x81, 0xF8, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x00, 0xF0, 0x3C, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xEF, 0x81, 0xE0, 0x7D, 0xF0,
  0x7E, 0x0F, 0xBC, 0x0F, 0xC1, 0xF7, 0x83, 0xF8, 0x3E, 0xF0, 0x7F, 0x07,
  0xBE, 0x07, 0xC0, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF1,
  0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x7C, 0x07, 0xC0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x7E, 0xF8, 0x00, 0x3F, 0x3C, 0x00, 0x1F, 0x8F, 0x00, 0x0F, 0xC3, 0xC0,
  0x07, 0xE0, 0xF0, 0x07, 0xE0, 0x3C, 0x00, 0xF0, 0x1F, 0x00, 0x38, 0x07,
  0x80, 0x04, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0x81, 0xFC, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x7C,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFC,
  0x0F, 0xE0, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF0, 0x1C, 0x00, 0x1F,
  0x00, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x10, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF8,
  0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3C, 0x7C,
  0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x03,
  0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xF8, 0x00, 0xF0, 0x0F,
  0x00, 0x1E, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x0F, 0x00, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xE0, 0x01,
  0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC3,
  0xF8, 0x00, 0x71, 0xFF, 0xC0, 0x1E, 0x7F, 0xFC, 0x03, 0xDF, 0xFF, 0xC0,
  0x7F, 0x01, 0xFC, 0x0F, 0x80, 0x0F, 0x81, 0xE0, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x40, 0x00, 0x3E, 0x1C, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0, 0xFC,
  0x00, 0x7C, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x3F, 0x80, 0x3E, 0x7F, 0xF0, 0x1E, 0x7F,
  0xFE, 0x1F, 0x7F, 0xFF, 0x8F, 0x78, 0x1F, 0xCF, 0xF0, 0x03, 0xF7, 0xE0,
  0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x7C,
  0x7C, 0x00, 0x7C, 0x1F, 0x80, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x70, 0x00, 0x0F, 0xBC,
  0x00, 0x03, 0xCF, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3E,
  0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFC,
  0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0xF8,
  0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0xC0, 0x07,
  0xC0, 0x3F, 0x01, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x3C, 0xF8, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF8,
  0x7C, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0x7F, 0x80, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x81, 0xFC, 0x07, 0xE1, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x1E, 0x78, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBF, 0x00, 0x3F,
  0xCF, 0xE0, 0x7B, 0xC7, 0xFF, 0xFB, 0xE1, 0xFF, 0xF9, 0xE0, 0x3F, 0xF9,
  0xF0, 0x07, 0xF0, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x07, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xF8, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF4,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE0, 0x08, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0x81,
  0xF9, 0xF8, 0x03, 0xF7, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3C,
  0xC0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x81,
  0xF8, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x1F, 0x0F,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0xF8,
  0xF1, 0xC0, 0x7F, 0x9E, 0x78, 0x1F, 0xFB, 0x8F, 0x07, 0xFF, 0x71, 0xE0,
  0xF8, 0x6E, 0x3C, 0x3E, 0x03, 0xCF, 0x07, 0x80, 0x79, 0xE1, 0xF0, 0x0F,
  0x3C, 0x3C, 0x01, 0xE7, 0x87, 0x80, 0x38, 0xF0, 0xF0, 0x0F, 0x1E, 0x1E,
  0x01, 0xE7, 0x87, 0xC0, 0x3C, 0xF0, 0xF0, 0x07, 0x9E, 0x1E, 0x01, 0xF3,
  0xC3, 0xC0, 0x3C, 0x78, 0x78, 0x0F, 0x8F, 0x07, 0x83, 0xF1, 0xE0, 0xFC,
  0xDE, 0x3C, 0x1F, 0xFB, 0xC7, 0x81, 0xFE, 0x78, 0xF0, 0x1F, 0x8E, 0x1E,
  0x00, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x01,
  0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x7C, 0x07,
  0x80, 0x07, 0x80, 0x78, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xC0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0xF8, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1E, 0x00,
  0x01, 0xE3, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1F,
  0x78, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x3C, 0x00, 0x7E, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0x78, 0x3E,
  0x00, 0x0F, 0x07, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07,
  0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0x83, 0xE0,
  0x01, 0xF0, 0x78, 0x00, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xF0, 0x01, 0xF8, 0x3C, 0x00,
  0x0F, 0x07, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0x78, 0xF8, 0x00, 0x1F, 0x1E, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x7C, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0x78,
  0x00, 0x7F, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xC0, 0x0F,
  0x81, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE3, 0xE0,
  0x00, 0x20, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0xC1, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07,
  0xC3, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x80, 0xFE,
  0x07, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xF8, 0x0F, 0x80, 0x1F,
  0x01, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE1, 0xF0,
  0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E,
  0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00,
  0x3E, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1E, 0x00, 0x1F,
  0x83, 0xC0, 0x07, 0xE0, 0x78, 0x03, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xC0, 0xFC,
  0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x0F, 0x80,
  0x01, 0xE1, 0xE0, 0x00, 0x20, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x01, 0xFF, 0xC7, 0x80, 0x7F, 0xF8, 0xF0, 0x0F, 0xFF, 0x1E, 0x01, 0xFF,
  0xE3, 0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x07, 0x9F, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3E,
  0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x07, 0xC0,
  0x1F, 0xC0, 0xFE, 0x0F, 0x78, 0x0F, 0xFF, 0xCF, 0x00, 0xFF, 0xF1, 0xE0,
  0x0F, 0xFC, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x1E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xF0, 0x7C, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x7C, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xE0, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3C, 0x0F,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x10, 0x00, 0x7C, 0x3C,
  0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x7C, 0x01, 0xF0,
  0x1F, 0x81, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x7E, 0x03, 0xC0, 0x00, 0xFC, 0x03, 0xC0, 0x01, 0xF8, 0x03, 0xC0, 0x03,
  0xF0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x1F,
  0x80, 0x07, 0x80, 0x3F, 0x00, 0x07, 0x80, 0x7E, 0x00, 0x07, 0x80, 0xFC,
  0x00, 0x07, 0x81, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0x0F, 0x0F, 0xC0, 0x00, 0x0F, 0x1F, 0x80, 0x00, 0x0F, 0x3F, 0x80,
  0x00, 0x0F, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xF3, 0xC0,
  0x00, 0x1F, 0xE3, 0xE0, 0x00, 0x1F, 0xC3, 0xE0, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xE0,
  0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x03,
  0xDE, 0x03, 0xDE, 0x07, 0xBC, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0x70, 0x1E,
  0x70, 0x39, 0xE0, 0x3C, 0xF0, 0xF3, 0xC0, 0xF1, 0xE3, 0xC7, 0x81, 0xE3,
  0xC7, 0x8F, 0x03, 0xC3, 0x9E, 0x1E, 0x07, 0x87, 0xBC, 0x78, 0x0F, 0x0F,
  0xF0, 0xF0, 0x1E, 0x1F, 0xC1, 0xE0, 0x78, 0x1F, 0x83, 0xC0, 0xF0, 0x3E,
  0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x80, 0xE0,
  0x78, 0x0F, 0x01, 0x80, 0xF0, 0x3C, 0x02, 0x01, 0xE0, 0x78, 0x04, 0x03,
  0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF8, 0x00, 0x78,
  0x1F, 0xC0, 0x03, 0xC0, 0xFE, 0x00, 0x1E, 0x07, 0xF0, 0x00, 0xF0, 0x7F,
  0xC0, 0x07, 0x83, 0xDE, 0x00, 0x78, 0x1E, 0xF0, 0x03, 0xC0, 0xF7, 0x80,
  0x1E, 0x07, 0x9C, 0x00, 0xF0, 0x3C, 0xF0, 0x07, 0x83, 0xE7, 0x80, 0x3C,
  0x1E, 0x3C, 0x03, 0xC0, 0xF1, 0xE0, 0x1E, 0x07, 0x87, 0x80, 0xF0, 0x3C,
  0x3C, 0x07, 0x81, 0xE1, 0xE0, 0x3C, 0x1F, 0x0F, 0x01, 0xE0, 0xF0, 0x38,
  0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x3C,
  0x0F, 0x03, 0xC1, 0xE0, 0xF8, 0x0F, 0x0F, 0x07, 0x80, 0x78, 0xF0, 0x3C,
  0x03, 0xC7, 0x81, 0xE0, 0x1E, 0x3C, 0x0F, 0x00, 0x71, 0xE0, 0x78, 0x03,
  0xCF, 0x07, 0xC0, 0x1E, 0x78, 0x3C, 0x00, 0xF7, 0x81, 0xE0, 0x07, 0xBC,
  0x0F, 0x00, 0x1F, 0xE0, 0x78, 0x00, 0xFF, 0x03, 0xC0, 0x07, 0xF8, 0x3E,
  0x00, 0x3F, 0xC1, 0xE0, 0x00, 0xFC, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x00, 0xF0, 0x3C,
  0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x7B, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7D,
  0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3E, 0xF0, 0x00,
  0x07, 0xBE, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0xF1, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x3C, 0x00, 0x3F, 0x01, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x78, 0x3E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x0F,
  0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xC0, 0x0F, 0x81, 0xF0,
  0x00, 0xF0, 0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0x3C,
  0x7C, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x1E, 0x7C, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x3E, 0xF0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3E, 0xF8,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x83, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xE0, 0x08, 0x00, 0x3E, 0x03, 0x80, 0x03, 0xE0, 0xF8,
  0x00, 0x3E, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3C,
  0x00, 0x3F, 0x01, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3E,
  0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x78, 0x3E,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0xE0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E,
  0x01, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xF0,
  0x0F, 0x80, 0x07, 0x80, 0x7C, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xF0, 0x1E,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x0C, 0x07, 0x80, 0x00, 0x20, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x83, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x7E, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x3C,
  0x3C, 0x00, 0x07, 0x87, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00,
  0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x7C, 0x7C,
  0x00, 0x0F, 0x8F, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07,
  0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8,
  0x78, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00,
  0x1F, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x78, 0x78,
  0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01,
  0xE0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x7C, 0x03,
  0xC0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x3E, 0x00,
  0x3E, 0x03, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1E, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F,
  0x7C, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x38, 0x1E, 0x07, 0xE0, 0x78, 0x1C, 0x07, 0xE0, 0x78,
  0x1C, 0x07, 0xE0, 0x78, 0x3C, 0x0F, 0xE0, 0x70, 0x3C, 0x0F, 0xE0, 0xF0,
  0x3C, 0x1E, 0xE0, 0xF0, 0x3C, 0x1E, 0xE0, 0xF0, 0x3C, 0x1C, 0xE0, 0xE0,
  0x3C, 0x3C, 0xE1, 0xE0, 0x3C, 0x38, 0xE1, 0xE0, 0x3C, 0x38, 0xE1, 0xE0,
  0x3C, 0x78, 0xE1, 0xE0, 0x38, 0x70, 0xE3, 0xC0, 0x38, 0xF0, 0xE3, 0xC0,
  0x38, 0xF0, 0xE3, 0xC0, 0x78, 0xE0, 0xE3, 0xC0, 0x79, 0xE0, 0xE7, 0x80,
  0x79, 0xC0, 0xE7, 0x80, 0x7B, 0xC0, 0xE7, 0x80, 0x7B, 0xC0, 0xE7, 0x80,
  0x7B, 0x80, 0xF7, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x77, 0x80, 0xFF, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00,
  0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00, 0x78, 0xF8,
  0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x01, 0xF0,
  0x3C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8,
  0x07, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0xF8, 0x00,
  0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x03, 0xE7,
  0x80, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3C, 0xF8,
  0x00, 0x0F, 0x0F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x1E,
  0x03, 0xC0, 0x07, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x0F, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x3E, 0x1E, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xFB,
  0x00, 0x00, 0x1C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x31, 0xF1, 0xE3, 0xC3, 0x87, 0x87, 0x0E, 0x1E,
  0x10, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF1, 0xF0, 0x3F, 0xFE, 0x78, 0x1F,
  0xFF, 0x9E, 0x0F, 0xE0, 0x77, 0x87, 0xE0, 0x05, 0xE1, 0xF0, 0x01, 0xF8,
  0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0xF1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0x8F, 0x80,
  0x01, 0xE3, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8F,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x3F,
  0x0F, 0x80, 0x0B, 0xC1, 0xF0, 0x0E, 0xF0, 0x7E, 0x0F, 0x3F, 0x8F, 0xFF,
  0x8F, 0xE3, 0xFF, 0xC3, 0xF8, 0x7F, 0xE0, 0x7E, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x0F, 0xC0, 0x0F, 0x0F, 0xFC, 0x03, 0xC7, 0xFF, 0x80, 0xF3, 0xFF,
  0xF0, 0x3D, 0xE0, 0xFE, 0x0F, 0x60, 0x0F, 0x87, 0xF0, 0x01, 0xE1, 0xF8,
  0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF1,
  0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x9F, 0x00,
  0x03, 0xE7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F,
  0x00, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xFE, 0x07, 0xF0, 0xF3, 0xFF, 0xF8,
  0x3C, 0x7F, 0xFC, 0x0F, 0x0F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xE0,
  0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x0D, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x10, 0xF0, 0x00, 0x1C, 0xF0, 0x00,
  0x3E, 0xF8, 0x00, 0x7C, 0x78, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x3F, 0x03,
  0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x07, 0xF0, 0x3C, 0x01, 0xFF, 0xC3, 0xC0, 0x3F,
  0xFE, 0x3C, 0x07, 0xFF, 0xF7, 0xC0, 0xFE, 0x07, 0x78, 0x1F, 0x80, 0x1F,
  0x81, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF8, 0x7C,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x1F, 0x0F,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x3E, 0x0F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC0,
  0x7C, 0x01, 0xBC, 0x07, 0xE0, 0x7B, 0xC0, 0x3F, 0xFF, 0x3C, 0x03, 0xFF,
  0xE3, 0xC0, 0x1F, 0xFC, 0x7C, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0x3F,
  0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F,
  0x7C, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0xFC,
  0xF8, 0x1F, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x08, 0xF0, 0x00, 0x1C,
  0xF8, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0xFC, 0x7F, 0x03, 0xF8,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xFC, 0x07, 0x80, 0x00, 0x0F,
  0xC0, 0xF0, 0x00, 0x00, 0xFC, 0x1E, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0x00, 0xFC, 0xF0, 0x00, 0x00, 0x0F, 0xDE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFC, 0x3C, 0x07, 0xFF,
  0xC7, 0x81, 0xFF, 0xFD, 0xF0, 0x7F, 0x03, 0xBC, 0x1F, 0x80, 0x1F, 0x83,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0xF8, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0xF8,
  0x00, 0x0F, 0x1F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x7C, 0x78, 0x00, 0x0F,
  0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x87, 0xC0,
  0x03, 0xF0, 0xF8, 0x00, 0xFE, 0x0F, 0x80, 0x37, 0x81, 0xF8, 0x1E, 0xF0,
  0x1F, 0xFF, 0x9E, 0x03, 0xFF, 0xE3, 0xC0, 0x3F, 0xF8, 0x78, 0x01, 0xFC,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x20, 0x00, 0xF8, 0x0E, 0x00, 0x3E, 0x03, 0xF0, 0x1F,
  0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x7E, 0x00, 0x78, 0xFF, 0xC0, 0x7C, 0xFF, 0xF0, 0x3E,
  0xFF, 0xFC, 0x1E, 0x70, 0x7E, 0x0F, 0x60, 0x1F, 0x07, 0xA0, 0x07, 0x83,
  0xE0, 0x03, 0xC3, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x78,
  0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1F, 0x00, 0x07,
  0x8F, 0x00, 0x07, 0xC7, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x78, 0x00, 0x3E, 0x3C, 0x00,
  0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC7, 0xC0,
  0x01, 0xE3, 0xC0, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x80, 0x0F, 0x00, 0xE0,
  0x07, 0x80, 0xF8, 0x07, 0x80, 0xFE, 0x03, 0xC0, 0xFC, 0x01, 0xE0, 0xFC,
  0x00, 0xF0, 0xFC, 0x00, 0x79, 0xF8, 0x00, 0x79, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x01, 0x00, 0x1E, 0x00, 0xC0, 0x1F, 0x00,
  0xF0, 0x0F, 0x00, 0xFC, 0x07, 0x80, 0x3F, 0x03, 0xC0, 0x0F, 0xC1, 0xE0,
  0x03, 0xF0, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x78, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC1, 0xF8, 0x00, 0x78, 0xFF, 0xC0, 0x1F, 0x3F, 0xFC, 0x03, 0xCF,
  0xFF, 0xC0, 0x79, 0xC1, 0xF8, 0x0F, 0x60, 0x0F, 0x01, 0xF8, 0x01, 0xE0,
  0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0x81, 0xF0, 0x00, 0xF0, 0x3E, 0x00,
  0x3E, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x03, 0xE0, 0x1E, 0x00, 0xF8, 0x07,
  0xC0, 0x7E, 0x00, 0xF0, 0xFF, 0x00, 0x1E, 0x3F, 0x80, 0x03, 0xC7, 0xC0,
  0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x80, 0x33, 0xE0, 0xF0, 0x0F, 0x78,
  0x1F, 0x03, 0xEF, 0x01, 0xE0, 0xF9, 0xE0, 0x3E, 0x7E, 0x3C, 0x03, 0xDF,
  0x87, 0x80, 0x7F, 0xE1, 0xF0, 0x0F, 0xF8, 0x3C, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x04, 0x07, 0x80, 0x38, 0x3C, 0x03,
  0xF0, 0xF0, 0x1F, 0x83, 0xC0, 0xFC, 0x0F, 0x07, 0xE0, 0x3C, 0x3E, 0x01,
  0xF3, 0xF0, 0x07, 0x9F, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x79, 0xFC, 0x3F, 0x83,
  0xDF, 0xE3, 0xFE, 0x1F, 0xFF, 0x3F, 0xF0, 0xEC, 0x7F, 0x8F, 0x8F, 0xC1,
  0xF8, 0x3C, 0x7C, 0x0F, 0x81, 0xE3, 0xC0, 0x7C, 0x0F, 0x1E, 0x03, 0xC0,
  0x78, 0xF0, 0x1E, 0x03, 0xC7, 0x00, 0xF0, 0x1C, 0x78, 0x07, 0x00, 0xE3,
  0xC0, 0x78, 0x0F, 0x1E, 0x03, 0xC0, 0x78, 0xF0, 0x1E, 0x03, 0xC7, 0x80,
  0xF0, 0x1E, 0x38, 0x07, 0x80, 0xE3, 0xC0, 0x78, 0x07, 0x1E, 0x03, 0xC0,
  0x78, 0xF0, 0x1E, 0x03, 0xC7, 0x80, 0xF0, 0x1E, 0x3C, 0x07, 0x80, 0xF1,
  0xC0, 0x38, 0x07, 0x1E, 0x03, 0xC0, 0x38, 0xF0, 0x1E, 0x03, 0xC7, 0x80,
  0xF0, 0x1E, 0x3C, 0x07, 0x80, 0xF1, 0xE0, 0x3C, 0x07, 0x80, 0x00, 0x03,
  0xF0, 0x03, 0xC7, 0xFE, 0x03, 0xE7, 0xFF, 0x81, 0xE7, 0xFF, 0xE0, 0xF3,
  0x83, 0xF0, 0x7B, 0x00, 0xF8, 0x3D, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x1F,
  0x80, 0x0F, 0x8F, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x78, 0x00, 0x3E,
  0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03,
  0xC7, 0xC0, 0x01, 0xE3, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x7E, 0x07, 0xF0, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0x3E,
  0x3C, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xDF, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xF3, 0xC0, 0x01, 0xF1, 0xF0,
  0x00, 0xF8, 0x78, 0x01, 0xF8, 0x3F, 0x03, 0xF8, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x3E, 0x3F, 0xF0, 0x03, 0xC7, 0xFF, 0x80, 0x3C, 0xFF, 0xFC, 0x03,
  0xDE, 0x0F, 0xE0, 0x3D, 0x80, 0x3E, 0x07, 0xF0, 0x01, 0xE0, 0x7E, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E,
  0x1F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x3F, 0xE0, 0x7F,
  0x03, 0xCF, 0xFF, 0xE0, 0x3C, 0x7F, 0xFC, 0x03, 0xC3, 0xFF, 0x80, 0x3C,
  0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF0, 0xF0, 0x3F, 0xFE, 0x3C,
  0x1F, 0xFF, 0xDF, 0x0F, 0xE0, 0x77, 0x87, 0xE0, 0x07, 0xE1, 0xF0, 0x00,
  0xF8, 0xF8, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xCF,
  0x80, 0x00, 0xF3, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07,
  0x8F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3E, 0x3E, 0x00,
  0x1F, 0x8F, 0x80, 0x0F, 0xC1, 0xF0, 0x06, 0xF0, 0x7E, 0x07, 0xBC, 0x0F,
  0xFF, 0xCF, 0x03, 0xFF, 0xE3, 0xC0, 0x7F, 0xF1, 0xF0, 0x07, 0xF0, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xF0, 0x1E, 0x70,
  0x00, 0x0F, 0x60, 0x00, 0x07, 0xA0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x7E,
  0x03, 0xF8, 0x7C, 0x00, 0x38, 0x3C, 0x00, 0x08, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE1, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x79, 0xF0, 0x00,
  0x7C, 0xFF, 0x01, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x04, 0x03, 0xC0, 0x0E, 0x03, 0xC0, 0x3E, 0x07, 0xC0, 0x7F, 0x07,
  0x81, 0xFC, 0x07, 0x83, 0xF8, 0x07, 0x8F, 0xE0, 0x07, 0x9F, 0xC0, 0x07,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x07, 0x8F, 0x00, 0x07, 0xC7, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x78, 0x00, 0x3E,
  0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03,
  0xC7, 0xC0, 0x03, 0xE3, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x8F, 0x80, 0x1F, 0x87, 0xC0, 0x0B, 0xC1, 0xF0, 0x1D, 0xE0, 0xFC,
  0x1C, 0xF0, 0x7F, 0xFC, 0xF8, 0x1F, 0xFE, 0x78, 0x07, 0xFE, 0x3C, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0x1F, 0xF8, 0x03, 0xE7, 0xFE, 0x00,
  0x79, 0xFF, 0x80, 0x1E, 0x7F, 0xC0, 0x07, 0xA0, 0xF0, 0x01, 0xF0, 0x3C,
  0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0xC0, 0xF0, 0x01, 0xF0,
  0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x03,
  0xE0, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0x3C, 0x07, 0x00, 0x1F, 0x03, 0xC0,
  0x07, 0x80, 0xF0, 0x03, 0xE0, 0x3C, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x03,
  0xC0, 0x7E, 0x00, 0xF0, 0x7F, 0x00, 0x78, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x60, 0xE0, 0x1C, 0x1E, 0x1E, 0x03, 0xC0, 0xE1, 0xE0, 0x3C, 0x0F,
  0x1E, 0x03, 0xC0, 0xF1, 0xE0, 0x3C, 0x0F, 0x1E, 0x03, 0x80, 0xF1, 0xC0,
  0x38, 0x0F, 0x3C, 0x07, 0x80, 0xF3, 0xC0, 0x78, 0x0F, 0x3C, 0x07, 0x80,
  0xF3, 0xC0, 0x78, 0x0F, 0x3C, 0x07, 0x00, 0xF3, 0x80, 0xF0, 0x0F, 0x78,
  0x0F, 0x00, 0xF7, 0x80, 0xF0, 0x0E, 0x78, 0x0F, 0x01, 0xE7, 0x80, 0xF0,
  0x1E, 0x78, 0x0E, 0x01, 0xE7, 0x01, 0xE0, 0x3C, 0x70, 0x1E, 0x03, 0xCF,
  0x01, 0xE0, 0x7C, 0xF0, 0x3E, 0x07, 0x8F, 0x07, 0xE0, 0xF8, 0xF8, 0xEF,
  0x1F, 0x0F, 0xFE, 0xFF, 0xE0, 0x7F, 0xCF, 0xFE, 0x07, 0xF8, 0x7F, 0x80,
  0x1F, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x01, 0xF8, 0x00, 0xFE, 0x07, 0xF8,
  0x03, 0xFC, 0x1F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0x7E, 0x79, 0xE1, 0xE1,
  0xF8, 0xF3, 0x83, 0xCF, 0xC0, 0xEE, 0x07, 0x8F, 0x01, 0xDC, 0x0F, 0x18,
  0x03, 0xB0, 0x1E, 0x00, 0x07, 0x60, 0x3C, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x1F, 0x00, 0x07, 0x80, 0x6E, 0x01, 0x0F, 0x00, 0xDC,
  0x03, 0x1E, 0x03, 0xB8, 0x0F, 0x3C, 0x06, 0x70, 0x7E, 0x7C, 0x1C, 0xE1,
  0xF0, 0x78, 0x79, 0xEF, 0xC0, 0xFF, 0xE3, 0xFF, 0x01, 0xFF, 0x87, 0xFC,
  0x01, 0xFE, 0x07, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0xF0, 0x3C, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03,
  0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x3E, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0,
  0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x7C, 0x0F, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF8,
  0x1F, 0x00, 0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x0F, 0x00, 0x2F, 0x00, 0xF8,
  0x06, 0xF0, 0x0F, 0xC1, 0xCF, 0x00, 0xFF, 0xFC, 0xF0, 0x07, 0xFF, 0x9F,
  0x00, 0x3F, 0xF1, 0xE0, 0x00, 0xFC, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x01, 0x00, 0x07,
  0xC0, 0x38, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x7C, 0x3F, 0xFF, 0x0F, 0x07, 0xFF, 0xF9, 0xE1,
  0xF0, 0x7F, 0xFC, 0x3C, 0x01, 0xFF, 0x87, 0x00, 0x07, 0xE1, 0xE0, 0x01,
  0xF0, 0x3C, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xC0, 0x0F,
  0x80, 0x38, 0x03, 0xE0, 0x07, 0x80, 0xF8, 0x00, 0xF0, 0x3E, 0x00, 0x1E,
  0x0F, 0xE0, 0x01, 0xE7, 0xFF, 0xE0, 0x3C, 0xF7, 0xFF, 0xC7, 0x9E, 0x1F,
  0xFF, 0xF3, 0xC0, 0x7F, 0xFC, 0x78, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x60, 0x3F, 0x80, 0x0F, 0x07, 0xFC, 0x00, 0xF0, 0xFF, 0xE0,
  0x0E, 0x1F, 0x1F, 0x01, 0xE1, 0xE0, 0xF0, 0x1C, 0x3C, 0x0F, 0x83, 0xC3,
  0x80, 0x7C, 0x78, 0x78, 0x03, 0xFF, 0x87, 0x80, 0x3F, 0xF0, 0x70, 0x01,
  0xFE, 0x0B, 0x00, 0x07, 0x80,
};

const GFXglyph IBMPlexMono_Italic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 12, 37, 32, 10, -37 },
  { 57, 16, 15, 32, 11, -39 },
  { 87, 32, 37, 32, 1, -37 },
  { 235, 30, 49, 32, 1, -43 },
  { 419, 36, 39, 32, -1, -38 },
  { 595, 31, 39, 32, 0, -38 },
  { 747, 6, 15, 32, 16, -39 },
  { 759, 20, 47, 32, 11, -40 },
  { 877, 20, 47, 32, 2, -40 },
  { 995, 27, 26, 32, 3, -29 },
  { 1083, 25, 26, 32, 4, -29 },
  { 1165, 12, 14, 32, 7, -7 },
  { 1186, 16, 4, 32, 8, -18 },
  { 1194, 8, 7, 32, 10, -7 },
  { 1201, 30, 47, 32, 1, -40 },
  { 1378, 27, 39, 32, 3, -38 },
  { 1510, 26, 37, 32, 2, -37 },
  { 1631, 27, 38, 32, 2, -38 },
  { 1760, 28, 39, 32, 1, -38 },
  { 1897, 28, 37, 32, 1, -37 },
  { 2027, 27, 38, 32, 3, -37 },
  { 2156, 25, 38, 32, 3, -37 },
  { 2275, 26, 37, 32, 6, -37 },
  { 2396, 28, 39, 32, 2, -38 },
  { 2533, 25, 38, 32, 5, -38 },
  { 2652, 12, 28, 32, 10, -28 },
  { 2694, 15, 35, 32, 7, -28 },
  { 2760, 25, 30, 32, 5, -31 },
  { 2854, 27, 15, 32, 3, -24 },
  { 2905, 25, 30, 32, 3, -31 },
  { 2999, 22, 38, 32, 7, -38 },
  { 3104, 27, 44, 32, 3, -38 },
  { 3253, 28, 37, 32, 0, -37 },
  { 3383, 27, 37, 32, 2, -37 },
  { 3508, 27, 39, 32, 4, -38 },
  { 3640, 27, 37, 32, 3, -37 },
  { 3765, 29, 37, 32, 2, -37 },
  { 3900, 30, 37, 32, 2, -37 },
  { 4039, 27, 39, 32, 3, -38 },
  { 4171, 29, 37, 32, 2, -37 },
  { 4306, 29, 37, 32, 2, -37 },
  { 4441, 26, 38, 32, 3, -37 },
  { 4565, 32, 37, 32, 2, -37 },
  { 4713, 23, 37, 32, 4, -37 },
  { 4820, 31, 37, 32, 1, -37 },
  { 4964, 29, 37, 32, 2, -37 },
  { 5099, 27, 39, 32, 3, -38 },
  { 5231, 29, 37, 32, 2, -37 },
  { 5366, 27, 48, 32, 3, -38 },
  { 5528, 29, 37, 32, 2, -37 },
  { 5663, 30, 39, 32, 1, -38 },
  { 5810, 29, 37, 32, 5, -37 },
  { 5945, 27, 38, 32, 4, -37 },
  { 6074, 28, 37, 32, 6, -37 },
  { 6204, 32, 37, 32, 2, -37 },
  { 6352, 35, 37, 32, -1, -37 },
  { 6514, 30, 37, 32, 5, -37 },
  { 6653, 32, 37, 32, 0, -37 },
  { 6801, 23, 47, 32, 8, -40 },
  { 6937, 13, 47, 32, 10, -40 },
  { 7014, 22, 47, 32, 1, -40 },
  { 7144, 27, 21, 32, 3, -37 },
  { 7215, 26, 4, 32, 0, 5 },
  { 7228, 7, 10, 32, 12, -41 },
  { 7237, 26, 29, 32, 3, -28 },
  { 7332, 26, 40, 32, 3, -39 },
  { 7462, 24, 29, 32, 4, -28 },
  { 7549, 28, 40, 32, 3, -39 },
  { 7689, 24, 29, 32, 4, -28 },
  { 7776, 35, 50, 32, -1, -39 },
  { 7995, 27, 39, 32, 2, -28 },
  { 8127, 25, 39, 32, 3, -39 },
  { 8249, 25, 40, 32, 4, -39 },
  { 8374, 25, 50, 32, 3, -39 },
  { 8531, 27, 40, 32, 3, -39 },
  { 8666, 22, 40, 32, 6, -39 },
  { 8776, 29, 28, 32, 1, -28 },
  { 8878, 25, 28, 32, 3, -28 },
  { 8966, 25, 29, 32, 3, -28 },
  { 9057, 28, 39, 32, 1, -28 },
  { 9194, 26, 39, 32, 3, -28 },
  { 9321, 25, 27, 32, 6, -27 },
  { 9406, 25, 29, 32, 3, -28 },
  { 9497, 24, 38, 32, 4, -37 },
  { 9611, 25, 28, 32, 4, -27 },
  { 9699, 26, 28, 32, 3, -28 },
  { 9790, 28, 29, 32, 2, -28 },
  { 9892, 31, 29, 32, 0, -28 },
  { 10005, 28, 38, 32, 1, -27 },
  { 10138, 27, 29, 32, 3, -28 },
  { 10236, 25, 47, 32, 6, -40 },
  { 10383, 11, 47, 32, 11, -40 },
  { 10448, 25, 47, 32, 2, -40 },
  { 10595, 28, 12, 32, 2, -22 },
};

const GFXfont IBMPlexMono_Italic53pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic53pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic53pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _IBMPLEXMONO_ITALIC53PT7B_H_
