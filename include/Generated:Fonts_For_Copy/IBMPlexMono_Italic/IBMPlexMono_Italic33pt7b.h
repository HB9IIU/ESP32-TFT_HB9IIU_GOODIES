#ifndef _IBMPLEXMONO_ITALIC33PT7B_H_
#define _IBMPLEXMONO_ITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C,
  0x18, 0x18, 0x18, 0x18, 0x10, 0x00, 0x00, 0x00, 0x78, 0x78, 0xF8, 0x70,
  0x71, 0xDC, 0x67, 0x19, 0x86, 0x63, 0x98, 0xEE, 0x3B, 0x8C, 0xE3, 0x00,
  0x00, 0x38, 0xE0, 0x03, 0x0C, 0x00, 0x71, 0xC0, 0x06, 0x18, 0x00, 0x61,
  0x80, 0x0E, 0x38, 0x00, 0xC3, 0x01, 0xFC, 0x3F, 0x1F, 0xC7, 0xF0, 0x18,
  0x60, 0x03, 0x86, 0x00, 0x38, 0xE0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x7F,
  0x1F, 0xCF, 0xE1, 0xFC, 0x0E, 0x18, 0x00, 0xE3, 0x80, 0x0C, 0x30, 0x01,
  0xC7, 0x00, 0x1C, 0x70, 0x01, 0x86, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xCD, 0xF1,
  0xC3, 0x1C, 0x70, 0x82, 0x38, 0x60, 0x0E, 0x18, 0x03, 0x86, 0x00, 0x71,
  0x80, 0x1E, 0x60, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0xC7,
  0x00, 0x31, 0xC0, 0x0C, 0x38, 0x06, 0x0E, 0x01, 0x83, 0x10, 0x61, 0xCE,
  0x18, 0xF1, 0xE6, 0x78, 0x3F, 0xFC, 0x03, 0xF8, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x0E, 0x0F, 0xE0, 0x38, 0x38, 0xE0,
  0x60, 0x60, 0xC1, 0x81, 0xC1, 0x87, 0x03, 0x03, 0x1C, 0x06, 0x06, 0x30,
  0x0C, 0x1C, 0xC0, 0x1C, 0x73, 0x80, 0x1F, 0xC6, 0x00, 0x1F, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x31, 0xFC, 0x00, 0xE7, 0x18, 0x03,
  0x9C, 0x18, 0x06, 0x30, 0x30, 0x18, 0x60, 0xE0, 0x70, 0xC1, 0xC0, 0xC1,
  0x83, 0x03, 0x03, 0x0E, 0x0E, 0x03, 0xF8, 0x38, 0x03, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0xC0, 0x0E, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x30, 0x0C,
  0x06, 0x01, 0x80, 0xC0, 0x38, 0x18, 0x07, 0x07, 0x00, 0x61, 0xC0, 0x1E,
  0x70, 0x0F, 0xF8, 0x03, 0x1C, 0x00, 0xE1, 0xC0, 0x38, 0x38, 0x07, 0x03,
  0x80, 0xE0, 0x70, 0x1C, 0x07, 0x0F, 0x81, 0x61, 0xF0, 0x2E, 0x67, 0x0C,
  0xDC, 0x7F, 0x1F, 0x07, 0xC1, 0xC0, 0x77, 0x66, 0x6E, 0xEE, 0xC0, 0x00,
  0x70, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x02, 0x0E, 0x0B, 0xE7, 0x7C,
  0xFF, 0xFD, 0x0F, 0xF0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xDC, 0x01, 0xC6,
  0x01, 0xC3, 0x81, 0xC0, 0xE0, 0x40, 0x20, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x1E, 0x78, 0xF1, 0xC7, 0x0E, 0x38, 0x70, 0xC0, 0x7F,
  0xFF, 0xF0, 0x7B, 0xFE, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xC3, 0xC3,
  0x80, 0xE1, 0x80, 0x31, 0xC0, 0x1C, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03,
  0xB8, 0xE1, 0xF8, 0xF8, 0xFC, 0x78, 0x7E, 0x1C, 0x77, 0x00, 0x3B, 0x80,
  0x1D, 0xC0, 0x0E, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x07, 0x0C, 0x03, 0x07,
  0x87, 0x81, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF8,
  0x07, 0xB8, 0x0E, 0x38, 0x3C, 0x38, 0x18, 0x30, 0x10, 0x30, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xC1, 0xC3, 0xC0,
  0x71, 0xC0, 0x38, 0x40, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0xFF, 0xFB, 0xFF, 0xF8, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xC1, 0xC3,
  0xC0, 0x70, 0x40, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x90, 0x03, 0x9C, 0x03, 0xC7,
  0x03, 0xC1, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x1C, 0xE0, 0x0E, 0x30, 0x03, 0x0C,
  0x01, 0xC3, 0x00, 0xE1, 0xC0, 0x70, 0x70, 0x38, 0x1C, 0x1C, 0x06, 0x06,
  0x01, 0x83, 0x80, 0xE1, 0xC0, 0x38, 0x7F, 0xFF, 0xDF, 0xFF, 0xF8, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x0F, 0xFF,
  0x87, 0xFF, 0xC3, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0xF8, 0x0D, 0xFF, 0x07, 0x83, 0xC7,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x10, 0x03, 0x9C, 0x03, 0x8F, 0x07, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0x00,
  0x3E, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x39, 0xF0, 0x77, 0xFC, 0x7C, 0x1E, 0x78,
  0x0E, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0xE0,
  0x0E, 0x60, 0x1C, 0x70, 0x78, 0x3F, 0xF0, 0x0F, 0xC0, 0x7F, 0xFF, 0xBF,
  0xFF, 0xD8, 0x01, 0xCC, 0x00, 0xE6, 0x00, 0xE3, 0x00, 0x72, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0xC0, 0x70, 0x78, 0x38, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71,
  0xC0, 0x1C, 0x70, 0x0E, 0x1C, 0x03, 0x83, 0x83, 0x80, 0x7F, 0xC0, 0x1F,
  0xF0, 0x1C, 0x0E, 0x0E, 0x01, 0xC7, 0x00, 0x31, 0xC0, 0x0E, 0xE0, 0x03,
  0xB8, 0x00, 0xCE, 0x00, 0x71, 0xC0, 0x3C, 0x78, 0x1E, 0x0F, 0xFF, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xF8, 0x3C, 0x1C, 0x70, 0x0E, 0x70, 0x06,
  0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1E,
  0x70, 0x6E, 0x7F, 0xDC, 0x1F, 0x9C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x1E, 0x3C, 0x78, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x1E, 0x7C, 0x70, 0x0F, 0x0F, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x3C, 0x38, 0x70, 0x70, 0xE0, 0xE0,
  0xC0, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x08, 0x7F, 0xFF, 0xBF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFD, 0xFF, 0xFC, 0x10, 0x00, 0x30, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x00, 0xF0, 0x01, 0x80, 0x02, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0xE3,
  0x83, 0x9C, 0x07, 0xE0, 0x1C, 0x80, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x0F, 0x81, 0xFC, 0x0F, 0xC0, 0x38, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x3E, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0x83, 0x83, 0x80, 0xE1, 0x80, 0x31,
  0xC0, 0x1C, 0xC0, 0x0E, 0xE0, 0xF6, 0x71, 0xFB, 0x30, 0xE3, 0x98, 0xE0,
  0xCC, 0x60, 0x6E, 0x70, 0x77, 0x38, 0x33, 0x9C, 0x19, 0x8E, 0x0C, 0xC7,
  0x0E, 0x63, 0x8F, 0x30, 0xFF, 0x98, 0x7D, 0x8C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0D, 0xC0, 0x0E, 0xE0, 0x07, 0x70,
  0x07, 0x18, 0x03, 0x8C, 0x01, 0x86, 0x01, 0xC3, 0x80, 0xC1, 0xC0, 0xE0,
  0xE0, 0x60, 0x70, 0x70, 0x38, 0x3F, 0xFC, 0x3F, 0xFE, 0x18, 0x03, 0x9C,
  0x01, 0xCE, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x06,
  0x1F, 0xFC, 0x1F, 0xFE, 0x1C, 0x0F, 0x18, 0x07, 0x18, 0x03, 0x38, 0x07,
  0x38, 0x07, 0x38, 0x07, 0x38, 0x06, 0x30, 0x1E, 0x3F, 0xF8, 0x7F, 0xF8,
  0x70, 0x1E, 0x70, 0x0E, 0x70, 0x06, 0x60, 0x07, 0x60, 0x06, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0C, 0xE0, 0x3C, 0xFF, 0xF8, 0xFF, 0xE0, 0x01, 0xF8,
  0x07, 0xFE, 0x0E, 0x0E, 0x1C, 0x07, 0x38, 0x07, 0x30, 0x04, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x08, 0xC0, 0x0E, 0xE0, 0x1C,
  0xE0, 0x38, 0x70, 0x78, 0x3F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFE,
  0x07, 0x07, 0x83, 0x80, 0xE1, 0xC0, 0x70, 0xC0, 0x18, 0x60, 0x0E, 0x70,
  0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE6, 0x00, 0x63, 0x00, 0x73,
  0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x0E, 0x38, 0x07, 0x18, 0x07,
  0x1C, 0x03, 0x8E, 0x07, 0x87, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xFF, 0xC7,
  0xFF, 0xE1, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xE1, 0xFF, 0xF8,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0xFF, 0xE1, 0xFF, 0xF8, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x03, 0xC3, 0xC3,
  0x80, 0xE1, 0xC0, 0x39, 0xC0, 0x10, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x0F, 0xF7, 0x07, 0xF3, 0x80,
  0x19, 0xC0, 0x0C, 0xE0, 0x0E, 0x70, 0x07, 0x18, 0x07, 0x8E, 0x03, 0x87,
  0x86, 0xC1, 0xFE, 0x60, 0x3E, 0x70, 0x0E, 0x00, 0xE1, 0xC0, 0x18, 0x30,
  0x07, 0x06, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x60, 0xE0,
  0x0C, 0x18, 0x03, 0x83, 0x00, 0x70, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0x80,
  0x30, 0x70, 0x0E, 0x0C, 0x01, 0xC1, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00,
  0xE1, 0xC0, 0x18, 0x38, 0x03, 0x06, 0x00, 0xE0, 0xC0, 0x1C, 0x38, 0x03,
  0x80, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x1F, 0xFF, 0x8F, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x18, 0x20, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0x70, 0xF0, 0x7F,
  0xE0, 0x1F, 0x80, 0x0E, 0x00, 0xF0, 0xE0, 0x1E, 0x0E, 0x03, 0xC0, 0xC0,
  0x78, 0x0C, 0x0F, 0x01, 0xC1, 0xE0, 0x1C, 0x3C, 0x01, 0xC7, 0x80, 0x1C,
  0xF0, 0x01, 0x9E, 0x00, 0x3B, 0xE0, 0x03, 0xBE, 0x00, 0x3F, 0x70, 0x03,
  0xE7, 0x00, 0x3C, 0x38, 0x03, 0x83, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x0C, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x06, 0x00, 0x70, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x01, 0xE3, 0xC0, 0x3C, 0x7C,
  0x0F, 0x8F, 0x83, 0xE1, 0xB0, 0x6C, 0x36, 0x1D, 0x86, 0xE3, 0x71, 0xCC,
  0xEE, 0x39, 0x99, 0xC7, 0x36, 0x30, 0xC7, 0xC6, 0x18, 0x70, 0xC3, 0x0E,
  0x38, 0xE1, 0x87, 0x1C, 0x30, 0xE3, 0x84, 0x18, 0x60, 0x03, 0x0C, 0x00,
  0x61, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0C, 0x30, 0x01,
  0x80, 0x0F, 0x00, 0xE1, 0xE0, 0x18, 0x3E, 0x03, 0x07, 0xC0, 0xE1, 0xD8,
  0x1C, 0x3B, 0x03, 0x87, 0x70, 0x60, 0xCE, 0x0C, 0x18, 0xC1, 0x83, 0x18,
  0x70, 0xE3, 0x0E, 0x1C, 0x71, 0xC3, 0x8E, 0x30, 0x60, 0xC6, 0x0C, 0x18,
  0xC1, 0x83, 0xB8, 0x70, 0x77, 0x0E, 0x06, 0xE1, 0xC0, 0xD8, 0x30, 0x1B,
  0x06, 0x03, 0xE0, 0xC0, 0x7C, 0x38, 0x07, 0x80, 0x01, 0xF8, 0x03, 0xFF,
  0x03, 0xC3, 0xC3, 0x80, 0xE1, 0x80, 0x31, 0xC0, 0x1C, 0xC0, 0x0E, 0xE0,
  0x07, 0x70, 0x03, 0xB8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x77,
  0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x07,
  0x0E, 0x03, 0x07, 0x87, 0x81, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x0F,
  0xFF, 0x87, 0x01, 0xE3, 0x00, 0x71, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0E,
  0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0x8C, 0x03, 0xCF, 0xFF, 0xC7, 0xFF,
  0x83, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0x01, 0xF8,
  0x03, 0xFF, 0x03, 0xC3, 0xC3, 0x80, 0xE1, 0x80, 0x31, 0xC0, 0x1C, 0xC0,
  0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x0E, 0x70, 0x07,
  0x38, 0x07, 0x0E, 0x03, 0x87, 0x87, 0x81, 0xFF, 0x80, 0x3F, 0x00, 0x07,
  0x00, 0x01, 0x82, 0x00, 0xE3, 0x80, 0x3B, 0x80, 0x1F, 0x00, 0x07, 0x00,
  0x1F, 0xFC, 0x0F, 0xFF, 0x87, 0x01, 0xE3, 0x00, 0x71, 0x80, 0x39, 0xC0,
  0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0x8C, 0x03, 0xCF,
  0xFF, 0xC7, 0xFF, 0x03, 0x87, 0x01, 0xC3, 0x80, 0xE0, 0xC0, 0x60, 0x70,
  0x70, 0x38, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x01, 0x87, 0x00, 0xE3, 0x00,
  0x78, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xF0, 0x7C, 0x70, 0x07, 0x1C, 0x00,
  0x8E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xC4, 0x00, 0x73, 0x80, 0x3C, 0x78, 0x1E,
  0x0F, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC7,
  0x00, 0x61, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80,
  0x30, 0xE0, 0x0C, 0x30, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C,
  0x70, 0x06, 0x1C, 0x01, 0x86, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38,
  0x03, 0x0E, 0x01, 0xC1, 0x80, 0x70, 0x70, 0x78, 0x0F, 0xFC, 0x00, 0xFC,
  0x00, 0xC0, 0x03, 0xE0, 0x03, 0xB0, 0x01, 0xDC, 0x00, 0xCE, 0x00, 0xE7,
  0x00, 0x63, 0x80, 0x70, 0xC0, 0x38, 0x60, 0x38, 0x30, 0x1C, 0x1C, 0x1C,
  0x0E, 0x0E, 0x07, 0x0E, 0x03, 0x87, 0x00, 0xC3, 0x00, 0x63, 0x80, 0x31,
  0x80, 0x19, 0xC0, 0x0E, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0x38, 0x00, 0x67,
  0x00, 0x1C, 0xC0, 0x03, 0x98, 0x78, 0x63, 0x0F, 0x0C, 0x61, 0xE3, 0x8C,
  0x7C, 0x71, 0x8D, 0x8C, 0x31, 0xB1, 0x8E, 0x66, 0x31, 0xCC, 0xCE, 0x3B,
  0x99, 0x87, 0x63, 0x30, 0xCC, 0x66, 0x1B, 0x8D, 0xC3, 0x61, 0xB0, 0x6C,
  0x36, 0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x1F, 0x00, 0x07, 0x00, 0x1C,
  0x1C, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x01, 0xC1, 0xE0, 0x07,
  0x07, 0x00, 0x0E, 0x38, 0x00, 0x39, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x1C, 0xE0, 0x00, 0x73, 0x80, 0x03, 0x87, 0x00, 0x1C, 0x1C, 0x00, 0xE0,
  0x30, 0x07, 0x00, 0xE0, 0x3C, 0x01, 0x80, 0xE0, 0x07, 0x0F, 0x00, 0x1E,
  0x00, 0xE0, 0x01, 0xEC, 0x00, 0x79, 0xC0, 0x0E, 0x38, 0x03, 0x83, 0x80,
  0xE0, 0x70, 0x38, 0x06, 0x07, 0x00, 0xE1, 0xC0, 0x1C, 0x70, 0x01, 0xDC,
  0x00, 0x3B, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0xFF,
  0xFF, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x60, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xC0,
  0x60, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x30,
  0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x7F, 0xC3,
  0xFF, 0x00, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x73, 0x00, 0x31,
  0xC0, 0x38, 0x60, 0x38, 0x38, 0x18, 0x1C, 0x1C, 0x06, 0x1C, 0x03, 0x9C,
  0x00, 0xCC, 0x00, 0x6E, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xCE, 0xE6,
  0x63, 0x07, 0xC7, 0x1F, 0xF7, 0x3C, 0x16, 0x38, 0x0E, 0x70, 0x0E, 0x60,
  0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0C, 0xE0, 0x0C, 0xC0, 0x1C, 0xC0,
  0x1C, 0xE0, 0x3C, 0xE0, 0x7C, 0x70, 0xD8, 0x7F, 0x9F, 0x1F, 0x0E, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0xF8, 0x39, 0xFE, 0x3B, 0x0E, 0x3C, 0x07, 0x38, 0x07, 0x38,
  0x07, 0x30, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0x60, 0x06, 0x60,
  0x0E, 0xE0, 0x0E, 0xF0, 0x1C, 0xF8, 0x38, 0xEF, 0xF0, 0xC7, 0xE0, 0x03,
  0xF0, 0x1F, 0xF8, 0x78, 0x79, 0xC0, 0x73, 0x80, 0x4E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x66, 0x00, 0xEE,
  0x03, 0x8E, 0x1E, 0x1F, 0xF8, 0x0F, 0xC0, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x0F, 0xCE,
  0x1F, 0xF7, 0x1E, 0x0F, 0x8E, 0x03, 0xCE, 0x00, 0xC6, 0x00, 0x67, 0x00,
  0x73, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x60, 0x06, 0x30, 0x07, 0x1C,
  0x03, 0x8E, 0x03, 0xC3, 0x86, 0xE1, 0xFE, 0x60, 0x3E, 0x30, 0x01, 0xF8,
  0x07, 0xFC, 0x1E, 0x0E, 0x38, 0x06, 0x30, 0x07, 0x70, 0x06, 0x70, 0x0E,
  0x60, 0x7C, 0xFF, 0xF8, 0xFF, 0x80, 0xE0, 0x00, 0xE0, 0x08, 0x60, 0x0E,
  0x70, 0x1C, 0x78, 0x38, 0x3F, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x60, 0x60, 0x03, 0xC3, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x38,
  0x00, 0x0E, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xE3,
  0x83, 0xFD, 0xC3, 0x83, 0xE3, 0x80, 0xE3, 0x80, 0x31, 0x80, 0x19, 0xC0,
  0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x1C, 0x01, 0x8E, 0x01, 0xC7,
  0x00, 0xE3, 0x80, 0xF0, 0xE1, 0xB8, 0x7F, 0x98, 0x0F, 0x8C, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x84, 0x03, 0x87, 0x03, 0x81, 0xFF, 0x80, 0x7F,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0C, 0x7C, 0x19, 0xFC, 0x76, 0x3C, 0xF0, 0x39, 0xE0, 0x73,
  0x80, 0xE6, 0x01, 0xCC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x19, 0x80,
  0x33, 0x00, 0xE6, 0x01, 0xDC, 0x03, 0xB8, 0x06, 0x70, 0x0C, 0x01, 0xC0,
  0x07, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x08, 0x1C, 0x1C, 0x38, 0x70, 0x61, 0xC0,
  0xCF, 0x03, 0xBC, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xF8,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x38, 0x20, 0x70, 0xE0, 0xE0, 0xE1, 0xC0, 0xE3, 0x01, 0xC6, 0x01,
  0xCC, 0x01, 0xF8, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x31, 0xF0, 0x19,
  0xFC, 0x1D, 0x8F, 0x0F, 0x03, 0x87, 0x81, 0xC3, 0x80, 0xE1, 0x80, 0x60,
  0xC0, 0x60, 0xE0, 0xE0, 0x73, 0xC0, 0x3B, 0xC0, 0x18, 0xE0, 0x4C, 0x30,
  0x76, 0x1C, 0x77, 0x06, 0x73, 0x83, 0xF1, 0xC0, 0xE0, 0xFF, 0x87, 0xF8,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18,
  0x11, 0xC0, 0xCE, 0x1C, 0x71, 0xC3, 0x9C, 0x19, 0xC0, 0xFC, 0x03, 0x80,
  0x1D, 0xE3, 0xC3, 0x7C, 0xF8, 0x69, 0xF3, 0x8E, 0x3C, 0x73, 0x87, 0x0E,
  0x70, 0xE1, 0xCE, 0x18, 0x31, 0x83, 0x06, 0x30, 0x60, 0xC6, 0x0C, 0x39,
  0xC3, 0x87, 0x38, 0x70, 0xC7, 0x0C, 0x18, 0xC1, 0x83, 0x18, 0x30, 0x63,
  0x06, 0x1C, 0xE1, 0xC3, 0x80, 0x18, 0xF8, 0x33, 0xF8, 0xEC, 0x79, 0xE0,
  0x73, 0xC0, 0xE7, 0x01, 0xCC, 0x03, 0x98, 0x07, 0x70, 0x0E, 0xE0, 0x1D,
  0xC0, 0x33, 0x00, 0x66, 0x01, 0xCC, 0x03, 0xB8, 0x07, 0x70, 0x0C, 0xE0,
  0x18, 0x03, 0xF0, 0x0F, 0xFC, 0x1C, 0x1E, 0x38, 0x0E, 0x70, 0x06, 0x70,
  0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0C, 0x60, 0x1C, 0x78, 0x78, 0x3F, 0xF0, 0x0F, 0xC0, 0x1C,
  0x7C, 0x0E, 0x7F, 0x87, 0x61, 0xC3, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x1C,
  0xE0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCC, 0x00, 0xC6, 0x00,
  0xE3, 0x00, 0x73, 0xC0, 0x71, 0xF0, 0x70, 0xEF, 0xF0, 0x63, 0xF0, 0x30,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x07, 0xE7, 0x1F, 0xF7, 0x3C, 0x1F, 0x38, 0x0E, 0x70, 0x06,
  0x60, 0x06, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xC0, 0x0C,
  0xC0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0x70, 0xDC, 0x7F, 0x9C, 0x1F, 0x18,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x30, 0xFE, 0x3F, 0xFC, 0xFC, 0x3B, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03, 0xF8,
  0x0F, 0xFE, 0x1C, 0x0F, 0x38, 0x04, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1F, 0x80, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0xC0, 0x1C, 0xF0, 0x38, 0x7F, 0xF0, 0x1F, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x08, 0x70, 0x71, 0x87, 0x8E, 0x3C, 0x3B, 0xC0, 0x7E, 0x01, 0xE0,
  0x00, 0x30, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x66, 0x00, 0xCC, 0x03,
  0x98, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x33, 0x00, 0xE6, 0x01, 0xCC,
  0x07, 0x9C, 0x17, 0x38, 0x6E, 0x3F, 0x98, 0x3E, 0x70, 0xFE, 0x06, 0xFC,
  0x0E, 0x0C, 0x07, 0x0C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C,
  0x07, 0x18, 0x06, 0x18, 0x0E, 0x18, 0x0C, 0x38, 0x1C, 0x38, 0x38, 0x38,
  0x70, 0x31, 0xE0, 0x3F, 0xC0, 0x1F, 0x00, 0x38, 0x71, 0x8E, 0x18, 0x63,
  0x06, 0x1C, 0xC1, 0x87, 0x30, 0x61, 0xCC, 0x38, 0x77, 0x0E, 0x1D, 0xC3,
  0x07, 0x60, 0xC1, 0x98, 0x30, 0x66, 0x0C, 0x19, 0x87, 0x0E, 0xE1, 0xC3,
  0x38, 0xB1, 0xCE, 0x2C, 0xE1, 0xF3, 0xF0, 0x38, 0x78, 0x00, 0x03, 0xC3,
  0xC0, 0xFC, 0x7E, 0x1E, 0xEC, 0x63, 0x8E, 0x87, 0x70, 0x78, 0x70, 0x07,
  0x06, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x0E, 0x0E, 0x00, 0xE1, 0xE0, 0xCE, 0x16, 0x3C, 0xE3, 0x77, 0x87,
  0xE3, 0xE0, 0x3C, 0x3C, 0x00, 0x0C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3,
  0x80, 0x61, 0xC0, 0x30, 0xC0, 0x38, 0x60, 0x1C, 0x70, 0x0E, 0x38, 0x07,
  0x1C, 0x03, 0x0E, 0x03, 0x86, 0x01, 0xC3, 0x01, 0xE1, 0xC1, 0x70, 0xF1,
  0xB8, 0x3F, 0x98, 0x0F, 0x8C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x04,
  0x03, 0x87, 0x03, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0x0F, 0xC3, 0x1F, 0xF3,
  0x38, 0x7F, 0x30, 0x1E, 0x70, 0x1C, 0x70, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x0C, 0x1C, 0x0E, 0x38, 0x06, 0x7C, 0x06,
  0xFF, 0xE6, 0xE7, 0xFE, 0xC0, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x3F, 0x80, 0x7F, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0x0E, 0x1C, 0x30, 0x60, 0xC1, 0x87, 0x0E, 0x18, 0x30,
  0x60, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x18, 0x30,
  0xE1, 0xC3, 0x06, 0x0C, 0x18, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xFF,
  0x00, 0xFF, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0x1E, 0x01, 0x1F, 0x81, 0xDC, 0xE0,
  0xCC, 0x30, 0xEE, 0x0C, 0xE6, 0x07, 0xE3, 0x01, 0xE0,
};

const GFXglyph IBMPlexMono_Italic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 8, 23, 20, 6, -23 },
  { 24, 10, 9, 20, 7, -24 },
  { 36, 20, 23, 20, 0, -23 },
  { 94, 18, 29, 20, 1, -26 },
  { 160, 23, 23, 20, -1, -23 },
  { 227, 19, 23, 20, 0, -23 },
  { 282, 4, 9, 20, 10, -24 },
  { 287, 12, 30, 20, 7, -25 },
  { 332, 13, 30, 20, 1, -25 },
  { 381, 17, 16, 20, 2, -18 },
  { 415, 16, 16, 20, 2, -18 },
  { 447, 7, 9, 20, 5, -4 },
  { 455, 10, 2, 20, 5, -11 },
  { 458, 5, 4, 20, 6, -4 },
  { 461, 19, 30, 20, 1, -25 },
  { 533, 17, 23, 20, 2, -23 },
  { 582, 16, 23, 20, 1, -23 },
  { 628, 17, 23, 20, 1, -23 },
  { 677, 17, 23, 20, 1, -23 },
  { 726, 18, 23, 20, 0, -23 },
  { 778, 17, 23, 20, 2, -23 },
  { 827, 16, 23, 20, 2, -23 },
  { 873, 17, 23, 20, 3, -23 },
  { 922, 18, 23, 20, 1, -23 },
  { 974, 16, 23, 20, 3, -23 },
  { 1020, 7, 17, 20, 6, -17 },
  { 1035, 8, 22, 20, 5, -17 },
  { 1057, 16, 19, 20, 3, -20 },
  { 1095, 17, 8, 20, 2, -14 },
  { 1112, 15, 19, 20, 2, -20 },
  { 1148, 14, 23, 20, 4, -23 },
  { 1189, 17, 27, 20, 2, -23 },
  { 1247, 17, 23, 20, 0, -23 },
  { 1296, 16, 23, 20, 2, -23 },
  { 1342, 16, 23, 20, 3, -23 },
  { 1388, 17, 23, 20, 2, -23 },
  { 1437, 18, 23, 20, 2, -23 },
  { 1489, 18, 23, 20, 2, -23 },
  { 1541, 17, 23, 20, 2, -23 },
  { 1590, 19, 23, 20, 1, -23 },
  { 1645, 18, 23, 20, 1, -23 },
  { 1697, 16, 23, 20, 2, -23 },
  { 1743, 20, 23, 20, 1, -23 },
  { 1801, 14, 23, 20, 3, -23 },
  { 1842, 19, 23, 20, 1, -23 },
  { 1897, 19, 23, 20, 1, -23 },
  { 1952, 17, 23, 20, 2, -23 },
  { 2001, 17, 23, 20, 2, -23 },
  { 2050, 17, 29, 20, 2, -23 },
  { 2112, 17, 23, 20, 2, -23 },
  { 2161, 18, 23, 20, 1, -23 },
  { 2213, 18, 23, 20, 3, -23 },
  { 2265, 18, 23, 20, 2, -23 },
  { 2317, 17, 23, 20, 4, -23 },
  { 2366, 19, 23, 20, 2, -23 },
  { 2421, 22, 23, 20, -1, -23 },
  { 2485, 19, 23, 20, 3, -23 },
  { 2540, 20, 23, 20, 0, -23 },
  { 2598, 14, 30, 20, 5, -25 },
  { 2651, 9, 30, 20, 6, -25 },
  { 2685, 14, 30, 20, 0, -25 },
  { 2738, 17, 13, 20, 2, -23 },
  { 2766, 16, 2, 20, 0, 3 },
  { 2770, 4, 6, 20, 8, -25 },
  { 2773, 16, 17, 20, 2, -17 },
  { 2807, 16, 24, 20, 2, -24 },
  { 2855, 15, 17, 20, 2, -17 },
  { 2887, 17, 24, 20, 2, -24 },
  { 2938, 16, 17, 20, 2, -17 },
  { 2972, 22, 31, 20, -1, -24 },
  { 3058, 17, 24, 20, 1, -17 },
  { 3109, 15, 24, 20, 2, -24 },
  { 3154, 15, 24, 20, 3, -24 },
  { 3199, 15, 31, 20, 2, -24 },
  { 3258, 17, 24, 20, 2, -24 },
  { 3309, 13, 24, 20, 4, -24 },
  { 3348, 19, 17, 20, 0, -17 },
  { 3389, 15, 17, 20, 2, -17 },
  { 3421, 16, 17, 20, 2, -17 },
  { 3455, 17, 24, 20, 1, -17 },
  { 3506, 16, 24, 20, 2, -17 },
  { 3554, 15, 17, 20, 4, -17 },
  { 3586, 16, 17, 20, 2, -17 },
  { 3620, 14, 23, 20, 3, -23 },
  { 3661, 15, 17, 20, 3, -17 },
  { 3693, 16, 17, 20, 2, -17 },
  { 3727, 18, 17, 20, 1, -17 },
  { 3766, 20, 17, 20, 0, -17 },
  { 3809, 17, 24, 20, 1, -17 },
  { 3860, 16, 17, 20, 2, -17 },
  { 3894, 15, 30, 20, 4, -25 },
  { 3951, 7, 30, 20, 7, -25 },
  { 3978, 16, 30, 20, 1, -25 },
  { 4038, 17, 7, 20, 2, -14 },
};

const GFXfont IBMPlexMono_Italic33pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic33pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic33pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _IBMPLEXMONO_ITALIC33PT7B_H_
