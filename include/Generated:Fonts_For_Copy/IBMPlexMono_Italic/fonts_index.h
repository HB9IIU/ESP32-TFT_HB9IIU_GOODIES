#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &IBMPlexMono_Italic6pt7b, 6, "IBMPlexMono_Italic6pt7b" },
  { &IBMPlexMono_Italic7pt7b, 7, "IBMPlexMono_Italic7pt7b" },
  { &IBMPlexMono_Italic8pt7b, 8, "IBMPlexMono_Italic8pt7b" },
  { &IBMPlexMono_Italic9pt7b, 9, "IBMPlexMono_Italic9pt7b" },
  { &IBMPlexMono_Italic10pt7b, 10, "IBMPlexMono_Italic10pt7b" },
  { &IBMPlexMono_Italic11pt7b, 11, "IBMPlexMono_Italic11pt7b" },
  { &IBMPlexMono_Italic12pt7b, 12, "IBMPlexMono_Italic12pt7b" },
  { &IBMPlexMono_Italic13pt7b, 13, "IBMPlexMono_Italic13pt7b" },
  { &IBMPlexMono_Italic14pt7b, 14, "IBMPlexMono_Italic14pt7b" },
  { &IBMPlexMono_Italic15pt7b, 15, "IBMPlexMono_Italic15pt7b" },
  { &IBMPlexMono_Italic16pt7b, 16, "IBMPlexMono_Italic16pt7b" },
  { &IBMPlexMono_Italic17pt7b, 17, "IBMPlexMono_Italic17pt7b" },
  { &IBMPlexMono_Italic18pt7b, 18, "IBMPlexMono_Italic18pt7b" },
  { &IBMPlexMono_Italic19pt7b, 19, "IBMPlexMono_Italic19pt7b" },
  { &IBMPlexMono_Italic20pt7b, 20, "IBMPlexMono_Italic20pt7b" },
  { &IBMPlexMono_Italic21pt7b, 21, "IBMPlexMono_Italic21pt7b" },
  { &IBMPlexMono_Italic22pt7b, 22, "IBMPlexMono_Italic22pt7b" },
  { &IBMPlexMono_Italic23pt7b, 23, "IBMPlexMono_Italic23pt7b" },
  { &IBMPlexMono_Italic24pt7b, 24, "IBMPlexMono_Italic24pt7b" },
  { &IBMPlexMono_Italic25pt7b, 25, "IBMPlexMono_Italic25pt7b" },
  { &IBMPlexMono_Italic26pt7b, 26, "IBMPlexMono_Italic26pt7b" },
  { &IBMPlexMono_Italic27pt7b, 27, "IBMPlexMono_Italic27pt7b" },
  { &IBMPlexMono_Italic28pt7b, 28, "IBMPlexMono_Italic28pt7b" },
  { &IBMPlexMono_Italic29pt7b, 29, "IBMPlexMono_Italic29pt7b" },
  { &IBMPlexMono_Italic30pt7b, 30, "IBMPlexMono_Italic30pt7b" },
  { &IBMPlexMono_Italic31pt7b, 31, "IBMPlexMono_Italic31pt7b" },
  { &IBMPlexMono_Italic32pt7b, 32, "IBMPlexMono_Italic32pt7b" },
  { &IBMPlexMono_Italic33pt7b, 33, "IBMPlexMono_Italic33pt7b" },
  { &IBMPlexMono_Italic34pt7b, 34, "IBMPlexMono_Italic34pt7b" },
  { &IBMPlexMono_Italic35pt7b, 35, "IBMPlexMono_Italic35pt7b" },
  { &IBMPlexMono_Italic36pt7b, 36, "IBMPlexMono_Italic36pt7b" },
  { &IBMPlexMono_Italic37pt7b, 37, "IBMPlexMono_Italic37pt7b" },
  { &IBMPlexMono_Italic38pt7b, 38, "IBMPlexMono_Italic38pt7b" },
  { &IBMPlexMono_Italic39pt7b, 39, "IBMPlexMono_Italic39pt7b" },
  { &IBMPlexMono_Italic40pt7b, 40, "IBMPlexMono_Italic40pt7b" },
  { &IBMPlexMono_Italic41pt7b, 41, "IBMPlexMono_Italic41pt7b" },
  { &IBMPlexMono_Italic42pt7b, 42, "IBMPlexMono_Italic42pt7b" },
  { &IBMPlexMono_Italic43pt7b, 43, "IBMPlexMono_Italic43pt7b" },
  { &IBMPlexMono_Italic44pt7b, 44, "IBMPlexMono_Italic44pt7b" },
  { &IBMPlexMono_Italic45pt7b, 45, "IBMPlexMono_Italic45pt7b" },
  { &IBMPlexMono_Italic46pt7b, 46, "IBMPlexMono_Italic46pt7b" },
  { &IBMPlexMono_Italic47pt7b, 47, "IBMPlexMono_Italic47pt7b" },
  { &IBMPlexMono_Italic48pt7b, 48, "IBMPlexMono_Italic48pt7b" },
  { &IBMPlexMono_Italic49pt7b, 49, "IBMPlexMono_Italic49pt7b" },
  { &IBMPlexMono_Italic50pt7b, 50, "IBMPlexMono_Italic50pt7b" },
  { &IBMPlexMono_Italic51pt7b, 51, "IBMPlexMono_Italic51pt7b" },
  { &IBMPlexMono_Italic52pt7b, 52, "IBMPlexMono_Italic52pt7b" },
  { &IBMPlexMono_Italic53pt7b, 53, "IBMPlexMono_Italic53pt7b" },
  { &IBMPlexMono_Italic54pt7b, 54, "IBMPlexMono_Italic54pt7b" },
  { &IBMPlexMono_Italic55pt7b, 55, "IBMPlexMono_Italic55pt7b" },
  { &IBMPlexMono_Italic56pt7b, 56, "IBMPlexMono_Italic56pt7b" },
  { &IBMPlexMono_Italic57pt7b, 57, "IBMPlexMono_Italic57pt7b" },
  { &IBMPlexMono_Italic58pt7b, 58, "IBMPlexMono_Italic58pt7b" },
  { &IBMPlexMono_Italic59pt7b, 59, "IBMPlexMono_Italic59pt7b" },
  { &IBMPlexMono_Italic60pt7b, 60, "IBMPlexMono_Italic60pt7b" },
  { &IBMPlexMono_Italic61pt7b, 61, "IBMPlexMono_Italic61pt7b" },
  { &IBMPlexMono_Italic62pt7b, 62, "IBMPlexMono_Italic62pt7b" },
  { &IBMPlexMono_Italic63pt7b, 63, "IBMPlexMono_Italic63pt7b" },
  { &IBMPlexMono_Italic64pt7b, 64, "IBMPlexMono_Italic64pt7b" },
  { &IBMPlexMono_Italic65pt7b, 65, "IBMPlexMono_Italic65pt7b" },
  { &IBMPlexMono_Italic66pt7b, 66, "IBMPlexMono_Italic66pt7b" },
  { &IBMPlexMono_Italic67pt7b, 67, "IBMPlexMono_Italic67pt7b" },
  { &IBMPlexMono_Italic68pt7b, 68, "IBMPlexMono_Italic68pt7b" },
  { &IBMPlexMono_Italic69pt7b, 69, "IBMPlexMono_Italic69pt7b" },
  { &IBMPlexMono_Italic70pt7b, 70, "IBMPlexMono_Italic70pt7b" },
  { &IBMPlexMono_Italic71pt7b, 71, "IBMPlexMono_Italic71pt7b" },
  { &IBMPlexMono_Italic72pt7b, 72, "IBMPlexMono_Italic72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
