#ifndef _IBMPLEXMONO_ITALIC15PT7B_H_
#define _IBMPLEXMONO_ITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xB4, 0x90, 0xD8, 0x5A, 0xB5, 0x20, 0x0D, 0x04, 0x82, 0xCE,
  0x71, 0x20, 0xA3, 0x9C, 0x48, 0x28, 0x24, 0x00, 0x04, 0x02, 0x07, 0xC4,
  0xB2, 0x41, 0x40, 0xE0, 0x1E, 0x09, 0x44, 0x94, 0xC7, 0x81, 0x00, 0x80,
  0x38, 0xD2, 0x24, 0xD1, 0x28, 0x72, 0x05, 0xC2, 0x91, 0x26, 0x49, 0x23,
  0x80, 0x1E, 0x19, 0x08, 0x86, 0x43, 0x62, 0xC2, 0x21, 0x19, 0xCD, 0x39,
  0x80, 0x57, 0x0C, 0x42, 0x10, 0x42, 0x08, 0x20, 0x82, 0x04, 0x10, 0x20,
  0x30, 0x82, 0x10, 0x84, 0x21, 0x10, 0x88, 0xCC, 0x00, 0x08, 0x32, 0x4B,
  0xF3, 0x0D, 0x33, 0x00, 0x08, 0x30, 0x47, 0xF1, 0x02, 0x0C, 0x00, 0x6D,
  0x40, 0xF8, 0xF0, 0x00, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10,
  0x10, 0x10, 0x08, 0x08, 0x0C, 0x00, 0x1C, 0x62, 0x42, 0xC3, 0x9A, 0x9A,
  0x82, 0x86, 0xC4, 0x78, 0x1C, 0x71, 0x24, 0x40, 0x83, 0x04, 0x08, 0x11,
  0xFC, 0x1E, 0x31, 0x21, 0x01, 0x03, 0x06, 0x08, 0x30, 0x60, 0xFF, 0x1E,
  0x31, 0x01, 0x03, 0x1C, 0x02, 0x03, 0x03, 0xC6, 0x7C, 0x03, 0x05, 0x0B,
  0x1A, 0x32, 0x22, 0x42, 0xFF, 0x04, 0x04, 0x3F, 0x20, 0x40, 0x40, 0x5C,
  0x66, 0x02, 0x06, 0x84, 0x78, 0x0E, 0x20, 0x82, 0x05, 0xDC, 0xE0, 0xC1,
  0xC4, 0xF0, 0xFF, 0x0E, 0x10, 0x41, 0x82, 0x08, 0x10, 0x41, 0x80, 0x3E,
  0x62, 0x43, 0x42, 0x3C, 0xC6, 0x82, 0x82, 0x84, 0x78, 0x3C, 0xC7, 0x0E,
  0x1C, 0x6F, 0x41, 0x06, 0x18, 0xC0, 0x6C, 0x00, 0x36, 0x33, 0x00, 0x00,
  0x66, 0x48, 0x03, 0x06, 0x18, 0x60, 0xC0, 0x60, 0x30, 0x0C, 0x04, 0xFE,
  0x00, 0x07, 0xF0, 0x40, 0xC0, 0x60, 0x60, 0x21, 0x8C, 0x60, 0x80, 0x7B,
  0x18, 0x41, 0x18, 0x82, 0x10, 0x61, 0x80, 0x3C, 0xC5, 0x0A, 0xF9, 0x36,
  0x68, 0xD3, 0x9F, 0x03, 0x03, 0xC0, 0x06, 0x0A, 0x0A, 0x12, 0x12, 0x22,
  0x3E, 0x43, 0x43, 0x81, 0x7E, 0x85, 0x0A, 0x17, 0xD8, 0xE0, 0xC1, 0x85,
  0xF0, 0x1E, 0x22, 0x43, 0x40, 0xC0, 0xC0, 0x80, 0x82, 0x44, 0x78, 0x7C,
  0xC5, 0x0A, 0x14, 0x28, 0x70, 0xC3, 0x85, 0xF0, 0x7F, 0x40, 0x40, 0x40,
  0x7E, 0xC0, 0xC0, 0x80, 0x80, 0xFC, 0x7F, 0x40, 0x40, 0x40, 0x7E, 0xC0,
  0x80, 0x80, 0x80, 0x80, 0x1E, 0x22, 0x43, 0xC0, 0xC0, 0x8E, 0x82, 0x86,
  0xC4, 0x7C, 0x61, 0x43, 0x42, 0x42, 0x7E, 0xC2, 0x86, 0x86, 0x84, 0x84,
  0x7F, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0xFC, 0x3E, 0x04,
  0x08, 0x30, 0x40, 0x81, 0x42, 0x8C, 0xF0, 0x61, 0xA1, 0x13, 0x0B, 0x07,
  0x07, 0x43, 0x21, 0x18, 0x84, 0x43, 0x00, 0x20, 0x41, 0x83, 0x04, 0x08,
  0x10, 0x20, 0xC1, 0xFC, 0x31, 0x98, 0xCC, 0xA7, 0xE4, 0xD2, 0x49, 0x24,
  0x82, 0x43, 0x61, 0x00, 0x61, 0x63, 0x52, 0x52, 0x52, 0xD2, 0x8A, 0x8E,
  0x8C, 0x8C, 0x1C, 0x62, 0x42, 0xC3, 0x82, 0x82, 0x82, 0x86, 0xC4, 0x78,
  0x7E, 0x43, 0x43, 0x43, 0x42, 0xFC, 0xC0, 0x80, 0x80, 0x80, 0x1C, 0x62,
  0x42, 0xC3, 0x82, 0x82, 0x82, 0x86, 0xC4, 0x78, 0x10, 0x1A, 0x0C, 0x7E,
  0x43, 0x43, 0x43, 0x42, 0xFC, 0xC8, 0x88, 0x84, 0x86, 0x1F, 0x10, 0xC8,
  0x04, 0x03, 0x80, 0x38, 0x05, 0x02, 0x43, 0x1E, 0x00, 0xFF, 0x84, 0x02,
  0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x18, 0x00, 0x61, 0x43, 0x42,
  0x42, 0x42, 0xC2, 0x86, 0x84, 0xC4, 0x78, 0x83, 0x82, 0x84, 0x84, 0x88,
  0xC8, 0x50, 0x50, 0x60, 0x60, 0x41, 0xE0, 0xA0, 0x53, 0x29, 0xA5, 0x52,
  0xA9, 0xD4, 0xCC, 0x66, 0x00, 0x20, 0xCC, 0x41, 0x30, 0x78, 0x0C, 0x03,
  0x01, 0x40, 0x98, 0x42, 0x30, 0xC0, 0xC1, 0xA1, 0x98, 0x84, 0x82, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x18, 0x00, 0x3F, 0x80, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x40, 0x40, 0x40, 0x7F, 0x80, 0x1E, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x20, 0x40, 0x81, 0x02, 0x0F, 0x80, 0x88, 0x88, 0x44, 0x44, 0x22, 0x22,
  0x10, 0x3E, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x4F,
  0x00, 0x0C, 0x14, 0x24, 0x62, 0x42, 0x83, 0xFE, 0xD4, 0x3A, 0x8F, 0x0C,
  0x38, 0x50, 0xA3, 0x3B, 0x20, 0xC1, 0x02, 0xE6, 0x28, 0x50, 0xE1, 0x87,
  0x8A, 0xE0, 0x3C, 0xCD, 0x06, 0x08, 0x10, 0xB1, 0xBC, 0x01, 0x03, 0x02,
  0x3A, 0x46, 0xC2, 0x86, 0x86, 0x84, 0x8C, 0x74, 0x3C, 0xC5, 0x0C, 0x3F,
  0x90, 0x31, 0xBC, 0x03, 0xC1, 0x00, 0x40, 0xFE, 0x04, 0x03, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x08, 0x82, 0x60, 0x50, 0x0C, 0x00, 0x1D, 0x23, 0x61,
  0x43, 0x42, 0x42, 0x46, 0x3A, 0x02, 0x44, 0xF8, 0x20, 0xC1, 0x02, 0xE6,
  0x68, 0x51, 0xE2, 0x85, 0x0A, 0x10, 0x18, 0x30, 0x07, 0x81, 0x02, 0x04,
  0x1A, 0x26, 0x58, 0xC0, 0x06, 0x0C, 0x01, 0xE0, 0x40, 0x83, 0x04, 0x08,
  0x12, 0x26, 0x47, 0x86, 0x00, 0x20, 0x60, 0x40, 0x5C, 0x66, 0x42, 0x44,
  0xF8, 0x92, 0x9F, 0x8C, 0xF0, 0x82, 0x08, 0x21, 0x84, 0x12, 0x4D, 0x46,
  0x00, 0x7B, 0x36, 0xD2, 0x49, 0x24, 0x92, 0x4B, 0x25, 0x26, 0x5C, 0xCD,
  0x0A, 0x3C, 0x50, 0xA1, 0x42, 0x3C, 0x8F, 0x0C, 0x18, 0x30, 0xF1, 0x3C,
  0x2E, 0x31, 0x21, 0x21, 0x61, 0x43, 0x62, 0x5C, 0x40, 0x40, 0xC0, 0x3A,
  0x8F, 0x0C, 0x38, 0x50, 0xA3, 0x3A, 0x04, 0x18, 0x20, 0xEE, 0x60, 0x83,
  0x04, 0x08, 0x10, 0x20, 0x3C, 0x85, 0x03, 0x80, 0xC0, 0xA1, 0x3C, 0x10,
  0x23, 0xF9, 0x82, 0x04, 0x08, 0x13, 0x68, 0x60, 0x42, 0x85, 0x0A, 0x3C,
  0x50, 0xB3, 0x3A, 0xE6, 0x45, 0x8A, 0x14, 0x68, 0x92, 0x38, 0x4A, 0x9A,
  0x93, 0x92, 0x92, 0x92, 0xB6, 0xDC, 0x3B, 0xB6, 0x43, 0x21, 0x00, 0x84,
  0xCA, 0x6D, 0xDC, 0x21, 0x21, 0x21, 0x23, 0x62, 0x42, 0x6E, 0x3A, 0x06,
  0x44, 0xF8, 0x7A, 0x8D, 0x10, 0xC3, 0x0C, 0xF8, 0xCF, 0x1E, 0x20, 0x80,
  0x81, 0x02, 0x38, 0x18, 0x10, 0x41, 0x02, 0x07, 0x80, 0x24, 0x94, 0x92,
  0x4A, 0x48, 0x38, 0x18, 0x20, 0x41, 0x02, 0x03, 0x98, 0x20, 0x20, 0x40,
  0x8E, 0x00, 0x63, 0x92, 0x8C,
};

const GFXglyph IBMPlexMono_Italic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 10, 9, 3, -10 },
  { 5, 5, 4, 9, 3, -11 },
  { 8, 9, 10, 9, 0, -10 },
  { 20, 9, 14, 9, 0, -12 },
  { 36, 10, 10, 9, 0, -10 },
  { 49, 9, 10, 9, 0, -10 },
  { 61, 2, 4, 9, 4, -11 },
  { 62, 6, 13, 9, 3, -11 },
  { 72, 5, 13, 9, 1, -11 },
  { 81, 7, 7, 9, 1, -8 },
  { 88, 7, 7, 9, 1, -8 },
  { 95, 3, 4, 9, 2, -2 },
  { 97, 5, 1, 9, 2, -5 },
  { 98, 2, 2, 9, 3, -2 },
  { 99, 9, 13, 9, 0, -11 },
  { 114, 8, 10, 9, 1, -10 },
  { 124, 7, 10, 9, 1, -10 },
  { 133, 8, 10, 9, 0, -10 },
  { 143, 8, 10, 9, 0, -10 },
  { 153, 8, 10, 9, 0, -10 },
  { 163, 8, 10, 9, 1, -10 },
  { 173, 7, 10, 9, 1, -10 },
  { 182, 7, 10, 9, 2, -10 },
  { 191, 8, 10, 9, 1, -10 },
  { 201, 7, 10, 9, 1, -10 },
  { 210, 3, 8, 9, 3, -8 },
  { 213, 4, 10, 9, 2, -8 },
  { 218, 8, 9, 9, 1, -9 },
  { 227, 7, 4, 9, 1, -7 },
  { 231, 7, 9, 9, 1, -9 },
  { 239, 6, 10, 9, 2, -10 },
  { 247, 7, 12, 9, 1, -10 },
  { 258, 8, 10, 9, 0, -10 },
  { 268, 7, 10, 9, 1, -10 },
  { 277, 8, 10, 9, 1, -10 },
  { 287, 7, 10, 9, 1, -10 },
  { 296, 8, 10, 9, 1, -10 },
  { 306, 8, 10, 9, 1, -10 },
  { 316, 8, 10, 9, 1, -10 },
  { 326, 8, 10, 9, 1, -10 },
  { 336, 8, 10, 9, 1, -10 },
  { 346, 7, 10, 9, 1, -10 },
  { 355, 9, 10, 9, 1, -10 },
  { 367, 7, 10, 9, 1, -10 },
  { 376, 9, 10, 9, 0, -10 },
  { 388, 8, 10, 9, 1, -10 },
  { 398, 8, 10, 9, 1, -10 },
  { 408, 8, 10, 9, 1, -10 },
  { 418, 8, 13, 9, 1, -10 },
  { 431, 8, 10, 9, 1, -10 },
  { 441, 9, 10, 9, 0, -10 },
  { 453, 9, 10, 9, 1, -10 },
  { 465, 8, 10, 9, 1, -10 },
  { 475, 8, 10, 9, 2, -10 },
  { 485, 9, 10, 9, 1, -10 },
  { 497, 10, 10, 9, 0, -10 },
  { 510, 9, 10, 9, 1, -10 },
  { 522, 9, 10, 9, 0, -10 },
  { 534, 7, 13, 9, 2, -11 },
  { 546, 4, 13, 9, 3, -11 },
  { 553, 7, 13, 9, 0, -11 },
  { 565, 8, 6, 9, 1, -10 },
  { 571, 7, 1, 9, 0, 1 },
  { 572, 2, 3, 9, 3, -12 },
  { 573, 7, 8, 9, 1, -8 },
  { 580, 7, 11, 9, 1, -11 },
  { 590, 7, 8, 9, 1, -8 },
  { 597, 8, 11, 9, 1, -11 },
  { 608, 7, 8, 9, 1, -8 },
  { 615, 10, 14, 9, 0, -11 },
  { 633, 8, 11, 9, 0, -8 },
  { 644, 7, 11, 9, 1, -11 },
  { 654, 7, 11, 9, 1, -11 },
  { 664, 7, 14, 9, 1, -11 },
  { 677, 8, 11, 9, 1, -11 },
  { 688, 6, 11, 9, 2, -11 },
  { 697, 9, 8, 9, 0, -8 },
  { 706, 7, 8, 9, 1, -8 },
  { 713, 7, 8, 9, 1, -8 },
  { 720, 8, 11, 9, 0, -8 },
  { 731, 7, 11, 9, 1, -8 },
  { 741, 7, 8, 9, 2, -8 },
  { 748, 7, 8, 9, 1, -8 },
  { 755, 7, 10, 9, 1, -10 },
  { 764, 7, 8, 9, 1, -8 },
  { 771, 7, 8, 9, 1, -8 },
  { 778, 8, 8, 9, 1, -8 },
  { 786, 9, 8, 9, 0, -8 },
  { 795, 8, 11, 9, 0, -8 },
  { 806, 7, 8, 9, 1, -8 },
  { 813, 7, 13, 9, 2, -11 },
  { 825, 3, 13, 9, 3, -11 },
  { 830, 7, 13, 9, 1, -11 },
  { 842, 8, 3, 9, 1, -6 },
};

const GFXfont IBMPlexMono_Italic15pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic15pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _IBMPLEXMONO_ITALIC15PT7B_H_
