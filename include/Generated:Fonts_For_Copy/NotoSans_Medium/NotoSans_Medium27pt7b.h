#ifndef _NOTOSANS_MEDIUM27PT7B_H_
#define _NOTOSANS_MEDIUM27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium27pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x66, 0x60, 0x04, 0xEF, 0xE0, 0xE7,
  0xE7, 0xC7, 0xC7, 0xC6, 0xC6, 0xC6, 0x07, 0x1C, 0x06, 0x18, 0x06, 0x18,
  0x06, 0x18, 0x06, 0x38, 0x7F, 0xFF, 0x7F, 0xFF, 0x0C, 0x30, 0x0C, 0x30,
  0x0C, 0x70, 0x0C, 0x60, 0xFF, 0xFE, 0xFF, 0xFE, 0x18, 0x60, 0x18, 0xE0,
  0x18, 0xC0, 0x38, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x06, 0x00, 0x60, 0x06,
  0x03, 0xFF, 0x7F, 0xEF, 0x66, 0xC6, 0x0C, 0x60, 0xE6, 0x0F, 0xE0, 0x7F,
  0x01, 0xFC, 0x07, 0xE0, 0x6F, 0x06, 0x70, 0x67, 0x86, 0x7F, 0xFE, 0xFF,
  0xC3, 0xF0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x08, 0x00, 0x01, 0xF0, 0x1C,
  0x1D, 0xC0, 0xC0, 0xC6, 0x0E, 0x0E, 0x30, 0x60, 0x71, 0x86, 0x03, 0x8E,
  0x70, 0x1C, 0x63, 0x00, 0xE3, 0x39, 0xC3, 0x19, 0x9F, 0x9D, 0xDD, 0xCC,
  0x7C, 0xCC, 0x60, 0x8E, 0x63, 0x80, 0x67, 0x1C, 0x06, 0x38, 0xE0, 0x70,
  0xC7, 0x03, 0x06, 0x38, 0x38, 0x31, 0x81, 0x81, 0xFC, 0x1C, 0x07, 0xC0,
  0x03, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00,
  0x70, 0xE0, 0x0E, 0x1C, 0x00, 0xE7, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x07, 0x3D, 0xE1, 0xC7, 0x1E, 0x39, 0xE1, 0xE7, 0x38, 0x0F, 0xC7,
  0x00, 0xF0, 0x70, 0x1E, 0x0F, 0x1F, 0xE0, 0xFF, 0xCE, 0x0F, 0xF0, 0xF0,
  0xFF, 0x6D, 0xB0, 0x1E, 0x30, 0xE1, 0x87, 0x0E, 0x18, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0xE1, 0xC1, 0x83, 0x83, 0x07, 0x80,
  0xE1, 0xC3, 0x0E, 0x38, 0x61, 0xC7, 0x1C, 0x70, 0xC3, 0x1C, 0x71, 0xC7,
  0x1C, 0x73, 0x8E, 0x71, 0xCE, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C,
  0x0C, 0x61, 0x7F, 0xFF, 0xFF, 0xE0, 0xE0, 0x0F, 0x80, 0xEE, 0x0E, 0x70,
  0x71, 0xC0, 0x88, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x00, 0x77, 0x76, 0xEE, 0xFF, 0xFC, 0x4E, 0xFE, 0x01, 0xC0, 0x60,
  0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x81, 0xC0, 0x70,
  0x18, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x0E, 0x00, 0x02, 0x00, 0xFE,
  0x0F, 0xF8, 0xF0, 0xE7, 0x07, 0x38, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1D, 0x80, 0xEE, 0x07, 0x70,
  0x71, 0xC7, 0x8F, 0xF8, 0x1F, 0x80, 0x07, 0x1F, 0x3F, 0x7F, 0xE7, 0x47,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x03, 0x01, 0xFE, 0x3F, 0xF8, 0xE0, 0xE4, 0x07, 0x00, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x01,
  0xFF, 0x3F, 0xFC, 0xC0, 0xE0, 0x07, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x01,
  0xE0, 0xFC, 0x07, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x7F, 0x07, 0xBF, 0xF8, 0xFF, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0xD8, 0x07, 0x60, 0x3B, 0x80, 0xCE, 0x07, 0x38, 0x38, 0xE0, 0xC3,
  0x86, 0x0E, 0x38, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x7F, 0xE7, 0xFE, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0xF0, 0xFF, 0xC7, 0x7E, 0x00, 0xF0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x0F, 0xC1, 0xEF, 0xFC, 0xFF, 0x80, 0x00, 0x40,
  0x3F, 0x87, 0xFC, 0x78, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x67,
  0xE7, 0x7F, 0xBE, 0x1F, 0xE0, 0x7E, 0x03, 0xF0, 0x1D, 0x80, 0xEE, 0x07,
  0x70, 0x39, 0xC3, 0x87, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x0F, 0x00, 0x03, 0x00, 0xFF, 0x0F, 0xFC, 0xE0, 0xE7, 0x03, 0xB8, 0x1D,
  0xC0, 0xCF, 0x0E, 0x3D, 0xE0, 0xFE, 0x07, 0xF0, 0x7B, 0xE7, 0x07, 0x70,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3B, 0x83, 0xDF, 0xFC, 0x3F, 0x80, 0x02,
  0x00, 0xFE, 0x0F, 0xF8, 0xE0, 0xE7, 0x07, 0x70, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3B, 0x83, 0xDE, 0x3E, 0x7F, 0xF1, 0xF3, 0x80, 0x1C, 0x00, 0xC0,
  0x0E, 0x00, 0xF0, 0x0F, 0x0F, 0xF0, 0x7E, 0x00, 0xEE, 0xFE, 0x00, 0x00,
  0x00, 0x04, 0xEF, 0xE0, 0x73, 0x9E, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x39, 0xCC, 0xE6, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x1E, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xE0, 0x1C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0x80, 0x04, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x80, 0x06, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x0F, 0x00,
  0x40, 0x00, 0x04, 0x0F, 0xFB, 0xFF, 0xB0, 0x70, 0x06, 0x00, 0xC0, 0x38,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00,
  0x04, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0xF0, 0x0E, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x38, 0xC1, 0xFC, 0x67, 0x1F,
  0xF1, 0x98, 0x70, 0xC7, 0x63, 0x87, 0x0D, 0x8C, 0x1C, 0x3E, 0x30, 0x70,
  0xF8, 0xC1, 0xC7, 0x63, 0x07, 0x19, 0x8E, 0x3C, 0xE6, 0x1F, 0xFF, 0x1C,
  0x3C, 0x78, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x08, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x07, 0x70, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x38, 0xE0, 0x0E, 0x1C,
  0x03, 0x07, 0x01, 0xC0, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0E, 0x01, 0xC3,
  0x80, 0x71, 0xC0, 0x1C, 0x70, 0x03, 0x9C, 0x00, 0xEE, 0x00, 0x3C, 0xFF,
  0xC7, 0xFF, 0xB0, 0x3D, 0x80, 0xFC, 0x03, 0xE0, 0x3F, 0x01, 0xD8, 0x1E,
  0xFF, 0xC7, 0xFF, 0x30, 0x3D, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0xC1, 0xF7, 0xFF, 0x3F, 0xF0, 0x00, 0x80, 0x3F, 0xF1, 0xFF, 0xCF,
  0x02, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF8, 0x71, 0xFF, 0xC3, 0xFE, 0xFF, 0xC1, 0xFF, 0xE3, 0x03, 0xE6, 0x01,
  0xEC, 0x01, 0xD8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xB0, 0x0F, 0x60, 0x3C, 0xC7,
  0xF1, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x00, 0x00, 0x40, 0x07, 0xFE, 0x1F, 0xFE, 0x3E,
  0x06, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70,
  0x07, 0x78, 0x07, 0x3E, 0x0F, 0x1F, 0xFF, 0x07, 0xFE, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x38, 0xFF, 0xFE, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0xFF,
  0x7C, 0xC0, 0x3F, 0x01, 0xCC, 0x0E, 0x30, 0x78, 0xC3, 0xC3, 0x0E, 0x0C,
  0x70, 0x33, 0x80, 0xDE, 0x03, 0xF8, 0x0F, 0x70, 0x39, 0xE0, 0xC3, 0xC3,
  0x07, 0x0C, 0x1E, 0x30, 0x3C, 0xC0, 0x73, 0x00, 0xEC, 0x03, 0xC0, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xBD,
  0x80, 0x7F, 0xB8, 0x0D, 0xF3, 0x01, 0xBE, 0x70, 0x77, 0xCE, 0x0C, 0xF8,
  0xC3, 0x9F, 0x1C, 0x73, 0xE3, 0x8C, 0x7C, 0x33, 0x8F, 0x87, 0x71, 0xF0,
  0xEC, 0x3E, 0x0F, 0x87, 0xC1, 0xE0, 0xF8, 0x3C, 0x1F, 0x03, 0x83, 0x80,
  0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3D, 0xC0, 0x7B, 0xC0, 0xF3,
  0x81, 0xE3, 0x83, 0xC7, 0x87, 0x87, 0x0F, 0x07, 0x1E, 0x0E, 0x3C, 0x0E,
  0x78, 0x1E, 0xF0, 0x1D, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x38,
  0x00, 0x80, 0x03, 0xFE, 0x03, 0xFF, 0xE0, 0xF0, 0x7C, 0x70, 0x07, 0x3C,
  0x01, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x39, 0xC0, 0x1E,
  0x78, 0x0F, 0x0F, 0x87, 0x81, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0x8F, 0xFE,
  0xC1, 0xEC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xEF, 0xFE,
  0xFF, 0xCF, 0xE0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x03, 0xFE, 0x03, 0xFF, 0xE0, 0xF0, 0x7C, 0x70,
  0x07, 0x3C, 0x01, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x39,
  0xC0, 0x1E, 0x78, 0x0F, 0x0F, 0x87, 0x81, 0xFF, 0xC0, 0x3F, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0xFF,
  0x83, 0xFF, 0x8C, 0x1F, 0x30, 0x1C, 0xC0, 0x73, 0x01, 0xCC, 0x07, 0x30,
  0x1C, 0xC1, 0xE3, 0xFF, 0x0F, 0xF8, 0x30, 0xE0, 0xC1, 0xC3, 0x07, 0x0C,
  0x0E, 0x30, 0x3C, 0xC0, 0x73, 0x00, 0xEC, 0x03, 0xC0, 0x02, 0x00, 0xFF,
  0x8F, 0xFC, 0xF0, 0x67, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00,
  0x77, 0x87, 0xBF, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x3C, 0x3C, 0x3F, 0xF8, 0x0F, 0xF0, 0xE0, 0x07, 0xB8, 0x03,
  0x9C, 0x01, 0xCE, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x70, 0x38,
  0x38, 0x1C, 0x1C, 0x0E, 0x1C, 0x03, 0x8E, 0x01, 0xC6, 0x00, 0xE7, 0x00,
  0x3B, 0x80, 0x1D, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0xE0, 0x1C, 0x03, 0xB8, 0x0F, 0x01, 0xDC, 0x0F, 0x81, 0xCE, 0x07,
  0xC0, 0xE7, 0x03, 0x60, 0x71, 0xC1, 0xB8, 0x38, 0xE1, 0xDC, 0x38, 0x70,
  0xE6, 0x1C, 0x18, 0x63, 0x8E, 0x0E, 0x71, 0xC7, 0x07, 0x38, 0x63, 0x03,
  0x9C, 0x3B, 0x80, 0xCC, 0x1D, 0xC0, 0x7E, 0x0E, 0xE0, 0x3F, 0x03, 0x60,
  0x1F, 0x01, 0xF0, 0x07, 0x80, 0xF8, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1C,
  0x00, 0xF0, 0x0F, 0x38, 0x0E, 0x38, 0x1C, 0x1C, 0x3C, 0x0E, 0x38, 0x0E,
  0x70, 0x07, 0x70, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07,
  0xF0, 0x0E, 0x70, 0x0E, 0x38, 0x1C, 0x38, 0x38, 0x1C, 0x38, 0x0E, 0x70,
  0x0E, 0xF0, 0x07, 0xF0, 0x0F, 0x70, 0x0E, 0x38, 0x1C, 0x38, 0x1C, 0x1C,
  0x38, 0x1C, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x07, 0xE0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0xFB, 0xFF, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0xFF, 0xC0, 0xE0, 0x1C, 0x07,
  0x00, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x18,
  0x07, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0xFF, 0xF1, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1F, 0xFF, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0x60, 0x1D, 0xC0,
  0x63, 0x03, 0x8E, 0x0C, 0x18, 0x70, 0x71, 0x80, 0xC6, 0x03, 0xB0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF1, 0xC3, 0x87, 0x0C, 0x0F, 0x83, 0xFE, 0x3D, 0xF2,
  0x07, 0x00, 0x70, 0x07, 0x07, 0xF3, 0xFF, 0x78, 0x7F, 0x07, 0xE0, 0x7E,
  0x07, 0xF0, 0xF7, 0xFB, 0x3F, 0x30, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x9E, 0x1D, 0xFC, 0xFF, 0xF7, 0x83, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFE,
  0x3D, 0xFF, 0xEC, 0xFC, 0x00, 0x07, 0xC3, 0xFC, 0xFF, 0xBC, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0xC2, 0x7F,
  0xC3, 0xF8, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x71, 0xC7, 0xF7, 0x3F, 0xFD, 0xE0, 0xF7, 0x03, 0xDC, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xD8, 0x07, 0x70, 0x3D, 0xC0, 0xF7, 0x87, 0xCF,
  0xF7, 0x1F, 0x9C, 0x07, 0x80, 0xFF, 0x0F, 0x3C, 0xE0, 0xF7, 0x03, 0xB8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0xC1,
  0x1F, 0xF8, 0x3F, 0xC0, 0x03, 0x81, 0xFC, 0x7F, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0xE7, 0xFC, 0xFF, 0x83, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x0F, 0x1C, 0x7F,
  0x73, 0xFF, 0xDE, 0x0F, 0x70, 0x3D, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1D, 0x80, 0x77, 0x01, 0xDC, 0x0F, 0x78, 0x7C, 0xFF, 0x71, 0xF9, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xE6, 0x07, 0x9F, 0xFC, 0x7F, 0xE0, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x8F, 0x1D, 0xFE, 0xFF,
  0xF7, 0x83, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0x80, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x71, 0xC0, 0x00, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0xFF,
  0xE0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x81,
  0xFC, 0x1E, 0xE1, 0xE7, 0x1E, 0x39, 0xE1, 0xCE, 0x0E, 0xE0, 0x7F, 0x03,
  0xFC, 0x1E, 0xF0, 0xE3, 0xC7, 0x0E, 0x38, 0x39, 0xC1, 0xEE, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE7, 0xC1, 0xE7, 0x7F,
  0x3F, 0xBF, 0xFF, 0xFF, 0xE0, 0xF0, 0x7F, 0x07, 0x83, 0xF0, 0x38, 0x0F,
  0x81, 0xC0, 0x7C, 0x0E, 0x03, 0xE0, 0x70, 0x1F, 0x03, 0x80, 0xF8, 0x1C,
  0x07, 0xC0, 0xE0, 0x3E, 0x07, 0x01, 0xF0, 0x38, 0x0F, 0x81, 0xC0, 0x60,
  0xE3, 0xC7, 0x7F, 0xBF, 0xFD, 0xE0, 0xFF, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xE0, 0x07, 0xC0, 0x7F, 0x83, 0xFF, 0x1E, 0x0E, 0x70, 0x1D, 0xC0, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x0E, 0x38, 0x78,
  0x7F, 0xC0, 0xFE, 0x00, 0xE7, 0x87, 0x7F, 0x3F, 0xFD, 0xE0, 0xFF, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0xFF,
  0x8F, 0x7F, 0xFB, 0x9F, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x0F, 0x1C, 0x7F, 0x73, 0xFF, 0xDE, 0x0F, 0x70, 0x3D,
  0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1D, 0x80, 0x77, 0x03, 0xDC, 0x0F,
  0x78, 0x7C, 0xFF, 0x71, 0xF9, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0xC3, 0xF7, 0xFF, 0xFF, 0x0F, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x1F, 0x8F, 0xFD,
  0xE7, 0x70, 0x0E, 0x00, 0xE0, 0x1F, 0x81, 0xFC, 0x07, 0xC0, 0x3C, 0x03,
  0x80, 0x7C, 0x1F, 0xFF, 0x9F, 0xE0, 0x08, 0x06, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xF1, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x70, 0x1F, 0xC3, 0xF0, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0xFF, 0x0F, 0xBF, 0xFC, 0xFC, 0xE0, 0xE0, 0x1F, 0x80, 0x77, 0x03, 0x9C,
  0x0E, 0x30, 0x38, 0xE1, 0xC3, 0x87, 0x06, 0x1C, 0x1C, 0xE0, 0x73, 0x80,
  0xEC, 0x03, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x70, 0x1B,
  0x03, 0xC1, 0xDC, 0x1E, 0x0E, 0xE1, 0xF0, 0x77, 0x0F, 0xC3, 0x1C, 0x6E,
  0x38, 0xE3, 0x31, 0xC7, 0x39, 0xCE, 0x19, 0x8E, 0xE0, 0xEC, 0x37, 0x07,
  0xE1, 0xB8, 0x3F, 0x0F, 0x80, 0xF0, 0x7C, 0x07, 0x81, 0xE0, 0x3C, 0x0F,
  0x00, 0x70, 0x1D, 0xE0, 0xE3, 0x87, 0x87, 0x1C, 0x1E, 0xE0, 0x3F, 0x80,
  0x7C, 0x00, 0xE0, 0x07, 0xC0, 0x3F, 0x01, 0xEE, 0x07, 0x1C, 0x38, 0x79,
  0xE0, 0xEF, 0x01, 0xC0, 0xE0, 0x1F, 0x80, 0x77, 0x03, 0x9C, 0x0E, 0x38,
  0x38, 0xE1, 0xC3, 0x87, 0x07, 0x1C, 0x1C, 0xE0, 0x33, 0x80, 0xEC, 0x03,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x3F, 0x80, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38,
  0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0x0F, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38,
  0xF8, 0xE0, 0xF8, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0F,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0x7C, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x03,
  0xE0, 0x70, 0xF8, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x87,
  0xC3, 0xC0, 0x7E, 0x0F, 0xFF, 0xE0, 0xFC,
};

const GFXglyph NotoSans_Medium27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 19, 7, 2, -19 },
  { 11, 8, 7, 12, 2, -19 },
  { 18, 16, 19, 17, 1, -19 },
  { 56, 12, 23, 15, 2, -21 },
  { 91, 21, 20, 23, 1, -20 },
  { 144, 19, 20, 20, 1, -20 },
  { 192, 3, 7, 6, 2, -19 },
  { 195, 7, 23, 8, 1, -19 },
  { 216, 6, 23, 8, 1, -19 },
  { 234, 13, 13, 15, 1, -21 },
  { 256, 13, 13, 15, 1, -16 },
  { 278, 4, 6, 7, 1, -3 },
  { 281, 7, 2, 9, 1, -8 },
  { 283, 4, 4, 7, 2, -4 },
  { 285, 10, 19, 10, 0, -19 },
  { 309, 13, 20, 15, 1, -20 },
  { 342, 8, 19, 15, 2, -19 },
  { 361, 13, 20, 15, 1, -20 },
  { 394, 13, 20, 15, 1, -20 },
  { 427, 14, 19, 15, 1, -19 },
  { 461, 12, 19, 15, 2, -19 },
  { 490, 13, 20, 15, 1, -20 },
  { 523, 13, 19, 15, 1, -19 },
  { 554, 13, 20, 15, 1, -20 },
  { 587, 13, 20, 15, 1, -20 },
  { 620, 4, 15, 7, 2, -15 },
  { 628, 5, 18, 7, 1, -15 },
  { 640, 13, 14, 15, 1, -17 },
  { 663, 13, 7, 15, 1, -13 },
  { 675, 13, 14, 15, 1, -17 },
  { 698, 11, 20, 12, 0, -20 },
  { 726, 22, 21, 24, 1, -19 },
  { 784, 18, 19, 18, 0, -19 },
  { 827, 13, 19, 18, 3, -19 },
  { 858, 14, 20, 17, 2, -20 },
  { 893, 15, 19, 20, 3, -19 },
  { 929, 10, 19, 15, 3, -19 },
  { 953, 10, 19, 14, 3, -19 },
  { 977, 16, 20, 20, 2, -20 },
  { 1017, 15, 19, 20, 3, -19 },
  { 1053, 8, 19, 10, 1, -19 },
  { 1072, 7, 24, 8, -2, -19 },
  { 1093, 14, 19, 17, 3, -19 },
  { 1127, 11, 19, 14, 3, -19 },
  { 1154, 19, 19, 25, 3, -19 },
  { 1200, 15, 19, 21, 3, -19 },
  { 1236, 18, 20, 21, 2, -20 },
  { 1281, 12, 19, 16, 3, -19 },
  { 1310, 18, 25, 21, 2, -20 },
  { 1367, 14, 19, 17, 3, -19 },
  { 1401, 13, 20, 15, 1, -20 },
  { 1434, 15, 19, 15, 0, -19 },
  { 1470, 16, 19, 20, 2, -19 },
  { 1508, 17, 19, 17, 0, -19 },
  { 1549, 25, 19, 25, 0, -19 },
  { 1609, 16, 19, 17, 0, -19 },
  { 1647, 16, 19, 16, 0, -19 },
  { 1685, 14, 19, 16, 1, -19 },
  { 1719, 6, 23, 9, 2, -19 },
  { 1737, 10, 19, 10, 0, -19 },
  { 1761, 6, 23, 9, 1, -19 },
  { 1779, 14, 12, 15, 1, -19 },
  { 1800, 12, 2, 12, 0, 2 },
  { 1803, 6, 5, 8, 1, -21 },
  { 1807, 12, 15, 15, 1, -15 },
  { 1830, 13, 21, 17, 2, -21 },
  { 1865, 11, 15, 13, 1, -15 },
  { 1886, 14, 21, 17, 1, -21 },
  { 1923, 13, 15, 16, 1, -15 },
  { 1948, 11, 21, 10, 0, -21 },
  { 1977, 14, 21, 17, 1, -15 },
  { 2014, 13, 21, 17, 2, -21 },
  { 2049, 3, 20, 7, 2, -20 },
  { 2057, 6, 26, 7, -1, -20 },
  { 2077, 13, 21, 15, 2, -21 },
  { 2112, 3, 21, 7, 2, -21 },
  { 2120, 21, 15, 26, 2, -15 },
  { 2160, 13, 15, 17, 2, -15 },
  { 2185, 14, 15, 17, 1, -15 },
  { 2212, 13, 21, 17, 2, -15 },
  { 2247, 14, 21, 17, 1, -15 },
  { 2284, 9, 15, 11, 2, -15 },
  { 2301, 11, 15, 13, 1, -15 },
  { 2322, 10, 18, 10, 0, -18 },
  { 2345, 13, 15, 17, 2, -15 },
  { 2370, 14, 15, 14, 0, -15 },
  { 2397, 21, 15, 22, 0, -15 },
  { 2437, 14, 15, 15, 0, -15 },
  { 2464, 14, 21, 14, 0, -15 },
  { 2501, 11, 15, 13, 1, -15 },
  { 2522, 8, 23, 10, 1, -19 },
  { 2545, 3, 27, 15, 6, -21 },
  { 2556, 9, 23, 10, 1, -19 },
  { 2582, 13, 3, 15, 1, -11 },
};

const GFXfont NotoSans_Medium27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium27pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_MEDIUM27PT7B_H_
