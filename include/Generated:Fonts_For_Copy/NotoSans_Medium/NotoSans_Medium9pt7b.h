#ifndef _NOTOSANS_MEDIUM9PT7B_H_
#define _NOTOSANS_MEDIUM9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x29, 0xF3, 0x3E, 0x51, 0x40, 0x23, 0xE8, 0xC3, 0xDD,
  0x84, 0x41, 0x4A, 0xA5, 0xB5, 0xA5, 0x49, 0x80, 0x20, 0xA1, 0x41, 0x05,
  0x51, 0x1D, 0x80, 0xC0, 0x6A, 0x48, 0x98, 0xD5, 0x5C, 0x25, 0x5C, 0xA0,
  0x27, 0xC8, 0x40, 0x60, 0xE0, 0x80, 0x25, 0x25, 0x00, 0x22, 0xA3, 0x18,
  0xA5, 0xC0, 0xF5, 0x50, 0x26, 0x84, 0x22, 0x23, 0xE0, 0x26, 0x84, 0xE1,
  0x87, 0xC0, 0x31, 0x95, 0x2F, 0x88, 0xE8, 0xE1, 0x1E, 0x13, 0x11, 0xE8,
  0xA5, 0xC0, 0xF8, 0x84, 0x42, 0x20, 0x22, 0x96, 0xE5, 0x45, 0xC0, 0x22,
  0xA2, 0xB6, 0x89, 0xC0, 0x88, 0x40, 0x60, 0x09, 0xB0, 0xC1, 0x80, 0xFF,
  0xC0, 0x83, 0x06, 0x6C, 0x00, 0x69, 0x12, 0x40, 0x40, 0x3E, 0x5E, 0xA5,
  0xA5, 0x9E, 0x40, 0x3C, 0x30, 0xC4, 0x9E, 0x4A, 0x10, 0xF9, 0xE9, 0x9F,
  0x2D, 0x88, 0x88, 0x70, 0xF4, 0x63, 0x19, 0xF8, 0xF3, 0xC9, 0xC0, 0xF3,
  0xC9, 0x00, 0x36, 0x61, 0x28, 0xC5, 0xE0, 0x8C, 0x7F, 0x18, 0xC4, 0xE9,
  0x25, 0xC0, 0x24, 0x92, 0x4E, 0x9D, 0x31, 0x4B, 0x4C, 0x88, 0x88, 0x8F,
  0xC7, 0x3C, 0xED, 0xB6, 0xD0, 0xCE, 0x6B, 0x59, 0xC4, 0x23, 0x68, 0xA3,
  0x8A, 0x27, 0x00, 0xF9, 0x9E, 0x88, 0x23, 0x68, 0xA3, 0x8A, 0x27, 0x04,
  0x08, 0xF4, 0xAD, 0xC9, 0x4C, 0x22, 0x90, 0xC1, 0x07, 0xC0, 0xF9, 0x08,
  0x42, 0x10, 0x8C, 0x63, 0x18, 0xF8, 0x8D, 0x24, 0x94, 0x30, 0x80, 0x99,
  0x59, 0x55, 0x56, 0x66, 0x22, 0xCA, 0x88, 0x65, 0x44, 0xCA, 0x8C, 0x42,
  0x10, 0xF8, 0x88, 0x44, 0x7C, 0xEA, 0xAC, 0x89, 0x22, 0x40, 0xD5, 0x5C,
  0x22, 0x95, 0x10, 0xF0, 0xD0, 0x71, 0x79, 0x70, 0x88, 0xE9, 0x99, 0xF0,
  0x74, 0x84, 0x70, 0x08, 0x5E, 0x98, 0xA5, 0xE0, 0x72, 0x7E, 0x87, 0x00,
  0x74, 0xE4, 0x44, 0x40, 0x7A, 0x62, 0x97, 0x85, 0xC0, 0x88, 0xE9, 0x99,
  0x90, 0xBE, 0x45, 0x55, 0xC0, 0x88, 0xBE, 0xCA, 0xB0, 0xFE, 0xED, 0x26,
  0x4C, 0x99, 0x20, 0xF9, 0x99, 0x90, 0x72, 0x62, 0x97, 0x00, 0xE9, 0x99,
  0xF8, 0x80, 0x7A, 0x62, 0x97, 0x84, 0x20, 0xF2, 0x48, 0x78, 0x61, 0xF0,
  0x5D, 0x24, 0xC0, 0x99, 0x99, 0xF0, 0x8C, 0x94, 0xA2, 0x00, 0x93, 0x35,
  0xAB, 0x66, 0x40, 0xDA, 0x88, 0xAD, 0x80, 0x8A, 0x94, 0xA2, 0x13, 0x00,
  0xF2, 0x24, 0xF0, 0x69, 0x44, 0x98, 0xFF, 0x80, 0xC9, 0x14, 0xB0, 0xF8,
};

const GFXglyph NotoSans_Medium9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 1, -6 },
  { 2, 2, 2, 4, 1, -6 },
  { 3, 6, 6, 6, 0, -6 },
  { 8, 5, 8, 5, 0, -7 },
  { 13, 7, 7, 8, 0, -7 },
  { 20, 7, 7, 7, 0, -7 },
  { 27, 1, 2, 2, 1, -6 },
  { 28, 3, 7, 3, 0, -6 },
  { 31, 2, 7, 3, 0, -6 },
  { 33, 5, 4, 5, 0, -7 },
  { 36, 5, 4, 5, 0, -5 },
  { 39, 2, 2, 2, 0, -1 },
  { 40, 3, 1, 3, 0, -3 },
  { 41, 1, 1, 2, 1, -1 },
  { 42, 3, 6, 3, 0, -6 },
  { 45, 5, 7, 5, 0, -7 },
  { 50, 2, 6, 5, 1, -6 },
  { 52, 5, 7, 5, 0, -7 },
  { 57, 5, 7, 5, 0, -7 },
  { 62, 5, 6, 5, 0, -6 },
  { 66, 4, 6, 5, 1, -6 },
  { 69, 5, 7, 5, 0, -7 },
  { 74, 5, 6, 5, 0, -6 },
  { 78, 5, 7, 5, 0, -7 },
  { 83, 5, 7, 5, 0, -7 },
  { 88, 1, 5, 2, 1, -5 },
  { 89, 2, 6, 2, 0, -5 },
  { 91, 5, 5, 5, 0, -6 },
  { 95, 5, 2, 5, 0, -4 },
  { 97, 5, 5, 5, 0, -6 },
  { 101, 4, 7, 4, 0, -7 },
  { 105, 8, 7, 8, 0, -6 },
  { 112, 6, 6, 6, 0, -6 },
  { 117, 4, 6, 6, 1, -6 },
  { 120, 4, 7, 6, 1, -7 },
  { 124, 5, 6, 7, 1, -6 },
  { 128, 3, 6, 5, 1, -6 },
  { 131, 3, 6, 5, 1, -6 },
  { 134, 5, 7, 7, 1, -7 },
  { 139, 5, 6, 7, 1, -6 },
  { 143, 3, 6, 3, 0, -6 },
  { 146, 3, 8, 3, -1, -6 },
  { 149, 5, 6, 6, 1, -6 },
  { 153, 4, 6, 5, 1, -6 },
  { 156, 6, 6, 8, 1, -6 },
  { 161, 5, 6, 7, 1, -6 },
  { 165, 6, 7, 7, 1, -7 },
  { 171, 4, 6, 5, 1, -6 },
  { 174, 6, 9, 7, 1, -7 },
  { 181, 5, 6, 6, 1, -6 },
  { 185, 5, 7, 5, 0, -7 },
  { 190, 5, 6, 5, 0, -6 },
  { 194, 5, 6, 7, 1, -6 },
  { 198, 6, 6, 6, 0, -6 },
  { 203, 8, 6, 8, 0, -6 },
  { 209, 5, 6, 6, 0, -6 },
  { 213, 5, 6, 5, 0, -6 },
  { 217, 5, 6, 5, 0, -6 },
  { 221, 2, 7, 3, 1, -6 },
  { 223, 3, 6, 3, 0, -6 },
  { 226, 2, 7, 3, 0, -6 },
  { 228, 5, 4, 5, 0, -6 },
  { 231, 4, 1, 4, 0, 1 },
  { 232, 2, 2, 3, 0, -7 },
  { 233, 4, 5, 5, 0, -5 },
  { 236, 4, 7, 6, 1, -7 },
  { 240, 4, 5, 4, 0, -5 },
  { 243, 5, 7, 6, 0, -7 },
  { 248, 5, 5, 5, 0, -5 },
  { 252, 4, 7, 3, 0, -7 },
  { 256, 5, 7, 6, 0, -5 },
  { 261, 4, 7, 6, 1, -7 },
  { 265, 1, 7, 2, 1, -7 },
  { 266, 2, 9, 2, 0, -7 },
  { 269, 4, 7, 5, 1, -7 },
  { 273, 1, 7, 2, 1, -7 },
  { 274, 7, 5, 9, 1, -5 },
  { 279, 4, 5, 6, 1, -5 },
  { 282, 5, 5, 6, 0, -5 },
  { 286, 4, 7, 6, 1, -5 },
  { 290, 5, 7, 6, 0, -5 },
  { 295, 3, 5, 4, 1, -5 },
  { 297, 4, 5, 4, 0, -5 },
  { 300, 3, 6, 3, 0, -6 },
  { 303, 4, 5, 6, 1, -5 },
  { 306, 5, 5, 5, 0, -5 },
  { 310, 7, 5, 7, 0, -5 },
  { 315, 5, 5, 5, 0, -5 },
  { 319, 5, 7, 5, 0, -5 },
  { 324, 4, 5, 4, 0, -5 },
  { 327, 3, 7, 3, 0, -6 },
  { 330, 1, 9, 5, 2, -7 },
  { 332, 3, 7, 3, 0, -6 },
  { 335, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Medium9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium9pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_MEDIUM9PT7B_H_
