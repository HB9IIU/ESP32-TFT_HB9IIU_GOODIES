#ifndef _NOTOSANS_MEDIUM19PT7B_H_
#define _NOTOSANS_MEDIUM19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xB6, 0xD2, 0x48, 0x0F, 0xC0, 0xCF, 0x3C, 0xF3, 0x4C, 0x04,
  0x40, 0xCC, 0x0C, 0xC0, 0xCC, 0x7F, 0xF7, 0xFF, 0x19, 0x81, 0x98, 0x19,
  0x8F, 0xFE, 0x11, 0x01, 0x10, 0x33, 0x03, 0x30, 0x08, 0x1F, 0x5F, 0xD9,
  0x2C, 0x87, 0x41, 0xF0, 0x3E, 0x0B, 0x84, 0xC2, 0x7F, 0xEF, 0xE0, 0x40,
  0x20, 0x70, 0x33, 0xE1, 0x8C, 0x86, 0x33, 0x30, 0x8C, 0x83, 0x36, 0x0C,
  0x97, 0xBE, 0xDB, 0x32, 0x44, 0x1B, 0x10, 0xC4, 0x43, 0x11, 0x18, 0x6C,
  0xC0, 0xE0, 0x1C, 0x01, 0xF8, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x1B, 0x00,
  0x70, 0x0F, 0x86, 0xE6, 0x36, 0x1B, 0x30, 0x79, 0x83, 0x87, 0xFE, 0x1F,
  0x1C, 0xFF, 0x40, 0x33, 0x66, 0xCC, 0xCC, 0xCC, 0xCC, 0xC4, 0x66, 0x30,
  0x8C, 0x66, 0x33, 0x33, 0x33, 0x33, 0x36, 0x64, 0xC0, 0x18, 0x0C, 0x26,
  0x5F, 0xF1, 0x81, 0xE1, 0xD8, 0xCE, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8,
  0x40, 0x20, 0x10, 0x08, 0x00, 0x7B, 0x60, 0xFF, 0xFC, 0x06, 0x0C, 0x30,
  0x60, 0xC3, 0x06, 0x0C, 0x30, 0x61, 0x83, 0x06, 0x18, 0x00, 0x1C, 0x3F,
  0x18, 0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x6C, 0x67,
  0xF1, 0xF0, 0x19, 0xDF, 0xB9, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x1C,
  0x3F, 0xB0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0F, 0xFF, 0xFC, 0x3C, 0x7F, 0xB0, 0xC0, 0x60, 0x30, 0x18, 0xF8, 0x7C,
  0x03, 0x00, 0xC0, 0x60, 0x7E, 0xF7, 0xF0, 0x01, 0x80, 0x70, 0x1E, 0x06,
  0xC0, 0xD8, 0x33, 0x0C, 0x61, 0x8C, 0x61, 0x9F, 0xFF, 0xFF, 0x80, 0xC0,
  0x18, 0x03, 0x00, 0x7F, 0x3F, 0x98, 0x0C, 0x04, 0x02, 0x03, 0xF8, 0x8E,
  0x01, 0x80, 0xC0, 0x60, 0x7F, 0xF7, 0xF0, 0x0F, 0x1F, 0x9C, 0x0C, 0x0C,
  0x06, 0x63, 0xFD, 0xC7, 0xC1, 0xE0, 0xF0, 0x6C, 0x37, 0x71, 0xF0, 0xFF,
  0xFF, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x06, 0x03,
  0x03, 0x03, 0x80, 0x1C, 0x3F, 0xB8, 0xD8, 0x3C, 0x33, 0x38, 0xF8, 0x7C,
  0x63, 0x60, 0xF0, 0x78, 0x3E, 0x73, 0xF0, 0x1C, 0x3F, 0x38, 0xD8, 0x3C,
  0x1E, 0x0F, 0x0E, 0xFF, 0x3D, 0x80, 0xC0, 0xC0, 0x65, 0xE3, 0xE0, 0xFC,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFB, 0x40, 0x00, 0x80, 0xC1, 0xC3,
  0x87, 0x06, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x40, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF8, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x3C, 0x70, 0xE0,
  0x40, 0x00, 0x3C, 0xFE, 0x43, 0x03, 0x03, 0x06, 0x0E, 0x18, 0x18, 0x10,
  0x00, 0x00, 0x38, 0x38, 0x01, 0xC0, 0x1F, 0xE0, 0xE0, 0x61, 0x00, 0x66,
  0x3E, 0x68, 0xCC, 0xF3, 0x19, 0xE6, 0x33, 0xCC, 0x67, 0x98, 0xCF, 0x3A,
  0xB6, 0x39, 0xC6, 0x00, 0x06, 0x02, 0x07, 0xF8, 0x01, 0xC0, 0x06, 0x00,
  0x70, 0x0F, 0x00, 0xD0, 0x0D, 0x81, 0x98, 0x18, 0xC3, 0x0C, 0x3F, 0xC3,
  0xFE, 0x60, 0x66, 0x06, 0x60, 0x3C, 0x03, 0xF8, 0x7F, 0xB0, 0xF8, 0x3C,
  0x1E, 0x1F, 0xF9, 0xFE, 0xC1, 0xE0, 0xF0, 0x78, 0x3F, 0xFF, 0xF0, 0x07,
  0x87, 0xF3, 0x85, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x06,
  0x01, 0xC0, 0x3F, 0xC7, 0xF0, 0xF8, 0x1F, 0xE3, 0x0E, 0x60, 0xEC, 0x0D,
  0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1B, 0x03, 0x60, 0xEF, 0xF9, 0xFC,
  0x00, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x3F, 0xFF, 0xC1, 0x83, 0x06, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x00, 0x07, 0x83, 0xFC, 0xE0, 0xB0, 0x06, 0x01, 0x80, 0x30,
  0x06, 0x1F, 0xC0, 0x7C, 0x0D, 0x81, 0xB8, 0x33, 0xFE, 0x3F, 0xC0, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x30, 0xFF, 0xD8, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC7, 0x7C, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x67,
  0xF7, 0x00, 0xC1, 0xF0, 0x6C, 0x33, 0x18, 0xCC, 0x36, 0x0F, 0x83, 0xE0,
  0xCC, 0x33, 0x8C, 0x73, 0x0C, 0xC1, 0xB0, 0x70, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F,
  0x80, 0xFE, 0x03, 0xFC, 0x0B, 0xF0, 0x6F, 0x61, 0xBD, 0x8C, 0xF6, 0x33,
  0xCC, 0x8F, 0x36, 0x3C, 0xD8, 0xF1, 0xC3, 0xC7, 0x0F, 0x0C, 0x30, 0xC0,
  0x7C, 0x0F, 0xC1, 0xF8, 0x3D, 0x87, 0xB0, 0xF3, 0x1E, 0x73, 0xC6, 0x78,
  0x6F, 0x0F, 0xE0, 0xFC, 0x0F, 0x81, 0xC0, 0x0F, 0x81, 0xFF, 0x1C, 0x18,
  0xC0, 0x6E, 0x03, 0x60, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x01, 0xD8,
  0x0C, 0xE0, 0xE3, 0xFE, 0x0F, 0xE0, 0xF8, 0x7F, 0x31, 0xD8, 0x7C, 0x1E,
  0x1F, 0x0D, 0xFE, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x0F, 0x81,
  0xFF, 0x1C, 0x18, 0xC0, 0x6E, 0x03, 0x60, 0x1F, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0x01, 0xD8, 0x0C, 0xE0, 0xE3, 0xFE, 0x0F, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0xF8, 0x3F, 0xCC, 0x33, 0x0E, 0xC1, 0xB0, 0xEC, 0x73, 0xF8,
  0xFC, 0x31, 0x8C, 0x73, 0x0C, 0xC1, 0xB0, 0x70, 0x1E, 0x3F, 0xB8, 0x58,
  0x0C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x60, 0x6F, 0xF7, 0xF0,
  0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x7F, 0x8F, 0xC0,
  0xC0, 0x3C, 0x06, 0x60, 0x66, 0x06, 0x60, 0xC3, 0x0C, 0x31, 0xC3, 0x98,
  0x19, 0x81, 0xB0, 0x0B, 0x00, 0xF0, 0x0E, 0x00, 0x60, 0xC0, 0xC0, 0xF8,
  0x30, 0x66, 0x1E, 0x19, 0x87, 0x86, 0x61, 0xE1, 0x9C, 0xC8, 0xC3, 0x33,
  0x30, 0xCC, 0xCC, 0x32, 0x33, 0x05, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78,
  0x1C, 0x0E, 0x03, 0x03, 0x00, 0xE0, 0x66, 0x0E, 0x30, 0xC3, 0x98, 0x1B,
  0x80, 0xF0, 0x0E, 0x00, 0xE0, 0x0F, 0x01, 0xB8, 0x31, 0x83, 0x0C, 0x60,
  0xEE, 0x07, 0xC0, 0x6C, 0x1D, 0x83, 0x18, 0xC3, 0x18, 0x36, 0x06, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xFF, 0xFF,
  0xC0, 0xE0, 0x60, 0x60, 0x70, 0x30, 0x30, 0x38, 0x18, 0x18, 0x1C, 0x0F,
  0xFF, 0xFC, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x1F,
  0xF8, 0xC0, 0xC1, 0x83, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x10, 0x30, 0x60,
  0x60, 0xC0, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x7F,
  0xF8, 0x08, 0x0C, 0x07, 0x06, 0x82, 0x63, 0x11, 0x0D, 0x82, 0xC1, 0x80,
  0xFF, 0xC6, 0x30, 0x7F, 0x63, 0x03, 0x03, 0x7F, 0xE3, 0xC3, 0xC3, 0xE7,
  0x7D, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0xE7, 0x3B, 0x0D, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x6F, 0xF5, 0xF0, 0x3F, 0x72, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xE0, 0x7F, 0x3F, 0x01, 0x80, 0xC0, 0x60, 0x33, 0xFB, 0x1F, 0x87, 0x83,
  0xC1, 0xE0, 0xF0, 0x7C, 0x37, 0x79, 0xEC, 0x3E, 0x31, 0xB0, 0x78, 0x3F,
  0xFE, 0x03, 0x01, 0xC0, 0x73, 0x1F, 0x80, 0x05, 0x1E, 0x30, 0x30, 0x30,
  0xFE, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3F, 0xB1,
  0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0x77, 0x9E, 0xC0, 0x60, 0x34,
  0x3B, 0xF8, 0x70, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xE3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFC, 0x06, 0xDB, 0x6D, 0xB6, 0xC0, 0x39,
  0xC0, 0x01, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x37, 0x90, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x76, 0x73, 0x71, 0xF0, 0xB0, 0x7C, 0x33, 0x19,
  0xCC, 0x66, 0x1C, 0xFF, 0xFF, 0xFF, 0xF0, 0xBE, 0xFD, 0xCF, 0x1B, 0x0C,
  0x36, 0x18, 0x7C, 0x30, 0xF8, 0x61, 0xF0, 0xC3, 0xE1, 0x87, 0xC3, 0x0F,
  0x86, 0x1C, 0xBF, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x3F, 0x18, 0xEE, 0x1B, 0x07, 0xC0, 0xF0, 0x3C, 0x1B, 0x86, 0x73, 0x8F,
  0x80, 0xBE, 0x73, 0xB0, 0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x86, 0xFF, 0x7F,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x3F, 0xB1, 0xF8, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0xC3, 0x77, 0x9E, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0xBE,
  0xDC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x7F, 0x87, 0x07, 0x07, 0x83,
  0xC1, 0x83, 0xCF, 0xF8, 0x10, 0x60, 0xC7, 0xF3, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0xD1, 0xE0, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x86,
  0xC3, 0x77, 0x9F, 0x40, 0xC0, 0xD8, 0x66, 0x19, 0x86, 0x33, 0x0C, 0xC1,
  0x20, 0x78, 0x1E, 0x03, 0x00, 0xC3, 0x86, 0xC7, 0x0D, 0x8B, 0x33, 0x36,
  0x62, 0x6C, 0xC6, 0xC9, 0x8D, 0x1E, 0x1E, 0x3C, 0x1C, 0x38, 0x30, 0x60,
  0xE1, 0xCC, 0xE3, 0xB0, 0x78, 0x0E, 0x07, 0x81, 0xF0, 0xCC, 0x71, 0xB8,
  0x70, 0xC0, 0xD8, 0x66, 0x18, 0xC6, 0x33, 0x0C, 0xC1, 0xA0, 0x78, 0x0E,
  0x03, 0x00, 0xC0, 0x30, 0x18, 0x3C, 0x06, 0x00, 0xFE, 0x0C, 0x30, 0xE1,
  0x86, 0x18, 0x30, 0xFF, 0xFC, 0x02, 0x3C, 0x60, 0xC1, 0x83, 0x06, 0x18,
  0xE1, 0xE0, 0x60, 0xC1, 0x83, 0x06, 0x0F, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x83, 0x86, 0x0C, 0x30, 0xC3, 0x0C, 0x1C, 0xF3, 0x0C, 0x30, 0xC6,
  0x38, 0xC0, 0xF8, 0xFF, 0xE1, 0xC0,
};

const GFXglyph NotoSans_Medium19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 6, 5, 8, 1, -14 },
  { 11, 12, 14, 12, 0, -14 },
  { 32, 9, 15, 11, 1, -14 },
  { 49, 14, 14, 16, 1, -14 },
  { 74, 13, 14, 14, 1, -14 },
  { 97, 2, 5, 5, 1, -14 },
  { 99, 4, 17, 6, 1, -14 },
  { 108, 4, 17, 6, 1, -14 },
  { 117, 9, 8, 10, 1, -14 },
  { 126, 9, 9, 11, 1, -11 },
  { 137, 3, 4, 5, 1, -2 },
  { 139, 4, 2, 6, 1, -6 },
  { 140, 3, 2, 5, 1, -2 },
  { 141, 7, 14, 7, 0, -14 },
  { 154, 9, 14, 11, 1, -14 },
  { 170, 5, 14, 11, 2, -14 },
  { 179, 9, 14, 11, 1, -14 },
  { 195, 9, 14, 11, 1, -14 },
  { 211, 11, 14, 11, 0, -14 },
  { 231, 9, 14, 11, 1, -14 },
  { 247, 9, 14, 11, 1, -14 },
  { 263, 9, 14, 11, 1, -14 },
  { 279, 9, 14, 11, 1, -14 },
  { 295, 9, 14, 11, 1, -14 },
  { 311, 3, 10, 5, 1, -10 },
  { 315, 3, 12, 5, 1, -10 },
  { 320, 9, 10, 11, 1, -12 },
  { 332, 9, 5, 11, 1, -9 },
  { 338, 9, 10, 11, 1, -12 },
  { 350, 8, 14, 9, 0, -14 },
  { 364, 15, 16, 17, 1, -14 },
  { 394, 12, 14, 12, 0, -14 },
  { 415, 9, 14, 12, 2, -14 },
  { 431, 10, 14, 12, 1, -14 },
  { 449, 11, 14, 14, 2, -14 },
  { 469, 7, 14, 11, 2, -14 },
  { 482, 7, 14, 10, 2, -14 },
  { 495, 11, 14, 14, 1, -14 },
  { 515, 10, 14, 14, 2, -14 },
  { 533, 5, 14, 7, 1, -14 },
  { 542, 5, 18, 6, -1, -14 },
  { 554, 10, 14, 12, 2, -14 },
  { 572, 8, 14, 10, 2, -14 },
  { 586, 14, 14, 17, 2, -14 },
  { 611, 11, 14, 15, 2, -14 },
  { 631, 13, 14, 15, 1, -14 },
  { 654, 9, 14, 12, 2, -14 },
  { 670, 13, 17, 15, 1, -14 },
  { 698, 10, 14, 12, 2, -14 },
  { 716, 9, 14, 10, 1, -14 },
  { 732, 10, 14, 11, 0, -14 },
  { 750, 10, 14, 14, 2, -14 },
  { 768, 12, 14, 12, 0, -14 },
  { 789, 18, 14, 18, 0, -14 },
  { 821, 12, 14, 12, 0, -14 },
  { 842, 11, 14, 11, 0, -14 },
  { 862, 9, 14, 11, 1, -14 },
  { 878, 5, 17, 6, 1, -14 },
  { 889, 7, 14, 7, 0, -14 },
  { 902, 5, 17, 6, 0, -14 },
  { 913, 9, 9, 11, 1, -14 },
  { 924, 8, 1, 8, 0, 2 },
  { 925, 4, 3, 6, 1, -15 },
  { 927, 8, 10, 11, 1, -10 },
  { 937, 9, 14, 12, 2, -14 },
  { 953, 8, 10, 9, 1, -10 },
  { 963, 9, 14, 12, 1, -14 },
  { 979, 9, 10, 11, 1, -10 },
  { 991, 8, 15, 7, 0, -15 },
  { 1006, 9, 15, 12, 1, -10 },
  { 1023, 8, 14, 12, 2, -14 },
  { 1037, 3, 14, 5, 1, -14 },
  { 1043, 5, 19, 5, -1, -14 },
  { 1055, 9, 14, 11, 2, -14 },
  { 1071, 2, 14, 5, 2, -14 },
  { 1075, 15, 10, 18, 2, -10 },
  { 1094, 8, 10, 12, 2, -10 },
  { 1104, 10, 10, 12, 1, -10 },
  { 1117, 9, 15, 12, 2, -10 },
  { 1134, 9, 15, 12, 1, -10 },
  { 1151, 6, 10, 8, 2, -10 },
  { 1159, 7, 10, 9, 1, -10 },
  { 1168, 7, 13, 7, 0, -13 },
  { 1180, 9, 10, 12, 1, -10 },
  { 1192, 10, 10, 10, 0, -10 },
  { 1205, 15, 10, 15, 0, -10 },
  { 1224, 10, 10, 10, 0, -10 },
  { 1237, 10, 15, 10, 0, -10 },
  { 1256, 7, 10, 9, 1, -10 },
  { 1265, 7, 17, 7, 0, -14 },
  { 1280, 2, 19, 10, 4, -14 },
  { 1285, 6, 17, 7, 1, -14 },
  { 1298, 9, 3, 11, 1, -8 },
};

const GFXfont NotoSans_Medium19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium19pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_MEDIUM19PT7B_H_
