#ifndef _NOTOSANS_MEDIUM26PT7B_H_
#define _NOTOSANS_MEDIUM26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF6, 0xC0, 0xFF, 0x80, 0xE7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0x80, 0x07, 0x18, 0x0C, 0x30, 0x18, 0xE0, 0x31, 0x80,
  0x63, 0x01, 0xC6, 0x1F, 0xFF, 0xBF, 0xFF, 0x0C, 0x60, 0x18, 0xC0, 0x71,
  0x80, 0xC3, 0x0F, 0xFF, 0xDF, 0xFF, 0x86, 0x30, 0x1C, 0x60, 0x30, 0xC0,
  0x61, 0x80, 0xC6, 0x00, 0x02, 0x00, 0x10, 0x01, 0xE0, 0x7F, 0xE7, 0xFF,
  0x39, 0x13, 0x88, 0x1C, 0x40, 0x72, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0,
  0x2F, 0x01, 0x18, 0x08, 0xF0, 0x4E, 0xFF, 0xF7, 0xFF, 0x07, 0xC0, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x3C, 0x03, 0x07, 0xE0, 0x70, 0x67, 0x06, 0x0E,
  0x30, 0xE0, 0xC3, 0x0C, 0x0C, 0x31, 0xC0, 0xC3, 0x18, 0x0C, 0x33, 0x00,
  0xE3, 0x37, 0xC6, 0x76, 0x7E, 0x7E, 0xEE, 0x73, 0xCC, 0xE3, 0x01, 0xCC,
  0x30, 0x18, 0xC3, 0x03, 0x8C, 0x30, 0x30, 0xC3, 0x06, 0x0E, 0x70, 0x60,
  0x7E, 0x0C, 0x03, 0xC0, 0x07, 0x80, 0x07, 0xF8, 0x03, 0xCE, 0x00, 0xE1,
  0xC0, 0x38, 0x70, 0x0E, 0x18, 0x01, 0x8E, 0x00, 0x7F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xF8, 0x39, 0xC7, 0x0C, 0xF0, 0xE7, 0x38, 0x1D, 0xCE,
  0x03, 0xE3, 0xC0, 0x78, 0x78, 0x7F, 0x1F, 0xFD, 0xE1, 0xFC, 0x3C, 0xFB,
  0x6D, 0xB0, 0x0C, 0x73, 0x8C, 0x71, 0xC6, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0x61, 0xC7, 0x0C, 0x38, 0x61, 0xC0, 0xC1, 0x87, 0x0C, 0x38,
  0xE1, 0x87, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x63, 0x8E, 0x71,
  0x8E, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xE6, 0x7F, 0xFF, 0x7F,
  0xE0, 0xF0, 0x1F, 0x81, 0x9C, 0x39, 0xE1, 0x08, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xE0, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x77, 0x76, 0xEC, 0xFF, 0xF0, 0xFF, 0x80, 0x01,
  0xC0, 0x60, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01,
  0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x00, 0x0F,
  0x80, 0xFE, 0x0F, 0x78, 0xE0, 0xE7, 0x07, 0x30, 0x3B, 0x80, 0xDC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x19, 0x81, 0xCE,
  0x0E, 0x38, 0xE1, 0xFF, 0x07, 0xF0, 0x07, 0x0F, 0x1F, 0x7F, 0xF7, 0x67,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x0F, 0x01, 0xFE, 0x3F, 0xF8, 0xC0, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0x83, 0xFF, 0x3F,
  0xF8, 0x80, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x1F, 0xC0, 0xFC,
  0x07, 0xF8, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xC0, 0x0E, 0xC0, 0xF7,
  0xFF, 0x1F, 0xE0, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x7E, 0x07,
  0x70, 0x33, 0x83, 0x9C, 0x38, 0xE1, 0x87, 0x1C, 0x39, 0xC1, 0xCC, 0x0E,
  0x7F, 0xFF, 0xFF, 0xE0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x7F, 0xCF,
  0xFB, 0xFF, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x20, 0xFF, 0x9F, 0xF8,
  0x07, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x81, 0xFF, 0xFB, 0xFC,
  0x00, 0x03, 0xE0, 0x7F, 0x07, 0xC8, 0x70, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x70, 0xEF, 0xE7, 0xEF, 0xBC, 0x1D, 0xC0, 0x7E, 0x03, 0xF0, 0x1D,
  0x80, 0xEE, 0x0E, 0x38, 0xF1, 0xFF, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x0F, 0x81, 0xFF, 0x1E, 0x3C, 0xE0, 0xE6, 0x07, 0x38,
  0x39, 0xC1, 0xC7, 0x1C, 0x1F, 0xC0, 0x7C, 0x0F, 0xF8, 0xE1, 0xEE, 0x07,
  0x70, 0x1F, 0x80, 0xFC, 0x07, 0x70, 0x73, 0xFF, 0x07, 0xF0, 0x0F, 0x01,
  0xFE, 0x1F, 0xF8, 0xE0, 0xEE, 0x07, 0x70, 0x1B, 0x80, 0xFC, 0x07, 0xE0,
  0x7B, 0x87, 0xDF, 0xEE, 0x3E, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x1C,
  0x01, 0xC3, 0xFE, 0x1F, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x77,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x76, 0xEE, 0xC0, 0x00, 0x08, 0x01, 0xC0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x80, 0x07, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x01, 0xE0,
  0x0C, 0x00, 0x00, 0x1F, 0x1F, 0xF9, 0xFF, 0x20, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0x00, 0x1C, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xF8, 0x01,
  0xE1, 0xF0, 0x3C, 0x01, 0xC1, 0x80, 0x07, 0x18, 0x1C, 0x19, 0xC3, 0xF8,
  0xCC, 0x38, 0xC3, 0x63, 0x86, 0x1B, 0x18, 0x30, 0xF8, 0xC1, 0x87, 0xC6,
  0x0C, 0x3E, 0x30, 0xE3, 0xB1, 0x87, 0x19, 0x8F, 0xEF, 0xCC, 0x3E, 0x38,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x40, 0x1F, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x6C, 0x00, 0x77,
  0x00, 0x3B, 0x80, 0x18, 0xC0, 0x1C, 0x70, 0x0E, 0x38, 0x06, 0x0C, 0x07,
  0x07, 0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0xE0, 0x38, 0xE0, 0x0E,
  0x70, 0x07, 0x38, 0x03, 0xB8, 0x00, 0xE0, 0xFF, 0x03, 0xFF, 0x8F, 0xFF,
  0x38, 0x1E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x1C, 0xFF, 0xE3, 0xFF,
  0x8E, 0x1F, 0x38, 0x0E, 0xE0, 0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x0E, 0xE0,
  0xFB, 0xFF, 0xCF, 0xFC, 0x00, 0x03, 0xE0, 0x7F, 0xF3, 0xFF, 0x9E, 0x02,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x18, 0xFF,
  0xE0, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xE7, 0x03, 0xEE, 0x01,
  0xDC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0x70, 0x1E, 0xE3, 0xF9, 0xFF,
  0xE3, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xFF, 0xDF, 0xFB, 0xFF, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xFB, 0xFF, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x03, 0xF0, 0x1F,
  0xFC, 0xFF, 0xF3, 0xE0, 0x27, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x81, 0xFF, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC,
  0x03, 0xBC, 0x07, 0x3C, 0x0E, 0x3F, 0xFC, 0x3F, 0xF0, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x38, 0xFF, 0xFD, 0xF1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x39,
  0xFF, 0xF8, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xF3, 0xFF, 0x7C, 0xE0,
  0x1F, 0x80, 0xEE, 0x07, 0x38, 0x3C, 0xE1, 0xE3, 0x87, 0x0E, 0x38, 0x39,
  0xC0, 0xEE, 0x03, 0xFC, 0x0F, 0xF8, 0x3C, 0xE0, 0xE1, 0xC3, 0x87, 0x8E,
  0x0E, 0x38, 0x1C, 0xE0, 0x7B, 0x80, 0xEE, 0x01, 0xC0, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x37,
  0xD8, 0x06, 0xFB, 0x81, 0xDF, 0x70, 0x33, 0xE6, 0x0E, 0x7C, 0xE1, 0x8F,
  0x8C, 0x31, 0xF1, 0x8E, 0x3E, 0x39, 0x87, 0xC3, 0x30, 0xF8, 0x7E, 0x1F,
  0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0x81, 0x80, 0xF0, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xEE, 0x07, 0xEF, 0x07,
  0xE7, 0x07, 0xE3, 0x87, 0xE3, 0xC7, 0xE1, 0xC7, 0xE0, 0xE7, 0xE0, 0xE7,
  0xE0, 0x77, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F,
  0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0x01, 0xC7, 0x00, 0x77, 0x00,
  0x3B, 0x80, 0x1D, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3B, 0xC0, 0x1C, 0xE0, 0x1C, 0x3C, 0x3E,
  0x0F, 0xFE, 0x03, 0xFC, 0x00, 0xFC, 0x07, 0xFE, 0x3F, 0xF9, 0xC1, 0xEE,
  0x07, 0x70, 0x1F, 0x80, 0xFC, 0x0E, 0xE0, 0x77, 0x1F, 0xBF, 0xF9, 0xFF,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00,
  0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0x01, 0xC7, 0x00, 0x77, 0x00,
  0x3B, 0x80, 0x1D, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3B, 0xC0, 0x1C, 0xE0, 0x1C, 0x3C, 0x3E,
  0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x7C, 0xFE, 0x03, 0xFF, 0x8F, 0xFF, 0x38, 0x1C, 0xE0, 0x7B, 0x80, 0xEE,
  0x03, 0xB8, 0x1C, 0xE0, 0x73, 0xFF, 0x8F, 0xFC, 0x38, 0x70, 0xE1, 0xC3,
  0x83, 0x8E, 0x0E, 0x38, 0x1C, 0xE0, 0x7B, 0x80, 0xEE, 0x01, 0xC0, 0x0F,
  0x83, 0xFF, 0x7F, 0xE7, 0x02, 0x60, 0x06, 0x00, 0x70, 0x07, 0x80, 0x3E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xE0,
  0xFF, 0xFE, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xD8, 0x03, 0xB8, 0x0E, 0x78, 0x3C, 0x7F, 0xF0,
  0x3F, 0x80, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x1C, 0x38, 0x1C, 0x38, 0x0C, 0x30,
  0x0E, 0x70, 0x0E, 0x70, 0x06, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x1C, 0x07, 0xE0, 0x3C, 0x07, 0x70, 0x3C,
  0x07, 0x70, 0x3C, 0x06, 0x70, 0x3E, 0x0E, 0x30, 0x76, 0x0E, 0x38, 0x76,
  0x0E, 0x38, 0x67, 0x0C, 0x38, 0xE7, 0x1C, 0x18, 0xE3, 0x1C, 0x1C, 0xC3,
  0x1C, 0x1C, 0xC3, 0x98, 0x1D, 0xC1, 0xB8, 0x0D, 0xC1, 0xB8, 0x0D, 0x81,
  0xB8, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x00,
  0xE0, 0xF0, 0x0E, 0x70, 0x0E, 0x38, 0x1C, 0x3C, 0x38, 0x1C, 0x38, 0x0E,
  0x70, 0x0E, 0x60, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xE0, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x38, 0x38, 0x3C, 0x38, 0x1C, 0x70,
  0x0E, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1D, 0xC0, 0x71, 0xC0, 0xE3, 0x83,
  0x83, 0x8E, 0x07, 0x1C, 0x07, 0x70, 0x0E, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0xFF, 0xC0, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x01,
  0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x0C,
  0x03, 0x80, 0x60, 0x1C, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F, 0xFF, 0xC0, 0x06, 0x00,
  0x30, 0x03, 0xC0, 0x1F, 0x01, 0xD8, 0x0C, 0xE0, 0x63, 0x06, 0x1C, 0x30,
  0x63, 0x03, 0x98, 0x0D, 0x80, 0x70, 0xFF, 0xFF, 0xFC, 0xF1, 0xC3, 0x87,
  0x1F, 0xC3, 0xFE, 0x30, 0xF0, 0x07, 0x00, 0x70, 0x0F, 0x3F, 0xF7, 0xC7,
  0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0x7F, 0xF3, 0xF3, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xBF, 0x1F, 0xFC, 0xF0, 0xF7,
  0x03, 0xB8, 0x0D, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x06, 0xF0,
  0x77, 0xC7, 0xBF, 0xF9, 0x9F, 0x80, 0x0F, 0xE7, 0xFD, 0xE1, 0x38, 0x07,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x33, 0xFE,
  0x3F, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x7E, 0xE7, 0xFF, 0x78, 0x7B, 0x81, 0xDC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xEE, 0x07, 0x70, 0x3B, 0xC3, 0xCF, 0xFE, 0x3F, 0x30, 0x0F,
  0xC1, 0xFF, 0x1E, 0x1C, 0xE0, 0xE6, 0x03, 0x70, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x23, 0xFF, 0x07, 0xF8, 0x07, 0xC3,
  0xF1, 0xE4, 0x70, 0x1C, 0x07, 0x07, 0xFB, 0xFE, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1F,
  0x99, 0xFF, 0xDE, 0x1E, 0xE0, 0x77, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3B, 0x01, 0xDC, 0x0E, 0xF0, 0xF3, 0xFF, 0x8F, 0xDC, 0x00, 0xE0,
  0x07, 0x00, 0x3B, 0x03, 0x9F, 0xFC, 0x7F, 0x80, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xEF, 0xCF, 0xFE, 0xF8, 0xFF, 0x07, 0xE0,
  0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xFD, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x70,
  0xC0, 0x00, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xFE, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0xFE, 0x1E, 0xE3, 0xCE, 0x38, 0xE7, 0x0E, 0xE0, 0xFE,
  0x0F, 0xF0, 0xF7, 0x0E, 0x38, 0xE1, 0xCE, 0x1E, 0xE0, 0xEE, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xCF, 0xC7, 0xE7, 0xFF, 0x7F,
  0xBC, 0x3E, 0x1D, 0xE0, 0xE0, 0x6E, 0x07, 0x03, 0xF0, 0x38, 0x1F, 0x81,
  0xC0, 0xFC, 0x0E, 0x07, 0xE0, 0x70, 0x3F, 0x03, 0x81, 0xF8, 0x1C, 0x0F,
  0xC0, 0xE0, 0x7E, 0x07, 0x03, 0xF0, 0x38, 0x1C, 0xCF, 0xCF, 0xFE, 0xF8,
  0xFF, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0x0F, 0xC0, 0xFF, 0xC7, 0x87, 0x1C, 0x0E,
  0x70, 0x3B, 0x80, 0x6E, 0x01, 0xF8, 0x07, 0xE0, 0x19, 0xC0, 0xE7, 0x03,
  0x8E, 0x1C, 0x3F, 0xF0, 0x3F, 0x00, 0xEF, 0xC7, 0xFF, 0x3C, 0x3D, 0xC0,
  0xEE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xBC, 0x1D,
  0xF1, 0xEF, 0xFE, 0x77, 0xE3, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x1F, 0x99, 0xFF, 0xDE, 0x1E, 0xE0, 0x77, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3B, 0x81, 0xDC, 0x0E, 0xF0, 0xF3, 0xFF,
  0x8F, 0xDC, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0xC7, 0xFF, 0xBF, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x00, 0x3F, 0xDF, 0xFE, 0x07, 0x80, 0xF0, 0x1F, 0x03,
  0xF0, 0x3E, 0x03, 0xC0, 0x30, 0x0F, 0x07, 0xFF, 0xFF, 0xE0, 0x18, 0x0C,
  0x06, 0x0F, 0xFF, 0xF9, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0x70, 0x3F, 0x0F, 0x80, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F,
  0x7F, 0xB3, 0xF3, 0xE0, 0x1D, 0x80, 0xE7, 0x03, 0x9C, 0x0C, 0x38, 0x70,
  0xE1, 0xC3, 0x8E, 0x07, 0x38, 0x1C, 0xC0, 0x37, 0x00, 0xFC, 0x03, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xE0, 0x70, 0x3B, 0x03, 0x83, 0x9C, 0x3E, 0x1C,
  0xE1, 0xB0, 0xE3, 0x0D, 0x86, 0x1C, 0xEE, 0x70, 0xE6, 0x73, 0x87, 0x31,
  0x9C, 0x1B, 0x8C, 0xC0, 0xDC, 0x7E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x00,
  0xF0, 0x78, 0x07, 0x03, 0xC0, 0x70, 0x3C, 0xE1, 0xC3, 0x87, 0x07, 0x38,
  0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xC0, 0x7B, 0x81, 0xCE,
  0x0E, 0x1C, 0x78, 0x3B, 0xC0, 0xF0, 0xE0, 0x1D, 0xC0, 0xE7, 0x03, 0x9C,
  0x0C, 0x38, 0x70, 0xE1, 0xC1, 0x86, 0x07, 0x38, 0x1C, 0xE0, 0x37, 0x00,
  0xFC, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x0F, 0xC0, 0x3E, 0x00, 0xFF, 0xFF, 0xF0, 0x1C, 0x0E, 0x07, 0x01,
  0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xFF, 0xFF, 0xF0, 0x01,
  0x0F, 0x1F, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x78, 0xE0, 0xF0,
  0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x1F, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0xF0, 0xF8, 0x38, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x1E, 0x07, 0x0F, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x38, 0x38, 0xF0, 0xE0, 0x7C, 0x0F, 0xFD, 0xF1, 0xFD, 0x01, 0x80,
};

const GFXglyph NotoSans_Medium26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 19, 7, 2, -19 },
  { 9, 7, 7, 11, 2, -19 },
  { 16, 15, 19, 17, 1, -19 },
  { 52, 13, 22, 15, 1, -20 },
  { 88, 20, 19, 22, 1, -19 },
  { 136, 18, 19, 19, 1, -19 },
  { 179, 3, 7, 6, 2, -19 },
  { 182, 6, 23, 8, 1, -19 },
  { 200, 6, 23, 8, 1, -19 },
  { 218, 12, 12, 14, 1, -20 },
  { 236, 13, 12, 15, 1, -15 },
  { 256, 4, 6, 7, 1, -3 },
  { 259, 6, 2, 8, 1, -8 },
  { 261, 3, 3, 7, 2, -3 },
  { 263, 10, 19, 10, 0, -19 },
  { 287, 13, 19, 15, 1, -19 },
  { 318, 8, 19, 15, 2, -19 },
  { 337, 13, 19, 15, 1, -19 },
  { 368, 13, 19, 15, 1, -19 },
  { 399, 13, 19, 15, 1, -19 },
  { 430, 11, 19, 15, 2, -19 },
  { 457, 13, 19, 15, 1, -19 },
  { 488, 13, 19, 15, 1, -19 },
  { 519, 13, 19, 15, 1, -19 },
  { 550, 13, 19, 15, 1, -19 },
  { 581, 3, 14, 7, 2, -14 },
  { 587, 4, 17, 7, 1, -14 },
  { 596, 13, 13, 15, 1, -16 },
  { 618, 12, 7, 15, 1, -13 },
  { 629, 13, 13, 15, 1, -16 },
  { 651, 11, 19, 12, 0, -19 },
  { 678, 21, 21, 23, 1, -19 },
  { 734, 17, 19, 17, 0, -19 },
  { 775, 14, 19, 17, 2, -19 },
  { 809, 14, 19, 17, 2, -19 },
  { 843, 15, 19, 19, 2, -19 },
  { 879, 11, 19, 14, 2, -19 },
  { 906, 11, 19, 14, 2, -19 },
  { 933, 15, 19, 19, 2, -19 },
  { 969, 15, 19, 19, 2, -19 },
  { 1005, 7, 19, 9, 1, -19 },
  { 1022, 7, 24, 8, -2, -19 },
  { 1043, 14, 19, 16, 2, -19 },
  { 1077, 11, 19, 14, 2, -19 },
  { 1104, 19, 19, 24, 2, -19 },
  { 1150, 16, 19, 20, 2, -19 },
  { 1188, 17, 19, 20, 2, -19 },
  { 1229, 13, 19, 16, 2, -19 },
  { 1260, 17, 23, 20, 2, -19 },
  { 1309, 14, 19, 16, 2, -19 },
  { 1343, 12, 19, 14, 1, -19 },
  { 1372, 14, 19, 15, 0, -19 },
  { 1406, 15, 19, 19, 2, -19 },
  { 1442, 16, 19, 16, 0, -19 },
  { 1480, 24, 19, 24, 0, -19 },
  { 1537, 16, 19, 16, 0, -19 },
  { 1575, 15, 19, 15, 0, -19 },
  { 1611, 13, 19, 15, 1, -19 },
  { 1642, 6, 23, 9, 2, -19 },
  { 1660, 10, 19, 10, 0, -19 },
  { 1684, 6, 23, 9, 1, -19 },
  { 1702, 13, 12, 15, 1, -19 },
  { 1722, 11, 2, 11, 0, 2 },
  { 1725, 6, 4, 8, 1, -20 },
  { 1728, 12, 14, 15, 1, -14 },
  { 1749, 13, 20, 16, 2, -20 },
  { 1782, 11, 14, 13, 1, -14 },
  { 1802, 13, 20, 16, 1, -20 },
  { 1835, 13, 14, 15, 1, -14 },
  { 1858, 10, 20, 9, 0, -20 },
  { 1883, 13, 20, 16, 1, -14 },
  { 1916, 12, 20, 16, 2, -20 },
  { 1946, 3, 19, 7, 2, -19 },
  { 1954, 6, 25, 7, -1, -19 },
  { 1973, 12, 20, 15, 2, -20 },
  { 2003, 3, 20, 7, 2, -20 },
  { 2011, 21, 14, 25, 2, -14 },
  { 2048, 12, 14, 16, 2, -14 },
  { 2069, 14, 14, 16, 1, -14 },
  { 2094, 13, 20, 16, 2, -14 },
  { 2127, 13, 20, 16, 1, -14 },
  { 2160, 9, 14, 11, 2, -14 },
  { 2176, 10, 14, 13, 1, -14 },
  { 2194, 9, 17, 10, 0, -17 },
  { 2214, 12, 14, 16, 2, -14 },
  { 2235, 14, 14, 14, 0, -14 },
  { 2260, 21, 14, 21, 0, -14 },
  { 2297, 14, 14, 14, 0, -14 },
  { 2322, 14, 20, 14, 0, -14 },
  { 2357, 10, 14, 12, 1, -14 },
  { 2375, 8, 23, 10, 1, -19 },
  { 2398, 2, 26, 14, 6, -20 },
  { 2405, 8, 23, 10, 1, -19 },
  { 2428, 13, 4, 15, 1, -11 },
};

const GFXfont NotoSans_Medium26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium26pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_MEDIUM26PT7B_H_
