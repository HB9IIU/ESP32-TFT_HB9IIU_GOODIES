#ifndef _NOTOSANS_MEDIUM61PT7B_H_
#define _NOTOSANS_MEDIUM61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium61pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC3, 0xFB, 0xFD, 0xFE, 0xFF, 0xFF,
  0xBF, 0xCF, 0xE3, 0xC0, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x7C, 0x0F,
  0xDF, 0x03, 0xF7, 0xC0, 0xFD, 0xF0, 0x3E, 0x7C, 0x07, 0x9F, 0x01, 0xE7,
  0x80, 0x79, 0xE0, 0x1E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFB, 0xC7, 0xF0, 0xFE, 0x1E, 0x03, 0x87,
  0xE0, 0xF0, 0x00, 0x7F, 0x07, 0x80, 0x03, 0xF8, 0x3C, 0x00, 0x1F, 0xC1,
  0xE0, 0x00, 0x7E, 0x0F, 0x00, 0x03, 0xF8, 0x78, 0x00, 0x1F, 0xE3, 0xC0,
  0x00, 0xFF, 0xDE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xF1,
  0xFF, 0x00, 0x07, 0x83, 0xF8, 0x00, 0x3C, 0x0F, 0xE0, 0x01, 0xE0, 0x7F,
  0x00, 0x0F, 0x03, 0xF8, 0x00, 0x78, 0x1F, 0xC0, 0x03, 0xC0, 0xFF, 0x80,
  0x1E, 0x0F, 0xEF, 0x80, 0xF0, 0xFF, 0x7F, 0xC7, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x0F,
  0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF0, 0x01, 0xF0,
  0x3E, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x00, 0x3F, 0x01,
  0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x1F,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0,
  0x0F, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0xF8, 0x07, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x07, 0xC0,
  0x78, 0x0F, 0x80, 0x7C, 0x3F, 0x0F, 0xF8, 0x3F, 0x03, 0xF0, 0xF8, 0x7F,
  0xF8, 0x7C, 0x0F, 0xC7, 0xE3, 0xFF, 0xF1, 0xF0, 0x3E, 0x1F, 0x1F, 0xFF,
  0xC7, 0xF3, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0xFF, 0xC3, 0xE3, 0xF0, 0x3E,
  0x1F, 0xFE, 0x1F, 0x0F, 0xC0, 0xF8, 0x3F, 0xF0, 0xFC, 0x3E, 0x03, 0xF0,
  0x3F, 0x83, 0xE0, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x1F, 0x00,
  0x00, 0x7C, 0x1F, 0x80, 0x7C, 0x00, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x00,
  0x0F, 0x81, 0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x00, 0x01,
  0xF0, 0x1F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0xC0,
  0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xE0, 0x3F, 0xFF, 0xE0, 0x03, 0xF8, 0x1F, 0xF7, 0xFC, 0x00, 0xFE,
  0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC,
  0x01, 0xFE, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0xC3, 0xF8, 0x3F, 0x80, 0x07,
  0xF8, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x0F,
  0xE0, 0x00, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE3, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xF0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9E, 0x3C,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x60, 0x0F, 0x80, 0x33, 0xF0, 0x7C, 0x1F,
  0x9F, 0xF1, 0xE7, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0x00, 0xF0, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x8F, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F,
  0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x3F, 0xBF, 0xDF, 0xEF, 0xFF, 0xFB,
  0xFC, 0xFE, 0x3C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFC, 0x7F, 0xC0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC,
  0x7E, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F,
  0x80, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x7F, 0xBF, 0x3F, 0xDF, 0xDF, 0xE7, 0xFF,
  0xF1, 0xFD, 0xF8, 0x7F, 0x38, 0x1F, 0xCC, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xF8,
  0xFF, 0xE1, 0xFC, 0x00, 0xFF, 0x07, 0xC0, 0x03, 0xFC, 0x18, 0x00, 0x0F,
  0xE0, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xE1, 0xF8, 0x00, 0xFF, 0x87, 0x00, 0x01,
  0xFC, 0x10, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE8, 0x00, 0x00, 0xFF, 0x60, 0x00,
  0x0F, 0xF3, 0xF0, 0x01, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0xE0, 0x0F,
  0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x07,
  0xE0, 0x00, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F,
  0x87, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x80, 0x00, 0x1F, 0xCC, 0x00, 0x03, 0xFC, 0xF8, 0x00, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0xF4, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x20, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x80, 0x03, 0xF0, 0xFF,
  0xE0, 0x3F, 0x9F, 0xFF, 0xC1, 0xF9, 0xFF, 0xFF, 0x0F, 0xDF, 0xFF, 0xFC,
  0x7E, 0xFF, 0xFF, 0xF3, 0xFF, 0x80, 0x7F, 0xDF, 0xF0, 0x00, 0xFE, 0xFF,
  0x00, 0x03, 0xF7, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0x81, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0xFE,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x3F, 0x9F, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7E,
  0x1F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x03, 0xF8, 0x1F,
  0xE0, 0x3F, 0x80, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xF1, 0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x0F,
  0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xE7, 0xE0, 0x00, 0x7F, 0x7F, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xF9, 0xFE, 0x00, 0x3F, 0xC7, 0xFF,
  0xBF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x0F, 0xE0,
  0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x01,
  0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0xFF, 0xBF, 0xC0, 0x0F, 0xFC, 0xFF, 0x01, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF,
  0x1F, 0xFF, 0xF9, 0xF8, 0x7F, 0xFF, 0x9F, 0xC0, 0xFF, 0xF8, 0xFC, 0x01,
  0xFF, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x18, 0x3F, 0x3F, 0xDF, 0xEF, 0xFF, 0xFB,
  0xFC, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x0F,
  0xEF, 0xF7, 0xFB, 0xFF, 0xFE, 0xFF, 0x3F, 0x8F, 0x00, 0x06, 0x07, 0xE3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0x7F, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xCF, 0xE3, 0xF8,
  0xFE, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xC3, 0xF0, 0xF8,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFC, 0x3F,
  0xF9, 0xE0, 0x03, 0xFC, 0x40, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF4, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x1F,
  0xFF, 0xE0, 0x3E, 0x1F, 0x00, 0x3F, 0xFF, 0xE0, 0x3E, 0x3F, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0x3E, 0x00, 0xFF, 0x8F, 0xE0, 0x1F, 0x3E, 0x01, 0xFC,
  0x03, 0xE0, 0x1F, 0x7E, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0x7C, 0x03, 0xF0,
  0x03, 0xE0, 0x1F, 0x7C, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x7C, 0x07, 0xE0,
  0x03, 0xE0, 0x0F, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0xFC, 0x07, 0xC0,
  0x03, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0xF8, 0x0F, 0xC0,
  0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xC0,
  0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0xFC, 0x07, 0xC0,
  0x0F, 0xE0, 0x3E, 0x7C, 0x07, 0xE0, 0x0F, 0xE0, 0x3E, 0x7C, 0x07, 0xF0,
  0x1F, 0xE0, 0x7C, 0x7C, 0x03, 0xF8, 0x3F, 0xF0, 0xFC, 0x7C, 0x01, 0xFF,
  0xFC, 0xFF, 0xF8, 0x7E, 0x01, 0xFF, 0xF8, 0xFF, 0xF0, 0x3E, 0x00, 0xFF,
  0xF0, 0x7F, 0xE0, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x3F, 0x00, 0x0F, 0xFC, 0x7E, 0x00, 0x07, 0xFC, 0xFC, 0x00, 0x07, 0xF9,
  0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x1F, 0xCF,
  0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0xFE, 0x7E,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0xC3, 0xF0,
  0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFC, 0x00,
  0x1F, 0xF1, 0xF8, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x0F, 0xF7, 0xE0, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0x3F,
  0xDF, 0x80, 0x01, 0xFF, 0x3F, 0x00, 0x3F, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x78, 0x1F, 0xF0, 0x00,
  0x0C, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x10, 0x1F, 0xFE, 0x01, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0x00, 0x0F, 0xFF, 0x07, 0xE0, 0x00, 0x3F, 0xF0, 0xFC, 0x00, 0x03,
  0xFE, 0x1F, 0x80, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x01, 0xFE, 0x7E, 0x00,
  0x00, 0x3F, 0xCF, 0xC0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0xBF,
  0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00,
  0x0F, 0xF7, 0xE0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0x80,
  0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x03, 0xFC, 0x7E, 0x00, 0x01, 0xFF, 0x0F,
  0xC0, 0x00, 0x7F, 0xE1, 0xF8, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xC0, 0xFF, 0xC0, 0x00, 0x08, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0x7F,
  0x80, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x07,
  0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0xC0,
  0x00, 0x7F, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xF0, 0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC0,
  0xFF, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x7E, 0x00, 0x00, 0x7F, 0x3F, 0x00,
  0x00, 0x7F, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7F, 0x87, 0xE0,
  0x00, 0x7F, 0x83, 0xF0, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0x7F, 0x80, 0xFC,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0xC0, 0x07, 0xE0, 0x3F, 0xC0, 0x03,
  0xF0, 0x3F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0x7E, 0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x0F, 0xDF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xDF, 0xE0, 0x00, 0x7F, 0xC7, 0xF8,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0x80, 0xFF, 0x00, 0x0F, 0xC0, 0x3F,
  0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x01, 0xF8, 0x01,
  0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x3F, 0xC0, 0x3F, 0x00,
  0x0F, 0xF0, 0x1F, 0x80, 0x03, 0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0x7F, 0x83, 0xF0, 0x00, 0x1F, 0xE1, 0xF8, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x03, 0xFC, 0x7E, 0x00, 0x00, 0xFF, 0x3F, 0x00, 0x00, 0x3F, 0xDF,
  0x80, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xBF, 0x00, 0x00, 0x0F, 0xFF, 0xFB, 0xF0, 0x00, 0x00, 0xFB, 0xFF,
  0x9F, 0x00, 0x00, 0x1F, 0xBF, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xFF, 0xDF,
  0x80, 0x00, 0x1F, 0x3F, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xFF, 0xCF, 0xC0,
  0x00, 0x3F, 0x3F, 0xFC, 0xFC, 0x00, 0x03, 0xE3, 0xFF, 0xC7, 0xE0, 0x00,
  0x7E, 0x3F, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xFF, 0xC7, 0xE0, 0x00, 0x7C,
  0x3F, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0x00, 0xF8, 0x3F,
  0xFC, 0x3F, 0x00, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0xFC,
  0x1F, 0x80, 0x1F, 0x03, 0xFF, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0xFC, 0x0F,
  0xC0, 0x3F, 0x03, 0xFF, 0xC0, 0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x07, 0xE0,
  0x7E, 0x03, 0xFF, 0xC0, 0x7E, 0x07, 0xC0, 0x3F, 0xFC, 0x07, 0xE0, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0xF8, 0x03,
  0xFF, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0x9F, 0x00, 0x3F, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xBF, 0x80, 0x00, 0x7F, 0xF9, 0xFC, 0x00,
  0x07, 0xFF, 0x9F, 0xE0, 0x00, 0x7F, 0xFC, 0xFE, 0x00, 0x07, 0xFF, 0xCF,
  0xF0, 0x00, 0x7F, 0xFC, 0x7F, 0x80, 0x07, 0xFF, 0xC3, 0xF8, 0x00, 0x7F,
  0xFC, 0x3F, 0xC0, 0x07, 0xFF, 0xC1, 0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0xE0,
  0x07, 0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xF0, 0x07, 0xFF, 0xC0,
  0x7F, 0x80, 0x7F, 0xFC, 0x03, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xC0, 0x7F,
  0xFC, 0x01, 0xFE, 0x07, 0xFF, 0xC0, 0x0F, 0xE0, 0x7F, 0xFC, 0x00, 0x7F,
  0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x3F, 0xFC, 0x00, 0x3F, 0x83, 0xFF, 0xC0,
  0x03, 0xFC, 0x3F, 0xFC, 0x00, 0x1F, 0xE3, 0xFF, 0xC0, 0x00, 0xFE, 0x3F,
  0xFC, 0x00, 0x0F, 0xF3, 0xFF, 0xC0, 0x00, 0x7F, 0x3F, 0xFC, 0x00, 0x03,
  0xFB, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE7, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x1A, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0xFC, 0x00, 0xFF, 0xEF, 0xC0, 0x03, 0xFE, 0xFC, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x01,
  0xFE, 0xFC, 0x00, 0x3F, 0xEF, 0xC0, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xE7, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x7F, 0xE0, 0xFC,
  0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x1F, 0xE0, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x03, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xFE, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC,
  0x3F, 0xC0, 0x07, 0x87, 0xF8, 0x00, 0x08, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x80, 0x00, 0x0F,
  0xEF, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00,
  0xFC, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x3F, 0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x07, 0xE3,
  0xF8, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x00, 0xFD, 0xFC, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xF8, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF7,
  0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0x1F,
  0x80, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xE0, 0x1F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE3, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x7E,
  0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0xFC, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00,
  0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0xFC,
  0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0x07, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x00,
  0x1F, 0x87, 0xE0, 0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF1,
  0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF9, 0xF8,
  0x00, 0x7C, 0x7E, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE1, 0xFC,
  0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0,
  0x01, 0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xFC, 0x3E,
  0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x7F, 0x81, 0x80, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xC0, 0xFD,
  0xFF, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xF7, 0xFF, 0x7F,
  0xFE, 0xFF, 0xFF, 0xE7, 0xCF, 0xFF, 0xF8, 0xF8, 0xFF, 0xFE, 0x1F, 0x07,
  0xFF, 0x03, 0xE0, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x7F, 0xE0, 0x0F, 0xC7,
  0xFF, 0xE0, 0x3F, 0x3F, 0xFF, 0xE0, 0xFD, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x07,
  0xF3, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE,
  0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xBF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03,
  0xFB, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x7F, 0x3F, 0xE0, 0x03, 0xFC,
  0xFF, 0xE0, 0x3F, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xDF, 0xFF, 0xFC, 0x3F,
  0x3F, 0xFF, 0xE0, 0xF8, 0x7F, 0xFF, 0x03, 0xE0, 0x7F, 0xF0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0xF0, 0xFF, 0x80,
  0x08, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x43, 0xFE, 0x00, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x03, 0xFF, 0x87, 0xF0, 0x3F, 0xFF, 0x9F, 0xC1, 0xFF,
  0xFF, 0x3F, 0x0F, 0xFF, 0xFE, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0x01,
  0xFF, 0xCF, 0xF0, 0x03, 0xFF, 0x3F, 0x80, 0x07, 0xFD, 0xFE, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x0F,
  0xF3, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x1F, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xEF, 0xC1, 0xFF, 0xFF, 0x3F, 0x03,
  0xFF, 0xF8, 0xFC, 0x03, 0xFF, 0x81, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0x9F,
  0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x08, 0x3F, 0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0xFC, 0x0F,
  0xFF, 0xE3, 0xF0, 0x7F, 0xFF, 0xCF, 0xC3, 0xFF, 0xFF, 0xBF, 0x1F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xC0, 0x7F, 0xF3, 0xFC, 0x00, 0xFF, 0xCF, 0xE0, 0x01,
  0xFF, 0x7F, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x7F, 0x7F, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x7F,
  0xC7, 0xF8, 0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFB, 0xF0,
  0x7F, 0xFF, 0xDF, 0xC0, 0xFF, 0xFE, 0x7F, 0x00, 0xFF, 0xE1, 0xFC, 0x00,
  0x3C, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x10, 0x00, 0x07, 0xF8, 0x78, 0x00, 0x7F, 0xC1, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC1, 0xFF, 0xC0, 0xFC, 0x3F, 0xFF, 0x0F,
  0xCF, 0xFF, 0xFC, 0xFD, 0xFF, 0xFF, 0xCF, 0xDF, 0xFF, 0xFE, 0xFF, 0xE0,
  0x1F, 0xEF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xDF,
  0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xC0, 0x00, 0x7C, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0xBF, 0xFF, 0x7F,
  0xFC, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFB,
  0xF0, 0x00, 0x7F, 0x9F, 0x80, 0x07, 0xF8, 0xFC, 0x00, 0x7F, 0x87, 0xE0,
  0x07, 0xF8, 0x3F, 0x00, 0x7F, 0x81, 0xF8, 0x07, 0xF8, 0x0F, 0xC0, 0x7F,
  0x80, 0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x83, 0xF8, 0x00,
  0xFC, 0x3F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xFB,
  0xFC, 0x00, 0x0F, 0xDF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0x9F, 0xE0, 0x07, 0xF8, 0x7F, 0x00,
  0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0xF0, 0x0F, 0xC0, 0x3F, 0xC0, 0x7E,
  0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xE0, 0xFC, 0x00,
  0x7F, 0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F,
  0xCF, 0xC0, 0x00, 0xFF, 0x7E, 0x00, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x1F, 0xFC, 0x00, 0xFF,
  0xC0, 0xF8, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0xFD, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFE, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0x87, 0xFF, 0xF0, 0xFC, 0xFF, 0xFF, 0xCF,
  0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFE,
  0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x1F, 0xFC,
  0x03, 0xF1, 0xFF, 0xF8, 0x0F, 0xCF, 0xFF, 0xF8, 0x3F, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0x3F,
  0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7E,
  0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x1F, 0xCF, 0xF8,
  0x00, 0xFF, 0x3F, 0xF8, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xF7, 0xFF,
  0xFF, 0x0F, 0xCF, 0xFF, 0xF8, 0x3F, 0x1F, 0xFF, 0xC0, 0xFC, 0x1F, 0xFC,
  0x03, 0xF0, 0x06, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0xFC, 0x0F, 0xFF, 0xE3, 0xF0, 0x7F, 0xFF, 0xCF, 0xC3, 0xFF, 0xFF, 0xBF,
  0x1F, 0xFF, 0xFE, 0xFC, 0x7F, 0x80, 0x7F, 0xF3, 0xFC, 0x00, 0x7F, 0xCF,
  0xE0, 0x01, 0xFF, 0x7F, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xF7, 0xF0,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x7F, 0xC7, 0xF8, 0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFB, 0xF0, 0x7F, 0xFF, 0xDF, 0xC0, 0xFF, 0xFC, 0x7F, 0x00, 0xFF, 0xE1,
  0xFC, 0x00, 0x30, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x0F, 0xFF,
  0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0xEF, 0xDF, 0xEE,
  0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF,
  0x00, 0x3C, 0xFE, 0x00, 0x04, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0xFF, 0xDF, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xF7, 0xF8, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0x3F,
  0xFF, 0xF1, 0xF0, 0xFF, 0xFE, 0x1F, 0x07, 0xFF, 0x81, 0xF0, 0x03, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x03,
  0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x0F,
  0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x1F,
  0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7E, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0xF0, 0x00,
  0xFE, 0x7E, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0xF8, 0x00,
  0xFC, 0x7F, 0x00, 0x3E, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3E, 0xF8, 0x01,
  0xF8, 0x3F, 0x00, 0x3E, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0xFC, 0x01,
  0xF8, 0x1F, 0x80, 0x7C, 0x7C, 0x03, 0xF8, 0x1F, 0x80, 0x7C, 0x7C, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x7E, 0x07,
  0xF0, 0x0F, 0xC0, 0xF8, 0x3E, 0x07, 0xF0, 0x0F, 0xC0, 0xF8, 0x3F, 0x07,
  0xE0, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x0F, 0xE1, 0xF8, 0x1F, 0x0F,
  0xE0, 0x07, 0xE1, 0xF0, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x1F, 0x8F,
  0xC0, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x03, 0xF3, 0xE0, 0x0F, 0x9F,
  0xC0, 0x03, 0xF3, 0xE0, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x0F, 0xDF,
  0x80, 0x03, 0xF7, 0xC0, 0x07, 0xDF, 0x80, 0x01, 0xF7, 0xC0, 0x07, 0xDF,
  0x00, 0x01, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC,
  0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x1F, 0xC0,
  0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80,
  0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F,
  0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x1F,
  0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03,
  0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01,
  0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0xFC, 0x3F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x09, 0xFF,
  0xE0, 0x00, 0xDF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xD0, 0x00, 0x3F, 0xF8,
  0x80, 0x00, 0x1F, 0x00,
};

const GFXglyph NotoSans_Medium61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 9, 45, 17, 4, -44 },
  { 52, 18, 16, 26, 4, -44 },
  { 88, 37, 44, 39, 1, -44 },
  { 292, 29, 50, 35, 3, -46 },
  { 474, 46, 45, 52, 3, -44 },
  { 733, 42, 45, 45, 3, -44 },
  { 970, 7, 16, 14, 4, -44 },
  { 984, 15, 54, 19, 2, -44 },
  { 1086, 15, 54, 19, 2, -44 },
  { 1188, 29, 27, 33, 2, -46 },
  { 1286, 29, 29, 35, 3, -36 },
  { 1392, 10, 15, 17, 2, -7 },
  { 1411, 15, 5, 20, 2, -19 },
  { 1421, 9, 9, 17, 4, -8 },
  { 1432, 22, 44, 23, 1, -44 },
  { 1553, 29, 45, 35, 3, -44 },
  { 1717, 18, 44, 35, 5, -44 },
  { 1816, 29, 44, 35, 3, -44 },
  { 1976, 29, 45, 35, 3, -44 },
  { 2140, 33, 44, 35, 1, -44 },
  { 2322, 28, 45, 35, 4, -44 },
  { 2480, 29, 45, 35, 3, -44 },
  { 2644, 30, 44, 35, 2, -44 },
  { 2809, 29, 45, 35, 3, -44 },
  { 2973, 29, 45, 35, 3, -44 },
  { 3137, 9, 35, 17, 4, -34 },
  { 3177, 10, 42, 17, 2, -34 },
  { 3230, 29, 30, 35, 3, -37 },
  { 3339, 29, 17, 35, 3, -30 },
  { 3401, 29, 30, 35, 3, -37 },
  { 3510, 25, 45, 27, 1, -44 },
  { 3651, 48, 49, 55, 3, -44 },
  { 3945, 40, 44, 40, 0, -44 },
  { 4165, 31, 44, 40, 6, -44 },
  { 4336, 33, 45, 39, 4, -44 },
  { 4522, 35, 44, 45, 6, -44 },
  { 4715, 24, 44, 34, 6, -44 },
  { 4847, 24, 44, 32, 6, -44 },
  { 4979, 36, 45, 44, 4, -44 },
  { 5182, 34, 44, 46, 6, -44 },
  { 5369, 17, 44, 22, 2, -44 },
  { 5463, 17, 56, 18, -5, -44 },
  { 5582, 33, 44, 39, 6, -44 },
  { 5764, 25, 44, 33, 6, -44 },
  { 5902, 44, 44, 56, 6, -44 },
  { 6144, 36, 44, 47, 6, -44 },
  { 6342, 40, 45, 48, 4, -44 },
  { 6567, 28, 44, 37, 6, -44 },
  { 6721, 40, 54, 48, 4, -44 },
  { 6991, 32, 44, 39, 6, -44 },
  { 7167, 28, 45, 34, 3, -44 },
  { 7325, 32, 44, 34, 1, -44 },
  { 7501, 35, 45, 45, 5, -44 },
  { 7698, 38, 44, 38, 0, -44 },
  { 7907, 57, 44, 57, 0, -44 },
  { 8221, 37, 44, 37, 0, -44 },
  { 8425, 36, 44, 36, 0, -44 },
  { 8623, 31, 44, 35, 2, -44 },
  { 8794, 14, 54, 20, 5, -44 },
  { 8889, 22, 44, 23, 1, -44 },
  { 9010, 13, 54, 20, 2, -44 },
  { 9098, 31, 28, 35, 2, -44 },
  { 9207, 27, 4, 26, 0, 5 },
  { 9221, 14, 10, 19, 2, -47 },
  { 9239, 27, 34, 35, 3, -33 },
  { 9354, 30, 47, 38, 5, -46 },
  { 9531, 25, 34, 30, 3, -33 },
  { 9638, 30, 47, 38, 3, -46 },
  { 9815, 29, 34, 35, 3, -33 },
  { 9939, 23, 47, 22, 1, -47 },
  { 10075, 30, 48, 38, 3, -33 },
  { 10255, 28, 46, 38, 5, -46 },
  { 10416, 7, 45, 16, 5, -45 },
  { 10456, 15, 60, 16, -3, -45 },
  { 10569, 29, 46, 34, 5, -46 },
  { 10736, 6, 46, 16, 5, -46 },
  { 10771, 48, 33, 58, 5, -33 },
  { 10969, 28, 33, 38, 5, -33 },
  { 11085, 31, 34, 37, 3, -33 },
  { 11217, 30, 48, 38, 5, -33 },
  { 11397, 30, 48, 38, 3, -33 },
  { 11577, 20, 33, 26, 5, -33 },
  { 11660, 24, 34, 30, 3, -33 },
  { 11762, 21, 41, 23, 1, -40 },
  { 11870, 28, 34, 38, 5, -33 },
  { 11989, 32, 33, 32, 0, -33 },
  { 12121, 48, 33, 49, 1, -33 },
  { 12319, 31, 33, 33, 1, -33 },
  { 12447, 32, 48, 32, 0, -33 },
  { 12639, 25, 33, 29, 2, -33 },
  { 12743, 20, 54, 23, 1, -44 },
  { 12878, 5, 60, 34, 14, -46 },
  { 12916, 20, 54, 23, 2, -44 },
  { 13051, 29, 9, 35, 3, -26 },
};

const GFXfont NotoSans_Medium61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium61pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_MEDIUM61PT7B_H_
