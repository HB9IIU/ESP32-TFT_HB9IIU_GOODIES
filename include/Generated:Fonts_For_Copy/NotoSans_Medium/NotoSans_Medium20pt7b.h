#ifndef _NOTOSANS_MEDIUM20PT7B_H_
#define _NOTOSANS_MEDIUM20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium20pt7bBitmaps[] PROGMEM = {
  0x00, 0xED, 0xB6, 0xDB, 0x68, 0x2F, 0xC0, 0xCF, 0x34, 0xD3, 0x4C, 0x06,
  0x60, 0x44, 0x0C, 0x40, 0xCC, 0x7F, 0xF0, 0x8C, 0x08, 0x81, 0x88, 0xFF,
  0xFF, 0xFF, 0x11, 0x81, 0x10, 0x31, 0x03, 0x30, 0x08, 0x06, 0x1F, 0xFD,
  0x3C, 0x86, 0x41, 0xE0, 0x7C, 0x0F, 0x84, 0xC2, 0x71, 0x3F, 0xFF, 0xF0,
  0x20, 0x10, 0x78, 0x31, 0x98, 0x43, 0x31, 0x86, 0x66, 0x0C, 0xCC, 0x19,
  0xB3, 0x33, 0x6F, 0x3D, 0xB3, 0x02, 0x66, 0x0C, 0xCC, 0x11, 0x98, 0x63,
  0x31, 0x86, 0x63, 0x07, 0x80, 0x04, 0x00, 0xFC, 0x07, 0x38, 0x18, 0x60,
  0x61, 0x80, 0xCC, 0x03, 0xE0, 0x0F, 0x00, 0x7E, 0x1B, 0x9C, 0xCC, 0x3B,
  0x30, 0x78, 0xE0, 0xE1, 0xFF, 0xC3, 0xF3, 0xC0, 0xF5, 0x40, 0x39, 0x98,
  0xCC, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x31, 0x86, 0x38, 0xC6, 0x63, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x66, 0xC0, 0x1C, 0x04, 0x22, 0x3F, 0xFF, 0xF8,
  0xE0, 0xD8, 0xEE, 0x22, 0x00, 0x0C, 0x06, 0x03, 0x01, 0x8F, 0xFF, 0xFC,
  0x30, 0x18, 0x0C, 0x06, 0x00, 0x7F, 0x68, 0xFF, 0xC0, 0x5F, 0x80, 0x07,
  0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x30, 0x70, 0x60, 0x60,
  0xC0, 0x08, 0x0F, 0xC7, 0x33, 0x86, 0xC1, 0xB0, 0x6C, 0x1B, 0x07, 0xC1,
  0xF0, 0x6C, 0x1B, 0x06, 0x61, 0x9F, 0xC3, 0xE0, 0x1B, 0xFF, 0xB1, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x7F, 0x38, 0xE4, 0x18, 0x06, 0x01, 0x80,
  0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF, 0xFF, 0xF0, 0x7F,
  0x71, 0xC0, 0x60, 0x30, 0x18, 0x38, 0xF0, 0x7E, 0x01, 0x80, 0xC0, 0x70,
  0x3F, 0xFF, 0xF0, 0x03, 0x80, 0x70, 0x1E, 0x06, 0xC0, 0xD8, 0x33, 0x0C,
  0x61, 0x0C, 0x61, 0x9F, 0xFF, 0xFF, 0x80, 0xC0, 0x18, 0x03, 0x00, 0x7F,
  0x3F, 0x98, 0x0C, 0x06, 0x03, 0xF3, 0xFC, 0x07, 0x01, 0x80, 0xC0, 0x70,
  0x3F, 0xF7, 0xF0, 0x1F, 0x8E, 0x06, 0x01, 0x80, 0xC0, 0x37, 0xCF, 0xFB,
  0x86, 0xC1, 0xF0, 0x7C, 0x19, 0x86, 0x7F, 0x8F, 0xC0, 0xFF, 0xFF, 0xE0,
  0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x38, 0x0C, 0x00, 0x7F, 0x18, 0xEC, 0x1B, 0x06, 0x63, 0x9F, 0xC1, 0xE1,
  0xDC, 0xE1, 0xB0, 0x6C, 0x1F, 0x06, 0x77, 0x8F, 0xC0, 0x3E, 0x18, 0xCC,
  0x1B, 0x06, 0xC1, 0xB0, 0x7E, 0x39, 0xFE, 0x3D, 0x80, 0x60, 0x18, 0x0C,
  0x7E, 0x1F, 0x00, 0x7D, 0x80, 0x00, 0x5F, 0x80, 0x7D, 0x80, 0x00, 0x1F,
  0x6D, 0x00, 0x00, 0x81, 0xC3, 0x87, 0x0E, 0x07, 0x00, 0xF0, 0x1E, 0x01,
  0x80, 0x40, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x1C, 0x38, 0xF0, 0xE0, 0x40, 0x00, 0xFE, 0x67, 0x03,
  0x03, 0x03, 0x07, 0x0C, 0x18, 0x18, 0x18, 0x00, 0x10, 0x38, 0x38, 0x07,
  0xF0, 0x1C, 0x1C, 0x30, 0x06, 0x60, 0x06, 0x63, 0xF3, 0xC6, 0x33, 0xCC,
  0x23, 0xCC, 0x23, 0xCC, 0x23, 0xCC, 0x62, 0xC7, 0xFE, 0x43, 0x9C, 0x60,
  0x00, 0x30, 0x10, 0x1F, 0xF0, 0x07, 0xC0, 0x07, 0x00, 0x38, 0x03, 0x60,
  0x1B, 0x00, 0xD8, 0x0C, 0x60, 0x63, 0x07, 0x1C, 0x3F, 0xE1, 0xFF, 0x1C,
  0x1C, 0xC0, 0x66, 0x03, 0xE0, 0x0C, 0xFF, 0x3F, 0xEC, 0x1F, 0x07, 0xC1,
  0xB0, 0xEF, 0xE3, 0x0E, 0xC1, 0xF0, 0x3C, 0x0F, 0x07, 0xFF, 0xBF, 0xC0,
  0x1F, 0xE7, 0x9D, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xE0,
  0x1C, 0x01, 0x80, 0x38, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xFB, 0x03,
  0x60, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0,
  0xEF, 0xF9, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x1F, 0xF3, 0xC6, 0x70,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC1, 0xFC, 0x1F, 0xE0, 0x36, 0x03, 0x60,
  0x37, 0x03, 0x3F, 0xF0, 0xFF, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xFF, 0xFE, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xC0, 0xFB, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x7C, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC7, 0xFB, 0xC0,
  0xC1, 0xD8, 0x73, 0x0C, 0x63, 0x0C, 0xC1, 0xB0, 0x3E, 0x07, 0x60, 0xCE,
  0x18, 0xC3, 0x0C, 0x61, 0xCC, 0x1D, 0x81, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F,
  0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xD8, 0x2F, 0x61, 0xBD, 0x86, 0xF3, 0x13,
  0xCC, 0xCF, 0x13, 0x3C, 0x78, 0xF1, 0xE3, 0xC3, 0x8F, 0x0C, 0x30, 0xE0,
  0x3F, 0x03, 0xF0, 0x3F, 0x83, 0xD8, 0x3C, 0xC3, 0xCE, 0x3C, 0x63, 0xC3,
  0x3C, 0x3B, 0xC1, 0xBC, 0x1F, 0xC0, 0xFC, 0x07, 0x02, 0x00, 0xFF, 0x0F,
  0x3C, 0xE0, 0x76, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x06, 0xC0, 0x77, 0x03, 0x1F, 0xF8, 0x3F, 0x00, 0xFE, 0x7F, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x1F, 0xFE, 0xF8, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x00, 0x02, 0x00, 0xFF, 0x0F, 0x3C, 0xE0, 0x76, 0x01, 0xF0, 0x0F, 0x80,
  0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x06, 0xC0, 0x77, 0x03, 0x1F, 0xF8,
  0x3F, 0x00, 0x18, 0x00, 0xE0, 0x03, 0xC0, 0xFF, 0x3F, 0xEC, 0x1B, 0x06,
  0xC1, 0xB0, 0x6F, 0xF3, 0xF8, 0xC6, 0x31, 0xCC, 0x33, 0x0E, 0xC1, 0xF0,
  0x30, 0x7F, 0xB9, 0xB0, 0x18, 0x0E, 0x03, 0x80, 0xF8, 0x1E, 0x03, 0x80,
  0xC0, 0x70, 0x3F, 0xF7, 0xF0, 0xFF, 0xFF, 0xFC, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x67, 0xFC, 0x7F, 0x00, 0xC0, 0x36, 0x07,
  0x60, 0x67, 0x06, 0x30, 0xE3, 0x0C, 0x38, 0xC1, 0x9C, 0x19, 0x81, 0xD8,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x60, 0xE0, 0xE0, 0xEC, 0x1C, 0x19, 0x87,
  0x83, 0x30, 0xD8, 0xE7, 0x1B, 0x18, 0x63, 0x63, 0x0C, 0xCC, 0x61, 0x98,
  0xCC, 0x3B, 0x1B, 0x03, 0x43, 0x60, 0x78, 0x2C, 0x0F, 0x07, 0x80, 0xE0,
  0xE0, 0x18, 0x1C, 0x00, 0xE0, 0x73, 0x0E, 0x38, 0xC1, 0x98, 0x1F, 0x80,
  0xF0, 0x06, 0x00, 0xF0, 0x0F, 0x81, 0x98, 0x38, 0xC3, 0x0E, 0x60, 0x6E,
  0x07, 0xE0, 0x76, 0x0E, 0x70, 0xC3, 0x1C, 0x19, 0x81, 0xB8, 0x0F, 0x00,
  0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF,
  0xE0, 0x38, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03,
  0x80, 0xFF, 0xFF, 0xF0, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xF0, 0xE0, 0x60, 0x60, 0x30, 0x30, 0x30, 0x18, 0x18, 0x18, 0x0C, 0x0C,
  0x06, 0x06, 0x07, 0xF8, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0xF8, 0x0C, 0x07, 0x01, 0x60, 0xD8, 0x23, 0x18, 0xC4, 0x1B, 0x06,
  0xC0, 0xC0, 0xFF, 0x80, 0xE6, 0x30, 0x3E, 0x3F, 0x90, 0x60, 0x30, 0x7B,
  0xFF, 0x87, 0x83, 0xC3, 0xF7, 0xDF, 0x60, 0xC0, 0x60, 0x30, 0x18, 0x0D,
  0xE7, 0xFB, 0x8F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3F, 0xFA, 0x78,
  0x1F, 0x7F, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x7F, 0x3F, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x3C, 0xDF, 0xF6, 0x1F, 0x87, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xE1, 0xDF, 0xF3, 0xEC, 0x1E, 0x3F, 0x98, 0x78, 0x3F, 0xFF,
  0xFF, 0x01, 0x80, 0x60, 0x3F, 0xCF, 0xE0, 0x1F, 0x39, 0x30, 0x30, 0x7E,
  0xFE, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3C, 0xDF,
  0xF6, 0x1F, 0x87, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x61, 0xDF, 0xF3, 0xEC,
  0x03, 0x01, 0xD0, 0x67, 0xF8, 0xF8, 0xC0, 0x60, 0x30, 0x18, 0x0D, 0xE7,
  0xFB, 0x8F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x06, 0x7D,
  0x06, 0xDB, 0x6D, 0xB6, 0xD8, 0x19, 0xC4, 0x01, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x19, 0xFD, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x3E,
  0x3B, 0x39, 0xB8, 0xF8, 0x7C, 0x3F, 0x19, 0x8C, 0x66, 0x3B, 0x0E, 0xFF,
  0xFF, 0xFF, 0xFC, 0x9E, 0x3D, 0xFF, 0xFF, 0x8E, 0x1E, 0x1C, 0x3C, 0x38,
  0x78, 0x70, 0xF0, 0xE1, 0xE1, 0xC3, 0xC3, 0x87, 0x87, 0x0F, 0x0E, 0x18,
  0x9E, 0x7F, 0xB8, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x60, 0x1E, 0x1F, 0xE6, 0x1F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x61,
  0xDF, 0xE3, 0xF0, 0x9E, 0x7F, 0xB8, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC3, 0xFF, 0xB7, 0x98, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x3C, 0xDF, 0xF6,
  0x1F, 0x87, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x61, 0xDF, 0xF3, 0xEC, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x9F, 0xFE, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x00, 0x3F, 0xFE, 0xC0, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x03, 0xEE,
  0xFC, 0x30, 0x61, 0xFF, 0xF3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xF1,
  0xE0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xFF,
  0xDF, 0x60, 0xC0, 0xFC, 0x19, 0x87, 0x30, 0xC3, 0x18, 0x67, 0x0C, 0xC0,
  0xD8, 0x1E, 0x01, 0xC0, 0x38, 0x00, 0xC1, 0x83, 0x61, 0xC7, 0x63, 0xC6,
  0x63, 0xC6, 0x62, 0x46, 0x36, 0x6C, 0x36, 0x6C, 0x36, 0x6C, 0x14, 0x3C,
  0x1C, 0x38, 0x1C, 0x38, 0xE0, 0xCE, 0x38, 0xCE, 0x0D, 0x81, 0xE0, 0x1C,
  0x07, 0x80, 0xD8, 0x31, 0x8E, 0x3B, 0x83, 0x80, 0xC0, 0xEC, 0x19, 0x87,
  0x30, 0xC3, 0x18, 0x67, 0x06, 0xC0, 0xD8, 0x1E, 0x01, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x30, 0x3E, 0x07, 0x00, 0xFF, 0xFF, 0x06, 0x0C, 0x1C, 0x18,
  0x30, 0x70, 0x60, 0xFF, 0xFF, 0x0E, 0x38, 0x60, 0xC1, 0x83, 0x06, 0x38,
  0xE0, 0x70, 0x60, 0xC1, 0x83, 0x06, 0x0F, 0x0E, 0xFF, 0xFF, 0xF0, 0xE1,
  0xC3, 0x0C, 0x30, 0xC3, 0x0E, 0x0C, 0xE3, 0x0C, 0x30, 0xC3, 0x38, 0xE0,
  0xFC, 0xC7, 0xC0,
};

const GFXglyph NotoSans_Medium20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 6, 5, 9, 1, -14 },
  { 11, 12, 14, 13, 0, -14 },
  { 32, 9, 16, 11, 1, -15 },
  { 50, 15, 14, 17, 1, -14 },
  { 77, 14, 15, 15, 1, -15 },
  { 104, 2, 5, 5, 1, -14 },
  { 106, 5, 17, 6, 1, -14 },
  { 117, 4, 17, 6, 1, -14 },
  { 126, 9, 9, 11, 1, -15 },
  { 137, 9, 10, 11, 1, -12 },
  { 149, 3, 5, 5, 1, -2 },
  { 151, 5, 2, 6, 1, -6 },
  { 153, 3, 3, 5, 1, -3 },
  { 155, 8, 14, 8, 0, -14 },
  { 169, 10, 15, 11, 1, -15 },
  { 188, 5, 14, 11, 2, -14 },
  { 197, 10, 14, 11, 1, -14 },
  { 215, 9, 14, 11, 1, -14 },
  { 231, 11, 14, 11, 0, -14 },
  { 251, 9, 14, 11, 1, -14 },
  { 267, 10, 14, 11, 1, -14 },
  { 285, 10, 14, 11, 1, -14 },
  { 303, 10, 14, 11, 1, -14 },
  { 321, 10, 14, 11, 1, -14 },
  { 339, 3, 11, 5, 1, -11 },
  { 344, 3, 14, 5, 1, -11 },
  { 350, 9, 10, 11, 1, -12 },
  { 362, 9, 6, 11, 1, -10 },
  { 369, 9, 10, 11, 1, -12 },
  { 381, 8, 14, 9, 0, -14 },
  { 395, 16, 16, 18, 1, -14 },
  { 427, 13, 14, 13, 0, -14 },
  { 450, 10, 14, 13, 2, -14 },
  { 468, 11, 14, 13, 1, -14 },
  { 488, 11, 14, 15, 2, -14 },
  { 508, 8, 14, 11, 2, -14 },
  { 522, 8, 14, 11, 2, -14 },
  { 536, 12, 14, 15, 1, -14 },
  { 557, 11, 14, 15, 2, -14 },
  { 577, 5, 14, 7, 1, -14 },
  { 586, 6, 18, 6, -2, -14 },
  { 600, 11, 14, 13, 2, -14 },
  { 620, 8, 14, 11, 2, -14 },
  { 634, 14, 14, 18, 2, -14 },
  { 659, 12, 14, 16, 2, -14 },
  { 680, 13, 15, 16, 1, -15 },
  { 705, 9, 14, 12, 2, -14 },
  { 721, 13, 18, 16, 1, -15 },
  { 751, 10, 14, 13, 2, -14 },
  { 769, 9, 14, 11, 1, -14 },
  { 785, 11, 14, 11, 0, -14 },
  { 805, 11, 14, 15, 2, -14 },
  { 825, 12, 14, 12, 0, -14 },
  { 846, 19, 14, 19, 0, -14 },
  { 880, 12, 14, 12, 0, -14 },
  { 901, 12, 14, 12, 0, -14 },
  { 922, 10, 14, 11, 1, -14 },
  { 940, 4, 17, 7, 2, -14 },
  { 949, 8, 14, 8, 0, -14 },
  { 963, 5, 17, 7, 0, -14 },
  { 974, 10, 9, 11, 1, -14 },
  { 986, 9, 1, 9, 0, 2 },
  { 988, 4, 3, 6, 1, -15 },
  { 990, 9, 11, 11, 1, -11 },
  { 1003, 9, 15, 12, 2, -15 },
  { 1020, 8, 11, 10, 1, -11 },
  { 1031, 10, 15, 12, 1, -15 },
  { 1050, 9, 11, 11, 1, -11 },
  { 1063, 8, 15, 7, 0, -15 },
  { 1078, 10, 16, 12, 1, -11 },
  { 1098, 9, 15, 13, 2, -15 },
  { 1115, 3, 15, 5, 1, -15 },
  { 1121, 5, 20, 5, -1, -15 },
  { 1134, 9, 15, 11, 2, -15 },
  { 1151, 2, 15, 5, 2, -15 },
  { 1155, 15, 11, 19, 2, -11 },
  { 1176, 9, 11, 13, 2, -11 },
  { 1189, 10, 11, 12, 1, -11 },
  { 1203, 9, 16, 12, 2, -11 },
  { 1221, 10, 16, 12, 1, -11 },
  { 1241, 6, 11, 8, 2, -11 },
  { 1250, 8, 11, 10, 1, -11 },
  { 1261, 7, 13, 8, 0, -13 },
  { 1273, 9, 11, 13, 2, -11 },
  { 1286, 11, 11, 11, 0, -11 },
  { 1302, 16, 11, 16, 0, -11 },
  { 1324, 11, 11, 11, 0, -11 },
  { 1340, 11, 16, 11, 0, -11 },
  { 1362, 8, 11, 10, 1, -11 },
  { 1373, 7, 17, 8, 0, -14 },
  { 1388, 1, 20, 11, 5, -15 },
  { 1391, 6, 17, 8, 1, -14 },
  { 1404, 9, 2, 11, 1, -8 },
};

const GFXfont NotoSans_Medium20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium20pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_MEDIUM20PT7B_H_
