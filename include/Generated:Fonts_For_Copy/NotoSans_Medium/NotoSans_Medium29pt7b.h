#ifndef _NOTOSANS_MEDIUM29PT7B_H_
#define _NOTOSANS_MEDIUM29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE6, 0x66, 0x66, 0x66, 0x60, 0x06, 0xFF, 0xF0,
  0xE7, 0xF1, 0xF8, 0xDC, 0x6E, 0x37, 0x1B, 0x8D, 0x86, 0x03, 0x0E, 0x01,
  0x86, 0x00, 0xC3, 0x00, 0xE1, 0x80, 0x71, 0xC0, 0x38, 0xE1, 0xFF, 0xFE,
  0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0x1C, 0x03, 0x8E, 0x01, 0x86, 0x00, 0xC3,
  0x07, 0xFF, 0xFB, 0xFF, 0xFC, 0x38, 0xE0, 0x18, 0x60, 0x0C, 0x30, 0x06,
  0x18, 0x07, 0x1C, 0x03, 0x8E, 0x00, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x7F,
  0xF7, 0xFF, 0x7B, 0x1B, 0x98, 0x1C, 0xC0, 0xE6, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x80, 0x7F, 0x03, 0x7C, 0x18, 0xE0, 0xC7, 0x06, 0x3E, 0x33, 0xFF,
  0xFD, 0xFF, 0xC0, 0xF0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x1E, 0x00, 0xC1,
  0xFC, 0x07, 0x07, 0x30, 0x18, 0x18, 0xE0, 0xE0, 0xE1, 0x87, 0x03, 0x86,
  0x1C, 0x0E, 0x18, 0xE0, 0x38, 0x63, 0x00, 0xE1, 0x9C, 0x61, 0x8E, 0x67,
  0xE7, 0x3B, 0xBF, 0xCF, 0xCC, 0xC7, 0x1E, 0x73, 0x0C, 0x03, 0x8C, 0x30,
  0x0E, 0x70, 0xC0, 0x71, 0xC3, 0x01, 0x83, 0x0C, 0x0E, 0x0C, 0x30, 0x30,
  0x39, 0xC1, 0xC0, 0x7E, 0x0E, 0x01, 0xF0, 0x07, 0xE0, 0x01, 0xFF, 0x00,
  0x1E, 0xF8, 0x03, 0xC3, 0x80, 0x38, 0x38, 0x03, 0xC3, 0x80, 0x1C, 0x78,
  0x01, 0xEF, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0xE3, 0xDE,
  0x0E, 0x78, 0xF1, 0xE7, 0x07, 0x9C, 0xF0, 0x3F, 0xCF, 0x01, 0xF8, 0xF0,
  0x0F, 0x07, 0x01, 0xF8, 0x7E, 0xFF, 0xC3, 0xFF, 0x9E, 0x1F, 0xE0, 0xF0,
  0xFF, 0xFF, 0xFE, 0x0E, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x38, 0x71, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0xE1, 0xC3, 0x87, 0x07, 0x0E, 0x0E,
  0x0C, 0x1C, 0xE0, 0xE1, 0xC1, 0xC3, 0x83, 0x87, 0x0E, 0x1C, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x38, 0x70, 0xE1, 0xC7, 0x0E, 0x38, 0x71,
  0xC0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xE3, 0x1B, 0xFF, 0xFF,
  0xFF, 0xC1, 0xE0, 0x0F, 0xC0, 0x37, 0x01, 0xCE, 0x0E, 0x3C, 0x18, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF,
  0xFF, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x7B, 0x9C, 0xE6, 0x73, 0x00, 0xFF, 0xFF, 0xF8, 0x6F, 0xFF, 0x00,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xC0, 0x38, 0x0E, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1E, 0x0E, 0x70,
  0x39, 0xC0, 0x77, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x70, 0x3D, 0xE0, 0xE3,
  0xCF, 0x87, 0xFC, 0x0F, 0xE0, 0x03, 0x83, 0xC7, 0xE7, 0xFF, 0xBB, 0x9D,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0F, 0xC0, 0xFF, 0xCF, 0xFF, 0x9C, 0x0E,
  0x20, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC1, 0xFF, 0xCF, 0xFF, 0x98,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0xF0, 0x7F, 0x81,
  0xFE, 0x07, 0xFE, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0xFF, 0x0F, 0xBF, 0xFC, 0x7F, 0xE0, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0x38, 0x1C, 0x70,
  0x30, 0xE0, 0xE1, 0xC3, 0x83, 0x86, 0x07, 0x1C, 0x0E, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x7F,
  0xF3, 0xFF, 0x9F, 0xFC, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00,
  0xFF, 0x87, 0xFF, 0x3F, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x7C, 0x03, 0xBC, 0xFD, 0xFF, 0xCF, 0xF8, 0x00, 0x01, 0xF8,
  0x1F, 0xE1, 0xFF, 0x87, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x73, 0xE1, 0xBF, 0xEF, 0xC7, 0xBE, 0x0F, 0xF0, 0x1F, 0xC0, 0x77, 0x01,
  0xDC, 0x07, 0x70, 0x1D, 0xE0, 0xF3, 0xE7, 0x87, 0xFC, 0x0F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x0F, 0xC0, 0x7F, 0xC3, 0xEF, 0x9C, 0x0E, 0x70, 0x1D, 0xC0, 0xF7, 0x03,
  0x8E, 0x0E, 0x3E, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xFC, 0x78, 0x79, 0xC0,
  0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1D, 0xC0, 0x77, 0x87, 0x8F, 0xFE, 0x1F,
  0xE0, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1E, 0x0E, 0x70, 0x3B, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1D, 0xC0, 0xF7, 0x87, 0xCF, 0xFF, 0x1F, 0xDC,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC4, 0x1F, 0x0F, 0xF0,
  0x3F, 0x80, 0xEF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xFF, 0x73, 0xDE,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xCE, 0x77, 0x39, 0x80, 0x00,
  0x04, 0x00, 0x30, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x70,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x03, 0x80, 0x08, 0x00, 0x00, 0x1F, 0x8F, 0xFE, 0x7F, 0xF4, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x40, 0x0E, 0x01, 0xE0,
  0x0E, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFE, 0x00, 0xFC, 0x7E, 0x07, 0x80,
  0x3C, 0x38, 0x00, 0x38, 0xC0, 0x00, 0x67, 0x07, 0xF1, 0xD8, 0x7F, 0xC3,
  0xE3, 0xC3, 0x0F, 0x0E, 0x0C, 0x3C, 0x30, 0x30, 0xF1, 0xC1, 0xC3, 0xC7,
  0x07, 0x0F, 0x1C, 0x1C, 0x3C, 0x30, 0x71, 0xF0, 0xE3, 0xEE, 0xE1, 0xF9,
  0xF3, 0x83, 0xC3, 0x87, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x80,
  0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xD8, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xEE,
  0x00, 0x38, 0xE0, 0x07, 0x1C, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x07, 0x07,
  0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xC0, 0x1C, 0x38, 0x03,
  0x8F, 0x00, 0x79, 0xC0, 0x07, 0x38, 0x00, 0xEE, 0x00, 0x1E, 0xFF, 0x03,
  0xFF, 0xCF, 0xFF, 0xB8, 0x1E, 0xE0, 0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x0E,
  0xE0, 0x7B, 0xFF, 0xCF, 0xFE, 0x38, 0x7E, 0xE0, 0x3F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE0, 0x03,
  0xF8, 0x0F, 0xFF, 0x1F, 0xFE, 0x3C, 0x06, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3F,
  0x9E, 0x1F, 0xFE, 0x07, 0xFC, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0,
  0x7C, 0xE0, 0x1E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1E, 0xE0, 0x3C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x01, 0xFC, 0x07,
  0xFF, 0xC7, 0xFF, 0xC7, 0xC0, 0x27, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0x78, 0x03, 0x9E, 0x01, 0xCF,
  0xE3, 0xE3, 0xFF, 0xF0, 0x7F, 0xF0, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xFF, 0xFF, 0x7E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xFF, 0xFF, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0xFE, 0xFC, 0xF0,
  0xE0, 0x1F, 0xC0, 0x7B, 0x80, 0xE7, 0x03, 0x8E, 0x0E, 0x1C, 0x3C, 0x38,
  0xF0, 0x73, 0xC0, 0xEF, 0x01, 0xDC, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0x38,
  0x1C, 0x78, 0x38, 0x78, 0x70, 0x70, 0xE0, 0xF1, 0xC0, 0xF3, 0x80, 0xF7,
  0x00, 0xEE, 0x01, 0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xB0, 0x03, 0xFD, 0xC0,
  0x1F, 0xEE, 0x01, 0xDF, 0xB0, 0x0E, 0xFD, 0xC0, 0x67, 0xEE, 0x07, 0x3F,
  0x38, 0x39, 0xF9, 0xC1, 0x8F, 0xCE, 0x1C, 0x7E, 0x38, 0xE3, 0xF1, 0xC6,
  0x1F, 0x8E, 0x70, 0xFC, 0x3B, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8,
  0x3C, 0x0F, 0xC1, 0xE0, 0x7E, 0x07, 0x03, 0x80, 0xF0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x7D, 0xC0, 0x3E, 0xF0, 0x1F, 0x38, 0x0F, 0xDE,
  0x07, 0xE7, 0x83, 0xF1, 0xC1, 0xF8, 0xF0, 0xFC, 0x3C, 0x7E, 0x0E, 0x3F,
  0x07, 0x9F, 0x81, 0xCF, 0xC0, 0xF7, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x78, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC,
  0x1E, 0x03, 0xC7, 0x80, 0x3C, 0xE0, 0x03, 0xBC, 0x00, 0x77, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0E, 0x78, 0x03, 0xCF, 0x80, 0xF0,
  0xFE, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0xFE, 0x07, 0xFF, 0x3F, 0xFD,
  0xC1, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xFF,
  0xFD, 0xFF, 0xCF, 0xF8, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF,
  0xFC, 0x1E, 0x03, 0xC7, 0x80, 0x3C, 0xE0, 0x03, 0xBC, 0x00, 0x77, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0E, 0x78, 0x03, 0xCF, 0x80,
  0xF0, 0xFE, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0xFF, 0x01, 0xFF, 0xC3,
  0xFF, 0xC7, 0x03, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0,
  0x39, 0xC1, 0xE3, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1C, 0x38, 0x38, 0x38,
  0x70, 0x78, 0xE0, 0x71, 0xC0, 0xF3, 0x80, 0xE7, 0x00, 0xEE, 0x01, 0xE0,
  0x0F, 0xE0, 0xFF, 0xE3, 0xFF, 0x9E, 0x04, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xEF, 0x9F, 0xBF, 0xFC, 0x7F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xF0, 0x1E, 0x7E, 0x7C, 0x3F, 0xF8, 0x1F,
  0xF0, 0xE0, 0x01, 0xFC, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x1E, 0x78, 0x07,
  0x0E, 0x01, 0xC3, 0x80, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x80,
  0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x3C, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1D,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x0E, 0x00, 0xEE, 0x01, 0xC0, 0x1D, 0xC0, 0x7C, 0x07, 0x38,
  0x0F, 0x80, 0xE7, 0x01, 0xB0, 0x1C, 0x70, 0x37, 0x03, 0x8E, 0x0E, 0xE0,
  0xE1, 0xC1, 0xDC, 0x1C, 0x3C, 0x39, 0xC3, 0x83, 0x8E, 0x38, 0x70, 0x71,
  0xC7, 0x1C, 0x0E, 0x38, 0x63, 0x81, 0xC6, 0x0E, 0x70, 0x1D, 0xC1, 0xCE,
  0x03, 0xB8, 0x3B, 0x80, 0x77, 0x03, 0x70, 0x0E, 0xC0, 0x7E, 0x00, 0xF8,
  0x0F, 0xC0, 0x1F, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x38, 0x03, 0xC0,
  0x70, 0x03, 0x9E, 0x01, 0xC3, 0x80, 0xF0, 0x70, 0x38, 0x1E, 0x1C, 0x03,
  0x8F, 0x00, 0x73, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x01, 0xDE, 0x00, 0xF3, 0x80, 0x38, 0x70,
  0x1C, 0x1E, 0x0F, 0x03, 0x83, 0x80, 0xF1, 0xC0, 0x1E, 0xF0, 0x03, 0xC0,
  0xF0, 0x07, 0xB8, 0x03, 0x9E, 0x03, 0xC7, 0x01, 0xC3, 0xC1, 0xE0, 0xE0,
  0xE0, 0x78, 0xF0, 0x1C, 0x70, 0x0F, 0x70, 0x03, 0xB8, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xFC,
  0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0x00, 0xE0, 0x0E, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xFF, 0xFF,
  0xF0, 0x03, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0xEC, 0x01, 0x9C,
  0x07, 0x18, 0x0C, 0x38, 0x38, 0x30, 0x60, 0x71, 0xC0, 0x63, 0x00, 0xEE,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0xF0, 0xE0, 0x70, 0x0F, 0xC1,
  0xFF, 0x8F, 0xFE, 0x20, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE3, 0xFF, 0x7F,
  0xFB, 0x81, 0xFC, 0x0F, 0xC0, 0x7F, 0x07, 0xBC, 0x7D, 0xFF, 0x67, 0xF3,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x3C,
  0x3B, 0xFC, 0xFF, 0xFB, 0xE0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFF, 0x1E, 0xEF,
  0xF3, 0x9F, 0x80, 0x0F, 0xC7, 0xFD, 0xFF, 0xB8, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xF9, 0xCF, 0xF8,
  0xFF, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x71,
  0xF1, 0xCF, 0xF7, 0x7F, 0xFF, 0xC1, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xDE, 0x3F,
  0x7F, 0xDC, 0x7E, 0x70, 0x0F, 0x81, 0xFF, 0x1F, 0x7C, 0xE0, 0xEE, 0x03,
  0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x01, 0xC0, 0x0F,
  0x00, 0x3E, 0x18, 0xFF, 0xC3, 0xFE, 0x07, 0xF0, 0xFE, 0x0E, 0x21, 0xC0,
  0x1C, 0x01, 0xC0, 0x1F, 0xCF, 0xFC, 0xFF, 0xC1, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x0F, 0x1C, 0xFF, 0x77, 0xFF, 0xFC, 0x1F, 0xE0, 0x3F,
  0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F,
  0xF0, 0x3D, 0xE3, 0xF7, 0xFD, 0xC7, 0xE7, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0xA0, 0x1E, 0x7F, 0xF1, 0xFF, 0xC3, 0xFC, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x3E, 0x3B, 0xFC, 0xFF, 0xFB,
  0xE0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x70, 0x6F,
  0xF6, 0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x06, 0x0F,
  0x0F, 0x06, 0x00, 0x00, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0xFE, 0xFC, 0xF8, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x03, 0xF8, 0x1E, 0xE0, 0xF3, 0x87, 0x8E, 0x3C, 0x39, 0xE0,
  0xEF, 0x03, 0xBC, 0x0F, 0xF0, 0x3E, 0xE0, 0xE3, 0xC3, 0x87, 0x8E, 0x0E,
  0x38, 0x1C, 0xE0, 0x7B, 0x80, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xE3, 0xC0, 0xF1, 0xDF, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF,
  0xC3, 0xF0, 0xFF, 0x03, 0xC0, 0xFE, 0x07, 0x81, 0xFC, 0x0E, 0x03, 0xF0,
  0x1C, 0x07, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1F, 0x80, 0xE0, 0x3F, 0x01,
  0xC0, 0x7E, 0x03, 0x80, 0xFC, 0x07, 0x01, 0xF8, 0x0E, 0x03, 0xF0, 0x1C,
  0x07, 0xE3, 0xE3, 0xBF, 0xEF, 0xFF, 0xBE, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0x0F, 0xC0, 0xFF, 0x87, 0xFF, 0x1C, 0x1E,
  0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x0F, 0xF0, 0x39, 0xE1, 0xE3, 0xFF, 0x07, 0xF0, 0xE3, 0xE3, 0xBF,
  0xCF, 0xFF, 0xBE, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xF1, 0xEE, 0xFF, 0x39,
  0xF8, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x0F, 0x1C, 0xFF, 0x77, 0xFF, 0xFC, 0x1F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xF0,
  0x3D, 0xE3, 0xF7, 0xFD, 0xC7, 0xE7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0xE3, 0xF9, 0xFE, 0xFF, 0xF0,
  0xF8, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0x0F, 0xC3, 0xFF, 0x7D, 0xEF, 0x00, 0xE0, 0x07, 0x00,
  0x7C, 0x03, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x00, 0x7E, 0x0E,
  0xFF, 0xE7, 0xF8, 0x18, 0x1C, 0x0E, 0x0F, 0xFF, 0xFF, 0xFC, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x9F, 0xC7,
  0xE0, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xF0, 0x3D,
  0xE3, 0xF7, 0xFD, 0xCF, 0xE7, 0xE0, 0x0F, 0xE0, 0x1D, 0xC0, 0x73, 0x80,
  0xE3, 0x81, 0xC7, 0x07, 0x0E, 0x0E, 0x0E, 0x3C, 0x1C, 0x70, 0x38, 0xE0,
  0x3B, 0x80, 0x77, 0x00, 0x6E, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0xF0,
  0x38, 0x0E, 0xE0, 0x78, 0x1D, 0xC1, 0xF0, 0x73, 0x83, 0xE0, 0xE7, 0x86,
  0xE1, 0xC7, 0x1D, 0xC3, 0x8E, 0x39, 0x8E, 0x1C, 0x73, 0x1C, 0x1C, 0xC7,
  0x38, 0x3B, 0x8E, 0x70, 0x77, 0x0D, 0xC0, 0xEC, 0x1F, 0x80, 0xD8, 0x3F,
  0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x78, 0x03, 0x80, 0xF0, 0x70, 0x1E, 0xF0,
  0x38, 0xF0, 0xF0, 0xE1, 0xC0, 0xE7, 0x01, 0xFE, 0x01, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0x73, 0x81, 0xC3, 0x87, 0x87, 0x9E,
  0x07, 0x78, 0x07, 0xE0, 0x0F, 0xE0, 0x1D, 0xC0, 0x7B, 0x80, 0xE3, 0x81,
  0xC7, 0x07, 0x0F, 0x0E, 0x0E, 0x1C, 0x1C, 0x70, 0x1C, 0xE0, 0x39, 0xC0,
  0x77, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x38, 0x07, 0xE0, 0x0F, 0xC0, 0x1E, 0x00, 0x00, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E,
  0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x83, 0xC3, 0xE3, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x0F,
  0x0F, 0x07, 0x80, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x78, 0x1F, 0x07, 0x80, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x7C, 0x3E, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x01, 0xE0, 0x78, 0x3C, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0xF1, 0xF0, 0xF0, 0x60, 0x00, 0x7E, 0x07, 0xFF, 0xFC, 0x3F,
  0xE0, 0x3C,
};

const GFXglyph NotoSans_Medium29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 21, 8, 2, -21 },
  { 12, 9, 8, 12, 2, -21 },
  { 21, 17, 21, 19, 1, -21 },
  { 66, 13, 24, 17, 2, -22 },
  { 105, 22, 21, 25, 1, -21 },
  { 163, 20, 21, 21, 1, -21 },
  { 216, 3, 8, 7, 2, -21 },
  { 219, 7, 26, 9, 1, -21 },
  { 242, 7, 26, 9, 1, -21 },
  { 265, 14, 13, 16, 1, -22 },
  { 288, 14, 14, 17, 1, -17 },
  { 313, 5, 7, 8, 1, -3 },
  { 318, 7, 3, 9, 1, -9 },
  { 321, 4, 4, 8, 2, -4 },
  { 323, 11, 21, 11, 0, -21 },
  { 352, 14, 21, 17, 1, -21 },
  { 389, 9, 21, 17, 2, -21 },
  { 413, 14, 21, 17, 1, -21 },
  { 450, 14, 21, 17, 1, -21 },
  { 487, 15, 21, 17, 1, -21 },
  { 527, 13, 21, 17, 2, -21 },
  { 562, 14, 21, 17, 1, -21 },
  { 599, 14, 21, 17, 1, -21 },
  { 636, 14, 21, 17, 1, -21 },
  { 673, 14, 21, 17, 1, -21 },
  { 710, 4, 16, 8, 2, -16 },
  { 718, 5, 20, 8, 1, -16 },
  { 731, 14, 15, 17, 1, -18 },
  { 758, 13, 8, 17, 2, -14 },
  { 771, 14, 15, 17, 1, -18 },
  { 798, 12, 21, 13, 0, -21 },
  { 830, 22, 24, 26, 2, -21 },
  { 896, 19, 21, 19, 0, -21 },
  { 946, 14, 21, 19, 3, -21 },
  { 983, 16, 21, 18, 2, -21 },
  { 1025, 16, 21, 21, 3, -21 },
  { 1067, 11, 21, 16, 3, -21 },
  { 1096, 11, 21, 15, 3, -21 },
  { 1125, 17, 21, 21, 2, -21 },
  { 1170, 16, 21, 22, 3, -21 },
  { 1212, 8, 21, 10, 1, -21 },
  { 1233, 8, 27, 8, -2, -21 },
  { 1260, 15, 21, 18, 3, -21 },
  { 1300, 12, 21, 15, 3, -21 },
  { 1332, 21, 21, 27, 3, -21 },
  { 1388, 17, 21, 23, 3, -21 },
  { 1433, 19, 21, 23, 2, -21 },
  { 1483, 13, 21, 18, 3, -21 },
  { 1518, 19, 26, 23, 2, -21 },
  { 1580, 15, 21, 18, 3, -21 },
  { 1620, 14, 21, 16, 1, -21 },
  { 1657, 16, 21, 16, 0, -21 },
  { 1699, 16, 21, 21, 3, -21 },
  { 1741, 18, 21, 18, 0, -21 },
  { 1789, 27, 21, 27, 0, -21 },
  { 1860, 18, 21, 18, 0, -21 },
  { 1908, 17, 21, 17, 0, -21 },
  { 1953, 15, 21, 17, 1, -21 },
  { 1993, 7, 26, 10, 2, -21 },
  { 2016, 11, 21, 11, 0, -21 },
  { 2045, 6, 26, 10, 1, -21 },
  { 2065, 15, 13, 17, 1, -21 },
  { 2090, 13, 2, 13, 0, 3 },
  { 2094, 7, 4, 9, 1, -22 },
  { 2098, 13, 16, 17, 1, -16 },
  { 2124, 14, 22, 18, 2, -22 },
  { 2163, 11, 16, 14, 2, -16 },
  { 2185, 14, 22, 18, 2, -22 },
  { 2224, 13, 16, 17, 2, -16 },
  { 2250, 12, 22, 10, 0, -22 },
  { 2283, 14, 23, 18, 2, -16 },
  { 2324, 14, 22, 18, 2, -22 },
  { 2363, 4, 22, 8, 2, -22 },
  { 2374, 8, 29, 8, -2, -22 },
  { 2403, 14, 22, 16, 2, -22 },
  { 2442, 3, 22, 8, 2, -22 },
  { 2451, 23, 16, 27, 2, -16 },
  { 2497, 14, 16, 18, 2, -16 },
  { 2525, 14, 16, 18, 2, -16 },
  { 2553, 14, 23, 18, 2, -16 },
  { 2594, 14, 23, 18, 2, -16 },
  { 2635, 10, 16, 12, 2, -16 },
  { 2655, 12, 16, 14, 1, -16 },
  { 2679, 9, 19, 11, 1, -19 },
  { 2701, 14, 16, 18, 2, -16 },
  { 2729, 15, 16, 15, 0, -16 },
  { 2759, 23, 16, 23, 0, -16 },
  { 2805, 15, 16, 16, 0, -16 },
  { 2835, 15, 23, 15, 0, -16 },
  { 2879, 12, 16, 14, 1, -16 },
  { 2903, 9, 26, 11, 1, -21 },
  { 2933, 2, 29, 16, 7, -22 },
  { 2941, 9, 26, 11, 1, -21 },
  { 2971, 14, 4, 17, 1, -12 },
};

const GFXfont NotoSans_Medium29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium29pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_MEDIUM29PT7B_H_
