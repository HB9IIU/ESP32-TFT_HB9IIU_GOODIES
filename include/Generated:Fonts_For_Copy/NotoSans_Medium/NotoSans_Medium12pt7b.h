#ifndef _NOTOSANS_MEDIUM12PT7B_H_
#define _NOTOSANS_MEDIUM12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0x80, 0xB6, 0xD0, 0x14, 0x28, 0x53, 0xF2, 0x45, 0x3F, 0x94,
  0x48, 0x27, 0xE9, 0x47, 0x1C, 0xBF, 0x21, 0x00, 0x42, 0x52, 0x29, 0x15,
  0x0A, 0xF2, 0xA4, 0x52, 0x49, 0x63, 0x00, 0x30, 0xD8, 0xC8, 0x50, 0x60,
  0x92, 0x8E, 0x8C, 0xFB, 0xF0, 0x25, 0x25, 0x92, 0x4C, 0x80, 0xC9, 0x92,
  0x49, 0x2B, 0x00, 0x12, 0x5F, 0xCC, 0x68, 0x21, 0x3E, 0x42, 0x10, 0x58,
  0xE0, 0xC0, 0x18, 0x84, 0x42, 0x31, 0x08, 0xC0, 0x76, 0xE3, 0x18, 0xC6,
  0x31, 0x70, 0x2E, 0x92, 0x49, 0x20, 0x76, 0xC2, 0x11, 0x19, 0x90, 0xF8,
  0x74, 0xC2, 0x36, 0x0C, 0x31, 0xF0, 0x08, 0x30, 0x61, 0x44, 0x89, 0x3F,
  0x84, 0x08, 0xFF, 0xE1, 0x0F, 0x84, 0x31, 0xF0, 0x3B, 0x21, 0x0F, 0xC6,
  0x31, 0x70, 0xFF, 0xF0, 0x42, 0x08, 0x41, 0x0C, 0x20, 0x76, 0xE3, 0xB6,
  0x4E, 0x31, 0xF8, 0x66, 0xE3, 0x19, 0xB4, 0x23, 0xF0, 0xC6, 0x50, 0x05,
  0x80, 0x09, 0xB1, 0xC1, 0x84, 0xF8, 0x3E, 0x83, 0x06, 0x7C, 0x40, 0x76,
  0xC2, 0x33, 0x10, 0x04, 0x60, 0x1C, 0x31, 0x90, 0x73, 0xDA, 0x4D, 0x26,
  0x9B, 0x36, 0x40, 0x1F, 0x00, 0x18, 0x18, 0x38, 0x24, 0x24, 0x7E, 0x7E,
  0x42, 0xC3, 0xF3, 0xF8, 0x63, 0xF2, 0x38, 0x63, 0xF8, 0x39, 0x9C, 0x20,
  0x82, 0x08, 0x30, 0x7C, 0xF1, 0xFA, 0x1C, 0x18, 0x30, 0x61, 0xC6, 0xF8,
  0xFF, 0xE1, 0x0F, 0xC2, 0x10, 0xF8, 0xFF, 0xE1, 0x0F, 0xC2, 0x10, 0x80,
  0x1C, 0xCF, 0x04, 0x08, 0xF1, 0xE0, 0xE1, 0x7E, 0x83, 0x06, 0x0C, 0x1F,
  0xF0, 0x60, 0xC1, 0x82, 0xF6, 0x66, 0x66, 0x66, 0xF0, 0x24, 0x92, 0x49,
  0x27, 0x80, 0x85, 0x1A, 0x65, 0x8A, 0x1A, 0x26, 0x46, 0x86, 0x84, 0x21,
  0x08, 0x42, 0x10, 0xF8, 0xC1, 0xE0, 0xE8, 0xB4, 0x5A, 0x2C, 0xA6, 0x53,
  0x39, 0x88, 0x80, 0xC3, 0x86, 0x8D, 0x99, 0x33, 0x63, 0xC3, 0x86, 0x38,
  0x6E, 0xC2, 0x83, 0x83, 0x83, 0x82, 0xC6, 0x7C, 0xE3, 0xE8, 0xE3, 0x9B,
  0xC8, 0x20, 0x80, 0x38, 0x6E, 0xC2, 0x83, 0x83, 0x83, 0x82, 0xC6, 0x7C,
  0x0C, 0x06, 0xE3, 0xE8, 0xE3, 0xFB, 0xC9, 0xA3, 0x84, 0x76, 0xE1, 0x07,
  0x0C, 0x31, 0xF0, 0xFF, 0xFC, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xE2, 0x7C, 0x83, 0x85, 0x1A, 0x26, 0x45,
  0x8A, 0x1C, 0x18, 0x84, 0x38, 0xC5, 0x39, 0xA5, 0x24, 0xA4, 0xD2, 0x8C,
  0x71, 0x8C, 0x31, 0x80, 0xC2, 0x88, 0xB1, 0xC1, 0x07, 0x0B, 0x22, 0xC6,
  0x82, 0x89, 0x11, 0x43, 0x82, 0x04, 0x08, 0x10, 0x7D, 0xF0, 0xC6, 0x10,
  0xC6, 0x10, 0xFC, 0xF2, 0x49, 0x24, 0x93, 0x80, 0x82, 0x10, 0x82, 0x10,
  0xC2, 0x18, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x10, 0xC2, 0x9A, 0x47, 0x10,
  0xF8, 0xC4, 0x26, 0xC2, 0xF8, 0xCF, 0xA0, 0x82, 0x09, 0x3E, 0x8E, 0x38,
  0xF3, 0xB8, 0x3E, 0xA1, 0x08, 0x41, 0xC0, 0x08, 0x4B, 0xB8, 0xC6, 0x31,
  0x78, 0x26, 0xE3, 0xF8, 0x41, 0xE0, 0x3B, 0x19, 0xE6, 0x31, 0x8C, 0x60,
  0x26, 0xE3, 0x18, 0xC5, 0xE1, 0x8F, 0x80, 0x82, 0x09, 0x3E, 0x8E, 0x38,
  0xE3, 0x8C, 0xDF, 0x80, 0x24, 0x12, 0x49, 0x24, 0xF0, 0x82, 0x08, 0x26,
  0xB3, 0x8F, 0x26, 0x8C, 0xFF, 0x80, 0x33, 0x6F, 0xE2, 0x31, 0x18, 0x8C,
  0x46, 0x22, 0x13, 0xE8, 0xE3, 0x8E, 0x38, 0xC0, 0x33, 0x68, 0xE3, 0x8E,
  0x27, 0x80, 0x33, 0xE8, 0xE3, 0x8F, 0x3B, 0xA0, 0x82, 0x00, 0x26, 0xE3,
  0x18, 0xC5, 0xE1, 0x08, 0x40, 0x1F, 0xC8, 0x88, 0x80, 0x69, 0x8E, 0x31,
  0xF0, 0x44, 0xF4, 0x44, 0x47, 0x8E, 0x38, 0xE3, 0x8F, 0xF0, 0xC5, 0x34,
  0x8A, 0x30, 0xC0, 0xCC, 0xD3, 0x25, 0x59, 0x4C, 0x33, 0x08, 0xC0, 0xCC,
  0xA3, 0x0E, 0x6B, 0x10, 0xC5, 0x34, 0x8A, 0x30, 0xC3, 0x08, 0xC0, 0x78,
  0x8C, 0x44, 0x7C, 0x13, 0x22, 0x2C, 0x62, 0x22, 0x30, 0xFF, 0xF0, 0x86,
  0x22, 0x21, 0x22, 0x26, 0xC0, 0xEC, 0x80,
};

const GFXglyph NotoSans_Medium12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 3, 4, 5, 1, -9 },
  { 5, 7, 9, 8, 0, -9 },
  { 13, 5, 10, 7, 1, -9 },
  { 20, 9, 9, 10, 1, -9 },
  { 31, 8, 9, 9, 1, -9 },
  { 40, 1, 4, 3, 1, -9 },
  { 41, 3, 11, 4, 0, -9 },
  { 46, 3, 11, 4, 0, -9 },
  { 51, 6, 5, 7, 0, -9 },
  { 55, 5, 6, 7, 1, -7 },
  { 59, 2, 3, 3, 0, -1 },
  { 60, 3, 1, 4, 0, -4 },
  { 61, 1, 2, 3, 1, -2 },
  { 62, 5, 9, 5, 0, -9 },
  { 68, 5, 9, 7, 1, -9 },
  { 74, 3, 9, 7, 1, -9 },
  { 78, 5, 9, 7, 1, -9 },
  { 84, 5, 9, 7, 1, -9 },
  { 90, 7, 9, 7, 0, -9 },
  { 98, 5, 9, 7, 1, -9 },
  { 104, 5, 9, 7, 1, -9 },
  { 110, 6, 9, 7, 0, -9 },
  { 117, 5, 9, 7, 1, -9 },
  { 123, 5, 9, 7, 1, -9 },
  { 129, 1, 7, 3, 1, -7 },
  { 130, 2, 9, 3, 0, -7 },
  { 133, 5, 6, 7, 1, -7 },
  { 137, 5, 3, 7, 1, -6 },
  { 139, 5, 6, 7, 1, -7 },
  { 143, 5, 9, 5, 0, -9 },
  { 149, 9, 10, 11, 1, -9 },
  { 161, 8, 9, 8, 0, -9 },
  { 170, 6, 9, 8, 1, -9 },
  { 177, 6, 9, 8, 1, -9 },
  { 184, 7, 9, 9, 1, -9 },
  { 192, 5, 9, 7, 1, -9 },
  { 198, 5, 9, 6, 1, -9 },
  { 204, 7, 9, 9, 1, -9 },
  { 212, 7, 9, 9, 1, -9 },
  { 220, 4, 9, 4, 0, -9 },
  { 225, 3, 11, 3, -1, -9 },
  { 230, 7, 9, 8, 1, -9 },
  { 238, 5, 9, 6, 1, -9 },
  { 244, 9, 9, 11, 1, -9 },
  { 255, 7, 9, 9, 1, -9 },
  { 263, 8, 9, 9, 1, -9 },
  { 272, 6, 9, 7, 1, -9 },
  { 279, 8, 11, 9, 1, -9 },
  { 290, 6, 9, 8, 1, -9 },
  { 297, 5, 9, 7, 1, -9 },
  { 303, 7, 9, 7, 0, -9 },
  { 311, 7, 9, 9, 1, -9 },
  { 319, 7, 9, 7, 0, -9 },
  { 327, 11, 9, 11, 0, -9 },
  { 340, 7, 9, 7, 0, -9 },
  { 348, 7, 9, 7, 0, -9 },
  { 356, 6, 9, 7, 0, -9 },
  { 363, 3, 11, 4, 1, -9 },
  { 368, 5, 9, 5, 0, -9 },
  { 374, 3, 11, 4, 0, -9 },
  { 379, 6, 6, 7, 0, -9 },
  { 384, 5, 1, 5, 0, 1 },
  { 385, 3, 2, 4, 0, -9 },
  { 386, 5, 7, 7, 1, -7 },
  { 391, 6, 9, 7, 1, -9 },
  { 398, 5, 7, 6, 1, -7 },
  { 403, 5, 9, 7, 1, -9 },
  { 409, 5, 7, 7, 1, -7 },
  { 414, 5, 9, 4, 0, -9 },
  { 420, 5, 10, 7, 1, -7 },
  { 427, 6, 9, 8, 1, -9 },
  { 434, 1, 9, 3, 1, -9 },
  { 436, 3, 12, 3, -1, -9 },
  { 441, 6, 9, 7, 1, -9 },
  { 448, 1, 9, 3, 1, -9 },
  { 450, 9, 7, 11, 1, -7 },
  { 458, 6, 7, 8, 1, -7 },
  { 464, 6, 7, 7, 1, -7 },
  { 470, 6, 10, 7, 1, -7 },
  { 478, 5, 10, 7, 1, -7 },
  { 485, 4, 7, 5, 1, -7 },
  { 489, 4, 7, 6, 1, -7 },
  { 493, 4, 8, 5, 0, -8 },
  { 497, 6, 6, 8, 1, -6 },
  { 502, 6, 6, 6, 0, -6 },
  { 507, 10, 6, 10, 0, -6 },
  { 515, 6, 6, 7, 0, -6 },
  { 520, 6, 9, 6, 0, -6 },
  { 527, 5, 6, 6, 0, -6 },
  { 531, 4, 11, 5, 0, -9 },
  { 537, 1, 12, 7, 3, -9 },
  { 539, 4, 11, 5, 0, -9 },
  { 545, 5, 2, 7, 1, -5 },
};

const GFXfont NotoSans_Medium12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium12pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_MEDIUM12PT7B_H_
