#ifndef _NOTOSANS_MEDIUM25PT7B_H_
#define _NOTOSANS_MEDIUM25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x6C, 0x07, 0xFC, 0xCF, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0x80, 0x06, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x71, 0x80, 0xC3,
  0x0F, 0xFF, 0xDF, 0xFF, 0x86, 0x30, 0x0C, 0x60, 0x30, 0xC0, 0x63, 0x07,
  0xFF, 0xEF, 0xFF, 0xC3, 0x18, 0x0C, 0x30, 0x18, 0xC0, 0x31, 0x80, 0x63,
  0x00, 0x06, 0x00, 0x60, 0x1F, 0xC3, 0xFF, 0x7E, 0xEE, 0x60, 0xE6, 0x07,
  0x60, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x06, 0x70, 0x67, 0x86, 0x7F,
  0x7E, 0xFF, 0xE3, 0xF0, 0x06, 0x00, 0x60, 0x3C, 0x07, 0x0F, 0xC0, 0xC3,
  0x98, 0x30, 0x63, 0x86, 0x0C, 0x31, 0x81, 0x86, 0x70, 0x31, 0xCC, 0x06,
  0x3B, 0xBC, 0x66, 0x6F, 0xCF, 0xDD, 0x9C, 0xF3, 0x31, 0x80, 0xCE, 0x30,
  0x19, 0xC6, 0x06, 0x38, 0xC0, 0xC3, 0x18, 0x30, 0x63, 0x0E, 0x0F, 0xC1,
  0x80, 0xF8, 0x0F, 0x80, 0x0F, 0xE0, 0x0E, 0x38, 0x06, 0x0C, 0x03, 0x06,
  0x01, 0xC7, 0x00, 0x77, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0xC1, 0x9C,
  0xF1, 0xDC, 0x3C, 0xEE, 0x0F, 0xE7, 0x03, 0xE3, 0x80, 0xF0, 0xE0, 0xFC,
  0x7F, 0xFF, 0x0F, 0xE3, 0xC0, 0xFF, 0xFC, 0x1C, 0x63, 0x8C, 0x71, 0x86,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0x61, 0xC7, 0x0E, 0x18, 0x70,
  0xC1, 0x87, 0x0C, 0x38, 0xE1, 0x86, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC6,
  0x38, 0xE3, 0x1C, 0x63, 0x00, 0x0E, 0x00, 0x60, 0x06, 0x08, 0x61, 0xF7,
  0xFF, 0xFF, 0x0E, 0x01, 0xF0, 0x1B, 0x83, 0x9C, 0x71, 0x80, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x77, 0x66, 0xEC, 0xFF, 0xF0, 0xFF, 0x80, 0x01,
  0x81, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03,
  0x03, 0x81, 0x80, 0xC0, 0xE0, 0x60, 0x70, 0x00, 0x1F, 0x83, 0xFC, 0x78,
  0xE7, 0x06, 0x60, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x76, 0x07, 0x70, 0x67, 0x0E, 0x3F, 0xC1, 0xF8, 0x06,
  0x3C, 0xFB, 0xBE, 0x68, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x1F, 0x87, 0xFC, 0xF1, 0xE4, 0x0E, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0x3F, 0x8F, 0xFC, 0x60, 0xE4, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x3C, 0x1F, 0x01, 0xFC, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x7C, 0x0E, 0xFF, 0xE7, 0xF8, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0x60, 0x19, 0x80, 0xE6, 0x03, 0x18, 0x18,
  0x60, 0xE1, 0x87, 0x06, 0x18, 0x18, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0xF8, 0x7F, 0xE2, 0x1E, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x7C, 0x0E, 0xFF, 0xC7, 0xF8, 0x07, 0xE1, 0xFE, 0x3C,
  0x03, 0x80, 0x70, 0x06, 0x00, 0x60, 0x0E, 0xFC, 0xFF, 0xEF, 0x07, 0xE0,
  0x7E, 0x03, 0xE0, 0x36, 0x07, 0x70, 0x77, 0x8E, 0x3F, 0xE1, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x1F, 0x83, 0xFE, 0x70, 0xE6, 0x07, 0x60, 0x77, 0x06, 0x70,
  0xE3, 0xFC, 0x1F, 0x03, 0xFC, 0x71, 0xE6, 0x07, 0xE0, 0x7E, 0x03, 0xE0,
  0x77, 0x07, 0x7F, 0xE3, 0xFC, 0x1F, 0x83, 0xFC, 0x70, 0xEE, 0x06, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x70, 0xF7, 0xFB, 0x3F, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0xE0, 0x1C, 0x7F, 0x87, 0xF0, 0xDF, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x67, 0x76, 0x00, 0x00, 0x00, 0x07, 0x76, 0xEC, 0xC0, 0x00,
  0x30, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x00, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0xC0, 0x0F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x70, 0x3E, 0x0F, 0x87, 0xC0, 0xF0, 0x0C, 0x00, 0x3F, 0x1F,
  0xF9, 0x87, 0x00, 0x60, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x30, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00,
  0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0x03, 0xC1, 0xC0, 0x0C, 0x38, 0x00, 0x63,
  0x0F, 0xE7, 0x61, 0xFE, 0x36, 0x38, 0xE3, 0x63, 0x0E, 0x3E, 0x70, 0xE3,
  0xC7, 0x0C, 0x3C, 0x70, 0xC3, 0xE3, 0x0E, 0x66, 0x3F, 0xFE, 0x61, 0xF3,
  0xC7, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x20, 0x0F, 0xFE, 0x00, 0x3F,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0x60, 0x06,
  0x70, 0x0E, 0x70, 0x0E, 0x30, 0x0C, 0x38, 0x1C, 0x38, 0x1C, 0x1C, 0x3F,
  0xFC, 0x3F, 0xFC, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x06, 0x60, 0x07, 0xE0,
  0x07, 0xFF, 0x87, 0xFF, 0x38, 0x7D, 0xC0, 0xEE, 0x03, 0x70, 0x1B, 0x81,
  0xDC, 0x3C, 0xFF, 0x87, 0xFF, 0x38, 0x1D, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x1E, 0xFF, 0xF7, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xF1, 0xF1,
  0x8E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x82, 0x1F,
  0xF8, 0x1F, 0xE0, 0xFF, 0x81, 0xFF, 0xC3, 0x8F, 0xE7, 0x01, 0xCE, 0x01,
  0xDC, 0x03, 0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x01, 0xDC, 0x03, 0xB8, 0x0E, 0x70, 0xFC, 0xFF, 0xE1, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF,
  0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x03,
  0xFC, 0x1F, 0xFC, 0x7C, 0x31, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x7F, 0xC0, 0xFD, 0x81, 0xFB, 0x80, 0x37, 0x00, 0x6E,
  0x00, 0xCE, 0x01, 0x9F, 0x03, 0x1F, 0xFE, 0x0F, 0xFC, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x30, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0xFF, 0xFC, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x7B, 0xDF, 0xBC, 0x00, 0xE0, 0x3F, 0x81, 0xCE, 0x0F, 0x38,
  0x38, 0xE1, 0xC3, 0x8E, 0x0E, 0x70, 0x3B, 0x80, 0xFE, 0x03, 0xFC, 0x0F,
  0x78, 0x38, 0xE0, 0xE1, 0xC3, 0x87, 0x8E, 0x0E, 0x38, 0x1C, 0xE0, 0x3B,
  0x80, 0xF0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xFF, 0xFF, 0xFC, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03,
  0xFF, 0xC0, 0x6F, 0xD8, 0x0D, 0xFB, 0x03, 0xBF, 0x70, 0x67, 0xE6, 0x0C,
  0xFC, 0xE3, 0x9F, 0x9C, 0x63, 0xF1, 0x8C, 0x7E, 0x3B, 0x8F, 0xC3, 0x61,
  0xF8, 0x7C, 0x3F, 0x0F, 0x07, 0xE0, 0xE0, 0xFC, 0x1C, 0x1C, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7D, 0xC0, 0xF9, 0xC1, 0xF3,
  0x83, 0xE3, 0x87, 0xC7, 0x0F, 0x87, 0x1F, 0x07, 0x3E, 0x0E, 0x7C, 0x0E,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3C, 0x07, 0xF0, 0x0F, 0xFE,
  0x0F, 0x8F, 0x87, 0x01, 0xE7, 0x00, 0x73, 0x80, 0x1D, 0xC0, 0x0E, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xD8, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B,
  0x80, 0x38, 0xE0, 0x1C, 0x78, 0x3C, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0xFF,
  0x0F, 0xFC, 0xE3, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE1,
  0xEF, 0xFC, 0xFF, 0x8E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0x8F, 0x87, 0x01, 0xE7, 0x00,
  0x73, 0x80, 0x1D, 0xC0, 0x0E, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xD8,
  0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x38, 0xE0, 0x1C, 0x78, 0x3C,
  0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0xFF, 0x03, 0xFF, 0x8E, 0x3E, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE,
  0x07, 0x38, 0x1C, 0xE3, 0xE3, 0xFF, 0x0F, 0xF8, 0x38, 0x70, 0xE1, 0xC3,
  0x83, 0x8E, 0x0E, 0x38, 0x1C, 0xE0, 0x3B, 0x80, 0xF0, 0x1F, 0xC3, 0xFE,
  0x78, 0xE6, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x6C, 0x0E, 0xFF, 0xC7, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x77, 0x01, 0xDE, 0x1E,
  0x3F, 0xF0, 0x7F, 0x80, 0xE0, 0x0F, 0xC0, 0x1D, 0xC0, 0x3B, 0x80, 0xE3,
  0x01, 0xC7, 0x03, 0x8E, 0x0E, 0x0C, 0x1C, 0x1C, 0x30, 0x38, 0xE0, 0x31,
  0xC0, 0x73, 0x00, 0xEE, 0x00, 0xDC, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0xE0, 0x38, 0x0E, 0xC0, 0x70, 0x1D, 0xC0, 0xF0, 0x3B, 0x83,
  0xE0, 0x67, 0x06, 0xC1, 0xC6, 0x0D, 0xC3, 0x8E, 0x1B, 0x87, 0x1C, 0x73,
  0x0C, 0x38, 0xC6, 0x38, 0x31, 0x8E, 0x70, 0x77, 0x0C, 0xE0, 0xEE, 0x19,
  0x81, 0xD8, 0x3F, 0x01, 0xB0, 0x7E, 0x03, 0x60, 0x7C, 0x07, 0x80, 0xF0,
  0x0F, 0x01, 0xE0, 0x0E, 0x01, 0xC0, 0xF0, 0x0E, 0xE0, 0x38, 0xE0, 0xE0,
  0xE1, 0xC1, 0xC7, 0x01, 0xDC, 0x01, 0xB8, 0x03, 0xE0, 0x03, 0x80, 0x07,
  0x80, 0x1F, 0x00, 0x77, 0x00, 0xC7, 0x03, 0x8E, 0x0E, 0x0E, 0x1C, 0x0E,
  0x70, 0x1D, 0xC0, 0x1C, 0xE0, 0x1E, 0xE0, 0x39, 0xC0, 0xE1, 0xC1, 0xC3,
  0x87, 0x03, 0x8E, 0x07, 0x38, 0x07, 0x70, 0x0F, 0xC0, 0x0F, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70,
  0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xF0, 0xE0, 0x30,
  0x1C, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0,
  0x60, 0x38, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0xFF, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3F, 0xFC, 0x06, 0x00, 0xE0,
  0x0F, 0x00, 0xF0, 0x19, 0x81, 0x98, 0x30, 0xC3, 0x0C, 0x60, 0x66, 0x06,
  0xC0, 0x30, 0xFF, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x07, 0x07, 0xF8, 0xE7,
  0x80, 0x70, 0x06, 0x00, 0xC7, 0xFB, 0xFF, 0xF0, 0x7C, 0x0F, 0x83, 0xF0,
  0xF7, 0xFE, 0x7C, 0xC0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x70, 0xFF, 0xCF, 0xFE, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0xED, 0xFE, 0xCF, 0xC0, 0x07, 0x87, 0xF3,
  0xFD, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xE1,
  0x3F, 0xC7, 0xF0, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x63,
  0x3F, 0xB7, 0xFF, 0x70, 0x77, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x37, 0x07, 0x70, 0x73, 0xFF, 0x1F, 0xB0, 0x07, 0x01, 0xFC, 0x39,
  0xE7, 0x07, 0x60, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x70,
  0x07, 0x81, 0x3F, 0xE1, 0xFE, 0x0F, 0xC7, 0xF1, 0xC0, 0x60, 0x18, 0x06,
  0x0F, 0xFB, 0xFE, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x06, 0x03, 0xFB, 0x3D, 0xF7, 0x07, 0x70,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x36, 0x03, 0x70, 0x77, 0x07, 0x3F,
  0xF1, 0xFB, 0x00, 0x30, 0x03, 0x00, 0x76, 0x0F, 0x7F, 0xE3, 0xF8, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x78, 0xFF, 0xCF, 0xDE, 0xF0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x70, 0x5F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x08, 0x71, 0xC0, 0x00, 0x01, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x73, 0xBE, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE1, 0xEE, 0x1C, 0xE3, 0x8E, 0x70, 0xEE, 0x0F,
  0xC0, 0xFE, 0x0F, 0x70, 0xE7, 0x0E, 0x38, 0xE1, 0xCE, 0x0E, 0xE0, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x03, 0x8D, 0xFC,
  0xFE, 0xFF, 0xFD, 0xEF, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x06, 0x07, 0xE0,
  0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E,
  0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0x07, 0x0D, 0xFE, 0xFD, 0xEF,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0x07, 0x80, 0xFF, 0x0F, 0x7C, 0xE0, 0xE7, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3B, 0x01, 0xDC, 0x0C, 0xF0, 0xE3,
  0xFE, 0x0F, 0xE0, 0x07, 0x0D, 0xFC, 0xFF, 0xEF, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0E, 0xFF, 0xEE, 0xFC,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x03, 0xFB,
  0x7D, 0xF7, 0x07, 0x70, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0x70, 0x77, 0x07, 0x3F, 0xF1, 0xF3, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x03, 0xCF, 0xDF, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1E, 0x1F, 0xFF, 0x3B, 0x80, 0xE0, 0x1E,
  0x07, 0xE0, 0x7E, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0xFF, 0xBF, 0xC0, 0x18,
  0x0C, 0x06, 0x07, 0x0F, 0xFF, 0xFC, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x3F, 0x0F, 0x80, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xF7,
  0xFF, 0x3F, 0x70, 0xE0, 0x3B, 0x81, 0x9C, 0x1C, 0x60, 0xE3, 0x86, 0x1C,
  0x70, 0x63, 0x83, 0x98, 0x1D, 0xC0, 0x6C, 0x03, 0x60, 0x0F, 0x00, 0x70,
  0x00, 0xE0, 0x70, 0x76, 0x0F, 0x07, 0x60, 0xF0, 0x67, 0x0F, 0x0E, 0x71,
  0xF8, 0xE3, 0x19, 0x8E, 0x39, 0x98, 0xC3, 0x99, 0xDC, 0x3B, 0x8D, 0xC1,
  0xB0, 0xD8, 0x1B, 0x0D, 0x81, 0xF0, 0xF8, 0x0E, 0x07, 0x80, 0xE0, 0x70,
  0x70, 0x79, 0xC3, 0x87, 0x38, 0x3B, 0x80, 0xFC, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0x1D, 0xC0, 0xE7, 0x0E, 0x18, 0xE0, 0xEF, 0x03, 0x80, 0xE0, 0x3B,
  0x81, 0x9C, 0x1C, 0x60, 0xE3, 0x86, 0x1C, 0x70, 0x63, 0x83, 0x98, 0x0D,
  0xC0, 0x6C, 0x03, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x1E, 0x07, 0xE0, 0x3E, 0x00, 0xFF, 0xFF, 0xF0, 0x38, 0x1C, 0x07, 0x03,
  0x81, 0xC0, 0x60, 0x38, 0x1C, 0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0x1F,
  0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0xF0, 0xF0, 0x38, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x1C, 0x0F, 0x0F, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x78, 0xF0,
  0xE0, 0x30, 0x1F, 0xE1, 0xFF, 0xF8, 0x1E,
};

const GFXglyph NotoSans_Medium25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 18, 7, 2, -18 },
  { 8, 7, 7, 11, 2, -18 },
  { 15, 15, 18, 16, 1, -18 },
  { 49, 12, 20, 14, 1, -19 },
  { 79, 19, 18, 21, 1, -18 },
  { 122, 17, 18, 18, 1, -18 },
  { 161, 2, 7, 6, 2, -18 },
  { 163, 6, 22, 8, 1, -18 },
  { 180, 6, 22, 8, 1, -18 },
  { 197, 12, 11, 14, 1, -19 },
  { 214, 12, 12, 14, 1, -15 },
  { 232, 4, 6, 7, 1, -3 },
  { 235, 6, 2, 8, 1, -8 },
  { 237, 3, 3, 7, 2, -3 },
  { 239, 9, 18, 10, 0, -18 },
  { 260, 12, 18, 14, 1, -18 },
  { 287, 7, 18, 14, 2, -18 },
  { 303, 12, 18, 14, 1, -18 },
  { 330, 12, 18, 14, 1, -18 },
  { 357, 14, 18, 14, 0, -18 },
  { 389, 12, 18, 14, 1, -18 },
  { 416, 12, 18, 14, 1, -18 },
  { 443, 12, 18, 14, 1, -18 },
  { 470, 12, 18, 14, 1, -18 },
  { 497, 12, 18, 14, 1, -18 },
  { 524, 3, 14, 7, 2, -14 },
  { 530, 4, 17, 7, 1, -14 },
  { 539, 12, 12, 14, 1, -15 },
  { 557, 12, 7, 14, 1, -12 },
  { 568, 12, 12, 14, 1, -15 },
  { 586, 11, 18, 11, 0, -18 },
  { 611, 20, 20, 22, 1, -18 },
  { 661, 16, 18, 16, 0, -18 },
  { 697, 13, 18, 16, 2, -18 },
  { 727, 14, 18, 16, 1, -18 },
  { 759, 15, 18, 18, 2, -18 },
  { 793, 10, 18, 14, 2, -18 },
  { 816, 10, 18, 13, 2, -18 },
  { 839, 15, 18, 18, 1, -18 },
  { 873, 14, 18, 19, 2, -18 },
  { 905, 7, 18, 9, 1, -18 },
  { 921, 7, 23, 7, -2, -18 },
  { 942, 14, 18, 16, 2, -18 },
  { 974, 11, 18, 13, 2, -18 },
  { 999, 19, 18, 23, 2, -18 },
  { 1042, 15, 18, 19, 2, -18 },
  { 1076, 17, 18, 20, 1, -18 },
  { 1115, 12, 18, 15, 2, -18 },
  { 1142, 17, 22, 20, 1, -18 },
  { 1189, 14, 18, 16, 2, -18 },
  { 1221, 12, 18, 14, 1, -18 },
  { 1248, 14, 18, 14, 0, -18 },
  { 1280, 14, 18, 18, 2, -18 },
  { 1312, 15, 18, 15, 0, -18 },
  { 1346, 23, 18, 24, 0, -18 },
  { 1398, 15, 18, 15, 0, -18 },
  { 1432, 15, 18, 15, 0, -18 },
  { 1466, 12, 18, 14, 1, -18 },
  { 1493, 6, 22, 8, 2, -18 },
  { 1510, 9, 18, 10, 0, -18 },
  { 1531, 5, 22, 8, 1, -18 },
  { 1545, 12, 11, 14, 1, -18 },
  { 1562, 11, 2, 11, 0, 2 },
  { 1565, 6, 4, 8, 1, -19 },
  { 1568, 11, 14, 14, 1, -14 },
  { 1588, 12, 19, 16, 2, -19 },
  { 1617, 10, 14, 12, 1, -14 },
  { 1635, 12, 19, 16, 1, -19 },
  { 1664, 12, 14, 14, 1, -14 },
  { 1685, 10, 19, 9, 0, -19 },
  { 1709, 12, 20, 16, 1, -14 },
  { 1739, 12, 19, 16, 2, -19 },
  { 1768, 3, 19, 7, 2, -19 },
  { 1776, 6, 25, 7, -1, -19 },
  { 1795, 12, 19, 14, 2, -19 },
  { 1824, 3, 19, 7, 2, -19 },
  { 1832, 20, 14, 24, 2, -14 },
  { 1867, 12, 14, 16, 2, -14 },
  { 1888, 13, 14, 15, 1, -14 },
  { 1911, 12, 20, 16, 2, -14 },
  { 1941, 12, 20, 16, 1, -14 },
  { 1971, 8, 14, 11, 2, -14 },
  { 1985, 10, 14, 12, 1, -14 },
  { 2003, 9, 17, 10, 0, -17 },
  { 2023, 12, 13, 16, 2, -13 },
  { 2043, 13, 13, 13, 0, -13 },
  { 2065, 20, 14, 20, 0, -14 },
  { 2100, 13, 13, 14, 0, -13 },
  { 2122, 13, 19, 13, 0, -13 },
  { 2153, 10, 13, 12, 1, -13 },
  { 2170, 8, 22, 10, 1, -18 },
  { 2192, 2, 25, 14, 6, -19 },
  { 2199, 8, 22, 10, 1, -18 },
  { 2221, 12, 4, 14, 1, -11 },
};

const GFXfont NotoSans_Medium25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium25pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_MEDIUM25PT7B_H_
