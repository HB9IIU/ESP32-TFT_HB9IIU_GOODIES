#ifndef _NOTOSANS_MEDIUM46PT7B_H_
#define _NOTOSANS_MEDIUM46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x80, 0x00, 0x00, 0x1E, 0xFF, 0xFF,
  0xFF, 0x7C, 0xC0, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7B,
  0xE1, 0xEF, 0x07, 0x9C, 0x1E, 0x70, 0x79, 0xC0, 0xE7, 0x03, 0x9C, 0x0E,
  0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x03,
  0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1C,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x0E, 0x07,
  0x80, 0x00, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x1E, 0x07, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1C, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0x03, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78,
  0x1C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFE, 0x71, 0xE7, 0xC3, 0x81, 0x3C, 0x1C,
  0x01, 0xE0, 0xE0, 0x0F, 0x87, 0x00, 0x7C, 0x38, 0x03, 0xF1, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xC7, 0xE0, 0x0E, 0x1F, 0x00,
  0x70, 0xF8, 0x03, 0x87, 0xC0, 0x1C, 0x3F, 0x80, 0xE3, 0xEF, 0xC7, 0xFF,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x07, 0xFE, 0x00, 0x1E, 0x00, 0xFF, 0xC0, 0x07,
  0x80, 0x3E, 0x7C, 0x00, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x01, 0xE0, 0x78,
  0x07, 0x80, 0x3C, 0x0F, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x3C, 0x00, 0xF0,
  0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x83, 0xE0, 0x03, 0xC0, 0xF0, 0x78, 0x00,
  0x78, 0x1E, 0x1E, 0x00, 0x0F, 0x03, 0xC3, 0xC0, 0x01, 0xE0, 0x78, 0xF0,
  0xFC, 0x3C, 0x0F, 0x1E, 0x7F, 0xC3, 0xC3, 0xC7, 0x8F, 0xFC, 0x7C, 0xF8,
  0xF3, 0xE7, 0xC7, 0xFE, 0x3C, 0x78, 0x78, 0x7F, 0xCF, 0x9E, 0x07, 0x87,
  0xE1, 0xE3, 0xC0, 0xF0, 0x00, 0x78, 0x78, 0x1E, 0x00, 0x0F, 0x0F, 0x03,
  0xC0, 0x03, 0xC1, 0xE0, 0x78, 0x00, 0x78, 0x3C, 0x0F, 0x00, 0x1E, 0x07,
  0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0xF0, 0x1E, 0x07, 0x80, 0x3E,
  0x03, 0xC0, 0xF0, 0x07, 0x80, 0x3C, 0x3C, 0x01, 0xE0, 0x07, 0x87, 0x80,
  0x3C, 0x00, 0x7F, 0xF0, 0x0F, 0x00, 0x0F, 0xFC, 0x03, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7C, 0x1F, 0xFF, 0x00,
  0x7C, 0x3F, 0x9F, 0x80, 0xF8, 0x7F, 0x0F, 0xC0, 0xF8, 0x7E, 0x07, 0xE0,
  0xF8, 0x7C, 0x03, 0xF1, 0xF0, 0xFC, 0x01, 0xF9, 0xF0, 0xF8, 0x00, 0xFF,
  0xE0, 0xF8, 0x00, 0x7F, 0xE0, 0xFC, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF9, 0xF8, 0x0F, 0xFF, 0xE0, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xCE, 0x73, 0x9C, 0xE0, 0x03, 0xE0, 0x78,
  0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78,
  0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x07,
  0x80, 0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8,
  0x0F, 0x01, 0xF0, 0x1F, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1E, 0x03,
  0xE0, 0x3C, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x02, 0x01, 0xC0, 0x3F, 0x0E,
  0x1F, 0xFF, 0x77, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0xF1, 0xE0, 0x0F, 0x8F,
  0x80, 0xFC, 0x3E, 0x07, 0xC1, 0xF8, 0x1E, 0x07, 0x00, 0x20, 0x20, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x7C, 0xFB, 0xE7, 0xCF, 0x9E, 0x3C, 0xF1, 0xE3, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF, 0xFF, 0xFD, 0xF3, 0x00, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x03, 0xF0,
  0xF8, 0x07, 0xC7, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0x80,
  0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE3, 0xC0, 0x0F,
  0x8F, 0x80, 0x7C, 0x3F, 0x03, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x78, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0,
  0xFF, 0x9F, 0xFD, 0xFB, 0xFF, 0x9F, 0xF8, 0xFB, 0x87, 0xC8, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03,
  0xFF, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7E, 0x03,
  0xF0, 0xE0, 0x07, 0xC1, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0x07,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7C, 0x03, 0xF0, 0xC0, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0xF8, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0xE0,
  0x03, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3D,
  0xF0, 0x00, 0x7D, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0xF1, 0xF0, 0x01, 0xE1,
  0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xC1, 0xF0, 0x07, 0x81, 0xF0, 0x0F, 0x81,
  0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3C, 0x01,
  0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC7, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7D, 0x00, 0x07, 0xEE, 0x00, 0x7E, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x3F, 0x01, 0xE3, 0xFF, 0x0F, 0x9F, 0xFE,
  0x3E, 0xFF, 0xFC, 0xFF, 0x83, 0xFB, 0xF8, 0x03, 0xEF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xDE, 0x00,
  0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3E,
  0x3F, 0x01, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0x01, 0xF9, 0xF0,
  0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03,
  0xE3, 0xE0, 0x0F, 0x8F, 0xC0, 0x7C, 0x1F, 0x87, 0xE0, 0x3F, 0xBF, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xF8,
  0xFE, 0x0F, 0xC0, 0xFC, 0x7C, 0x01, 0xF9, 0xF0, 0x03, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x1F, 0x7E, 0x00, 0xF9, 0xFF, 0x1F, 0xE3, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3F, 0x03, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x0F, 0xBE,
  0x00, 0x3E, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xDF, 0x00, 0x7F,
  0x7F, 0x03, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xF7, 0xC3, 0xFF, 0x9F, 0x03,
  0xF8, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0x7C, 0xC0, 0x1F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0x78,
  0x78, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0x80, 0x7E, 0x40, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x03, 0xC3,
  0xC0, 0x1F, 0xF0, 0x3E, 0x7C, 0x07, 0xFF, 0xC1, 0xE7, 0x80, 0xFF, 0xFC,
  0x1E, 0x78, 0x1F, 0x83, 0xC0, 0xEF, 0x03, 0xE0, 0x3C, 0x0F, 0xF0, 0x3C,
  0x03, 0xC0, 0xFF, 0x07, 0xC0, 0x3C, 0x0F, 0xF0, 0x78, 0x03, 0xC0, 0xFE,
  0x07, 0x80, 0x3C, 0x0F, 0xE0, 0x78, 0x03, 0xC0, 0xFE, 0x07, 0x80, 0x78,
  0x0F, 0xE0, 0x78, 0x07, 0x80, 0xEE, 0x07, 0x80, 0x78, 0x1E, 0xE0, 0x78,
  0x07, 0xC1, 0xEF, 0x07, 0xC0, 0xFC, 0x3C, 0xF0, 0x3F, 0x3D, 0xE7, 0xCF,
  0x01, 0xFF, 0xDF, 0xF8, 0xF8, 0x0F, 0xF8, 0xFF, 0x07, 0x80, 0x7E, 0x03,
  0xC0, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x00,
  0x7F, 0xF3, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3F, 0x0F,
  0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7C, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xF8, 0x07,
  0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0xFC, 0xF8, 0x03, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0xF8, 0x01, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x01,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0xFF, 0x01, 0xF0, 0xFE, 0x00, 0x10, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x70, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0x80,
  0xFF, 0xE1, 0xF0, 0x01, 0xFE, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFC,
  0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xBE,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x7F, 0x8F, 0x80, 0x7F, 0xE1, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x78, 0x3F, 0x80, 0x01, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F,
  0x7E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0x8F, 0xE0,
  0x01, 0xF1, 0xFF, 0x00, 0x3E, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFE, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x83, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0xC3, 0xFB, 0xFF,
  0xDF, 0xFC, 0xFF, 0xC3, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xBE, 0x00, 0x1F, 0x9F, 0x00, 0x1F, 0x8F, 0x80, 0x1F, 0x87, 0xC0, 0x1F,
  0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x0F,
  0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x0F, 0x8F, 0xC0, 0x07, 0xCF,
  0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xDF, 0x80, 0x1F, 0xC7, 0xE0, 0x0F, 0x83, 0xF0, 0x07,
  0xC0, 0xFC, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xE0,
  0x7C, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x0F,
  0xC7, 0xC0, 0x03, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7E, 0xF8, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xEF, 0x00, 0x03, 0xDF, 0xFB, 0xC0, 0x00, 0xF7, 0xFE,
  0xF8, 0x00, 0x7D, 0xFF, 0x9E, 0x00, 0x1E, 0x7F, 0xE7, 0xC0, 0x07, 0x9F,
  0xF9, 0xF0, 0x03, 0xC7, 0xFE, 0x3C, 0x00, 0xF1, 0xFF, 0x8F, 0x80, 0x7C,
  0x7F, 0xE3, 0xE0, 0x1E, 0x1F, 0xF8, 0x78, 0x07, 0x87, 0xFE, 0x1F, 0x03,
  0xE1, 0xFF, 0x83, 0xC0, 0xF0, 0x7F, 0xE0, 0xF0, 0x3C, 0x1F, 0xF8, 0x3E,
  0x1F, 0x07, 0xFE, 0x07, 0x87, 0x81, 0xFF, 0x81, 0xE1, 0xE0, 0x7F, 0xE0,
  0x7C, 0xF0, 0x1F, 0xF8, 0x0F, 0x3C, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF8, 0x07, 0xF8, 0x07,
  0xFE, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xE0, 0x0F, 0xC0,
  0x1F, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFB, 0xF0, 0x01,
  0xFF, 0x3E, 0x00, 0x3F, 0xE7, 0xE0, 0x07, 0xFC, 0x7C, 0x00, 0xFF, 0x8F,
  0xC0, 0x1F, 0xF0, 0xFC, 0x03, 0xFE, 0x0F, 0x80, 0x7F, 0xC1, 0xF8, 0x0F,
  0xF8, 0x1F, 0x81, 0xFF, 0x01, 0xF0, 0x3F, 0xE0, 0x3F, 0x07, 0xFC, 0x03,
  0xE0, 0xFF, 0x80, 0x7E, 0x1F, 0xF0, 0x07, 0xE3, 0xFE, 0x00, 0x7C, 0x7F,
  0xC0, 0x0F, 0xCF, 0xF8, 0x00, 0xFD, 0xFF, 0x00, 0x0F, 0xBF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0xF8, 0x1F, 0xF3, 0xE0, 0x0F, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0x80, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xDF,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0x80, 0xFF, 0x87, 0xC0,
  0x0F, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x0F, 0x87,
  0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x3F, 0xE0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0xC0, 0xF8, 0x03,
  0xE0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x0F, 0x80,
  0x0F, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x7E, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE3, 0xF0, 0x1F, 0x3F, 0x00, 0x11, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xE7, 0xC0, 0x01,
  0xF9, 0xF8, 0x00, 0x7C, 0x3F, 0x80, 0x7F, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x3E,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x7C, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80,
  0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0xF8, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x79, 0xF0,
  0x00, 0x07, 0xDE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xEF, 0x80,
  0x03, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7F, 0x80,
  0x1F, 0x0F, 0x80, 0x1E, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xDE, 0x00, 0x7C,
  0x1F, 0x00, 0x7B, 0xC0, 0x0F, 0x83, 0xE0, 0x1F, 0x7C, 0x03, 0xE0, 0x7C,
  0x03, 0xE7, 0x80, 0x7C, 0x0F, 0x80, 0x78, 0xF0, 0x0F, 0x80, 0xF8, 0x0F,
  0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x3C,
  0x0F, 0x80, 0x7C, 0x0F, 0x07, 0x81, 0xF0, 0x07, 0xC3, 0xE0, 0xF8, 0x3E,
  0x00, 0xF8, 0x7C, 0x0F, 0x0F, 0x80, 0x1F, 0x0F, 0x01, 0xE1, 0xF0, 0x03,
  0xE1, 0xE0, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x07, 0xC7, 0xC0, 0x07, 0xCF,
  0x80, 0x79, 0xF0, 0x00, 0xF9, 0xE0, 0x0F, 0x3E, 0x00, 0x1F, 0x3C, 0x01,
  0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x1E, 0xF0, 0x00, 0x3F, 0xE0, 0x03, 0xDE,
  0x00, 0x07, 0xFC, 0x00, 0x7B, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x3F, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC,
  0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x07,
  0xC3, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x0F, 0x80, 0x7C,
  0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x83, 0xE0,
  0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xE7, 0x80, 0x07, 0x8F, 0x00,
  0x0F, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF0,
  0x00, 0xF1, 0xE0, 0x01, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0x81, 0xE0, 0x3C, 0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xC0, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xBF, 0xE0, 0x7D, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xBF,
  0x9F, 0xFD, 0xFF, 0xF9, 0xE7, 0xFF, 0x8F, 0x1F, 0xF8, 0x78, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x8F, 0xF0, 0x3E, 0x7F, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xCF, 0xF0, 0x3F, 0x3F, 0x00, 0x7E, 0xFC, 0x00, 0xFB, 0xE0, 0x03, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFB, 0xF0, 0x07, 0xEF, 0xE0, 0x3F, 0x3F,
  0xFF, 0xFC, 0xF7, 0xFF, 0xE3, 0xCF, 0xFF, 0x0F, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xF8, 0x0C, 0x7E,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF8,
  0x06, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0xF8, 0x3F, 0xF9, 0xF0, 0xFF, 0xFB,
  0xE3, 0xFF, 0xFF, 0xCF, 0xE0, 0x7F, 0x9F, 0x00, 0x7F, 0x7E, 0x00, 0x7E,
  0xF8, 0x00, 0xFD, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0xF8,
  0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xE0, 0x07, 0xE7, 0xC0,
  0x0F, 0xCF, 0xC0, 0x7F, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBE, 0x1F, 0xFE,
  0x3C, 0x0F, 0xF8, 0x78, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x3F, 0x01, 0xF8, 0xF8, 0x03, 0xE7, 0xE0, 0x07, 0x9F,
  0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x80, 0x18, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xFF,
  0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x1E, 0x0F, 0xFE, 0x3C, 0x3F, 0xFE,
  0xF8, 0xFF, 0xFF, 0xF3, 0xF8, 0x1F, 0xE7, 0xC0, 0x1F, 0xDF, 0x80, 0x1F,
  0xBE, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xBE,
  0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF8, 0x01, 0xF9, 0xF0,
  0x03, 0xF3, 0xF0, 0x0F, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xEF, 0x87, 0xFF,
  0x9F, 0x03, 0xFE, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x88, 0x00, 0x3F, 0x1E, 0x01, 0xFC,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x3F, 0xE1, 0xF3, 0xFF, 0x8F, 0xFF, 0xFE, 0x7B, 0xFF,
  0xFB, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x79, 0xFF, 0xDF, 0x78,
  0x00, 0x00, 0x01, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF0, 0x03, 0xC0,
  0x7C, 0x1F, 0x81, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0xDF, 0xFB, 0xFE, 0x7F, 0x8F, 0xE0,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x07, 0xEF, 0x80, 0x7E, 0x7C, 0x07,
  0xE3, 0xE0, 0x7E, 0x1F, 0x07, 0xE0, 0xF8, 0x7E, 0x07, 0xC7, 0xE0, 0x3E,
  0x7E, 0x01, 0xF3, 0xE0, 0x0F, 0xBE, 0x00, 0x7B, 0xF0, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0xFE, 0xFC, 0x07, 0xE3, 0xE0, 0x3E, 0x1F, 0x81, 0xF0,
  0x7E, 0x0F, 0x81, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3F, 0x1F, 0x00, 0xFC,
  0xF8, 0x03, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0x3F,
  0xFC, 0x3F, 0xF8, 0xF7, 0xFF, 0xE7, 0xFF, 0xCF, 0x7F, 0xFE, 0xFF, 0xFE,
  0xFF, 0x07, 0xFE, 0x07, 0xEF, 0xC0, 0x3F, 0xC0, 0x3F, 0xFC, 0x01, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0x00, 0x1F, 0xF8, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x1F,
  0xF8, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x1F, 0xF8, 0x01, 0xF0,
  0x01, 0xFF, 0x80, 0x1F, 0x00, 0x1F, 0xF8, 0x01, 0xF0, 0x01, 0xFF, 0x80,
  0x1F, 0x00, 0x1F, 0xF8, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x1F,
  0xF8, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x1F, 0xF8, 0x01, 0xF0,
  0x01, 0xFF, 0x80, 0x1F, 0x00, 0x1F, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0xF0,
  0xFF, 0x87, 0x8F, 0xFF, 0x3D, 0xFF, 0xFD, 0xEF, 0xFF, 0xEF, 0xF0, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x3E, 0x00, 0x7C, 0x7E,
  0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7E,
  0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xF0, 0xFF, 0x03, 0xC7,
  0xFF, 0x0F, 0x7F, 0xFE, 0x3D, 0xFF, 0xFC, 0xFF, 0x03, 0xF3, 0xF0, 0x07,
  0xEF, 0xC0, 0x0F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x0F,
  0xBF, 0x00, 0x7E, 0xFE, 0x03, 0xF3, 0xFF, 0xFF, 0xCF, 0x7F, 0xFE, 0x3E,
  0xFF, 0xF0, 0xF8, 0xFF, 0x83, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xFC, 0x1E, 0x0F, 0xFE, 0x7C, 0x3F, 0xFE, 0xF8, 0xFF, 0xFF, 0xF3, 0xF8,
  0x1F, 0xE7, 0xC0, 0x1F, 0xDF, 0x80, 0x1F, 0xBE, 0x00, 0x3F, 0x7C, 0x00,
  0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E,
  0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xF3, 0xF0, 0x1F, 0xE3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xEF, 0x87, 0xFF, 0x9F, 0x03, 0xFE, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0xF0, 0x7F, 0xE3, 0xFF, 0xCF,
  0xFF, 0xBF, 0xEF, 0x7C, 0x3F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0xF3, 0xFF,
  0xF9, 0xFF, 0xFE, 0x7C, 0x01, 0xBE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFC,
  0x3F, 0xFC, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xF0,
  0x01, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x7E, 0x03, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFB, 0xC7, 0xFF, 0xCF, 0x07, 0xFC, 0x3C, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x0F, 0x00, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0x81, 0xF0,
  0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xE7, 0xC0,
  0x01, 0xE7, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xE0, 0x0F, 0x9F, 0x00, 0x7F,
  0x00, 0x7C, 0xF8, 0x03, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0xE0, 0x1E, 0x1F,
  0x01, 0xEF, 0x01, 0xF0, 0xF8, 0x0F, 0x78, 0x0F, 0x83, 0xC0, 0x7B, 0xC0,
  0x7C, 0x1F, 0x07, 0xDF, 0x07, 0xC0, 0xF8, 0x3C, 0x78, 0x3E, 0x07, 0xC1,
  0xE3, 0xC1, 0xF0, 0x1E, 0x0F, 0x1F, 0x0F, 0x00, 0xF8, 0xF8, 0x78, 0xF8,
  0x07, 0xC7, 0x83, 0xC7, 0xC0, 0x3E, 0x3C, 0x1E, 0x3E, 0x00, 0xF3, 0xE0,
  0xF9, 0xE0, 0x07, 0xDE, 0x03, 0xDF, 0x00, 0x3E, 0xF0, 0x1E, 0xF8, 0x00,
  0xF7, 0x80, 0xF7, 0x80, 0x07, 0xB8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0xF8,
  0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x01, 0xF0,
  0x7C, 0x03, 0xF1, 0xF8, 0x03, 0xE3, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0x8F, 0x80,
  0x3F, 0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xF0, 0x1F, 0x07, 0xE0, 0x3F, 0x1F,
  0x80, 0x3F, 0x3E, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x07, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x07,
  0xC3, 0xE0, 0x03, 0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xE7, 0xC0, 0x01,
  0xE7, 0xC0, 0x01, 0xF7, 0x80, 0x00, 0xF7, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0xC0, 0x1F, 0x83, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x03, 0xF8,
  0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0x7F,
  0xC1, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7C, 0x00, 0x3F, 0xE0,
  0x05, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0x3F, 0xFA,
  0x00, 0x1F, 0x80,
};

const GFXglyph NotoSans_Medium46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 6, 34, 13, 3, -33 },
  { 27, 14, 12, 20, 3, -33 },
  { 48, 28, 33, 30, 1, -33 },
  { 164, 21, 38, 26, 3, -35 },
  { 264, 35, 33, 39, 2, -33 },
  { 409, 32, 33, 34, 2, -33 },
  { 541, 5, 12, 11, 3, -33 },
  { 549, 11, 40, 14, 2, -33 },
  { 604, 12, 40, 14, 1, -33 },
  { 664, 21, 21, 25, 2, -35 },
  { 720, 22, 22, 26, 2, -27 },
  { 781, 7, 11, 13, 2, -5 },
  { 791, 11, 4, 15, 2, -14 },
  { 797, 6, 7, 13, 3, -6 },
  { 803, 17, 33, 18, 0, -33 },
  { 874, 22, 33, 26, 2, -33 },
  { 965, 13, 33, 26, 4, -33 },
  { 1019, 22, 33, 26, 2, -33 },
  { 1110, 22, 33, 26, 2, -33 },
  { 1201, 24, 33, 26, 1, -33 },
  { 1300, 21, 33, 26, 3, -33 },
  { 1387, 22, 33, 26, 2, -33 },
  { 1478, 22, 33, 26, 2, -33 },
  { 1569, 22, 33, 26, 2, -33 },
  { 1660, 22, 33, 26, 2, -33 },
  { 1751, 6, 26, 13, 3, -25 },
  { 1771, 8, 31, 13, 1, -25 },
  { 1802, 22, 23, 26, 2, -28 },
  { 1866, 22, 13, 26, 2, -23 },
  { 1902, 22, 23, 26, 2, -28 },
  { 1966, 19, 34, 21, 0, -33 },
  { 2047, 36, 37, 41, 3, -33 },
  { 2214, 30, 33, 30, 0, -33 },
  { 2338, 24, 33, 30, 4, -33 },
  { 2437, 25, 33, 29, 3, -33 },
  { 2541, 27, 33, 34, 4, -33 },
  { 2653, 19, 33, 26, 4, -33 },
  { 2732, 19, 33, 24, 4, -33 },
  { 2811, 27, 33, 33, 3, -33 },
  { 2923, 26, 33, 34, 4, -33 },
  { 3031, 12, 33, 16, 2, -33 },
  { 3081, 13, 42, 13, -4, -33 },
  { 3150, 25, 33, 29, 4, -33 },
  { 3254, 19, 33, 25, 4, -33 },
  { 3333, 34, 33, 42, 4, -33 },
  { 3474, 27, 33, 36, 4, -33 },
  { 3586, 30, 33, 36, 3, -33 },
  { 3710, 22, 33, 28, 4, -33 },
  { 3801, 30, 41, 36, 3, -33 },
  { 3955, 25, 33, 29, 4, -33 },
  { 4059, 21, 33, 25, 2, -33 },
  { 4146, 24, 33, 26, 1, -33 },
  { 4245, 26, 33, 34, 4, -33 },
  { 4353, 28, 33, 28, 0, -33 },
  { 4469, 43, 33, 43, 0, -33 },
  { 4647, 28, 33, 28, 0, -33 },
  { 4763, 27, 33, 27, 0, -33 },
  { 4875, 23, 33, 26, 2, -33 },
  { 4970, 10, 40, 15, 4, -33 },
  { 5020, 17, 33, 18, 0, -33 },
  { 5091, 11, 40, 15, 1, -33 },
  { 5146, 23, 21, 26, 2, -33 },
  { 5207, 20, 3, 20, 0, 4 },
  { 5215, 10, 7, 14, 2, -35 },
  { 5224, 21, 25, 26, 2, -25 },
  { 5290, 22, 35, 29, 4, -35 },
  { 5387, 19, 25, 23, 2, -25 },
  { 5447, 23, 35, 29, 2, -35 },
  { 5548, 22, 25, 26, 2, -25 },
  { 5617, 17, 35, 16, 1, -35 },
  { 5692, 23, 36, 29, 2, -25 },
  { 5796, 21, 35, 29, 4, -35 },
  { 5888, 6, 34, 12, 3, -34 },
  { 5914, 11, 45, 12, -2, -34 },
  { 5976, 21, 35, 26, 4, -35 },
  { 6068, 5, 35, 12, 4, -35 },
  { 6090, 36, 25, 44, 4, -25 },
  { 6203, 21, 25, 29, 4, -25 },
  { 6269, 24, 25, 28, 2, -25 },
  { 6344, 22, 36, 29, 4, -25 },
  { 6443, 23, 36, 29, 2, -25 },
  { 6547, 15, 25, 19, 4, -25 },
  { 6594, 18, 25, 22, 2, -25 },
  { 6651, 15, 30, 18, 1, -30 },
  { 6708, 22, 25, 29, 3, -25 },
  { 6777, 24, 25, 24, 0, -25 },
  { 6852, 37, 25, 37, 0, -25 },
  { 6968, 23, 25, 25, 1, -25 },
  { 7040, 24, 36, 24, 0, -25 },
  { 7148, 18, 25, 22, 2, -25 },
  { 7205, 15, 40, 18, 1, -33 },
  { 7280, 4, 46, 25, 11, -35 },
  { 7303, 15, 40, 18, 2, -33 },
  { 7378, 22, 6, 26, 2, -19 },
};

const GFXfont NotoSans_Medium46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium46pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_MEDIUM46PT7B_H_
